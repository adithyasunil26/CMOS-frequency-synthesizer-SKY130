* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C2 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Q 0.20fF
C3 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C4 divbuf_0/a_1920_n1600# divbuf_0/OUT2 0.00fF
C5 divbuf_0/a_0_n1600# divbuf_0/OUT 0.26fF
C6 divbuf_0/a_40902_n240# divbuf_0/a_41382_n240# 0.05fF
C7 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n1540# 0.19fF
C8 divbuf_0/a_22110_n840# divbuf_0/a_22110_n1540# 0.01fF
C9 divbuf_0/a_52350_n840# divbuf_0/a_52830_n840# 0.07fF
C10 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C11 divbuf_0/a_38880_n1600# divbuf_0/a_39360_n1600# 0.26fF
C12 divbuf_0/a_29742_n240# divbuf_0/a_29790_n840# 0.04fF
C13 divbuf_0/a_31230_n1540# divbuf_0/a_31710_n1540# 0.11fF
C14 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n840# 0.04fF
C15 divbuf_0/a_14702_170# divbuf_0/OUT4 0.19fF
C16 divbuf_0/a_26352_170# divbuf_0/a_26352_n240# 0.01fF
C17 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n1540# 0.19fF
C18 divbuf_0/a_14222_n240# divbuf_0/OUT4 0.04fF
C19 divbuf_0/a_5852_n240# divbuf_0/a_6332_n240# 0.05fF
C20 divbuf_0/a_18270_n840# divbuf_0/a_18750_n840# 0.07fF
C21 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C22 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.06fF
C23 divbuf_0/a_12480_n1600# divbuf_0/OUT4 0.00fF
C24 divbuf_0/a_4800_n1600# divbuf_0/a_5280_n1600# 0.26fF
C25 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C26 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C27 divbuf_0/a_27870_n840# divbuf_0/a_27870_n1540# 0.01fF
C28 divbuf_0/a_58110_n840# divbuf_0/a_58590_n840# 0.07fF
C29 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n1540# 0.19fF
C30 divbuf_0/a_5852_170# divbuf_0/a_6332_170# 0.07fF
C31 divbuf_0/a_15672_n240# divbuf_0/a_15390_n840# 0.01fF
C32 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C33 divbuf_0/a_35562_n240# divbuf_0/a_35550_n840# 0.05fF
C34 divbuf_0/a_44640_n1600# divbuf_0/a_45120_n1600# 0.26fF
C35 divbuf_0/a_36990_n1540# divbuf_0/a_37470_n1540# 0.11fF
C36 divbuf_0/a_24892_170# divbuf_0/OUT4 0.19fF
C37 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n840# 0.04fF
C38 divbuf_0/a_25862_n240# divbuf_0/OUT4 0.04fF
C39 divbuf_0/a_12282_n240# divbuf_0/a_12772_n240# 0.04fF
C40 divbuf_0/a_24030_n840# divbuf_0/a_24510_n840# 0.07fF
C41 divbuf_0/a_32172_170# divbuf_0/a_32172_n240# 0.01fF
C42 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n1540# 0.19fF
C43 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C44 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z2 0.01fF
C45 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/D 0.32fF
C46 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C47 divbuf_0/a_24000_n1600# divbuf_0/OUT4 0.00fF
C48 divbuf_0/a_10560_n1600# divbuf_0/a_11040_n1600# 0.26fF
C49 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C50 divbuf_0/a_2910_n1540# divbuf_0/a_3390_n1540# 0.11fF
C51 divbuf_0/a_33630_n840# divbuf_0/a_33630_n1540# 0.01fF
C52 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C53 divbuf_0/a_480_n1600# divbuf_0/a_510_n840# 0.04fF
C54 divbuf_0/a_18582_170# divbuf_0/a_19072_170# 0.07fF
C55 divbuf_0/a_50400_n1600# divbuf_0/a_50880_n1600# 0.26fF
C56 divbuf_0/a_41382_n240# divbuf_0/a_41310_n840# 0.03fF
C57 divbuf_0/a_4882_170# divbuf_0/OUT3 0.19fF
C58 divbuf_0/a_42750_n1540# divbuf_0/a_43230_n1540# 0.11fF
C59 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n840# 0.04fF
C60 divbuf_0/a_36532_170# divbuf_0/OUT4 0.19fF
C61 divbuf_0/a_18582_170# divbuf_0/a_18582_n240# 0.01fF
C62 divbuf_0/a_37992_170# divbuf_0/a_37992_n240# 0.01fF
C63 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n1540# 0.19fF
C64 divbuf_0/a_37502_n240# divbuf_0/OUT4 0.04fF
C65 divbuf_0/a_18092_n240# divbuf_0/a_18582_n240# 0.04fF
C66 divbuf_0/a_29790_n840# divbuf_0/a_30270_n840# 0.07fF
C67 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C68 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C69 pd_0/DIV pd_0/R 0.51fF
C70 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C71 gnd divider_0/tspc_0/Z2 0.16fF
C72 divbuf_0/a_35520_n1600# divbuf_0/OUT4 0.00fF
C73 divbuf_0/a_16320_n1600# divbuf_0/a_16800_n1600# 0.26fF
C74 divbuf_0/a_6822_n240# divbuf_0/a_6750_n840# 0.03fF
C75 divbuf_0/a_8670_n1540# divbuf_0/a_9150_n1540# 0.11fF
C76 divbuf_0/a_39390_n840# divbuf_0/a_39390_n1540# 0.01fF
C77 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n840# 0.04fF
C78 divbuf_0/a_22952_170# divbuf_0/a_23442_170# 0.07fF
C79 divbuf_0/a_56160_n1600# divbuf_0/a_56640_n1600# 0.26fF
C80 divbuf_0/a_8272_170# divbuf_0/OUT3 0.19fF
C81 divbuf_0/a_48510_n1540# divbuf_0/a_48990_n1540# 0.11fF
C82 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n840# 0.04fF
C83 divbuf_0/a_8762_n240# divbuf_0/OUT3 0.04fF
C84 divbuf_0/a_23922_n240# divbuf_0/a_24412_n240# 0.04fF
C85 divbuf_0/a_5310_n840# divbuf_0/a_5310_n1540# 0.01fF
C86 divbuf_0/a_35550_n840# divbuf_0/a_36030_n840# 0.07fF
C87 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n1540# 0.19fF
C88 divider_0/tspc_1/a_630_n680# divider_0/nor_0/B 0.00fF
C89 divider_0/tspc_0/a_630_n680# divider_0/nor_1/A 0.35fF
C90 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C91 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C92 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C93 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C94 divbuf_0/a_12772_n240# divbuf_0/a_12990_n840# 0.02fF
C95 divbuf_0/a_9242_170# divbuf_0/a_9732_170# 0.07fF
C96 divbuf_0/a_22080_n1600# divbuf_0/a_22560_n1600# 0.26fF
C97 divbuf_0/a_14430_n1540# divbuf_0/a_14910_n1540# 0.11fF
C98 divbuf_0/a_45150_n840# divbuf_0/a_45150_n1540# 0.01fF
C99 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n840# 0.04fF
C100 divbuf_0/a_28772_170# divbuf_0/a_29262_170# 0.07fF
C101 divbuf_0/a_1470_n840# divbuf_0/a_1950_n840# 0.07fF
C102 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n1540# 0.19fF
C103 divbuf_0/a_54270_n1540# divbuf_0/a_54750_n1540# 0.11fF
C104 divbuf_0/a_20532_n240# divbuf_0/OUT4 0.04fF
C105 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n840# 0.04fF
C106 divider_0/tspc_0/Q divider_0/tspc_1/a_630_n680# 0.01fF
C107 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C108 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n1540# 0.19fF
C109 divbuf_0/a_29742_n240# divbuf_0/a_30232_n240# 0.04fF
C110 divbuf_0/a_11070_n840# divbuf_0/a_11070_n1540# 0.01fF
C111 divbuf_0/a_41310_n840# divbuf_0/a_41790_n840# 0.07fF
C112 divider_0/tspc_1/Q divider_0/tspc_2/Z3 0.45fF
C113 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C114 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/Out 0.08fF
C115 divider_0/nor_1/A gnd 1.02fF
C116 divbuf_0/a_27840_n1600# divbuf_0/a_28320_n1600# 0.26fF
C117 divbuf_0/a_18582_n240# divbuf_0/a_18750_n840# 0.02fF
C118 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C119 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C120 divbuf_0/a_20190_n1540# divbuf_0/a_20670_n1540# 0.11fF
C121 divbuf_0/a_50910_n840# divbuf_0/a_50910_n1540# 0.01fF
C122 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n840# 0.04fF
C123 divbuf_0/a_34592_170# divbuf_0/a_35082_170# 0.07fF
C124 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n1540# 0.19fF
C125 divbuf_0/a_60030_n1540# divbuf_0/a_60510_n1540# 0.11fF
C126 divbuf_0/a_31202_170# divbuf_0/OUT4 0.19fF
C127 divbuf_0/a_7230_n840# divbuf_0/a_7710_n840# 0.07fF
C128 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n840# 0.04fF
C129 divbuf_0/a_32172_n240# divbuf_0/OUT4 0.04fF
C130 divider_0/tspc_0/Z4 divider_0/tspc_0/a_630_n680# 0.12fF
C131 divbuf_0/a_35562_n240# divbuf_0/a_36052_n240# 0.04fF
C132 divbuf_0/a_16830_n840# divbuf_0/a_16830_n1540# 0.01fF
C133 divbuf_0/a_47070_n840# divbuf_0/a_47550_n840# 0.07fF
C134 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n1540# 0.19fF
C135 cp_1/a_10_n50# cp_1/a_1710_0# 0.04fF
C136 divbuf_0/a_24412_n240# divbuf_0/a_24510_n840# 0.03fF
C137 divbuf_0/a_12772_170# divbuf_0/a_13252_170# 0.07fF
C138 divbuf_0/a_33600_n1600# divbuf_0/a_34080_n1600# 0.26fF
C139 divbuf_0/a_7302_170# divbuf_0/a_7792_170# 0.07fF
C140 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C141 divbuf_0/a_25950_n1540# divbuf_0/a_26430_n1540# 0.11fF
C142 divbuf_0/a_56670_n840# divbuf_0/a_56670_n1540# 0.01fF
C143 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n840# 0.04fF
C144 divbuf_0/a_21012_170# divbuf_0/a_21012_n240# 0.01fF
C145 divbuf_0/a_40412_170# divbuf_0/a_40902_170# 0.07fF
C146 divbuf_0/a_3422_n240# divbuf_0/OUT3 0.07fF
C147 divbuf_0/a_12990_n840# divbuf_0/a_13470_n840# 0.07fF
C148 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n1540# 0.19fF
C149 divbuf_0/a_2880_n1600# divbuf_0/OUT2 0.00fF
C150 divider_0/mc2 divider_0/and_0/out1 0.06fF
C151 divider_0/tspc_0/Z4 gnd 0.44fF
C152 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Q 0.04fF
C153 pd_0/DOWN pd_0/UP 0.46fF
C154 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C155 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n1540# 0.19fF
C156 divbuf_0/a_22590_n840# divbuf_0/a_22590_n1540# 0.01fF
C157 divbuf_0/a_52830_n840# divbuf_0/a_53310_n840# 0.07fF
C158 divbuf_0/a_39360_n1600# divbuf_0/a_39840_n1600# 0.26fF
C159 divbuf_0/a_30232_n240# divbuf_0/a_30270_n840# 0.05fF
C160 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C161 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C162 divbuf_0/a_31710_n1540# divbuf_0/a_32190_n1540# 0.11fF
C163 divbuf_0/a_15672_170# divbuf_0/OUT4 0.19fF
C164 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n840# 0.04fF
C165 divbuf_0/a_6332_n240# divbuf_0/a_6822_n240# 0.04fF
C166 divbuf_0/a_26832_170# divbuf_0/a_26832_n240# 0.01fF
C167 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n1540# 0.19fF
C168 divbuf_0/a_15182_n240# divbuf_0/OUT4 0.04fF
C169 divbuf_0/a_18750_n840# divbuf_0/a_19230_n840# 0.07fF
C170 divbuf_0/a_13440_n1600# divbuf_0/OUT4 0.00fF
C171 divider_0/tspc_1/Z2 gnd 0.16fF
C172 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C173 divbuf_0/a_5280_n1600# divbuf_0/a_5760_n1600# 0.26fF
C174 divbuf_0/a_28350_n840# divbuf_0/a_28350_n1540# 0.01fF
C175 divbuf_0/a_58590_n840# divbuf_0/a_59070_n840# 0.07fF
C176 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n1540# 0.19fF
C177 divbuf_0/a_16152_n240# divbuf_0/a_15870_n840# 0.01fF
C178 divbuf_0/a_36052_n240# divbuf_0/a_36030_n840# 0.05fF
C179 divbuf_0/a_45120_n1600# divbuf_0/a_45600_n1600# 0.26fF
C180 divbuf_0/a_37470_n1540# divbuf_0/a_37950_n1540# 0.11fF
C181 divbuf_0/a_25862_170# divbuf_0/OUT4 0.19fF
C182 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n840# 0.04fF
C183 divbuf_0/a_12772_n240# divbuf_0/a_13252_n240# 0.05fF
C184 divbuf_0/a_32652_170# divbuf_0/a_32652_n240# 0.01fF
C185 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.35fF
C186 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C187 divbuf_0/a_24510_n840# divbuf_0/a_24990_n840# 0.07fF
C188 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n1540# 0.19fF
C189 divbuf_0/a_26832_n240# divbuf_0/OUT4 0.04fF
C190 divbuf_0/a_24960_n1600# divbuf_0/OUT4 0.00fF
C191 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C192 divider_0/prescaler_0/tspc_0/Q divider_0/prescaler_0/tspc_2/D 0.04fF
C193 cp_1/upbar cp_1/a_1710_n2840# 0.29fF
C194 divbuf_0/a_11040_n1600# divbuf_0/a_11520_n1600# 0.26fF
C195 divbuf_0/a_3390_n1540# divbuf_0/a_3870_n1540# 0.11fF
C196 divbuf_0/a_34110_n840# divbuf_0/a_34110_n1540# 0.01fF
C197 divbuf_0/a_960_n1600# divbuf_0/a_990_n840# 0.04fF
C198 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C199 divbuf_0/a_50880_n1600# divbuf_0/a_51360_n1600# 0.26fF
C200 divbuf_0/a_5362_170# divbuf_0/a_5362_n240# 0.01fF
C201 divbuf_0/a_19072_170# divbuf_0/a_19562_170# 0.07fF
C202 divbuf_0/a_43230_n1540# divbuf_0/a_43710_n1540# 0.11fF
C203 divbuf_0/a_19072_170# divbuf_0/a_19072_n240# 0.01fF
C204 divbuf_0/a_37502_170# divbuf_0/OUT4 0.19fF
C205 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n840# 0.04fF
C206 divbuf_0/a_18582_n240# divbuf_0/a_19072_n240# 0.04fF
C207 divbuf_0/a_38472_170# divbuf_0/a_38472_n240# 0.01fF
C208 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C209 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n1540# 0.19fF
C210 divbuf_0/a_38472_n240# divbuf_0/OUT4 0.04fF
C211 divbuf_0/a_30270_n840# divbuf_0/a_30750_n840# 0.07fF
C212 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C213 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C214 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C215 divbuf_0/a_36480_n1600# divbuf_0/OUT4 0.00fF
C216 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C217 divbuf_0/a_16800_n1600# divbuf_0/a_17280_n1600# 0.26fF
C218 divbuf_0/a_9150_n1540# divbuf_0/a_9630_n1540# 0.11fF
C219 divbuf_0/a_39870_n840# divbuf_0/a_39870_n1540# 0.01fF
C220 divbuf_0/a_7302_n240# divbuf_0/a_7230_n840# 0.03fF
C221 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n840# 0.04fF
C222 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C223 divbuf_0/a_23442_170# divbuf_0/a_23922_170# 0.07fF
C224 divbuf_0/a_56640_n1600# divbuf_0/a_57120_n1600# 0.26fF
C225 divbuf_0/a_48990_n1540# divbuf_0/a_49470_n1540# 0.11fF
C226 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n840# 0.04fF
C227 divbuf_0/a_9732_n240# divbuf_0/OUT3 0.04fF
C228 divbuf_0/a_24412_n240# divbuf_0/a_24892_n240# 0.05fF
C229 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C230 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C231 divbuf_0/a_5790_n840# divbuf_0/a_5790_n1540# 0.01fF
C232 divbuf_0/a_36030_n840# divbuf_0/a_36510_n840# 0.07fF
C233 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n1540# 0.19fF
C234 divbuf_0/a_8640_n1600# divbuf_0/OUT3 0.00fF
C235 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C236 divbuf_0/a_9732_170# divbuf_0/a_10212_170# 0.07fF
C237 divbuf_0/a_13252_n240# divbuf_0/a_13470_n840# 0.02fF
C238 divbuf_0/a_22560_n1600# divbuf_0/a_23040_n1600# 0.26fF
C239 divbuf_0/a_14910_n1540# divbuf_0/a_15390_n1540# 0.11fF
C240 divbuf_0/a_45630_n840# divbuf_0/a_45630_n1540# 0.01fF
C241 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n840# 0.04fF
C242 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C243 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C244 divbuf_0/a_20532_170# divbuf_0/OUT4 0.19fF
C245 divbuf_0/a_1950_n840# divbuf_0/a_2430_n840# 0.07fF
C246 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n1540# 0.19fF
C247 divbuf_0/a_29262_170# divbuf_0/a_29742_170# 0.07fF
C248 divbuf_0/a_54750_n1540# divbuf_0/a_55230_n1540# 0.11fF
C249 divbuf_0/a_21502_n240# divbuf_0/OUT4 0.04fF
C250 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n840# 0.04fF
C251 divbuf_0/a_30232_n240# divbuf_0/a_30712_n240# 0.05fF
C252 divider_0/tspc_1/Q divider_0/tspc_2/Z4 0.15fF
C253 divider_0/tspc_1/Z4 gnd 0.44fF
C254 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/Out 0.11fF
C255 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C256 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n1540# 0.19fF
C257 divbuf_0/a_19680_n1600# divbuf_0/OUT4 0.00fF
C258 divbuf_0/a_11550_n840# divbuf_0/a_11550_n1540# 0.01fF
C259 divbuf_0/a_41790_n840# divbuf_0/a_42270_n840# 0.07fF
C260 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C261 divbuf_0/a_28320_n1600# divbuf_0/a_28800_n1600# 0.26fF
C262 divbuf_0/a_20670_n1540# divbuf_0/a_21150_n1540# 0.11fF
C263 divbuf_0/a_51390_n840# divbuf_0/a_51390_n1540# 0.01fF
C264 divbuf_0/a_19072_n240# divbuf_0/a_19230_n840# 0.02fF
C265 divbuf_0/a_6822_170# divbuf_0/OUT3 0.19fF
C266 divbuf_0/a_2322_170# divbuf_0/a_2322_n240# 0.01fF
C267 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n840# 0.04fF
C268 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n1540# 0.19fF
C269 divbuf_0/a_35082_170# divbuf_0/a_35562_170# 0.07fF
C270 divbuf_0/a_32172_170# divbuf_0/OUT4 0.19fF
C271 divbuf_0/a_7710_n840# divbuf_0/a_8190_n840# 0.07fF
C272 divbuf_0/a_60510_n1540# divbuf_0/a_60990_n1540# 0.11fF
C273 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C274 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C275 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n840# 0.04fF
C276 divbuf_0/a_33142_n240# divbuf_0/OUT4 0.04fF
C277 divbuf_0/a_36052_n240# divbuf_0/a_36532_n240# 0.05fF
C278 gnd divider_0/tspc_2/Z3 0.27fF
C279 divbuf_0/a_17310_n840# divbuf_0/a_17310_n1540# 0.01fF
C280 divbuf_0/a_47550_n840# divbuf_0/a_48030_n840# 0.07fF
C281 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n1540# 0.19fF
C282 divbuf_0/a_31200_n1600# divbuf_0/OUT4 0.00fF
C283 divbuf_0/a_10590_n840# divbuf_0/OUT4 0.03fF
C284 divbuf_0/a_13252_170# divbuf_0/a_13742_170# 0.07fF
C285 divbuf_0/a_24892_n240# divbuf_0/a_24990_n840# 0.03fF
C286 divbuf_0/a_34080_n1600# divbuf_0/a_34560_n1600# 0.26fF
C287 divbuf_0/a_26430_n1540# divbuf_0/a_26910_n1540# 0.11fF
C288 divbuf_0/a_57150_n840# divbuf_0/a_57150_n1540# 0.01fF
C289 divbuf_0/a_3422_170# divbuf_0/a_3422_n240# 0.01fF
C290 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n840# 0.04fF
C291 divbuf_0/a_13470_n840# divbuf_0/a_13950_n840# 0.07fF
C292 divbuf_0/a_21502_170# divbuf_0/a_21502_n240# 0.01fF
C293 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n1540# 0.19fF
C294 divbuf_0/a_40902_170# divbuf_0/a_41382_170# 0.07fF
C295 divbuf_0/a_4392_n240# divbuf_0/OUT3 0.04fF
C296 divbuf_0/a_0_n1600# divbuf_0/a_480_n1600# 0.26fF
C297 pd_0/R pd_0/REF 0.61fF
C298 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C299 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n1540# 0.19fF
C300 divbuf_0/a_23070_n840# divbuf_0/a_23070_n1540# 0.01fF
C301 divbuf_0/a_53310_n840# divbuf_0/a_53790_n840# 0.07fF
C302 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C303 divbuf_0/a_39840_n1600# divbuf_0/a_40320_n1600# 0.26fF
C304 divbuf_0/a_32190_n1540# divbuf_0/a_32670_n1540# 0.11fF
C305 divbuf_0/a_30712_n240# divbuf_0/a_30750_n840# 0.05fF
C306 divbuf_0/a_16642_170# divbuf_0/OUT4 0.19fF
C307 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n840# 0.04fF
C308 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n1540# 0.19fF
C309 divbuf_0/a_16152_n240# divbuf_0/OUT4 0.04fF
C310 divbuf_0/a_6822_n240# divbuf_0/a_7302_n240# 0.05fF
C311 divbuf_0/a_19230_n840# divbuf_0/a_19710_n840# 0.07fF
C312 divbuf_0/a_27322_170# divbuf_0/a_27322_n240# 0.01fF
C313 divider_0/tspc_1/Q gnd 0.33fF
C314 divbuf_0/a_5760_n1600# divbuf_0/a_6240_n1600# 0.26fF
C315 divbuf_0/a_28830_n840# divbuf_0/a_28830_n1540# 0.01fF
C316 divbuf_0/a_59070_n840# divbuf_0/a_59550_n840# 0.07fF
C317 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n1540# 0.19fF
C318 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C319 divbuf_0/a_16642_n240# divbuf_0/a_16350_n840# 0.00fF
C320 divbuf_0/a_2322_170# divbuf_0/OUT2 0.19fF
C321 divbuf_0/a_36532_n240# divbuf_0/a_36510_n840# 0.05fF
C322 divbuf_0/a_45600_n1600# divbuf_0/a_46080_n1600# 0.26fF
C323 divbuf_0/a_37950_n1540# divbuf_0/a_38430_n1540# 0.11fF
C324 divbuf_0/a_26832_170# divbuf_0/OUT4 0.19fF
C325 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n840# 0.04fF
C326 divbuf_0/a_13252_n240# divbuf_0/a_13742_n240# 0.04fF
C327 divbuf_0/a_24990_n840# divbuf_0/a_25470_n840# 0.07fF
C328 divbuf_0/a_33142_170# divbuf_0/a_33142_n240# 0.01fF
C329 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n1540# 0.19fF
C330 divbuf_0/a_27802_n240# divbuf_0/OUT4 0.04fF
C331 divbuf_0/a_492_n240# divbuf_0/a_510_n840# 0.00fF
C332 divider_0/prescaler_0/tspc_0/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C333 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/Out 0.05fF
C334 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C335 divbuf_0/a_11520_n1600# divbuf_0/a_12000_n1600# 0.26fF
C336 cp_1/out cp_1/a_1710_0# 0.84fF
C337 divbuf_0/a_3870_n1540# divbuf_0/a_4350_n1540# 0.11fF
C338 divbuf_0/a_34590_n840# divbuf_0/a_34590_n1540# 0.01fF
C339 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n840# 0.04fF
C340 divbuf_0/a_5852_170# divbuf_0/a_5852_n240# 0.01fF
C341 divbuf_0/a_51360_n1600# divbuf_0/a_51840_n1600# 0.26fF
C342 divbuf_0/a_43710_n1540# divbuf_0/a_44190_n1540# 0.11fF
C343 divbuf_0/a_3422_170# divbuf_0/OUT3 0.23fF
C344 divbuf_0/a_19562_170# divbuf_0/a_19562_n240# 0.01fF
C345 divbuf_0/a_38472_170# divbuf_0/OUT4 0.19fF
C346 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n840# 0.04fF
C347 divbuf_0/a_510_n840# divbuf_0/a_510_n1540# 0.01fF
C348 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n1540# 0.19fF
C349 divbuf_0/a_39442_n240# divbuf_0/OUT4 0.04fF
C350 divbuf_0/a_19072_n240# divbuf_0/a_19562_n240# 0.04fF
C351 divbuf_0/a_30750_n840# divbuf_0/a_31230_n840# 0.07fF
C352 divbuf_0/a_38962_170# divbuf_0/a_38962_n240# 0.01fF
C353 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C354 divider_0/mc2 divider_0/nor_0/B 0.15fF
C355 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C356 io_clamp_high[2] io_analog[6] 0.53fF
C357 gnd divider_0/and_0/B 0.45fF
C358 divbuf_0/a_17280_n1600# divbuf_0/a_17760_n1600# 0.26fF
C359 divbuf_0/a_7792_n240# divbuf_0/a_7710_n840# 0.03fF
C360 divbuf_0/a_9630_n1540# divbuf_0/a_10110_n1540# 0.11fF
C361 divbuf_0/a_40350_n840# divbuf_0/a_40350_n1540# 0.01fF
C362 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n840# 0.04fF
C363 divbuf_0/a_23922_170# divbuf_0/a_24412_170# 0.07fF
C364 divbuf_0/a_1352_170# divbuf_0/a_1352_n240# 0.01fF
C365 divbuf_0/a_57120_n1600# divbuf_0/a_57600_n1600# 0.26fF
C366 divbuf_0/a_11312_170# divbuf_0/OUT4 0.23fF
C367 divbuf_0/a_49470_n1540# divbuf_0/a_49950_n1540# 0.11fF
C368 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n840# 0.04fF
C369 divbuf_0/a_10212_n240# divbuf_0/OUT4 0.04fF
C370 divbuf_0/a_24892_n240# divbuf_0/a_25382_n240# 0.04fF
C371 divbuf_0/a_6270_n840# divbuf_0/a_6270_n1540# 0.01fF
C372 divbuf_0/a_36510_n840# divbuf_0/a_36990_n840# 0.07fF
C373 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n1540# 0.19fF
C374 divbuf_0/a_9600_n1600# divbuf_0/OUT3 0.00fF
C375 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C376 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C377 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C378 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C379 divbuf_0/a_13742_n240# divbuf_0/a_13950_n840# 0.02fF
C380 divbuf_0/a_23040_n1600# divbuf_0/a_23520_n1600# 0.26fF
C381 divbuf_0/a_15390_n1540# divbuf_0/a_15870_n1540# 0.11fF
C382 divbuf_0/a_46110_n840# divbuf_0/a_46110_n1540# 0.01fF
C383 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n840# 0.04fF
C384 divbuf_0/a_29742_170# divbuf_0/a_30232_170# 0.07fF
C385 divbuf_0/a_55230_n1540# divbuf_0/a_55710_n1540# 0.11fF
C386 divbuf_0/a_21502_170# divbuf_0/OUT4 0.19fF
C387 divbuf_0/a_2430_n840# divbuf_0/a_2910_n840# 0.07fF
C388 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n1540# 0.19fF
C389 divbuf_0/a_22472_n240# divbuf_0/OUT4 0.04fF
C390 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n840# 0.04fF
C391 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C392 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n1540# 0.19fF
C393 divbuf_0/a_20640_n1600# divbuf_0/OUT4 0.00fF
C394 divbuf_0/a_30712_n240# divbuf_0/a_31202_n240# 0.04fF
C395 divbuf_0/a_12030_n840# divbuf_0/a_12030_n1540# 0.01fF
C396 divbuf_0/a_42270_n840# divbuf_0/a_42750_n840# 0.07fF
C397 divider_0/prescaler_0/tspc_1/Z4 divider_0/prescaler_0/Out 0.28fF
C398 divbuf_0/a_990_n840# divbuf_0/OUT2 0.02fF
C399 divbuf_0/a_28800_n1600# divbuf_0/a_29280_n1600# 0.26fF
C400 divbuf_0/a_19562_n240# divbuf_0/a_19710_n840# 0.03fF
C401 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C402 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C403 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C404 divbuf_0/a_21150_n1540# divbuf_0/a_21630_n1540# 0.11fF
C405 divbuf_0/a_51870_n840# divbuf_0/a_51870_n1540# 0.01fF
C406 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n840# 0.04fF
C407 divbuf_0/a_35562_170# divbuf_0/a_36052_170# 0.07fF
C408 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n1540# 0.19fF
C409 divbuf_0/a_33142_170# divbuf_0/OUT4 0.19fF
C410 divbuf_0/a_8190_n840# divbuf_0/a_8670_n840# 0.07fF
C411 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n840# 0.04fF
C412 divbuf_0/a_34112_n240# divbuf_0/OUT4 0.04fF
C413 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C414 divbuf_0/a_36532_n240# divbuf_0/a_37022_n240# 0.04fF
C415 divbuf_0/a_17790_n840# divbuf_0/a_17790_n1540# 0.01fF
C416 divbuf_0/a_48030_n840# divbuf_0/a_48510_n840# 0.07fF
C417 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n1540# 0.19fF
C418 divbuf_0/a_32160_n1600# divbuf_0/OUT4 0.00fF
C419 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C420 gnd divider_0/tspc_2/Z4 0.44fF
C421 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/Out 0.91fF
C422 divbuf_0/a_25382_n240# divbuf_0/a_25470_n840# 0.03fF
C423 divbuf_0/a_13742_170# divbuf_0/a_14222_170# 0.07fF
C424 divbuf_0/a_34560_n1600# divbuf_0/a_35040_n1600# 0.26fF
C425 divbuf_0/a_26910_n1540# divbuf_0/a_27390_n1540# 0.11fF
C426 divbuf_0/a_57630_n840# divbuf_0/a_57630_n1540# 0.01fF
C427 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n840# 0.04fF
C428 divbuf_0/a_21982_170# divbuf_0/a_21982_n240# 0.01fF
C429 divbuf_0/a_13950_n840# divbuf_0/a_14430_n840# 0.07fF
C430 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n1540# 0.19fF
C431 divbuf_0/a_5362_n240# divbuf_0/OUT3 0.04fF
C432 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C433 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C434 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C435 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n1540# 0.19fF
C436 divbuf_0/a_480_n1600# divbuf_0/a_960_n1600# 0.26fF
C437 divbuf_0/a_23550_n840# divbuf_0/a_23550_n1540# 0.01fF
C438 divbuf_0/a_53790_n840# divbuf_0/a_54270_n840# 0.07fF
C439 divider_0/prescaler_0/Out divider_0/tspc_0/Z3 0.45fF
C440 divbuf_0/a_11312_n240# divbuf_0/a_11070_n840# 0.02fF
C441 divbuf_0/a_40320_n1600# divbuf_0/a_40800_n1600# 0.26fF
C442 divbuf_0/a_31202_n240# divbuf_0/a_31230_n840# 0.05fF
C443 divbuf_0/a_32670_n1540# divbuf_0/a_33150_n1540# 0.11fF
C444 divbuf_0/a_17612_170# divbuf_0/OUT4 0.19fF
C445 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n840# 0.04fF
C446 divbuf_0/a_7302_n240# divbuf_0/a_7792_n240# 0.04fF
C447 divbuf_0/a_27802_170# divbuf_0/a_27802_n240# 0.01fF
C448 divider_0/mc2 divider_0/nor_1/B 0.06fF
C449 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n1540# 0.19fF
C450 divbuf_0/a_17122_n240# divbuf_0/OUT4 0.04fF
C451 divbuf_0/a_19710_n840# divbuf_0/a_20190_n840# 0.07fF
C452 divider_0/tspc_0/a_630_n680# gnd 0.62fF
C453 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C454 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C455 divbuf_0/a_6240_n1600# divbuf_0/a_6720_n1600# 0.26fF
C456 divbuf_0/a_29310_n840# divbuf_0/a_29310_n1540# 0.01fF
C457 divbuf_0/a_59550_n840# divbuf_0/a_60030_n840# 0.07fF
C458 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n1540# 0.19fF
C459 divbuf_0/a_17122_n240# divbuf_0/a_16830_n840# 0.00fF
C460 divbuf_0/a_37022_n240# divbuf_0/a_36990_n840# 0.05fF
C461 divbuf_0/a_46080_n1600# divbuf_0/a_46560_n1600# 0.26fF
C462 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C463 divbuf_0/a_38430_n1540# divbuf_0/a_38910_n1540# 0.11fF
C464 divbuf_0/a_27802_170# divbuf_0/OUT4 0.19fF
C465 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n840# 0.04fF
C466 divbuf_0/a_13742_n240# divbuf_0/a_14222_n240# 0.05fF
C467 divbuf_0/a_33622_170# divbuf_0/a_33622_n240# 0.01fF
C468 divbuf_0/a_25470_n840# divbuf_0/a_25950_n840# 0.07fF
C469 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n1540# 0.19fF
C470 divbuf_0/a_28772_n240# divbuf_0/OUT4 0.04fF
C471 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_1/z1 0.21fF
C472 divbuf_0/a_12000_n1600# divbuf_0/a_12480_n1600# 0.26fF
C473 divbuf_0/a_4350_n1540# divbuf_0/a_4830_n1540# 0.11fF
C474 divbuf_0/a_35070_n840# divbuf_0/a_35070_n1540# 0.01fF
C475 divbuf_0/a_9242_170# divbuf_0/a_8762_170# 0.07fF
C476 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C477 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n840# 0.04fF
C478 divbuf_0/a_9242_170# divbuf_0/a_9242_n240# 0.01fF
C479 divbuf_0/a_51840_n1600# divbuf_0/a_52320_n1600# 0.26fF
C480 divbuf_0/a_44190_n1540# divbuf_0/a_44670_n1540# 0.11fF
C481 divbuf_0/a_39442_170# divbuf_0/OUT4 0.19fF
C482 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n840# 0.04fF
C483 divbuf_0/a_19562_n240# divbuf_0/a_20042_n240# 0.05fF
C484 divbuf_0/a_39442_170# divbuf_0/a_39442_n240# 0.01fF
C485 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n1540# 0.19fF
C486 divbuf_0/a_40412_n240# divbuf_0/OUT4 0.04fF
C487 divbuf_0/a_990_n840# divbuf_0/a_990_n1540# 0.01fF
C488 divbuf_0/a_31230_n840# divbuf_0/a_31710_n840# 0.07fF
C489 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C490 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C491 io_clamp_low[1] io_analog[5] 0.53fF
C492 divbuf_0/a_17760_n1600# divbuf_0/a_18240_n1600# 0.26fF
C493 divbuf_0/a_10110_n1540# divbuf_0/a_10590_n1540# 0.11fF
C494 divbuf_0/a_40830_n840# divbuf_0/a_40830_n1540# 0.01fF
C495 divbuf_0/a_8272_n240# divbuf_0/a_8190_n840# 0.03fF
C496 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n840# 0.04fF
C497 divbuf_0/a_24412_170# divbuf_0/a_24892_170# 0.07fF
C498 divbuf_0/a_57600_n1600# divbuf_0/a_58080_n1600# 0.26fF
C499 divbuf_0/a_12282_170# divbuf_0/OUT4 0.19fF
C500 divbuf_0/a_49950_n1540# divbuf_0/a_50430_n1540# 0.11fF
C501 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n840# 0.04fF
C502 divbuf_0/a_11802_n240# divbuf_0/OUT4 0.04fF
C503 divbuf_0/a_25382_n240# divbuf_0/a_25862_n240# 0.05fF
C504 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C505 divider_0/nor_1/Z1 divider_0/and_0/A 0.80fF
C506 divbuf_0/a_6750_n840# divbuf_0/a_6750_n1540# 0.01fF
C507 divbuf_0/a_36990_n840# divbuf_0/a_37470_n840# 0.07fF
C508 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n1540# 0.19fF
C509 divbuf_0/a_10560_n1600# divbuf_0/OUT3 0.01fF
C510 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C511 divbuf_0/a_14222_n240# divbuf_0/a_14430_n840# 0.02fF
C512 divbuf_0/a_23520_n1600# divbuf_0/a_24000_n1600# 0.26fF
C513 divbuf_0/a_15870_n1540# divbuf_0/a_16350_n1540# 0.11fF
C514 divbuf_0/a_46590_n840# divbuf_0/a_46590_n1540# 0.01fF
C515 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n840# 0.04fF
C516 divbuf_0/a_22472_170# divbuf_0/OUT4 0.19fF
C517 divbuf_0/a_2910_n840# divbuf_0/a_3390_n840# 0.07fF
C518 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n1540# 0.19fF
C519 divbuf_0/a_30232_170# divbuf_0/a_30712_170# 0.07fF
C520 divbuf_0/a_55710_n1540# divbuf_0/a_56190_n1540# 0.11fF
C521 divbuf_0/a_23442_n240# divbuf_0/OUT4 0.04fF
C522 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n840# 0.04fF
C523 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C524 divbuf_0/a_31202_n240# divbuf_0/a_31682_n240# 0.05fF
C525 divider_0/and_0/OUT gnd 0.28fF
C526 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n1540# 0.19fF
C527 divbuf_0/a_21600_n1600# divbuf_0/OUT4 0.01fF
C528 divbuf_0/a_12510_n840# divbuf_0/a_12510_n1540# 0.01fF
C529 divbuf_0/a_42750_n840# divbuf_0/a_43230_n840# 0.07fF
C530 divbuf_0/a_21630_n1540# divbuf_0/a_22110_n1540# 0.11fF
C531 divbuf_0/a_52350_n840# divbuf_0/a_52350_n1540# 0.01fF
C532 divbuf_0/a_20042_n240# divbuf_0/a_20190_n840# 0.03fF
C533 divbuf_0/a_29280_n1600# divbuf_0/a_29760_n1600# 0.26fF
C534 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C535 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n840# 0.04fF
C536 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n1540# 0.19fF
C537 divbuf_0/a_36052_170# divbuf_0/a_36532_170# 0.07fF
C538 divbuf_0/a_34112_170# divbuf_0/OUT4 0.19fF
C539 divbuf_0/a_8670_n840# divbuf_0/a_9150_n840# 0.07fF
C540 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n840# 0.04fF
C541 divbuf_0/a_35082_n240# divbuf_0/OUT4 0.04fF
C542 divider_0/tspc_0/Q divider_0/nor_1/A 0.55fF
C543 divbuf_0/a_37022_n240# divbuf_0/a_37502_n240# 0.05fF
C544 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C545 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C546 divider_0/nor_0/B divider_0/tspc_2/Z1 0.03fF
C547 divbuf_0/a_18270_n840# divbuf_0/a_18270_n1540# 0.01fF
C548 divbuf_0/a_48510_n840# divbuf_0/a_48990_n840# 0.07fF
C549 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n1540# 0.19fF
C550 divbuf_0/a_33120_n1600# divbuf_0/OUT4 0.01fF
C551 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C552 divbuf_0/a_25862_n240# divbuf_0/a_25950_n840# 0.03fF
C553 divbuf_0/a_35040_n1600# divbuf_0/a_35520_n1600# 0.26fF
C554 divbuf_0/a_27390_n1540# divbuf_0/a_27870_n1540# 0.11fF
C555 divbuf_0/a_58110_n840# divbuf_0/a_58110_n1540# 0.01fF
C556 divbuf_0/a_1352_170# divbuf_0/OUT2 0.23fF
C557 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n840# 0.04fF
C558 divbuf_0/a_14430_n840# divbuf_0/a_14910_n840# 0.07fF
C559 divbuf_0/a_1352_n240# divbuf_0/a_1842_n240# 0.04fF
C560 divbuf_0/a_22472_170# divbuf_0/a_22472_n240# 0.01fF
C561 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n1540# 0.19fF
C562 divbuf_0/a_6332_n240# divbuf_0/OUT3 0.04fF
C563 divider_0/mc2 divider_0/and_0/A 0.16fF
C564 divbuf_0/a_960_n1600# divbuf_0/a_1440_n1600# 0.26fF
C565 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C566 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C567 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n1540# 0.19fF
C568 divbuf_0/a_24030_n840# divbuf_0/a_24030_n1540# 0.01fF
C569 divbuf_0/a_54270_n840# divbuf_0/a_54750_n840# 0.07fF
C570 divbuf_0/a_11802_n240# divbuf_0/a_11550_n840# 0.02fF
C571 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C572 divbuf_0/a_33150_n1540# divbuf_0/a_33630_n1540# 0.11fF
C573 divbuf_0/a_31682_n240# divbuf_0/a_31710_n840# 0.05fF
C574 divbuf_0/a_40800_n1600# divbuf_0/a_41280_n1600# 0.26fF
C575 divbuf_0/a_7792_170# divbuf_0/a_7792_n240# 0.01fF
C576 divbuf_0/a_18582_170# divbuf_0/OUT4 0.19fF
C577 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n840# 0.04fF
C578 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n1540# 0.19fF
C579 divbuf_0/a_18092_n240# divbuf_0/OUT4 0.04fF
C580 divbuf_0/a_7792_n240# divbuf_0/a_8272_n240# 0.05fF
C581 divbuf_0/a_20190_n840# divbuf_0/a_20670_n840# 0.07fF
C582 divbuf_0/a_28292_170# divbuf_0/a_28292_n240# 0.01fF
C583 divider_0/nor_1/A divider_0/prescaler_0/tspc_1/Q 0.03fF
C584 divider_0/tspc_1/Q divider_0/tspc_2/a_630_n680# 0.01fF
C585 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/Out 0.11fF
C586 divbuf_0/a_6720_n1600# divbuf_0/a_7200_n1600# 0.26fF
C587 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C588 divbuf_0/a_29790_n840# divbuf_0/a_29790_n1540# 0.01fF
C589 divbuf_0/a_60030_n840# divbuf_0/a_60510_n840# 0.07fF
C590 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n1540# 0.19fF
C591 divbuf_0/a_17612_n240# divbuf_0/a_17310_n840# 0.00fF
C592 divbuf_0/a_14702_170# divbuf_0/a_15182_170# 0.07fF
C593 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C594 divbuf_0/a_37502_n240# divbuf_0/a_37470_n840# 0.05fF
C595 divbuf_0/a_46560_n1600# divbuf_0/a_47040_n1600# 0.26fF
C596 divbuf_0/a_38910_n1540# divbuf_0/a_39390_n1540# 0.11fF
C597 divbuf_0/a_9732_170# divbuf_0/OUT3 0.19fF
C598 divbuf_0/a_14702_170# divbuf_0/a_14702_n240# 0.01fF
C599 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n840# 0.04fF
C600 divbuf_0/a_28772_170# divbuf_0/OUT4 0.19fF
C601 divbuf_0/a_14222_n240# divbuf_0/a_14702_n240# 0.05fF
C602 divbuf_0/a_25950_n840# divbuf_0/a_26430_n840# 0.07fF
C603 divbuf_0/a_34112_170# divbuf_0/a_34112_n240# 0.01fF
C604 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n1540# 0.19fF
C605 divbuf_0/a_29742_n240# divbuf_0/OUT4 0.04fF
C606 divider_0/tspc_0/Q divider_0/tspc_1/Z2 0.14fF
C607 divider_0/nor_1/A divider_0/tspc_0/Z3 0.38fF
C608 divbuf_0/a_12480_n1600# divbuf_0/a_12960_n1600# 0.26fF
C609 divbuf_0/a_4830_n1540# divbuf_0/a_5310_n1540# 0.11fF
C610 divbuf_0/a_35550_n840# divbuf_0/a_35550_n1540# 0.01fF
C611 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n840# 0.04fF
C612 divbuf_0/a_9732_170# divbuf_0/a_9732_n240# 0.01fF
C613 divbuf_0/a_3912_170# divbuf_0/a_3912_n240# 0.01fF
C614 divbuf_0/a_44670_n1540# divbuf_0/a_45150_n1540# 0.11fF
C615 divbuf_0/a_12772_170# divbuf_0/OUT4 0.19fF
C616 divbuf_0/a_52320_n1600# divbuf_0/a_52800_n1600# 0.26fF
C617 divbuf_0/a_40412_170# divbuf_0/OUT4 0.19fF
C618 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n840# 0.04fF
C619 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n1540# 0.19fF
C620 divbuf_0/a_41382_n240# divbuf_0/OUT4 0.04fF
C621 divbuf_0/a_20042_n240# divbuf_0/a_20532_n240# 0.04fF
C622 divbuf_0/a_1470_n840# divbuf_0/a_1470_n1540# 0.01fF
C623 divbuf_0/a_31710_n840# divbuf_0/a_32190_n840# 0.07fF
C624 divbuf_0/a_39932_170# divbuf_0/a_39932_n240# 0.01fF
C625 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C626 divider_0/nor_1/B divider_0/nor_1/A 1.21fF
C627 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C628 divbuf_0/a_8762_n240# divbuf_0/a_8670_n840# 0.03fF
C629 divbuf_0/a_18240_n1600# divbuf_0/a_18720_n1600# 0.26fF
C630 divbuf_0/a_10590_n1540# divbuf_0/a_11070_n1540# 0.11fF
C631 divbuf_0/a_41310_n840# divbuf_0/a_41310_n1540# 0.01fF
C632 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n840# 0.04fF
C633 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C634 divbuf_0/a_24892_170# divbuf_0/a_25382_170# 0.07fF
C635 divbuf_0/a_58080_n1600# divbuf_0/a_58560_n1600# 0.26fF
C636 divbuf_0/a_50430_n1540# divbuf_0/a_50910_n1540# 0.11fF
C637 divider_0/mc2 divider_0/prescaler_0/tspc_0/a_630_n680# 0.33fF
C638 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n840# 0.04fF
C639 divbuf_0/a_12772_n240# divbuf_0/OUT4 0.04fF
C640 divbuf_0/a_7230_n840# divbuf_0/a_7230_n1540# 0.01fF
C641 divbuf_0/a_37470_n840# divbuf_0/a_37950_n840# 0.07fF
C642 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n1540# 0.19fF
C643 divbuf_0/a_11040_n1600# divbuf_0/OUT4 0.00fF
C644 divbuf_0/a_25862_n240# divbuf_0/a_26352_n240# 0.04fF
C645 divider_0/tspc_0/Z4 divider_0/tspc_0/Z3 0.65fF
C646 cp_0/a_1710_0# io_analog[0] 0.84fF
C647 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C648 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C649 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C650 divbuf_0/a_5362_170# divbuf_0/a_5852_170# 0.07fF
C651 divbuf_0/a_14702_n240# divbuf_0/a_14910_n840# 0.02fF
C652 divbuf_0/a_24000_n1600# divbuf_0/a_24480_n1600# 0.26fF
C653 divbuf_0/a_16350_n1540# divbuf_0/a_16830_n1540# 0.11fF
C654 divbuf_0/a_47070_n840# divbuf_0/a_47070_n1540# 0.01fF
C655 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n840# 0.04fF
C656 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C657 divbuf_0/a_30712_170# divbuf_0/a_31202_170# 0.07fF
C658 divbuf_0/a_56190_n1540# divbuf_0/a_56670_n1540# 0.11fF
C659 divbuf_0/a_23442_170# divbuf_0/OUT4 0.19fF
C660 divbuf_0/a_3390_n840# divbuf_0/a_3870_n840# 0.07fF
C661 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n1540# 0.19fF
C662 divider_0/tspc_0/Q divider_0/tspc_1/Z1 0.01fF
C663 divbuf_0/a_24412_n240# divbuf_0/OUT4 0.04fF
C664 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n840# 0.04fF
C665 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n1540# 0.19fF
C666 divbuf_0/a_22560_n1600# divbuf_0/OUT4 0.01fF
C667 divbuf_0/a_31682_n240# divbuf_0/a_32172_n240# 0.04fF
C668 divbuf_0/a_12990_n840# divbuf_0/a_12990_n1540# 0.01fF
C669 divbuf_0/a_43230_n840# divbuf_0/a_43710_n840# 0.07fF
C670 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C671 divider_0/prescaler_0/tspc_0/D gnd 0.05fF
C672 divbuf_0/a_20532_n240# divbuf_0/a_20670_n840# 0.03fF
C673 divbuf_0/a_29760_n1600# divbuf_0/a_30240_n1600# 0.26fF
C674 divbuf_0/a_22110_n1540# divbuf_0/a_22590_n1540# 0.11fF
C675 divbuf_0/a_52830_n840# divbuf_0/a_52830_n1540# 0.01fF
C676 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n840# 0.04fF
C677 divbuf_0/a_36532_170# divbuf_0/a_37022_170# 0.07fF
C678 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n1540# 0.19fF
C679 divbuf_0/a_35082_170# divbuf_0/OUT4 0.19fF
C680 divbuf_0/a_9150_n840# divbuf_0/a_9630_n840# 0.07fF
C681 divider_0/tspc_0/Q divider_0/tspc_1/Z4 0.15fF
C682 divider_0/nor_1/B divider_0/tspc_1/Z2 0.30fF
C683 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C684 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n840# 0.04fF
C685 divbuf_0/a_36052_n240# divbuf_0/OUT4 0.04fF
C686 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C687 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C688 divbuf_0/a_18750_n840# divbuf_0/a_18750_n1540# 0.01fF
C689 divbuf_0/a_48990_n840# divbuf_0/a_49470_n840# 0.07fF
C690 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n1540# 0.19fF
C691 divbuf_0/a_34080_n1600# divbuf_0/OUT4 0.01fF
C692 divbuf_0/a_37502_n240# divbuf_0/a_37992_n240# 0.04fF
C693 gnd divider_0/and_0/out1 0.23fF
C694 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C695 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C696 divider_0/nor_0/B divider_0/tspc_2/Z3 0.38fF
C697 cp_1/a_1710_0# cp_1/down 0.32fF
C698 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C699 divbuf_0/a_26352_n240# divbuf_0/a_26430_n840# 0.04fF
C700 divbuf_0/a_35520_n1600# divbuf_0/a_36000_n1600# 0.26fF
C701 divbuf_0/a_27870_n1540# divbuf_0/a_28350_n1540# 0.11fF
C702 divbuf_0/a_58590_n840# divbuf_0/a_58590_n1540# 0.01fF
C703 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n840# 0.04fF
C704 divbuf_0/a_22952_170# divbuf_0/a_22952_n240# 0.01fF
C705 divbuf_0/a_492_n240# divbuf_0/a_960_n1600# 0.00fF
C706 divbuf_0/a_1842_n240# divbuf_0/a_2322_n240# 0.05fF
C707 divbuf_0/a_14910_n840# divbuf_0/a_15390_n840# 0.07fF
C708 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n1540# 0.19fF
C709 divbuf_0/a_7302_n240# divbuf_0/OUT3 0.04fF
C710 divider_0/prescaler_0/tspc_0/Z3 gnd 0.27fF
C711 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C712 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n1540# 0.19fF
C713 divbuf_0/a_1440_n1600# divbuf_0/a_1920_n1600# 0.26fF
C714 divbuf_0/a_24510_n840# divbuf_0/a_24510_n1540# 0.01fF
C715 divbuf_0/a_54750_n840# divbuf_0/a_55230_n840# 0.07fF
C716 io_clamp_low[2] io_clamp_high[2] 0.53fF
C717 divbuf_0/a_12282_n240# divbuf_0/a_12030_n840# 0.02fF
C718 divbuf_0/a_7792_170# divbuf_0/a_8272_170# 0.07fF
C719 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C720 divbuf_0/a_32172_n240# divbuf_0/a_32190_n840# 0.06fF
C721 divbuf_0/a_41280_n1600# divbuf_0/a_41760_n1600# 0.26fF
C722 divbuf_0/a_33630_n1540# divbuf_0/a_34110_n1540# 0.11fF
C723 divbuf_0/a_1842_170# divbuf_0/OUT2 0.19fF
C724 divbuf_0/a_19562_170# divbuf_0/OUT4 0.19fF
C725 divbuf_0/a_8272_170# divbuf_0/a_8272_n240# 0.01fF
C726 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n840# 0.04fF
C727 divbuf_0/a_8272_n240# divbuf_0/a_8762_n240# 0.04fF
C728 divbuf_0/a_28772_170# divbuf_0/a_28772_n240# 0.01fF
C729 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n1540# 0.19fF
C730 divbuf_0/a_19072_n240# divbuf_0/OUT4 0.04fF
C731 divbuf_0/a_20670_n840# divbuf_0/a_21150_n840# 0.07fF
C732 divider_0/tspc_1/Q divider_0/nor_0/B 0.22fF
C733 divider_0/and_0/OUT divider_0/prescaler_0/tspc_0/D 0.03fF
C734 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C735 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C736 divbuf_0/a_30270_n840# divbuf_0/a_30270_n1540# 0.01fF
C737 divbuf_0/a_60510_n840# divbuf_0/a_60990_n840# 0.07fF
C738 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n1540# 0.19fF
C739 divbuf_0/a_7200_n1600# divbuf_0/a_7680_n1600# 0.26fF
C740 divbuf_0/a_18092_n240# divbuf_0/a_17790_n840# 0.00fF
C741 divbuf_0/a_15182_170# divbuf_0/a_15672_170# 0.07fF
C742 divbuf_0/a_37992_n240# divbuf_0/a_37950_n840# 0.04fF
C743 divbuf_0/a_47040_n1600# divbuf_0/a_47520_n1600# 0.26fF
C744 divbuf_0/a_10212_170# divbuf_0/OUT4 0.07fF
C745 divbuf_0/a_39390_n1540# divbuf_0/a_39870_n1540# 0.11fF
C746 divbuf_0/a_15182_170# divbuf_0/a_15182_n240# 0.01fF
C747 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n840# 0.04fF
C748 divbuf_0/a_29742_170# divbuf_0/OUT4 0.19fF
C749 divbuf_0/a_34592_170# divbuf_0/a_34592_n240# 0.01fF
C750 divbuf_0/a_14702_n240# divbuf_0/a_15182_n240# 0.05fF
C751 divider_0/nor_1/B divider_0/tspc_1/Z1 0.03fF
C752 divbuf_0/a_26430_n840# divbuf_0/a_26910_n840# 0.07fF
C753 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n1540# 0.19fF
C754 divbuf_0/a_30712_n240# divbuf_0/OUT4 0.04fF
C755 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C756 gnd divider_0/tspc_2/a_630_n680# 0.61fF
C757 divider_0/nor_1/A divider_0/and_0/A 0.01fF
C758 divbuf_0/a_3422_n240# divbuf_0/a_3390_n840# 0.05fF
C759 divbuf_0/a_12960_n1600# divbuf_0/a_13440_n1600# 0.26fF
C760 divbuf_0/a_5310_n1540# divbuf_0/a_5790_n1540# 0.11fF
C761 divbuf_0/a_36030_n840# divbuf_0/a_36030_n1540# 0.01fF
C762 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C763 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C764 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C765 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n840# 0.04fF
C766 divbuf_0/a_10212_170# divbuf_0/a_10212_n240# 0.01fF
C767 divbuf_0/a_13742_170# divbuf_0/OUT4 0.19fF
C768 divbuf_0/a_52800_n1600# divbuf_0/a_53280_n1600# 0.26fF
C769 divbuf_0/a_45150_n1540# divbuf_0/a_45630_n1540# 0.11fF
C770 divbuf_0/a_1842_n240# divbuf_0/OUT2 0.04fF
C771 divbuf_0/a_41382_170# divbuf_0/OUT4 0.19fF
C772 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n840# 0.04fF
C773 divbuf_0/a_20532_n240# divbuf_0/a_21012_n240# 0.05fF
C774 divbuf_0/a_40412_170# divbuf_0/a_40412_n240# 0.01fF
C775 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_1/A 0.01fF
C776 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C777 divider_0/nor_1/B divider_0/tspc_1/Z4 0.21fF
C778 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.15fF
C779 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n1540# 0.19fF
C780 divbuf_0/a_1440_n1600# divbuf_0/OUT2 0.01fF
C781 divbuf_0/a_1950_n840# divbuf_0/a_1950_n1540# 0.01fF
C782 divbuf_0/a_32190_n840# divbuf_0/a_32670_n840# 0.07fF
C783 io_clamp_high[0] io_analog[4] 0.53fF
C784 divider_0/nor_0/B divider_0/and_0/B 0.29fF
C785 divbuf_0/a_9242_n240# divbuf_0/a_9150_n840# 0.03fF
C786 divbuf_0/a_18720_n1600# divbuf_0/a_19200_n1600# 0.26fF
C787 filter_0/a_4216_n2998# filter_0/v 0.31fF
C788 divbuf_0/a_11070_n1540# divbuf_0/a_11550_n1540# 0.11fF
C789 divbuf_0/a_41790_n840# divbuf_0/a_41790_n1540# 0.01fF
C790 divbuf_0/a_12772_170# divbuf_0/a_12282_170# 0.07fF
C791 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C792 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C793 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n840# 0.04fF
C794 divbuf_0/a_25382_170# divbuf_0/a_25862_170# 0.07fF
C795 divbuf_0/a_58560_n1600# divbuf_0/a_59040_n1600# 0.26fF
C796 divbuf_0/a_50910_n1540# divbuf_0/a_51390_n1540# 0.11fF
C797 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n840# 0.04fF
C798 divbuf_0/a_13742_n240# divbuf_0/OUT4 0.04fF
C799 divbuf_0/a_26352_n240# divbuf_0/a_26832_n240# 0.05fF
C800 divider_0/prescaler_0/tspc_1/Z3 gnd 0.27fF
C801 divbuf_0/a_7710_n840# divbuf_0/a_7710_n1540# 0.01fF
C802 divbuf_0/a_37950_n840# divbuf_0/a_38430_n840# 0.07fF
C803 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n1540# 0.19fF
C804 divbuf_0/a_12000_n1600# divbuf_0/OUT4 0.00fF
C805 cp_0/a_1710_0# io_analog[1] 0.32fF
C806 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C807 divbuf_0/a_15182_n240# divbuf_0/a_15390_n840# 0.02fF
C808 divbuf_0/a_24480_n1600# divbuf_0/a_24960_n1600# 0.26fF
C809 divbuf_0/a_16830_n1540# divbuf_0/a_17310_n1540# 0.11fF
C810 divbuf_0/a_47550_n840# divbuf_0/a_47550_n1540# 0.01fF
C811 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n840# 0.04fF
C812 divbuf_0/a_31202_170# divbuf_0/a_31682_170# 0.07fF
C813 divbuf_0/a_24412_170# divbuf_0/OUT4 0.19fF
C814 divbuf_0/a_3870_n840# divbuf_0/a_4350_n840# 0.07fF
C815 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n1540# 0.19fF
C816 divbuf_0/a_56670_n1540# divbuf_0/a_57150_n1540# 0.11fF
C817 divbuf_0/a_25382_n240# divbuf_0/OUT4 0.04fF
C818 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n840# 0.04fF
C819 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C820 divbuf_0/a_32172_n240# divbuf_0/a_32652_n240# 0.05fF
C821 divider_0/prescaler_0/nand_0/z1 gnd 0.16fF
C822 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C823 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n1540# 0.19fF
C824 divbuf_0/a_23520_n1600# divbuf_0/OUT4 0.00fF
C825 divbuf_0/a_13470_n840# divbuf_0/a_13470_n1540# 0.01fF
C826 divbuf_0/a_43710_n840# divbuf_0/a_44190_n840# 0.07fF
C827 divbuf_0/a_21012_n240# divbuf_0/a_21150_n840# 0.03fF
C828 divbuf_0/a_30240_n1600# divbuf_0/a_30720_n1600# 0.26fF
C829 divbuf_0/a_22590_n1540# divbuf_0/a_23070_n1540# 0.11fF
C830 divbuf_0/a_53310_n840# divbuf_0/a_53310_n1540# 0.01fF
C831 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n840# 0.04fF
C832 divbuf_0/a_37022_170# divbuf_0/a_37502_170# 0.07fF
C833 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n1540# 0.19fF
C834 divbuf_0/a_36052_170# divbuf_0/OUT4 0.19fF
C835 divbuf_0/a_9630_n840# divbuf_0/a_10110_n840# 0.07fF
C836 divbuf_0/a_60990_n1540# divbuf_0/OUT5 0.19fF
C837 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n840# 0.04fF
C838 divbuf_0/a_37022_n240# divbuf_0/OUT4 0.04fF
C839 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C840 divider_0/nor_1/B divider_0/tspc_1/Q 0.51fF
C841 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C842 divbuf_0/a_37992_n240# divbuf_0/a_38472_n240# 0.05fF
C843 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C844 divider_0/nor_0/B divider_0/tspc_2/Z4 0.22fF
C845 gnd divider_0/clk 0.07fF
C846 divbuf_0/a_19230_n840# divbuf_0/a_19230_n1540# 0.01fF
C847 divbuf_0/a_49470_n840# divbuf_0/a_49950_n840# 0.07fF
C848 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n1540# 0.19fF
C849 divbuf_0/a_35040_n1600# divbuf_0/OUT4 0.00fF
C850 divbuf_0/a_26832_n240# divbuf_0/a_26910_n840# 0.04fF
C851 divbuf_0/a_36000_n1600# divbuf_0/a_36480_n1600# 0.26fF
C852 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C853 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C854 divbuf_0/a_28350_n1540# divbuf_0/a_28830_n1540# 0.11fF
C855 divbuf_0/a_59070_n840# divbuf_0/a_59070_n1540# 0.01fF
C856 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n840# 0.04fF
C857 divbuf_0/a_7792_170# divbuf_0/OUT3 0.19fF
C858 divbuf_0/a_23442_170# divbuf_0/a_23442_n240# 0.01fF
C859 divbuf_0/a_15390_n840# divbuf_0/a_15870_n840# 0.07fF
C860 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n1540# 0.19fF
C861 divbuf_0/a_8272_n240# divbuf_0/OUT3 0.04fF
C862 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C863 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C864 divider_0/prescaler_0/tspc_0/Z4 gnd 0.44fF
C865 divider_0/nor_0/Z1 divider_0/and_0/B 0.78fF
C866 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C867 divbuf_0/a_1920_n1600# divbuf_0/a_2400_n1600# 0.26fF
C868 divbuf_0/a_24990_n840# divbuf_0/a_24990_n1540# 0.01fF
C869 divbuf_0/a_55230_n840# divbuf_0/a_55710_n840# 0.07fF
C870 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n1540# 0.19fF
C871 divbuf_0/a_12772_n240# divbuf_0/a_12510_n840# 0.01fF
C872 divbuf_0/a_32652_n240# divbuf_0/a_32670_n840# 0.06fF
C873 divbuf_0/a_8272_170# divbuf_0/a_8762_170# 0.07fF
C874 divbuf_0/a_41760_n1600# divbuf_0/a_42240_n1600# 0.26fF
C875 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C876 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C877 divbuf_0/a_34110_n1540# divbuf_0/a_34590_n1540# 0.11fF
C878 divbuf_0/a_8762_170# divbuf_0/a_8762_n240# 0.01fF
C879 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n840# 0.04fF
C880 divbuf_0/a_8762_n240# divbuf_0/a_9242_n240# 0.05fF
C881 divbuf_0/a_29262_170# divbuf_0/a_29262_n240# 0.01fF
C882 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n1540# 0.19fF
C883 divbuf_0/a_20042_n240# divbuf_0/OUT4 0.04fF
C884 divbuf_0/a_21150_n840# divbuf_0/a_21630_n840# 0.07fF
C885 divider_0/nor_1/B divider_0/and_0/B 0.31fF
C886 divider_0/tspc_1/Q divider_0/tspc_2/Z2 0.14fF
C887 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C888 divider_0/prescaler_0/tspc_2/Z3 gnd 0.27fF
C889 divbuf_0/a_7680_n1600# divbuf_0/a_8160_n1600# 0.26fF
C890 divbuf_0/a_30750_n840# divbuf_0/a_30750_n1540# 0.01fF
C891 divbuf_0/a_38472_n240# divbuf_0/a_38430_n840# 0.04fF
C892 divbuf_0/a_15672_170# divbuf_0/a_16152_170# 0.07fF
C893 divbuf_0/a_47520_n1600# divbuf_0/a_48000_n1600# 0.26fF
C894 divbuf_0/a_5852_170# divbuf_0/OUT3 0.19fF
C895 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C896 divbuf_0/a_39870_n1540# divbuf_0/a_40350_n1540# 0.11fF
C897 divbuf_0/a_15672_170# divbuf_0/a_15672_n240# 0.01fF
C898 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n840# 0.04fF
C899 divbuf_0/a_30712_170# divbuf_0/OUT4 0.19fF
C900 divbuf_0/a_35082_170# divbuf_0/a_35082_n240# 0.01fF
C901 divbuf_0/a_15182_n240# divbuf_0/a_15672_n240# 0.04fF
C902 divbuf_0/a_26910_n840# divbuf_0/a_27390_n840# 0.07fF
C903 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n1540# 0.19fF
C904 divbuf_0/a_31682_n240# divbuf_0/OUT4 0.04fF
C905 divider_0/tspc_0/Q divider_0/tspc_0/a_630_n680# 0.04fF
C906 divider_0/and_0/OUT divider_0/clk 0.04fF
C907 gnd divider_0/nor_0/B 1.08fF
C908 divbuf_0/a_3912_n240# divbuf_0/a_3870_n840# 0.04fF
C909 divbuf_0/a_13440_n1600# divbuf_0/a_13920_n1600# 0.26fF
C910 divbuf_0/a_5790_n1540# divbuf_0/a_6270_n1540# 0.11fF
C911 divbuf_0/a_36510_n840# divbuf_0/a_36510_n1540# 0.01fF
C912 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n840# 0.04fF
C913 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C914 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C915 divbuf_0/a_20042_170# divbuf_0/a_20532_170# 0.07fF
C916 divbuf_0/a_53280_n1600# divbuf_0/a_53760_n1600# 0.26fF
C917 divbuf_0/a_45630_n1540# divbuf_0/a_46110_n1540# 0.11fF
C918 divbuf_0/a_2322_n240# divbuf_0/OUT3 0.04fF
C919 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n840# 0.04fF
C920 divbuf_0/a_21012_n240# divbuf_0/a_21502_n240# 0.04fF
C921 divbuf_0/a_40902_170# divbuf_0/a_40902_n240# 0.01fF
C922 divbuf_0/a_2400_n1600# divbuf_0/OUT2 0.00fF
C923 divbuf_0/a_2430_n840# divbuf_0/a_2430_n1540# 0.01fF
C924 divbuf_0/a_32670_n840# divbuf_0/a_33150_n840# 0.07fF
C925 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n1540# 0.19fF
C926 divider_0/tspc_1/Z3 divider_0/tspc_1/Q 0.05fF
C927 divider_0/tspc_0/Q gnd 0.33fF
C928 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C929 filter_0/a_4216_n5230# filter_0/v 0.19fF
C930 divbuf_0/a_11550_n1540# divbuf_0/a_12030_n1540# 0.11fF
C931 divbuf_0/a_42270_n840# divbuf_0/a_42270_n1540# 0.01fF
C932 divbuf_0/a_9732_n240# divbuf_0/a_9630_n840# 0.03fF
C933 divbuf_0/a_19200_n1600# divbuf_0/a_19680_n1600# 0.26fF
C934 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n840# 0.04fF
C935 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C936 divbuf_0/a_25862_170# divbuf_0/a_26352_170# 0.07fF
C937 divbuf_0/a_12772_170# divbuf_0/a_12772_n240# 0.01fF
C938 divbuf_0/a_59040_n1600# divbuf_0/a_59520_n1600# 0.26fF
C939 divbuf_0/a_15182_170# divbuf_0/OUT4 0.19fF
C940 divbuf_0/a_51390_n1540# divbuf_0/a_51870_n1540# 0.11fF
C941 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n840# 0.04fF
C942 divbuf_0/a_14702_n240# divbuf_0/OUT4 0.04fF
C943 divbuf_0/a_26832_n240# divbuf_0/a_27322_n240# 0.04fF
C944 divbuf_0/a_8190_n840# divbuf_0/a_8190_n1540# 0.01fF
C945 divbuf_0/a_38430_n840# divbuf_0/a_38910_n840# 0.07fF
C946 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n1540# 0.19fF
C947 divbuf_0/a_12960_n1600# divbuf_0/OUT4 0.00fF
C948 divider_0/nor_1/B divider_0/tspc_2/Z4 0.02fF
C949 divider_0/prescaler_0/tspc_1/Z4 gnd 0.44fF
C950 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C951 divbuf_0/a_15672_n240# divbuf_0/a_15870_n840# 0.02fF
C952 divbuf_0/a_24960_n1600# divbuf_0/a_25440_n1600# 0.26fF
C953 divbuf_0/a_17310_n1540# divbuf_0/a_17790_n1540# 0.11fF
C954 divbuf_0/a_48030_n840# divbuf_0/a_48030_n1540# 0.01fF
C955 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n840# 0.04fF
C956 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C957 divbuf_0/a_25382_170# divbuf_0/OUT4 0.19fF
C958 divbuf_0/a_4350_n840# divbuf_0/a_4830_n840# 0.07fF
C959 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n1540# 0.19fF
C960 divbuf_0/a_31682_170# divbuf_0/a_32172_170# 0.07fF
C961 divbuf_0/a_57150_n1540# divbuf_0/a_57630_n1540# 0.11fF
C962 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C963 divbuf_0/a_26352_n240# divbuf_0/OUT4 0.04fF
C964 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n840# 0.04fF
C965 divbuf_0/a_32652_n240# divbuf_0/a_33142_n240# 0.04fF
C966 divbuf_0/a_24480_n1600# divbuf_0/OUT4 0.00fF
C967 divbuf_0/a_13950_n840# divbuf_0/a_13950_n1540# 0.01fF
C968 divbuf_0/a_44190_n840# divbuf_0/a_44670_n840# 0.07fF
C969 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n1540# 0.19fF
C970 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C971 divider_0/prescaler_0/tspc_1/Q gnd 0.83fF
C972 divbuf_0/a_23070_n1540# divbuf_0/a_23550_n1540# 0.11fF
C973 divbuf_0/a_53790_n840# divbuf_0/a_53790_n1540# 0.01fF
C974 divbuf_0/a_21502_n240# divbuf_0/a_21630_n840# 0.03fF
C975 divbuf_0/a_30720_n1600# divbuf_0/a_31200_n1600# 0.26fF
C976 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n840# 0.04fF
C977 divbuf_0/a_37502_170# divbuf_0/a_37992_170# 0.07fF
C978 divbuf_0/a_37022_170# divbuf_0/OUT4 0.19fF
C979 divbuf_0/a_10110_n840# divbuf_0/a_10590_n840# 0.07fF
C980 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n1540# 0.19fF
C981 divbuf_0/OUT2 divbuf_0/OUT3 0.36fF
C982 divider_0/nor_1/B divider_0/tspc_0/a_630_n680# 0.01fF
C983 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C984 divider_0/nor_0/Z1 gnd 0.01fF
C985 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n840# 0.04fF
C986 divbuf_0/a_37992_n240# divbuf_0/OUT4 0.04fF
C987 divbuf_0/a_38472_n240# divbuf_0/a_38962_n240# 0.04fF
C988 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C989 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C990 divbuf_0/a_19710_n840# divbuf_0/a_19710_n1540# 0.01fF
C991 divbuf_0/a_49950_n840# divbuf_0/a_50430_n840# 0.07fF
C992 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n1540# 0.19fF
C993 divbuf_0/a_36000_n1600# divbuf_0/OUT4 0.00fF
C994 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C995 divider_0/tspc_2/Z3 divider_0/Out 0.05fF
C996 gnd divider_0/tspc_0/Z3 0.27fF
C997 divbuf_0/a_2322_170# divbuf_0/a_1842_170# 0.07fF
C998 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C999 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C1000 divbuf_0/a_36480_n1600# divbuf_0/a_36960_n1600# 0.26fF
C1001 divbuf_0/a_28830_n1540# divbuf_0/a_29310_n1540# 0.11fF
C1002 divbuf_0/a_59550_n840# divbuf_0/a_59550_n1540# 0.01fF
C1003 divbuf_0/a_27322_n240# divbuf_0/a_27390_n840# 0.04fF
C1004 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n840# 0.04fF
C1005 divbuf_0/a_8762_170# divbuf_0/OUT3 0.19fF
C1006 divbuf_0/a_15870_n840# divbuf_0/a_16350_n840# 0.07fF
C1007 divbuf_0/a_23922_170# divbuf_0/a_23922_n240# 0.01fF
C1008 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n1540# 0.19fF
C1009 divbuf_0/a_9242_n240# divbuf_0/OUT3 0.04fF
C1010 divbuf_0/a_3422_n240# divbuf_0/a_3912_n240# 0.04fF
C1011 divider_0/nor_1/B gnd 1.10fF
C1012 divbuf_0/a_2400_n1600# divbuf_0/a_2880_n1600# 0.26fF
C1013 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1014 divbuf_0/a_25470_n840# divbuf_0/a_25470_n1540# 0.01fF
C1015 divbuf_0/a_55710_n840# divbuf_0/a_56190_n840# 0.07fF
C1016 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n1540# 0.19fF
C1017 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1018 io_clamp_low[1] io_clamp_high[1] 0.53fF
C1019 divbuf_0/a_13252_n240# divbuf_0/a_12990_n840# 0.01fF
C1020 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.45fF
C1021 divbuf_0/a_34590_n1540# divbuf_0/a_35070_n1540# 0.11fF
C1022 divbuf_0/a_33142_n240# divbuf_0/a_33150_n840# 0.06fF
C1023 divbuf_0/a_42240_n1600# divbuf_0/a_42720_n1600# 0.26fF
C1024 divbuf_0/a_20042_170# divbuf_0/OUT4 0.19fF
C1025 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n840# 0.04fF
C1026 divbuf_0/a_21012_n240# divbuf_0/OUT4 0.04fF
C1027 divbuf_0/a_9242_n240# divbuf_0/a_9732_n240# 0.04fF
C1028 divbuf_0/a_21630_n840# divbuf_0/a_22110_n840# 0.07fF
C1029 divbuf_0/a_29742_170# divbuf_0/a_29742_n240# 0.01fF
C1030 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n1540# 0.19fF
C1031 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1032 divider_0/prescaler_0/tspc_2/Z4 gnd 0.44fF
C1033 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/Out 0.19fF
C1034 divbuf_0/a_19200_n1600# divbuf_0/OUT4 0.00fF
C1035 divbuf_0/a_8160_n1600# divbuf_0/a_8640_n1600# 0.26fF
C1036 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1037 divbuf_0/a_510_n1540# divbuf_0/a_990_n1540# 0.11fF
C1038 divbuf_0/a_31230_n840# divbuf_0/a_31230_n1540# 0.01fF
C1039 divbuf_0/a_16152_170# divbuf_0/a_16642_170# 0.07fF
C1040 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1041 divbuf_0/a_48000_n1600# divbuf_0/a_48480_n1600# 0.26fF
C1042 divbuf_0/a_40350_n1540# divbuf_0/a_40830_n1540# 0.11fF
C1043 divbuf_0/a_6332_170# divbuf_0/OUT3 0.19fF
C1044 divbuf_0/a_38962_n240# divbuf_0/a_38910_n840# 0.04fF
C1045 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n840# 0.04fF
C1046 divbuf_0/a_31682_170# divbuf_0/OUT4 0.19fF
C1047 divbuf_0/a_16152_170# divbuf_0/a_16152_n240# 0.01fF
C1048 divbuf_0/a_27390_n840# divbuf_0/a_27870_n840# 0.07fF
C1049 divbuf_0/a_35562_170# divbuf_0/a_35562_n240# 0.01fF
C1050 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n1540# 0.19fF
C1051 divbuf_0/a_32652_n240# divbuf_0/OUT4 0.04fF
C1052 divbuf_0/a_15672_n240# divbuf_0/a_16152_n240# 0.05fF
C1053 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C1054 gnd divider_0/tspc_2/Z2 0.16fF
C1055 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.26fF
C1056 divbuf_0/a_13920_n1600# divbuf_0/a_14400_n1600# 0.26fF
C1057 divbuf_0/a_4392_n240# divbuf_0/a_4350_n840# 0.04fF
C1058 cp_1/a_1710_n2840# cp_1/a_1710_0# 0.83fF
C1059 divbuf_0/a_6270_n1540# divbuf_0/a_6750_n1540# 0.11fF
C1060 divbuf_0/a_36990_n840# divbuf_0/a_36990_n1540# 0.01fF
C1061 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1062 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C1063 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n840# 0.04fF
C1064 divbuf_0/a_20532_170# divbuf_0/a_21012_170# 0.07fF
C1065 divbuf_0/a_4882_170# divbuf_0/a_4882_n240# 0.01fF
C1066 divbuf_0/a_46110_n1540# divbuf_0/a_46590_n1540# 0.11fF
C1067 divbuf_0/a_53760_n1600# divbuf_0/a_54240_n1600# 0.26fF
C1068 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n840# 0.04fF
C1069 divbuf_0/a_3912_n240# divbuf_0/OUT3 0.04fF
C1070 divbuf_0/a_21502_n240# divbuf_0/a_21982_n240# 0.05fF
C1071 divbuf_0/a_2910_n840# divbuf_0/a_2910_n1540# 0.01fF
C1072 divbuf_0/a_33150_n840# divbuf_0/a_33630_n840# 0.07fF
C1073 divbuf_0/a_41382_170# divbuf_0/a_41382_n240# 0.01fF
C1074 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n1540# 0.19fF
C1075 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C1076 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 0.22fF
C1077 divbuf_0/a_10212_n240# divbuf_0/a_10110_n840# 0.03fF
C1078 divbuf_0/a_19680_n1600# divbuf_0/a_20160_n1600# 0.26fF
C1079 divbuf_0/a_12030_n1540# divbuf_0/a_12510_n1540# 0.11fF
C1080 divbuf_0/a_42750_n840# divbuf_0/a_42750_n1540# 0.01fF
C1081 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1082 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n840# 0.04fF
C1083 divbuf_0/a_60990_n840# divbuf_0/OUT5 0.04fF
C1084 divbuf_0/a_26352_170# divbuf_0/a_26832_170# 0.07fF
C1085 divbuf_0/a_13252_170# divbuf_0/a_13252_n240# 0.01fF
C1086 divbuf_0/a_59520_n1600# divbuf_0/a_60000_n1600# 0.26fF
C1087 divbuf_0/a_16152_170# divbuf_0/OUT4 0.19fF
C1088 divbuf_0/a_51870_n1540# divbuf_0/a_52350_n1540# 0.11fF
C1089 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n840# 0.04fF
C1090 divbuf_0/a_15672_n240# divbuf_0/OUT4 0.04fF
C1091 divbuf_0/a_8670_n840# divbuf_0/a_8670_n1540# 0.01fF
C1092 divbuf_0/a_38910_n840# divbuf_0/a_39390_n840# 0.07fF
C1093 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n1540# 0.19fF
C1094 divbuf_0/a_27322_n240# divbuf_0/a_27802_n240# 0.05fF
C1095 divider_0/tspc_1/Z3 gnd 0.27fF
C1096 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.45fF
C1097 cp_0/a_10_n50# io_analog[3] 0.22fF
C1098 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1099 divbuf_0/a_25440_n1600# divbuf_0/a_25920_n1600# 0.26fF
C1100 divbuf_0/a_6332_170# divbuf_0/a_6822_170# 0.07fF
C1101 divbuf_0/a_16152_n240# divbuf_0/a_16350_n840# 0.02fF
C1102 divbuf_0/a_17790_n1540# divbuf_0/a_18270_n1540# 0.11fF
C1103 divbuf_0/a_48510_n840# divbuf_0/a_48510_n1540# 0.01fF
C1104 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C1105 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n840# 0.04fF
C1106 divbuf_0/a_32172_170# divbuf_0/a_32652_170# 0.07fF
C1107 divbuf_0/a_57630_n1540# divbuf_0/a_58110_n1540# 0.11fF
C1108 divbuf_0/a_26352_170# divbuf_0/OUT4 0.19fF
C1109 divbuf_0/a_4830_n840# divbuf_0/a_5310_n840# 0.07fF
C1110 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n1540# 0.19fF
C1111 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n840# 0.04fF
C1112 divbuf_0/a_27322_n240# divbuf_0/OUT4 0.04fF
C1113 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1114 divbuf_0/a_33142_n240# divbuf_0/a_33622_n240# 0.05fF
C1115 divbuf_0/a_14430_n840# divbuf_0/a_14430_n1540# 0.01fF
C1116 divbuf_0/a_44670_n840# divbuf_0/a_45150_n840# 0.07fF
C1117 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n1540# 0.19fF
C1118 divider_0/prescaler_0/tspc_0/Q gnd 0.35fF
C1119 cp_1/vbias cp_1/a_10_n50# 0.19fF
C1120 cp_1/out cp_1/a_1710_n2840# 0.61fF
C1121 divbuf_0/a_1352_n240# divbuf_0/a_1470_n840# 0.03fF
C1122 divbuf_0/a_21982_n240# divbuf_0/a_22110_n840# 0.03fF
C1123 divbuf_0/a_31200_n1600# divbuf_0/a_31680_n1600# 0.26fF
C1124 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1125 divbuf_0/a_23550_n1540# divbuf_0/a_24030_n1540# 0.11fF
C1126 divbuf_0/a_54270_n840# divbuf_0/a_54270_n1540# 0.01fF
C1127 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n840# 0.04fF
C1128 divbuf_0/a_37992_170# divbuf_0/a_38472_170# 0.07fF
C1129 divbuf_0/OUT3 divbuf_0/OUT4 0.36fF
C1130 divbuf_0/a_37992_170# divbuf_0/OUT4 0.19fF
C1131 divbuf_0/a_10590_n840# divbuf_0/a_11070_n840# 0.07fF
C1132 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n1540# 0.19fF
C1133 divbuf_0/a_38962_n240# divbuf_0/OUT4 0.04fF
C1134 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1135 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1136 pd_0/DOWN pd_0/R 0.36fF
C1137 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1138 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C1139 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C1140 io_clamp_low[2] io_analog[6] 0.53fF
C1141 divbuf_0/a_20190_n840# divbuf_0/a_20190_n1540# 0.01fF
C1142 divbuf_0/a_50430_n840# divbuf_0/a_50910_n840# 0.07fF
C1143 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n1540# 0.19fF
C1144 divbuf_0/a_38962_n240# divbuf_0/a_39442_n240# 0.05fF
C1145 gnd divider_0/and_0/A 0.53fF
C1146 divbuf_0/a_36960_n1600# divbuf_0/a_37440_n1600# 0.26fF
C1147 divbuf_0/a_27802_n240# divbuf_0/a_27870_n840# 0.04fF
C1148 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1149 divbuf_0/a_29310_n1540# divbuf_0/a_29790_n1540# 0.11fF
C1150 divbuf_0/a_60030_n840# divbuf_0/a_60030_n1540# 0.01fF
C1151 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n840# 0.04fF
C1152 divbuf_0/a_24412_170# divbuf_0/a_24412_n240# 0.01fF
C1153 divbuf_0/a_3912_n240# divbuf_0/a_4392_n240# 0.05fF
C1154 divbuf_0/a_16350_n840# divbuf_0/a_16830_n840# 0.07fF
C1155 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n1540# 0.19fF
C1156 divbuf_0/a_10212_n240# divbuf_0/OUT3 0.04fF
C1157 divbuf_0/a_9120_n1600# divbuf_0/OUT3 0.00fF
C1158 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1159 divider_0/prescaler_0/m1_2700_2190# gnd 0.22fF
C1160 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1161 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1162 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1163 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1164 divbuf_0/a_2880_n1600# divbuf_0/a_3360_n1600# 0.26fF
C1165 divbuf_0/a_25950_n840# divbuf_0/a_25950_n1540# 0.01fF
C1166 divbuf_0/a_56190_n840# divbuf_0/a_56670_n840# 0.07fF
C1167 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n1540# 0.19fF
C1168 divbuf_0/a_13742_n240# divbuf_0/a_13470_n840# 0.01fF
C1169 divbuf_0/a_33622_n240# divbuf_0/a_33630_n840# 0.06fF
C1170 divbuf_0/a_42720_n1600# divbuf_0/a_43200_n1600# 0.26fF
C1171 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C1172 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1173 divbuf_0/a_35070_n1540# divbuf_0/a_35550_n1540# 0.11fF
C1174 divbuf_0/a_21012_170# divbuf_0/OUT4 0.19fF
C1175 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n840# 0.04fF
C1176 divbuf_0/a_9732_n240# divbuf_0/a_10212_n240# 0.05fF
C1177 divbuf_0/a_30232_170# divbuf_0/a_30232_n240# 0.01fF
C1178 divbuf_0/a_21982_n240# divbuf_0/OUT4 0.04fF
C1179 divbuf_0/a_22110_n840# divbuf_0/a_22590_n840# 0.07fF
C1180 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n1540# 0.19fF
C1181 divbuf_0/a_20160_n1600# divbuf_0/OUT4 0.00fF
C1182 divider_0/and_0/OUT divider_0/prescaler_0/tspc_0/Q 0.04fF
C1183 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1184 divbuf_0/a_990_n1540# divbuf_0/a_1470_n1540# 0.11fF
C1185 divbuf_0/a_31710_n840# divbuf_0/a_31710_n1540# 0.01fF
C1186 divbuf_0/a_510_n840# divbuf_0/OUT2 0.02fF
C1187 divbuf_0/a_8640_n1600# divbuf_0/a_9120_n1600# 0.26fF
C1188 divbuf_0/a_3912_170# divbuf_0/a_4392_170# 0.07fF
C1189 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1190 divbuf_0/a_48480_n1600# divbuf_0/a_48960_n1600# 0.26fF
C1191 divbuf_0/a_7302_170# divbuf_0/OUT3 0.19fF
C1192 divbuf_0/a_39442_n240# divbuf_0/a_39390_n840# 0.04fF
C1193 divbuf_0/a_16642_170# divbuf_0/a_17122_170# 0.07fF
C1194 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C1195 divbuf_0/a_40830_n1540# divbuf_0/a_41310_n1540# 0.11fF
C1196 divbuf_0/a_16642_170# divbuf_0/a_16642_n240# 0.01fF
C1197 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n840# 0.04fF
C1198 divbuf_0/a_32652_170# divbuf_0/OUT4 0.19fF
C1199 divbuf_0/a_36052_170# divbuf_0/a_36052_n240# 0.01fF
C1200 divbuf_0/a_16152_n240# divbuf_0/a_16642_n240# 0.04fF
C1201 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Q 0.04fF
C1202 divbuf_0/a_27870_n840# divbuf_0/a_28350_n840# 0.07fF
C1203 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n1540# 0.19fF
C1204 divbuf_0/a_33622_n240# divbuf_0/OUT4 0.04fF
C1205 divbuf_0/a_31680_n1600# divbuf_0/OUT4 0.00fF
C1206 gnd divider_0/Out 0.29fF
C1207 divider_0/tspc_2/a_630_n680# divider_0/nor_0/B 0.35fF
C1208 divbuf_0/a_14400_n1600# divbuf_0/a_14880_n1600# 0.26fF
C1209 divbuf_0/a_6750_n1540# divbuf_0/a_7230_n1540# 0.11fF
C1210 divbuf_0/a_37470_n840# divbuf_0/a_37470_n1540# 0.01fF
C1211 divbuf_0/a_4882_n240# divbuf_0/a_4830_n840# 0.04fF
C1212 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n840# 0.04fF
C1213 divbuf_0/a_21012_170# divbuf_0/a_21502_170# 0.07fF
C1214 divbuf_0/a_54240_n1600# divbuf_0/a_54720_n1600# 0.26fF
C1215 divbuf_0/a_46590_n1540# divbuf_0/a_47070_n1540# 0.11fF
C1216 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n840# 0.04fF
C1217 divbuf_0/a_4882_n240# divbuf_0/OUT3 0.04fF
C1218 divbuf_0/a_21982_n240# divbuf_0/a_22472_n240# 0.04fF
C1219 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1220 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 0.61fF
C1221 divbuf_0/a_3390_n840# divbuf_0/a_3390_n1540# 0.01fF
C1222 divbuf_0/a_33630_n840# divbuf_0/a_34110_n840# 0.07fF
C1223 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n1540# 0.19fF
C1224 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C1225 divider_0/prescaler_0/Out divider_0/tspc_0/Z2 0.11fF
C1226 divbuf_0/a_12510_n1540# divbuf_0/a_12990_n1540# 0.11fF
C1227 divbuf_0/a_43230_n840# divbuf_0/a_43230_n1540# 0.01fF
C1228 divbuf_0/a_20160_n1600# divbuf_0/a_20640_n1600# 0.26fF
C1229 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n840# 0.04fF
C1230 divbuf_0/a_510_n1540# divbuf_0/OUT 0.11fF
C1231 divbuf_0/a_26832_170# divbuf_0/a_27322_170# 0.07fF
C1232 divbuf_0/a_13742_170# divbuf_0/a_13742_n240# 0.01fF
C1233 divbuf_0/a_60000_n1600# divbuf_0/a_60480_n1600# 0.26fF
C1234 divbuf_0/a_17122_170# divbuf_0/OUT4 0.19fF
C1235 divbuf_0/a_52350_n1540# divbuf_0/a_52830_n1540# 0.11fF
C1236 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n840# 0.04fF
C1237 divbuf_0/a_16642_n240# divbuf_0/OUT4 0.04fF
C1238 divbuf_0/a_27802_n240# divbuf_0/a_28292_n240# 0.04fF
C1239 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C1240 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 0.22fF
C1241 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1242 divbuf_0/a_9150_n840# divbuf_0/a_9150_n1540# 0.01fF
C1243 divbuf_0/a_39390_n840# divbuf_0/a_39870_n840# 0.07fF
C1244 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n1540# 0.19fF
C1245 divbuf_0/a_6822_170# divbuf_0/a_7302_170# 0.07fF
C1246 divbuf_0/a_25920_n1600# divbuf_0/a_26400_n1600# 0.26fF
C1247 divbuf_0/a_18270_n1540# divbuf_0/a_18750_n1540# 0.11fF
C1248 divbuf_0/a_48990_n840# divbuf_0/a_48990_n1540# 0.01fF
C1249 divbuf_0/a_16642_n240# divbuf_0/a_16830_n840# 0.02fF
C1250 divbuf_0/a_1352_170# divbuf_0/a_1842_170# 0.07fF
C1251 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1252 divbuf_0/a_2322_170# divbuf_0/OUT3 0.07fF
C1253 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n840# 0.04fF
C1254 divbuf_0/a_27322_170# divbuf_0/OUT4 0.19fF
C1255 divbuf_0/a_5310_n840# divbuf_0/a_5790_n840# 0.07fF
C1256 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n1540# 0.19fF
C1257 divbuf_0/a_32652_170# divbuf_0/a_33142_170# 0.07fF
C1258 divbuf_0/a_58110_n1540# divbuf_0/a_58590_n1540# 0.11fF
C1259 divider_0/mc2 divider_0/nor_1/A 0.04fF
C1260 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n840# 0.04fF
C1261 divbuf_0/a_28292_n240# divbuf_0/OUT4 0.04fF
C1262 divbuf_0/a_33622_n240# divbuf_0/a_34112_n240# 0.04fF
C1263 divider_0/nor_1/A divider_0/prescaler_0/Out 0.15fF
C1264 divider_0/prescaler_0/tspc_2/D gnd 0.05fF
C1265 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.64fF
C1266 divbuf_0/a_14910_n840# divbuf_0/a_14910_n1540# 0.01fF
C1267 divbuf_0/a_45150_n840# divbuf_0/a_45630_n840# 0.07fF
C1268 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n1540# 0.19fF
C1269 divbuf_0/a_1842_n240# divbuf_0/a_1950_n840# 0.03fF
C1270 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1271 divbuf_0/a_24030_n1540# divbuf_0/a_24510_n1540# 0.11fF
C1272 divbuf_0/a_54750_n840# divbuf_0/a_54750_n1540# 0.01fF
C1273 divbuf_0/a_22472_n240# divbuf_0/a_22590_n840# 0.03fF
C1274 divbuf_0/a_31680_n1600# divbuf_0/a_32160_n1600# 0.26fF
C1275 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n840# 0.04fF
C1276 divbuf_0/a_38472_170# divbuf_0/a_38962_170# 0.07fF
C1277 divbuf_0/a_38962_170# divbuf_0/OUT4 0.19fF
C1278 divbuf_0/a_11070_n840# divbuf_0/a_11550_n840# 0.07fF
C1279 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n1540# 0.19fF
C1280 divbuf_0/OUT4 divbuf_0/OUT5 0.26fF
C1281 divider_0/tspc_0/Z1 divider_0/nor_1/A 0.03fF
C1282 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1283 divbuf_0/a_39932_n240# divbuf_0/OUT4 0.04fF
C1284 divbuf_0/a_39442_n240# divbuf_0/a_39932_n240# 0.04fF
C1285 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C1286 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1287 divbuf_0/a_20670_n840# divbuf_0/a_20670_n1540# 0.01fF
C1288 divbuf_0/a_50910_n840# divbuf_0/a_51390_n840# 0.07fF
C1289 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n1540# 0.19fF
C1290 divbuf_0/a_37440_n1600# divbuf_0/a_37920_n1600# 0.26fF
C1291 divbuf_0/a_29790_n1540# divbuf_0/a_30270_n1540# 0.11fF
C1292 divbuf_0/a_60510_n840# divbuf_0/a_60510_n1540# 0.01fF
C1293 divbuf_0/a_28292_n240# divbuf_0/a_28350_n840# 0.04fF
C1294 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n840# 0.04fF
C1295 divbuf_0/a_11802_170# divbuf_0/OUT4 0.19fF
C1296 divbuf_0/a_16830_n840# divbuf_0/a_17310_n840# 0.07fF
C1297 divbuf_0/a_24892_170# divbuf_0/a_24892_n240# 0.01fF
C1298 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n1540# 0.19fF
C1299 divbuf_0/a_11312_n240# divbuf_0/OUT4 0.07fF
C1300 divbuf_0/a_4392_n240# divbuf_0/a_4882_n240# 0.04fF
C1301 divider_0/tspc_0/Z4 divider_0/prescaler_0/Out 0.12fF
C1302 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1303 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 0.61fF
C1304 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1305 divbuf_0/a_10080_n1600# divbuf_0/OUT3 0.00fF
C1306 divbuf_0/a_3360_n1600# divbuf_0/a_3840_n1600# 0.26fF
C1307 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1308 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1309 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1310 divbuf_0/a_26430_n840# divbuf_0/a_26430_n1540# 0.01fF
C1311 divbuf_0/a_56670_n840# divbuf_0/a_57150_n840# 0.07fF
C1312 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n1540# 0.19fF
C1313 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1314 divbuf_0/a_14222_n240# divbuf_0/a_13950_n840# 0.01fF
C1315 divbuf_0/a_11312_170# divbuf_0/a_11802_170# 0.07fF
C1316 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C1317 divbuf_0/a_34112_n240# divbuf_0/a_34110_n840# 0.06fF
C1318 divbuf_0/a_43200_n1600# divbuf_0/a_43680_n1600# 0.26fF
C1319 divbuf_0/a_35550_n1540# divbuf_0/a_36030_n1540# 0.11fF
C1320 divbuf_0/a_11312_170# divbuf_0/a_11312_n240# 0.01fF
C1321 divbuf_0/a_21982_170# divbuf_0/OUT4 0.19fF
C1322 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n840# 0.04fF
C1323 divbuf_0/a_22952_n240# divbuf_0/OUT4 0.04fF
C1324 divbuf_0/a_22590_n840# divbuf_0/a_23070_n840# 0.07fF
C1325 divbuf_0/a_30712_170# divbuf_0/a_30712_n240# 0.01fF
C1326 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n1540# 0.19fF
C1327 divider_0/tspc_0/Z4 divider_0/tspc_0/Z1 0.00fF
C1328 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1329 divbuf_0/a_21120_n1600# divbuf_0/OUT4 0.00fF
C1330 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1331 divbuf_0/a_9120_n1600# divbuf_0/a_9600_n1600# 0.26fF
C1332 divbuf_0/a_1470_n1540# divbuf_0/a_1950_n1540# 0.11fF
C1333 divbuf_0/a_32190_n840# divbuf_0/a_32190_n1540# 0.01fF
C1334 divbuf_0/a_60480_n1600# divbuf_0/OUT5 0.26fF
C1335 divbuf_0/a_17122_170# divbuf_0/a_17612_170# 0.07fF
C1336 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.44fF
C1337 divbuf_0/a_48960_n1600# divbuf_0/a_49440_n1600# 0.26fF
C1338 divbuf_0/a_41310_n1540# divbuf_0/a_41790_n1540# 0.11fF
C1339 divbuf_0/a_39932_n240# divbuf_0/a_39870_n840# 0.04fF
C1340 divbuf_0/a_17122_170# divbuf_0/a_17122_n240# 0.01fF
C1341 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n840# 0.04fF
C1342 divbuf_0/a_33622_170# divbuf_0/OUT4 0.19fF
C1343 divbuf_0/a_28350_n840# divbuf_0/a_28830_n840# 0.07fF
C1344 divbuf_0/a_36532_170# divbuf_0/a_36532_n240# 0.01fF
C1345 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n1540# 0.19fF
C1346 divbuf_0/a_34592_n240# divbuf_0/OUT4 0.04fF
C1347 divbuf_0/a_16642_n240# divbuf_0/a_17122_n240# 0.05fF
C1348 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C1349 divbuf_0/a_32640_n1600# divbuf_0/OUT4 0.00fF
C1350 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C1351 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1352 divbuf_0/a_14880_n1600# divbuf_0/a_15360_n1600# 0.26fF
C1353 divbuf_0/a_5362_n240# divbuf_0/a_5310_n840# 0.04fF
C1354 divbuf_0/a_7230_n1540# divbuf_0/a_7710_n1540# 0.11fF
C1355 divbuf_0/a_37950_n840# divbuf_0/a_37950_n1540# 0.01fF
C1356 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n840# 0.04fF
C1357 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1358 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C1359 divbuf_0/a_21502_170# divbuf_0/a_21982_170# 0.07fF
C1360 divbuf_0/a_54720_n1600# divbuf_0/a_55200_n1600# 0.26fF
C1361 divbuf_0/a_47070_n1540# divbuf_0/a_47550_n1540# 0.11fF
C1362 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n840# 0.04fF
C1363 divbuf_0/a_5852_n240# divbuf_0/OUT3 0.04fF
C1364 divbuf_0/a_22472_n240# divbuf_0/a_22952_n240# 0.05fF
C1365 divbuf_0/a_3870_n840# divbuf_0/a_3870_n1540# 0.01fF
C1366 divbuf_0/a_34110_n840# divbuf_0/a_34590_n840# 0.07fF
C1367 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n1540# 0.19fF
C1368 divider_0/tspc_1/a_630_n680# gnd 0.62fF
C1369 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_0/D 0.16fF
C1370 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Q 0.05fF
C1371 pd_0/R pd_0/UP 0.45fF
C1372 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C1373 divbuf_0/a_11312_n240# divbuf_0/a_11550_n840# 0.02fF
C1374 divbuf_0/a_20640_n1600# divbuf_0/a_21120_n1600# 0.26fF
C1375 divbuf_0/a_12990_n1540# divbuf_0/a_13470_n1540# 0.11fF
C1376 divbuf_0/a_43710_n840# divbuf_0/a_43710_n1540# 0.01fF
C1377 divbuf_0/a_14222_170# divbuf_0/a_14702_170# 0.07fF
C1378 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n840# 0.04fF
C1379 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C1380 divbuf_0/a_27322_170# divbuf_0/a_27802_170# 0.07fF
C1381 divbuf_0/a_14222_170# divbuf_0/a_14222_n240# 0.01fF
C1382 divbuf_0/a_18092_170# divbuf_0/OUT4 0.19fF
C1383 divbuf_0/a_52830_n1540# divbuf_0/a_53310_n1540# 0.11fF
C1384 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n840# 0.04fF
C1385 divbuf_0/a_17612_n240# divbuf_0/OUT4 0.04fF
C1386 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n1540# 0.19fF
C1387 divbuf_0/a_28292_n240# divbuf_0/a_28772_n240# 0.05fF
C1388 divbuf_0/a_9630_n840# divbuf_0/a_9630_n1540# 0.01fF
C1389 divbuf_0/a_39870_n840# divbuf_0/a_40350_n840# 0.07fF
C1390 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1391 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 0.63fF
C1392 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C1393 divbuf_0/a_26400_n1600# divbuf_0/a_26880_n1600# 0.26fF
C1394 divbuf_0/a_17122_n240# divbuf_0/a_17310_n840# 0.02fF
C1395 divbuf_0/a_18750_n1540# divbuf_0/a_19230_n1540# 0.11fF
C1396 divbuf_0/a_49470_n840# divbuf_0/a_49470_n1540# 0.01fF
C1397 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n840# 0.04fF
C1398 divbuf_0/a_9242_170# divbuf_0/OUT3 0.19fF
C1399 divbuf_0/a_33142_170# divbuf_0/a_33622_170# 0.07fF
C1400 divbuf_0/a_5790_n840# divbuf_0/a_6270_n840# 0.07fF
C1401 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n1540# 0.19fF
C1402 divbuf_0/a_58590_n1540# divbuf_0/a_59070_n1540# 0.11fF
C1403 divbuf_0/a_28292_170# divbuf_0/OUT4 0.19fF
C1404 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n840# 0.04fF
C1405 divbuf_0/a_29262_n240# divbuf_0/OUT4 0.04fF
C1406 divbuf_0/a_34112_n240# divbuf_0/a_34592_n240# 0.05fF
C1407 divbuf_0/a_15390_n840# divbuf_0/a_15390_n1540# 0.01fF
C1408 divbuf_0/a_45630_n840# divbuf_0/a_46110_n840# 0.07fF
C1409 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n1540# 0.19fF
C1410 io_analog[0] io_analog[1] 12.30fF
C1411 divider_0/nor_1/A divider_0/tspc_0/Z2 0.23fF
C1412 gnd divider_0/prescaler_0/nand_1/z1 0.16fF
C1413 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1414 divbuf_0/a_2322_n240# divbuf_0/a_2430_n840# 0.03fF
C1415 divbuf_0/a_22952_n240# divbuf_0/a_23070_n840# 0.03fF
C1416 divbuf_0/a_32160_n1600# divbuf_0/a_32640_n1600# 0.26fF
C1417 divbuf_0/a_24510_n1540# divbuf_0/a_24990_n1540# 0.11fF
C1418 divbuf_0/a_55230_n840# divbuf_0/a_55230_n1540# 0.01fF
C1419 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n840# 0.04fF
C1420 divbuf_0/a_19562_170# divbuf_0/a_20042_170# 0.07fF
C1421 divbuf_0/a_6332_170# divbuf_0/a_6332_n240# 0.01fF
C1422 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1423 divbuf_0/a_38962_170# divbuf_0/a_39442_170# 0.07fF
C1424 divbuf_0/a_39932_170# divbuf_0/OUT4 0.19fF
C1425 divbuf_0/a_11550_n840# divbuf_0/a_12030_n840# 0.07fF
C1426 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n1540# 0.19fF
C1427 divbuf_0/a_480_n1600# divbuf_0/IN 0.00fF
C1428 divbuf_0/a_40902_n240# divbuf_0/OUT4 0.04fF
C1429 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C1430 io_clamp_high[1] io_analog[5] 0.53fF
C1431 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n1540# 0.19fF
C1432 divbuf_0/a_39932_n240# divbuf_0/a_40412_n240# 0.05fF
C1433 divbuf_0/a_21150_n840# divbuf_0/a_21150_n1540# 0.01fF
C1434 divbuf_0/a_51390_n840# divbuf_0/a_51870_n840# 0.07fF
C1435 gnd divider_0/and_0/Z1 0.41fF
C1436 divbuf_0/a_37920_n1600# divbuf_0/a_38400_n1600# 0.26fF
C1437 divbuf_0/a_28772_n240# divbuf_0/a_28830_n840# 0.04fF
C1438 divbuf_0/a_30270_n1540# divbuf_0/a_30750_n1540# 0.11fF
C1439 divbuf_0/a_60990_n840# divbuf_0/a_60990_n1540# 0.01fF
C1440 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n840# 0.04fF
C1441 divbuf_0/a_25382_170# divbuf_0/a_25382_n240# 0.01fF
C1442 divbuf_0/a_4882_n240# divbuf_0/a_5362_n240# 0.05fF
C1443 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n1540# 0.19fF
C1444 divbuf_0/a_12282_n240# divbuf_0/OUT4 0.04fF
C1445 divbuf_0/a_17310_n840# divbuf_0/a_17790_n840# 0.07fF
C1446 divider_0/nor_1/Z1 divider_0/and_0/B 0.18fF
C1447 divider_0/nor_1/B divider_0/nor_0/B 0.47fF
C1448 divider_0/tspc_0/Z4 divider_0/tspc_0/Z2 0.36fF
C1449 divider_0/tspc_0/Q divider_0/tspc_0/Z3 0.05fF
C1450 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1451 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.01fF
C1452 divbuf_0/a_11040_n1600# divbuf_0/OUT3 0.00fF
C1453 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1454 divbuf_0/a_3840_n1600# divbuf_0/a_4320_n1600# 0.26fF
C1455 divbuf_0/a_26910_n840# divbuf_0/a_26910_n1540# 0.01fF
C1456 divbuf_0/a_57150_n840# divbuf_0/a_57630_n840# 0.07fF
C1457 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n1540# 0.19fF
C1458 divbuf_0/a_14702_n240# divbuf_0/a_14430_n840# 0.01fF
C1459 divbuf_0/a_34592_n240# divbuf_0/a_34590_n840# 0.06fF
C1460 divbuf_0/a_11802_170# divbuf_0/a_12282_170# 0.07fF
C1461 divbuf_0/a_43680_n1600# divbuf_0/a_44160_n1600# 0.26fF
C1462 divbuf_0/a_36030_n1540# divbuf_0/a_36510_n1540# 0.11fF
C1463 divbuf_0/a_22952_170# divbuf_0/OUT4 0.19fF
C1464 divbuf_0/a_11802_170# divbuf_0/a_11802_n240# 0.01fF
C1465 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n840# 0.04fF
C1466 divbuf_0/a_1842_170# divbuf_0/a_1842_n240# 0.01fF
C1467 divbuf_0/a_11312_n240# divbuf_0/a_11802_n240# 0.04fF
C1468 divbuf_0/a_31202_170# divbuf_0/a_31202_n240# 0.01fF
C1469 divider_0/tspc_0/Q divider_0/nor_1/B 0.22fF
C1470 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1471 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1472 divbuf_0/a_23922_n240# divbuf_0/OUT4 0.04fF
C1473 divbuf_0/a_23070_n840# divbuf_0/a_23550_n840# 0.07fF
C1474 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n1540# 0.19fF
C1475 divbuf_0/a_22080_n1600# divbuf_0/OUT4 0.01fF
C1476 divbuf_0/a_510_n840# divbuf_0/OUT 0.07fF
C1477 divbuf_0/a_9600_n1600# divbuf_0/a_10080_n1600# 0.26fF
C1478 divbuf_0/a_1950_n1540# divbuf_0/a_2430_n1540# 0.11fF
C1479 divbuf_0/a_32670_n840# divbuf_0/a_32670_n1540# 0.01fF
C1480 divbuf_0/a_4392_170# divbuf_0/a_4882_170# 0.07fF
C1481 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1482 divbuf_0/a_49440_n1600# divbuf_0/a_49920_n1600# 0.26fF
C1483 divbuf_0/a_40412_n240# divbuf_0/a_40350_n840# 0.04fF
C1484 divbuf_0/a_17612_170# divbuf_0/a_18092_170# 0.07fF
C1485 divbuf_0/a_3912_170# divbuf_0/OUT3 0.19fF
C1486 divbuf_0/a_41790_n1540# divbuf_0/a_42270_n1540# 0.11fF
C1487 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n840# 0.04fF
C1488 divbuf_0/a_34592_170# divbuf_0/OUT4 0.19fF
C1489 divbuf_0/a_17612_170# divbuf_0/a_17612_n240# 0.01fF
C1490 divbuf_0/a_37022_170# divbuf_0/a_37022_n240# 0.01fF
C1491 divbuf_0/a_17122_n240# divbuf_0/a_17612_n240# 0.04fF
C1492 divider_0/tspc_0/Z4 divider_0/nor_1/A 0.21fF
C1493 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1494 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n1540# 0.19fF
C1495 divbuf_0/a_35562_n240# divbuf_0/OUT4 0.04fF
C1496 divbuf_0/a_28830_n840# divbuf_0/a_29310_n840# 0.07fF
C1497 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C1498 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C1499 divider_0/tspc_2/a_630_n680# divider_0/Out 0.04fF
C1500 divider_0/nor_0/B divider_0/tspc_2/Z2 0.40fF
C1501 divider_0/prescaler_0/tspc_0/Q divider_0/clk 0.05fF
C1502 divbuf_0/a_33600_n1600# divbuf_0/OUT4 0.01fF
C1503 divbuf_0/a_15360_n1600# divbuf_0/a_15840_n1600# 0.26fF
C1504 divbuf_0/a_7710_n1540# divbuf_0/a_8190_n1540# 0.11fF
C1505 divbuf_0/a_38430_n840# divbuf_0/a_38430_n1540# 0.01fF
C1506 divbuf_0/a_5852_n240# divbuf_0/a_5790_n840# 0.04fF
C1507 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1508 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n840# 0.04fF
C1509 divbuf_0/a_21982_170# divbuf_0/a_22472_170# 0.07fF
C1510 divbuf_0/a_55200_n1600# divbuf_0/a_55680_n1600# 0.26fF
C1511 divbuf_0/a_47550_n1540# divbuf_0/a_48030_n1540# 0.11fF
C1512 divbuf_0/a_492_n240# divbuf_0/a_480_n1600# 0.00fF
C1513 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n840# 0.04fF
C1514 divbuf_0/a_6822_n240# divbuf_0/OUT3 0.04fF
C1515 divbuf_0/a_22952_n240# divbuf_0/a_23442_n240# 0.04fF
C1516 divider_0/tspc_1/Z2 divider_0/nor_1/A 0.15fF
C1517 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C1518 divider_0/prescaler_0/tspc_0/Z2 gnd 0.16fF
C1519 divider_0/mc2 divider_0/and_0/B 0.20fF
C1520 divbuf_0/a_4350_n840# divbuf_0/a_4350_n1540# 0.01fF
C1521 divbuf_0/a_34590_n840# divbuf_0/a_35070_n840# 0.07fF
C1522 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n1540# 0.19fF
C1523 divbuf_0/a_11802_n240# divbuf_0/a_12030_n840# 0.02fF
C1524 divbuf_0/a_21120_n1600# divbuf_0/a_21600_n1600# 0.26fF
C1525 divbuf_0/a_13470_n1540# divbuf_0/a_13950_n1540# 0.11fF
C1526 divbuf_0/a_44190_n840# divbuf_0/a_44190_n1540# 0.01fF
C1527 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1528 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C1529 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n840# 0.04fF
C1530 divbuf_0/a_19072_170# divbuf_0/OUT4 0.19fF
C1531 divbuf_0/a_510_n840# divbuf_0/a_990_n840# 0.07fF
C1532 divbuf_0/a_480_n1600# divbuf_0/a_510_n1540# 0.19fF
C1533 divbuf_0/a_27802_170# divbuf_0/a_28292_170# 0.07fF
C1534 divbuf_0/a_53310_n1540# divbuf_0/a_53790_n1540# 0.11fF
C1535 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n840# 0.04fF
C1536 divbuf_0/a_18582_n240# divbuf_0/OUT4 0.04fF
C1537 divider_0/nor_0/Z1 divider_0/nor_1/B 0.18fF
C1538 divbuf_0/a_28772_n240# divbuf_0/a_29262_n240# 0.04fF
C1539 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1540 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.03fF
C1541 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C1542 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n1540# 0.19fF
C1543 divbuf_0/a_10110_n840# divbuf_0/a_10110_n1540# 0.01fF
C1544 divbuf_0/a_40350_n840# divbuf_0/a_40830_n840# 0.07fF
C1545 io_analog[2] io_analog[1] 0.02fF
C1546 divbuf_0/a_5362_170# divbuf_0/a_4882_170# 0.07fF
C1547 divbuf_0/a_26880_n1600# divbuf_0/a_27360_n1600# 0.26fF
C1548 divbuf_0/a_19230_n1540# divbuf_0/a_19710_n1540# 0.11fF
C1549 divbuf_0/a_49950_n840# divbuf_0/a_49950_n1540# 0.01fF
C1550 divbuf_0/a_17612_n240# divbuf_0/a_17790_n840# 0.02fF
C1551 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n840# 0.04fF
C1552 divbuf_0/a_10212_170# divbuf_0/OUT3 0.19fF
C1553 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n1540# 0.19fF
C1554 divbuf_0/a_33622_170# divbuf_0/a_34112_170# 0.07fF
C1555 divbuf_0/a_29262_170# divbuf_0/OUT4 0.19fF
C1556 divbuf_0/a_6270_n840# divbuf_0/a_6750_n840# 0.07fF
C1557 divbuf_0/a_59070_n1540# divbuf_0/a_59550_n1540# 0.11fF
C1558 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n840# 0.04fF
C1559 divbuf_0/a_30232_n240# divbuf_0/OUT4 0.04fF
C1560 divider_0/tspc_0/Q divider_0/tspc_1/Z3 0.45fF
C1561 divbuf_0/a_34592_n240# divbuf_0/a_35082_n240# 0.04fF
C1562 divbuf_0/a_15870_n840# divbuf_0/a_15870_n1540# 0.01fF
C1563 divbuf_0/a_46110_n840# divbuf_0/a_46590_n840# 0.07fF
C1564 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n1540# 0.19fF
C1565 cp_1/upbar cp_1/down 0.02fF
C1566 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1567 divbuf_0/a_23442_n240# divbuf_0/a_23550_n840# 0.03fF
C1568 divbuf_0/a_32640_n1600# divbuf_0/a_33120_n1600# 0.26fF
C1569 divbuf_0/a_24990_n1540# divbuf_0/a_25470_n1540# 0.11fF
C1570 divbuf_0/a_55710_n840# divbuf_0/a_55710_n1540# 0.01fF
C1571 divbuf_0/a_6822_170# divbuf_0/a_6822_n240# 0.01fF
C1572 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n840# 0.04fF
C1573 divbuf_0/a_13252_170# divbuf_0/OUT4 0.19fF
C1574 divbuf_0/a_1352_n240# divbuf_0/OUT2 0.07fF
C1575 divbuf_0/a_40902_170# divbuf_0/OUT4 0.19fF
C1576 divbuf_0/a_12030_n840# divbuf_0/a_12510_n840# 0.07fF
C1577 divbuf_0/a_20042_170# divbuf_0/a_20042_n240# 0.01fF
C1578 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n1540# 0.19fF
C1579 divbuf_0/a_39442_170# divbuf_0/a_39932_170# 0.07fF
C1580 divbuf_0/a_960_n1600# divbuf_0/OUT2 0.00fF
C1581 divbuf_0/a_41382_n240# divbuf_0/OUT5 0.04fF
C1582 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.05fF
C1583 divider_0/nor_1/Z1 gnd 0.01fF
C1584 io_clamp_low[0] io_analog[4] 0.53fF
C1585 divbuf_0/a_40412_n240# divbuf_0/a_40902_n240# 0.04fF
C1586 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n1540# 0.19fF
C1587 divbuf_0/a_21630_n840# divbuf_0/a_21630_n1540# 0.01fF
C1588 divbuf_0/a_51870_n840# divbuf_0/a_52350_n840# 0.07fF
C1589 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C1590 divbuf_0/a_38400_n1600# divbuf_0/a_38880_n1600# 0.26fF
C1591 divbuf_0/a_30750_n1540# divbuf_0/a_31230_n1540# 0.11fF
C1592 divbuf_0/a_29262_n240# divbuf_0/a_29310_n840# 0.04fF
C1593 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n840# 0.04fF
C1594 divbuf_0/a_25862_170# divbuf_0/a_25862_n240# 0.01fF
C1595 divbuf_0/a_5362_n240# divbuf_0/a_5852_n240# 0.04fF
C1596 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n1540# 0.19fF
C1597 divbuf_0/a_13252_n240# divbuf_0/OUT4 0.04fF
C1598 divbuf_0/a_17790_n840# divbuf_0/a_18270_n840# 0.07fF
C1599 divbuf_0/a_11520_n1600# divbuf_0/OUT4 0.01fF
C1600 divider_0/nor_1/A divider_0/tspc_1/Z4 0.02fF
C1601 divider_0/nor_1/B divider_0/tspc_2/Z2 0.20fF
C1602 divider_0/prescaler_0/tspc_1/Z2 gnd 0.17fF
C1603 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C1604 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C1605 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C1606 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C1607 divbuf_0/a_4320_n1600# divbuf_0/a_4800_n1600# 0.26fF
C1608 divbuf_0/a_27390_n840# divbuf_0/a_27390_n1540# 0.01fF
C1609 divbuf_0/a_57630_n840# divbuf_0/a_58110_n840# 0.07fF
C1610 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n1540# 0.19fF
C1611 divbuf_0/a_15182_n240# divbuf_0/a_14910_n840# 0.01fF
C1612 divbuf_0/a_35082_n240# divbuf_0/a_35070_n840# 0.05fF
C1613 divbuf_0/a_44160_n1600# divbuf_0/a_44640_n1600# 0.26fF
C1614 divbuf_0/a_36510_n1540# divbuf_0/a_36990_n1540# 0.11fF
C1615 divbuf_0/a_12282_170# divbuf_0/a_12282_n240# 0.01fF
C1616 divbuf_0/a_23922_170# divbuf_0/OUT4 0.19fF
C1617 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n840# 0.04fF
C1618 divbuf_0/a_11802_n240# divbuf_0/a_12282_n240# 0.05fF
C1619 divbuf_0/a_31682_170# divbuf_0/a_31682_n240# 0.01fF
C1620 divbuf_0/a_24892_n240# divbuf_0/OUT4 0.04fF
C1621 divbuf_0/a_23550_n840# divbuf_0/a_24030_n840# 0.07fF
C1622 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n1540# 0.19fF
C1623 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1624 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1625 divbuf_0/a_23040_n1600# divbuf_0/OUT4 0.01fF
C1626 divider_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.01fF
C1627 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/Q 0.19fF
C1628 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.14fF
C1629 divbuf_0/a_10080_n1600# divbuf_0/a_10560_n1600# 0.26fF
C1630 divbuf_0/a_2910_n840# divbuf_0/OUT3 0.03fF
C1631 divbuf_0/a_2430_n1540# divbuf_0/a_2910_n1540# 0.11fF
C1632 divbuf_0/a_33150_n840# divbuf_0/a_33150_n1540# 0.01fF
C1633 divbuf_0/a_3912_170# divbuf_0/a_3422_170# 0.07fF
C1634 divbuf_0/a_41790_n840# divbuf_0/OUT5 0.03fF
C1635 divbuf_0/a_18092_170# divbuf_0/a_18582_170# 0.07fF
C1636 divbuf_0/a_49920_n1600# divbuf_0/a_50400_n1600# 0.26fF
C1637 divbuf_0/a_42270_n1540# divbuf_0/a_42750_n1540# 0.11fF
C1638 divbuf_0/a_40902_n240# divbuf_0/a_40830_n840# 0.03fF
C1639 divbuf_0/a_4392_170# divbuf_0/OUT3 0.19fF
C1640 divbuf_0/a_18092_170# divbuf_0/a_18092_n240# 0.01fF
C1641 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n840# 0.04fF
C1642 divbuf_0/a_35562_170# divbuf_0/OUT4 0.19fF
C1643 divbuf_0/a_37502_170# divbuf_0/a_37502_n240# 0.01fF
C1644 divbuf_0/a_17612_n240# divbuf_0/a_18092_n240# 0.05fF
C1645 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n1540# 0.19fF
C1646 divbuf_0/a_36532_n240# divbuf_0/OUT4 0.04fF
C1647 divbuf_0/a_29310_n840# divbuf_0/a_29790_n840# 0.07fF
C1648 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C1649 divider_0/nor_1/B divider_0/tspc_1/Z3 0.38fF
C1650 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1651 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1652 divider_0/mc2 gnd 1.36fF
C1653 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C1654 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C1655 divbuf_0/a_34560_n1600# divbuf_0/OUT4 0.01fF
C1656 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C1657 divider_0/nor_0/B divider_0/Out 0.22fF
C1658 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.29fF
C1659 gnd divider_0/prescaler_0/Out 0.46fF
C1660 divbuf_0/a_15840_n1600# divbuf_0/a_16320_n1600# 0.26fF
C1661 divbuf_0/a_6332_n240# divbuf_0/a_6270_n840# 0.04fF
C1662 divbuf_0/a_8190_n1540# divbuf_0/a_8670_n1540# 0.11fF
C1663 divbuf_0/a_38910_n840# divbuf_0/a_38910_n1540# 0.01fF
C1664 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n840# 0.04fF
C1665 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1666 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C1667 divbuf_0/a_22472_170# divbuf_0/a_22952_170# 0.07fF
C1668 divbuf_0/a_55680_n1600# divbuf_0/a_56160_n1600# 0.26fF
C1669 divbuf_0/a_48030_n1540# divbuf_0/a_48510_n1540# 0.11fF
C1670 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n840# 0.04fF
C1671 divbuf_0/a_7792_n240# divbuf_0/OUT3 0.04fF
C1672 divbuf_0/a_23442_n240# divbuf_0/a_23922_n240# 0.05fF
C1673 divbuf_0/a_4830_n840# divbuf_0/a_4830_n1540# 0.01fF
C1674 divbuf_0/a_35070_n840# divbuf_0/a_35550_n840# 0.07fF
C1675 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n1540# 0.19fF
C1676 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1677 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C1678 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1679 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C1680 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C1681 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C1682 divbuf_0/a_12282_n240# divbuf_0/a_12510_n840# 0.02fF
C1683 divbuf_0/a_21600_n1600# divbuf_0/a_22080_n1600# 0.26fF
C1684 divbuf_0/a_13950_n1540# divbuf_0/a_14430_n1540# 0.11fF
C1685 divbuf_0/a_44670_n840# divbuf_0/a_44670_n1540# 0.01fF
C1686 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n840# 0.04fF
C1687 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C1688 divbuf_0/a_28292_170# divbuf_0/a_28772_170# 0.07fF
C1689 divbuf_0/a_53790_n1540# divbuf_0/a_54270_n1540# 0.11fF
C1690 divbuf_0/a_990_n840# divbuf_0/a_1470_n840# 0.07fF
C1691 divbuf_0/a_960_n1600# divbuf_0/a_990_n1540# 0.19fF
C1692 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n840# 0.04fF
C1693 divbuf_0/a_19562_n240# divbuf_0/OUT4 0.04fF
C1694 divbuf_0/a_29262_n240# divbuf_0/a_29742_n240# 0.05fF
C1695 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n1540# 0.19fF
C1696 divbuf_0/a_10590_n840# divbuf_0/a_10590_n1540# 0.01fF
C1697 divbuf_0/a_40830_n840# divbuf_0/a_41310_n840# 0.07fF
C1698 divider_0/tspc_1/Q divider_0/tspc_2/Z1 0.01fF
C1699 divider_0/prescaler_0/tspc_2/Z2 gnd 0.16fF
C1700 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1701 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C1702 divider_0/nor_1/B divider_0/and_0/A 0.26fF
C1703 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C1704 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1705 divbuf_0/a_27360_n1600# divbuf_0/a_27840_n1600# 0.26fF
C1706 divbuf_0/a_18092_n240# divbuf_0/a_18270_n840# 0.02fF
C1707 divbuf_0/a_19710_n1540# divbuf_0/a_20190_n1540# 0.11fF
C1708 divbuf_0/a_50430_n840# divbuf_0/a_50430_n1540# 0.01fF
C1709 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n840# 0.04fF
C1710 divbuf_0/a_5362_170# divbuf_0/OUT3 0.19fF
C1711 divbuf_0/a_34112_170# divbuf_0/a_34592_170# 0.07fF
C1712 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n1540# 0.19fF
C1713 divbuf_0/a_59550_n1540# divbuf_0/a_60030_n1540# 0.11fF
C1714 divbuf_0/a_30232_170# divbuf_0/OUT4 0.19fF
C1715 divbuf_0/a_6750_n840# divbuf_0/a_7230_n840# 0.07fF
C1716 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C1717 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n840# 0.04fF
C1718 divbuf_0/a_31202_n240# divbuf_0/OUT4 0.04fF
C1719 divbuf_0/a_35082_n240# divbuf_0/a_35562_n240# 0.05fF
C1720 divbuf_0/a_16350_n840# divbuf_0/a_16350_n1540# 0.01fF
C1721 divbuf_0/a_46590_n840# divbuf_0/a_47070_n840# 0.07fF
C1722 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n1540# 0.19fF
C1723 divider_0/nor_1/A divider_0/and_0/B 0.08fF
C1724 divbuf_0/a_23922_n240# divbuf_0/a_24030_n840# 0.03fF
C1725 divbuf_0/a_33120_n1600# divbuf_0/a_33600_n1600# 0.26fF
C1726 divbuf_0/a_25470_n1540# divbuf_0/a_25950_n1540# 0.11fF
C1727 divbuf_0/a_56190_n840# divbuf_0/a_56190_n1540# 0.01fF
C1728 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C1729 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n840# 0.04fF
C1730 divbuf_0/a_14222_170# divbuf_0/OUT4 0.19fF
C1731 divbuf_0/a_7302_170# divbuf_0/a_7302_n240# 0.01fF
C1732 divbuf_0/a_4392_170# divbuf_0/a_4392_n240# 0.01fF
C1733 divbuf_0/a_2322_n240# divbuf_0/OUT2 0.04fF
C1734 divbuf_0/a_12510_n840# divbuf_0/a_12990_n840# 0.07fF
C1735 divbuf_0/a_20532_170# divbuf_0/a_20532_n240# 0.01fF
C1736 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n1540# 0.19fF
C1737 divbuf_0/a_41382_170# divbuf_0/OUT5 0.07fF
C1738 divbuf_0/a_39932_170# divbuf_0/a_40412_170# 0.07fF
Xpd_0 VDD vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xcp_0 io_analog[3] vdda1 vssa1 io_analog[0] io_analog[1] io_analog[2] cp
Xcp_1 cp_1/vbias vdd vssa1 cp_1/out cp_1/down cp_1/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xdivbuf_0 VDD divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ vssa1 divbuf
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
C1739 io_analog[4] vdda1 25.05fF
C1740 io_analog[5] vdda1 25.05fF
C1741 io_analog[6] vdda1 25.05fF
C1742 io_in_3v3[0] vdda1 0.61fF
C1743 io_oeb[26] vdda1 0.61fF
C1744 io_in[0] vdda1 0.61fF
C1745 io_out[26] vdda1 0.61fF
C1746 io_out[0] vdda1 0.61fF
C1747 io_in[26] vdda1 0.61fF
C1748 io_oeb[0] vdda1 0.61fF
C1749 io_in_3v3[26] vdda1 0.61fF
C1750 io_in_3v3[1] vdda1 0.61fF
C1751 io_oeb[25] vdda1 0.61fF
C1752 io_in[1] vdda1 0.61fF
C1753 io_out[25] vdda1 0.61fF
C1754 io_out[1] vdda1 0.61fF
C1755 io_in[25] vdda1 0.61fF
C1756 io_oeb[1] vdda1 0.61fF
C1757 io_in_3v3[25] vdda1 0.61fF
C1758 io_in_3v3[2] vdda1 0.61fF
C1759 io_oeb[24] vdda1 0.61fF
C1760 io_in[2] vdda1 0.61fF
C1761 io_out[24] vdda1 0.61fF
C1762 io_out[2] vdda1 0.61fF
C1763 io_in[24] vdda1 0.61fF
C1764 io_oeb[2] vdda1 0.61fF
C1765 io_in_3v3[24] vdda1 0.61fF
C1766 io_in_3v3[3] vdda1 0.61fF
C1767 gpio_noesd[17] vdda1 0.61fF
C1768 io_in[3] vdda1 0.61fF
C1769 gpio_analog[17] vdda1 0.61fF
C1770 io_out[3] vdda1 0.61fF
C1771 io_oeb[3] vdda1 0.61fF
C1772 io_in_3v3[4] vdda1 0.61fF
C1773 io_in[4] vdda1 0.61fF
C1774 io_out[4] vdda1 0.61fF
C1775 io_oeb[4] vdda1 0.61fF
C1776 io_oeb[23] vdda1 0.61fF
C1777 io_out[23] vdda1 0.61fF
C1778 io_in[23] vdda1 0.61fF
C1779 io_in_3v3[23] vdda1 0.61fF
C1780 gpio_noesd[16] vdda1 0.61fF
C1781 gpio_analog[16] vdda1 0.61fF
C1782 io_in_3v3[5] vdda1 0.61fF
C1783 io_in[5] vdda1 0.61fF
C1784 io_out[5] vdda1 0.61fF
C1785 io_oeb[5] vdda1 0.61fF
C1786 io_oeb[22] vdda1 0.61fF
C1787 io_out[22] vdda1 0.61fF
C1788 io_in[22] vdda1 0.61fF
C1789 io_in_3v3[22] vdda1 0.61fF
C1790 gpio_noesd[15] vdda1 0.61fF
C1791 gpio_analog[15] vdda1 0.61fF
C1792 io_in_3v3[6] vdda1 0.61fF
C1793 io_in[6] vdda1 0.61fF
C1794 io_out[6] vdda1 0.61fF
C1795 io_oeb[6] vdda1 0.61fF
C1796 io_oeb[21] vdda1 0.61fF
C1797 io_out[21] vdda1 0.61fF
C1798 io_in[21] vdda1 0.61fF
C1799 io_in_3v3[21] vdda1 0.61fF
C1800 gpio_noesd[14] vdda1 0.61fF
C1801 gpio_analog[14] vdda1 0.61fF
C1802 vssd2 vdda1 13.04fF
C1803 vssd1 vdda1 13.04fF
C1804 vdda2 vdda1 13.04fF
C1805 io_oeb[20] vdda1 0.61fF
C1806 io_out[20] vdda1 0.61fF
C1807 io_in[20] vdda1 0.61fF
C1808 io_in_3v3[20] vdda1 0.61fF
C1809 gpio_noesd[13] vdda1 0.61fF
C1810 gpio_analog[13] vdda1 0.61fF
C1811 gpio_analog[0] vdda1 0.61fF
C1812 gpio_noesd[0] vdda1 0.61fF
C1813 io_in_3v3[7] vdda1 0.61fF
C1814 io_in[7] vdda1 0.61fF
C1815 io_out[7] vdda1 0.61fF
C1816 io_oeb[7] vdda1 0.61fF
C1817 io_oeb[19] vdda1 0.61fF
C1818 io_out[19] vdda1 0.61fF
C1819 io_in[19] vdda1 0.61fF
C1820 io_in_3v3[19] vdda1 0.61fF
C1821 gpio_noesd[12] vdda1 0.61fF
C1822 gpio_analog[12] vdda1 0.61fF
C1823 gpio_analog[1] vdda1 0.61fF
C1824 gpio_noesd[1] vdda1 0.61fF
C1825 io_in_3v3[8] vdda1 0.61fF
C1826 io_in[8] vdda1 0.61fF
C1827 io_out[8] vdda1 0.61fF
C1828 io_oeb[8] vdda1 0.61fF
C1829 io_oeb[18] vdda1 0.61fF
C1830 io_out[18] vdda1 0.61fF
C1831 io_in[18] vdda1 0.61fF
C1832 io_in_3v3[18] vdda1 0.61fF
C1833 gpio_noesd[11] vdda1 0.61fF
C1834 gpio_analog[11] vdda1 0.61fF
C1835 gpio_analog[2] vdda1 0.61fF
C1836 gpio_noesd[2] vdda1 0.61fF
C1837 io_in_3v3[9] vdda1 0.61fF
C1838 io_in[9] vdda1 0.61fF
C1839 io_out[9] vdda1 0.61fF
C1840 io_oeb[9] vdda1 0.61fF
C1841 io_oeb[17] vdda1 0.61fF
C1842 io_out[17] vdda1 0.61fF
C1843 io_in[17] vdda1 0.61fF
C1844 io_in_3v3[17] vdda1 0.61fF
C1845 gpio_noesd[10] vdda1 0.61fF
C1846 gpio_analog[10] vdda1 0.61fF
C1847 gpio_analog[3] vdda1 0.61fF
C1848 gpio_noesd[3] vdda1 0.61fF
C1849 io_in_3v3[10] vdda1 0.61fF
C1850 io_in[10] vdda1 0.61fF
C1851 io_out[10] vdda1 0.61fF
C1852 io_oeb[10] vdda1 0.61fF
C1853 io_oeb[16] vdda1 0.61fF
C1854 io_out[16] vdda1 0.61fF
C1855 io_in[16] vdda1 0.61fF
C1856 io_in_3v3[16] vdda1 0.61fF
C1857 gpio_noesd[9] vdda1 0.61fF
C1858 gpio_analog[9] vdda1 0.61fF
C1859 gpio_analog[4] vdda1 0.61fF
C1860 gpio_noesd[4] vdda1 0.61fF
C1861 io_in_3v3[11] vdda1 0.61fF
C1862 io_in[11] vdda1 0.61fF
C1863 io_out[11] vdda1 0.61fF
C1864 io_oeb[11] vdda1 0.61fF
C1865 io_oeb[15] vdda1 0.61fF
C1866 io_out[15] vdda1 0.61fF
C1867 io_in[15] vdda1 0.61fF
C1868 io_in_3v3[15] vdda1 0.61fF
C1869 gpio_noesd[8] vdda1 0.61fF
C1870 gpio_analog[8] vdda1 0.61fF
C1871 gpio_analog[5] vdda1 0.61fF
C1872 gpio_noesd[5] vdda1 0.61fF
C1873 io_in_3v3[12] vdda1 0.61fF
C1874 io_in[12] vdda1 0.61fF
C1875 io_out[12] vdda1 0.61fF
C1876 io_oeb[12] vdda1 0.61fF
C1877 io_oeb[14] vdda1 0.61fF
C1878 io_out[14] vdda1 0.61fF
C1879 io_in[14] vdda1 0.61fF
C1880 io_in_3v3[14] vdda1 0.61fF
C1881 gpio_noesd[7] vdda1 0.61fF
C1882 gpio_analog[7] vdda1 0.61fF
C1883 vssa2 vdda1 13.04fF
C1884 gpio_analog[6] vdda1 0.61fF
C1885 gpio_noesd[6] vdda1 0.61fF
C1886 io_in_3v3[13] vdda1 0.61fF
C1887 io_in[13] vdda1 0.61fF
C1888 io_out[13] vdda1 0.61fF
C1889 io_oeb[13] vdda1 0.61fF
C1890 vccd1 vdda1 13.04fF
C1891 vccd2 vdda1 13.04fF
C1892 io_analog[10] vdda1 6.83fF
C1893 io_clamp_high[0] vdda1 3.58fF
C1894 io_clamp_low[0] vdda1 3.58fF
C1895 io_clamp_high[1] vdda1 3.58fF
C1896 io_clamp_low[1] vdda1 3.58fF
C1897 io_clamp_high[2] vdda1 3.58fF
C1898 io_clamp_low[2] vdda1 3.58fF
C1899 io_analog[7] vdda1 6.83fF
C1900 io_analog[8] vdda1 6.83fF
C1901 io_analog[9] vdda1 6.83fF
C1902 user_irq[2] vdda1 0.63fF
C1903 user_irq[1] vdda1 0.63fF
C1904 user_irq[0] vdda1 0.63fF
C1905 user_clock2 vdda1 0.63fF
C1906 la_oenb[127] vdda1 0.63fF
C1907 la_data_out[127] vdda1 0.63fF
C1908 la_data_in[127] vdda1 0.63fF
C1909 la_oenb[126] vdda1 0.63fF
C1910 la_data_out[126] vdda1 0.63fF
C1911 la_data_in[126] vdda1 0.63fF
C1912 la_oenb[125] vdda1 0.63fF
C1913 la_data_out[125] vdda1 0.63fF
C1914 la_data_in[125] vdda1 0.63fF
C1915 la_oenb[124] vdda1 0.63fF
C1916 la_data_out[124] vdda1 0.63fF
C1917 la_data_in[124] vdda1 0.63fF
C1918 la_oenb[123] vdda1 0.63fF
C1919 la_data_out[123] vdda1 0.63fF
C1920 la_data_in[123] vdda1 0.63fF
C1921 la_oenb[122] vdda1 0.63fF
C1922 la_data_out[122] vdda1 0.63fF
C1923 la_data_in[122] vdda1 0.63fF
C1924 la_oenb[121] vdda1 0.63fF
C1925 la_data_out[121] vdda1 0.63fF
C1926 la_data_in[121] vdda1 0.63fF
C1927 la_oenb[120] vdda1 0.63fF
C1928 la_data_out[120] vdda1 0.63fF
C1929 la_data_in[120] vdda1 0.63fF
C1930 la_oenb[119] vdda1 0.63fF
C1931 la_data_out[119] vdda1 0.63fF
C1932 la_data_in[119] vdda1 0.63fF
C1933 la_oenb[118] vdda1 0.63fF
C1934 la_data_out[118] vdda1 0.63fF
C1935 la_data_in[118] vdda1 0.63fF
C1936 la_oenb[117] vdda1 0.63fF
C1937 la_data_out[117] vdda1 0.63fF
C1938 la_data_in[117] vdda1 0.63fF
C1939 la_oenb[116] vdda1 0.63fF
C1940 la_data_out[116] vdda1 0.63fF
C1941 la_data_in[116] vdda1 0.63fF
C1942 la_oenb[115] vdda1 0.63fF
C1943 la_data_out[115] vdda1 0.63fF
C1944 la_data_in[115] vdda1 0.63fF
C1945 la_oenb[114] vdda1 0.63fF
C1946 la_data_out[114] vdda1 0.63fF
C1947 la_data_in[114] vdda1 0.63fF
C1948 la_oenb[113] vdda1 0.63fF
C1949 la_data_out[113] vdda1 0.63fF
C1950 la_data_in[113] vdda1 0.63fF
C1951 la_oenb[112] vdda1 0.63fF
C1952 la_data_out[112] vdda1 0.63fF
C1953 la_data_in[112] vdda1 0.63fF
C1954 la_oenb[111] vdda1 0.63fF
C1955 la_data_out[111] vdda1 0.63fF
C1956 la_data_in[111] vdda1 0.63fF
C1957 la_oenb[110] vdda1 0.63fF
C1958 la_data_out[110] vdda1 0.63fF
C1959 la_data_in[110] vdda1 0.63fF
C1960 la_oenb[109] vdda1 0.63fF
C1961 la_data_out[109] vdda1 0.63fF
C1962 la_data_in[109] vdda1 0.63fF
C1963 la_oenb[108] vdda1 0.63fF
C1964 la_data_out[108] vdda1 0.63fF
C1965 la_data_in[108] vdda1 0.63fF
C1966 la_oenb[107] vdda1 0.63fF
C1967 la_data_out[107] vdda1 0.63fF
C1968 la_data_in[107] vdda1 0.63fF
C1969 la_oenb[106] vdda1 0.63fF
C1970 la_data_out[106] vdda1 0.63fF
C1971 la_data_in[106] vdda1 0.63fF
C1972 la_oenb[105] vdda1 0.63fF
C1973 la_data_out[105] vdda1 0.63fF
C1974 la_data_in[105] vdda1 0.63fF
C1975 la_oenb[104] vdda1 0.63fF
C1976 la_data_out[104] vdda1 0.63fF
C1977 la_data_in[104] vdda1 0.63fF
C1978 la_oenb[103] vdda1 0.63fF
C1979 la_data_out[103] vdda1 0.63fF
C1980 la_data_in[103] vdda1 0.63fF
C1981 la_oenb[102] vdda1 0.63fF
C1982 la_data_out[102] vdda1 0.63fF
C1983 la_data_in[102] vdda1 0.63fF
C1984 la_oenb[101] vdda1 0.63fF
C1985 la_data_out[101] vdda1 0.63fF
C1986 la_data_in[101] vdda1 0.63fF
C1987 la_oenb[100] vdda1 0.63fF
C1988 la_data_out[100] vdda1 0.63fF
C1989 la_data_in[100] vdda1 0.63fF
C1990 la_oenb[99] vdda1 0.63fF
C1991 la_data_out[99] vdda1 0.63fF
C1992 la_data_in[99] vdda1 0.63fF
C1993 la_oenb[98] vdda1 0.63fF
C1994 la_data_out[98] vdda1 0.63fF
C1995 la_data_in[98] vdda1 0.63fF
C1996 la_oenb[97] vdda1 0.63fF
C1997 la_data_out[97] vdda1 0.63fF
C1998 la_data_in[97] vdda1 0.63fF
C1999 la_oenb[96] vdda1 0.63fF
C2000 la_data_out[96] vdda1 0.63fF
C2001 la_data_in[96] vdda1 0.63fF
C2002 la_oenb[95] vdda1 0.63fF
C2003 la_data_out[95] vdda1 0.63fF
C2004 la_data_in[95] vdda1 0.63fF
C2005 la_oenb[94] vdda1 0.63fF
C2006 la_data_out[94] vdda1 0.63fF
C2007 la_data_in[94] vdda1 0.63fF
C2008 la_oenb[93] vdda1 0.63fF
C2009 la_data_out[93] vdda1 0.63fF
C2010 la_data_in[93] vdda1 0.63fF
C2011 la_oenb[92] vdda1 0.63fF
C2012 la_data_out[92] vdda1 0.63fF
C2013 la_data_in[92] vdda1 0.63fF
C2014 la_oenb[91] vdda1 0.63fF
C2015 la_data_out[91] vdda1 0.63fF
C2016 la_data_in[91] vdda1 0.63fF
C2017 la_oenb[90] vdda1 0.63fF
C2018 la_data_out[90] vdda1 0.63fF
C2019 la_data_in[90] vdda1 0.63fF
C2020 la_oenb[89] vdda1 0.63fF
C2021 la_data_out[89] vdda1 0.63fF
C2022 la_data_in[89] vdda1 0.63fF
C2023 la_oenb[88] vdda1 0.63fF
C2024 la_data_out[88] vdda1 0.63fF
C2025 la_data_in[88] vdda1 0.63fF
C2026 la_oenb[87] vdda1 0.63fF
C2027 la_data_out[87] vdda1 0.63fF
C2028 la_data_in[87] vdda1 0.63fF
C2029 la_oenb[86] vdda1 0.63fF
C2030 la_data_out[86] vdda1 0.63fF
C2031 la_data_in[86] vdda1 0.63fF
C2032 la_oenb[85] vdda1 0.63fF
C2033 la_data_out[85] vdda1 0.63fF
C2034 la_data_in[85] vdda1 0.63fF
C2035 la_oenb[84] vdda1 0.63fF
C2036 la_data_out[84] vdda1 0.63fF
C2037 la_data_in[84] vdda1 0.63fF
C2038 la_oenb[83] vdda1 0.63fF
C2039 la_data_out[83] vdda1 0.63fF
C2040 la_data_in[83] vdda1 0.63fF
C2041 la_oenb[82] vdda1 0.63fF
C2042 la_data_out[82] vdda1 0.63fF
C2043 la_data_in[82] vdda1 0.63fF
C2044 la_oenb[81] vdda1 0.63fF
C2045 la_data_out[81] vdda1 0.63fF
C2046 la_data_in[81] vdda1 0.63fF
C2047 la_oenb[80] vdda1 0.63fF
C2048 la_data_out[80] vdda1 0.63fF
C2049 la_data_in[80] vdda1 0.63fF
C2050 la_oenb[79] vdda1 0.63fF
C2051 la_data_out[79] vdda1 0.63fF
C2052 la_data_in[79] vdda1 0.63fF
C2053 la_oenb[78] vdda1 0.63fF
C2054 la_data_out[78] vdda1 0.63fF
C2055 la_data_in[78] vdda1 0.63fF
C2056 la_oenb[77] vdda1 0.63fF
C2057 la_data_out[77] vdda1 0.63fF
C2058 la_data_in[77] vdda1 0.63fF
C2059 la_oenb[76] vdda1 0.63fF
C2060 la_data_out[76] vdda1 0.63fF
C2061 la_data_in[76] vdda1 0.63fF
C2062 la_oenb[75] vdda1 0.63fF
C2063 la_data_out[75] vdda1 0.63fF
C2064 la_data_in[75] vdda1 0.63fF
C2065 la_oenb[74] vdda1 0.63fF
C2066 la_data_out[74] vdda1 0.63fF
C2067 la_data_in[74] vdda1 0.63fF
C2068 la_oenb[73] vdda1 0.63fF
C2069 la_data_out[73] vdda1 0.63fF
C2070 la_data_in[73] vdda1 0.63fF
C2071 la_oenb[72] vdda1 0.63fF
C2072 la_data_out[72] vdda1 0.63fF
C2073 la_data_in[72] vdda1 0.63fF
C2074 la_oenb[71] vdda1 0.63fF
C2075 la_data_out[71] vdda1 0.63fF
C2076 la_data_in[71] vdda1 0.63fF
C2077 la_oenb[70] vdda1 0.63fF
C2078 la_data_out[70] vdda1 0.63fF
C2079 la_data_in[70] vdda1 0.63fF
C2080 la_oenb[69] vdda1 0.63fF
C2081 la_data_out[69] vdda1 0.63fF
C2082 la_data_in[69] vdda1 0.63fF
C2083 la_oenb[68] vdda1 0.63fF
C2084 la_data_out[68] vdda1 0.63fF
C2085 la_data_in[68] vdda1 0.63fF
C2086 la_oenb[67] vdda1 0.63fF
C2087 la_data_out[67] vdda1 0.63fF
C2088 la_data_in[67] vdda1 0.63fF
C2089 la_oenb[66] vdda1 0.63fF
C2090 la_data_out[66] vdda1 0.63fF
C2091 la_data_in[66] vdda1 0.63fF
C2092 la_oenb[65] vdda1 0.63fF
C2093 la_data_out[65] vdda1 0.63fF
C2094 la_data_in[65] vdda1 0.63fF
C2095 la_oenb[64] vdda1 0.63fF
C2096 la_data_out[64] vdda1 0.63fF
C2097 la_data_in[64] vdda1 0.63fF
C2098 la_oenb[63] vdda1 0.63fF
C2099 la_data_out[63] vdda1 0.63fF
C2100 la_data_in[63] vdda1 0.63fF
C2101 la_oenb[62] vdda1 0.63fF
C2102 la_data_out[62] vdda1 0.63fF
C2103 la_data_in[62] vdda1 0.63fF
C2104 la_oenb[61] vdda1 0.63fF
C2105 la_data_out[61] vdda1 0.63fF
C2106 la_data_in[61] vdda1 0.63fF
C2107 la_oenb[60] vdda1 0.63fF
C2108 la_data_out[60] vdda1 0.63fF
C2109 la_data_in[60] vdda1 0.63fF
C2110 la_oenb[59] vdda1 0.63fF
C2111 la_data_out[59] vdda1 0.63fF
C2112 la_data_in[59] vdda1 0.63fF
C2113 la_oenb[58] vdda1 0.63fF
C2114 la_data_out[58] vdda1 0.63fF
C2115 la_data_in[58] vdda1 0.63fF
C2116 la_oenb[57] vdda1 0.63fF
C2117 la_data_out[57] vdda1 0.63fF
C2118 la_data_in[57] vdda1 0.63fF
C2119 la_oenb[56] vdda1 0.63fF
C2120 la_data_out[56] vdda1 0.63fF
C2121 la_data_in[56] vdda1 0.63fF
C2122 la_oenb[55] vdda1 0.63fF
C2123 la_data_out[55] vdda1 0.63fF
C2124 la_data_in[55] vdda1 0.63fF
C2125 la_oenb[54] vdda1 0.63fF
C2126 la_data_out[54] vdda1 0.63fF
C2127 la_data_in[54] vdda1 0.63fF
C2128 la_oenb[53] vdda1 0.63fF
C2129 la_data_out[53] vdda1 0.63fF
C2130 la_data_in[53] vdda1 0.63fF
C2131 la_oenb[52] vdda1 0.63fF
C2132 la_data_out[52] vdda1 0.63fF
C2133 la_data_in[52] vdda1 0.63fF
C2134 la_oenb[51] vdda1 0.63fF
C2135 la_data_out[51] vdda1 0.63fF
C2136 la_data_in[51] vdda1 0.63fF
C2137 la_oenb[50] vdda1 0.63fF
C2138 la_data_out[50] vdda1 0.63fF
C2139 la_data_in[50] vdda1 0.63fF
C2140 la_oenb[49] vdda1 0.63fF
C2141 la_data_out[49] vdda1 0.63fF
C2142 la_data_in[49] vdda1 0.63fF
C2143 la_oenb[48] vdda1 0.63fF
C2144 la_data_out[48] vdda1 0.63fF
C2145 la_data_in[48] vdda1 0.63fF
C2146 la_oenb[47] vdda1 0.63fF
C2147 la_data_out[47] vdda1 0.63fF
C2148 la_data_in[47] vdda1 0.63fF
C2149 la_oenb[46] vdda1 0.63fF
C2150 la_data_out[46] vdda1 0.63fF
C2151 la_data_in[46] vdda1 0.63fF
C2152 la_oenb[45] vdda1 0.63fF
C2153 la_data_out[45] vdda1 0.63fF
C2154 la_data_in[45] vdda1 0.63fF
C2155 la_oenb[44] vdda1 0.63fF
C2156 la_data_out[44] vdda1 0.63fF
C2157 la_data_in[44] vdda1 0.63fF
C2158 la_oenb[43] vdda1 0.63fF
C2159 la_data_out[43] vdda1 0.63fF
C2160 la_data_in[43] vdda1 0.63fF
C2161 la_oenb[42] vdda1 0.63fF
C2162 la_data_out[42] vdda1 0.63fF
C2163 la_data_in[42] vdda1 0.63fF
C2164 la_oenb[41] vdda1 0.63fF
C2165 la_data_out[41] vdda1 0.63fF
C2166 la_data_in[41] vdda1 0.63fF
C2167 la_oenb[40] vdda1 0.63fF
C2168 la_data_out[40] vdda1 0.63fF
C2169 la_data_in[40] vdda1 0.63fF
C2170 la_oenb[39] vdda1 0.63fF
C2171 la_data_out[39] vdda1 0.63fF
C2172 la_data_in[39] vdda1 0.63fF
C2173 la_oenb[38] vdda1 0.63fF
C2174 la_data_out[38] vdda1 0.63fF
C2175 la_data_in[38] vdda1 0.63fF
C2176 la_oenb[37] vdda1 0.63fF
C2177 la_data_out[37] vdda1 0.63fF
C2178 la_data_in[37] vdda1 0.63fF
C2179 la_oenb[36] vdda1 0.63fF
C2180 la_data_out[36] vdda1 0.63fF
C2181 la_data_in[36] vdda1 0.63fF
C2182 la_oenb[35] vdda1 0.63fF
C2183 la_data_out[35] vdda1 0.63fF
C2184 la_data_in[35] vdda1 0.63fF
C2185 la_oenb[34] vdda1 0.63fF
C2186 la_data_out[34] vdda1 0.63fF
C2187 la_data_in[34] vdda1 0.63fF
C2188 la_oenb[33] vdda1 0.63fF
C2189 la_data_out[33] vdda1 0.63fF
C2190 la_data_in[33] vdda1 0.63fF
C2191 la_oenb[32] vdda1 0.63fF
C2192 la_data_out[32] vdda1 0.63fF
C2193 la_data_in[32] vdda1 0.63fF
C2194 la_oenb[31] vdda1 0.63fF
C2195 la_data_out[31] vdda1 0.63fF
C2196 la_data_in[31] vdda1 0.63fF
C2197 la_oenb[30] vdda1 0.63fF
C2198 la_data_out[30] vdda1 0.63fF
C2199 la_data_in[30] vdda1 0.63fF
C2200 la_oenb[29] vdda1 0.63fF
C2201 la_data_out[29] vdda1 0.63fF
C2202 la_data_in[29] vdda1 0.63fF
C2203 la_oenb[28] vdda1 0.63fF
C2204 la_data_out[28] vdda1 0.63fF
C2205 la_data_in[28] vdda1 0.63fF
C2206 la_oenb[27] vdda1 0.63fF
C2207 la_data_out[27] vdda1 0.63fF
C2208 la_data_in[27] vdda1 0.63fF
C2209 la_oenb[26] vdda1 0.63fF
C2210 la_data_out[26] vdda1 0.63fF
C2211 la_data_in[26] vdda1 0.63fF
C2212 la_oenb[25] vdda1 0.63fF
C2213 la_data_out[25] vdda1 0.63fF
C2214 la_data_in[25] vdda1 0.63fF
C2215 la_oenb[24] vdda1 0.63fF
C2216 la_data_out[24] vdda1 0.63fF
C2217 la_data_in[24] vdda1 0.63fF
C2218 la_oenb[23] vdda1 0.63fF
C2219 la_data_out[23] vdda1 0.63fF
C2220 la_data_in[23] vdda1 0.63fF
C2221 la_oenb[22] vdda1 0.63fF
C2222 la_data_out[22] vdda1 0.63fF
C2223 la_data_in[22] vdda1 0.63fF
C2224 la_oenb[21] vdda1 0.63fF
C2225 la_data_out[21] vdda1 0.63fF
C2226 la_data_in[21] vdda1 0.63fF
C2227 la_oenb[20] vdda1 0.63fF
C2228 la_data_out[20] vdda1 0.63fF
C2229 la_data_in[20] vdda1 0.63fF
C2230 la_oenb[19] vdda1 0.63fF
C2231 la_data_out[19] vdda1 0.63fF
C2232 la_data_in[19] vdda1 0.63fF
C2233 la_oenb[18] vdda1 0.63fF
C2234 la_data_out[18] vdda1 0.63fF
C2235 la_data_in[18] vdda1 0.63fF
C2236 la_oenb[17] vdda1 0.63fF
C2237 la_data_out[17] vdda1 0.63fF
C2238 la_data_in[17] vdda1 0.63fF
C2239 la_oenb[16] vdda1 0.63fF
C2240 la_data_out[16] vdda1 0.63fF
C2241 la_data_in[16] vdda1 0.63fF
C2242 la_oenb[15] vdda1 0.63fF
C2243 la_data_out[15] vdda1 0.63fF
C2244 la_data_in[15] vdda1 0.63fF
C2245 la_oenb[14] vdda1 0.63fF
C2246 la_data_out[14] vdda1 0.63fF
C2247 la_data_in[14] vdda1 0.63fF
C2248 la_oenb[13] vdda1 0.63fF
C2249 la_data_out[13] vdda1 0.63fF
C2250 la_data_in[13] vdda1 0.63fF
C2251 la_oenb[12] vdda1 0.63fF
C2252 la_data_out[12] vdda1 0.63fF
C2253 la_data_in[12] vdda1 0.63fF
C2254 la_oenb[11] vdda1 0.63fF
C2255 la_data_out[11] vdda1 0.63fF
C2256 la_data_in[11] vdda1 0.63fF
C2257 la_oenb[10] vdda1 0.63fF
C2258 la_data_out[10] vdda1 0.63fF
C2259 la_data_in[10] vdda1 0.63fF
C2260 la_oenb[9] vdda1 0.63fF
C2261 la_data_out[9] vdda1 0.63fF
C2262 la_data_in[9] vdda1 0.63fF
C2263 la_oenb[8] vdda1 0.63fF
C2264 la_data_out[8] vdda1 0.63fF
C2265 la_data_in[8] vdda1 0.63fF
C2266 la_oenb[7] vdda1 0.63fF
C2267 la_data_out[7] vdda1 0.63fF
C2268 la_data_in[7] vdda1 0.63fF
C2269 la_oenb[6] vdda1 0.63fF
C2270 la_data_out[6] vdda1 0.63fF
C2271 la_data_in[6] vdda1 0.63fF
C2272 la_oenb[5] vdda1 0.63fF
C2273 la_data_out[5] vdda1 0.63fF
C2274 la_data_in[5] vdda1 0.63fF
C2275 la_oenb[4] vdda1 0.63fF
C2276 la_data_out[4] vdda1 0.63fF
C2277 la_data_in[4] vdda1 0.63fF
C2278 la_oenb[3] vdda1 0.63fF
C2279 la_data_out[3] vdda1 0.63fF
C2280 la_data_in[3] vdda1 0.63fF
C2281 la_oenb[2] vdda1 0.63fF
C2282 la_data_out[2] vdda1 0.63fF
C2283 la_data_in[2] vdda1 0.63fF
C2284 la_oenb[1] vdda1 0.63fF
C2285 la_data_out[1] vdda1 0.63fF
C2286 la_data_in[1] vdda1 0.63fF
C2287 la_oenb[0] vdda1 0.63fF
C2288 la_data_out[0] vdda1 0.63fF
C2289 la_data_in[0] vdda1 0.63fF
C2290 wbs_dat_o[31] vdda1 0.63fF
C2291 wbs_dat_i[31] vdda1 0.63fF
C2292 wbs_adr_i[31] vdda1 0.63fF
C2293 wbs_dat_o[30] vdda1 0.63fF
C2294 wbs_dat_i[30] vdda1 0.63fF
C2295 wbs_adr_i[30] vdda1 0.63fF
C2296 wbs_dat_o[29] vdda1 0.63fF
C2297 wbs_dat_i[29] vdda1 0.63fF
C2298 wbs_adr_i[29] vdda1 0.63fF
C2299 wbs_dat_o[28] vdda1 0.63fF
C2300 wbs_dat_i[28] vdda1 0.63fF
C2301 wbs_adr_i[28] vdda1 0.63fF
C2302 wbs_dat_o[27] vdda1 0.63fF
C2303 wbs_dat_i[27] vdda1 0.63fF
C2304 wbs_adr_i[27] vdda1 0.63fF
C2305 wbs_dat_o[26] vdda1 0.63fF
C2306 wbs_dat_i[26] vdda1 0.63fF
C2307 wbs_adr_i[26] vdda1 0.63fF
C2308 wbs_dat_o[25] vdda1 0.63fF
C2309 wbs_dat_i[25] vdda1 0.63fF
C2310 wbs_adr_i[25] vdda1 0.63fF
C2311 wbs_dat_o[24] vdda1 0.63fF
C2312 wbs_dat_i[24] vdda1 0.63fF
C2313 wbs_adr_i[24] vdda1 0.63fF
C2314 wbs_dat_o[23] vdda1 0.63fF
C2315 wbs_dat_i[23] vdda1 0.63fF
C2316 wbs_adr_i[23] vdda1 0.63fF
C2317 wbs_dat_o[22] vdda1 0.63fF
C2318 wbs_dat_i[22] vdda1 0.63fF
C2319 wbs_adr_i[22] vdda1 0.63fF
C2320 wbs_dat_o[21] vdda1 0.63fF
C2321 wbs_dat_i[21] vdda1 0.63fF
C2322 wbs_adr_i[21] vdda1 0.63fF
C2323 wbs_dat_o[20] vdda1 0.63fF
C2324 wbs_dat_i[20] vdda1 0.63fF
C2325 wbs_adr_i[20] vdda1 0.63fF
C2326 wbs_dat_o[19] vdda1 0.63fF
C2327 wbs_dat_i[19] vdda1 0.63fF
C2328 wbs_adr_i[19] vdda1 0.63fF
C2329 wbs_dat_o[18] vdda1 0.63fF
C2330 wbs_dat_i[18] vdda1 0.63fF
C2331 wbs_adr_i[18] vdda1 0.63fF
C2332 wbs_dat_o[17] vdda1 0.63fF
C2333 wbs_dat_i[17] vdda1 0.63fF
C2334 wbs_adr_i[17] vdda1 0.63fF
C2335 wbs_dat_o[16] vdda1 0.63fF
C2336 wbs_dat_i[16] vdda1 0.63fF
C2337 wbs_adr_i[16] vdda1 0.63fF
C2338 wbs_dat_o[15] vdda1 0.63fF
C2339 wbs_dat_i[15] vdda1 0.63fF
C2340 wbs_adr_i[15] vdda1 0.63fF
C2341 wbs_dat_o[14] vdda1 0.63fF
C2342 wbs_dat_i[14] vdda1 0.63fF
C2343 wbs_adr_i[14] vdda1 0.63fF
C2344 wbs_dat_o[13] vdda1 0.63fF
C2345 wbs_dat_i[13] vdda1 0.63fF
C2346 wbs_adr_i[13] vdda1 0.63fF
C2347 wbs_dat_o[12] vdda1 0.63fF
C2348 wbs_dat_i[12] vdda1 0.63fF
C2349 wbs_adr_i[12] vdda1 0.63fF
C2350 wbs_dat_o[11] vdda1 0.63fF
C2351 wbs_dat_i[11] vdda1 0.63fF
C2352 wbs_adr_i[11] vdda1 0.63fF
C2353 wbs_dat_o[10] vdda1 0.63fF
C2354 wbs_dat_i[10] vdda1 0.63fF
C2355 wbs_adr_i[10] vdda1 0.63fF
C2356 wbs_dat_o[9] vdda1 0.63fF
C2357 wbs_dat_i[9] vdda1 0.63fF
C2358 wbs_adr_i[9] vdda1 0.63fF
C2359 wbs_dat_o[8] vdda1 0.63fF
C2360 wbs_dat_i[8] vdda1 0.63fF
C2361 wbs_adr_i[8] vdda1 0.63fF
C2362 wbs_dat_o[7] vdda1 0.63fF
C2363 wbs_dat_i[7] vdda1 0.63fF
C2364 wbs_adr_i[7] vdda1 0.63fF
C2365 wbs_dat_o[6] vdda1 0.63fF
C2366 wbs_dat_i[6] vdda1 0.63fF
C2367 wbs_adr_i[6] vdda1 0.63fF
C2368 wbs_dat_o[5] vdda1 0.63fF
C2369 wbs_dat_i[5] vdda1 0.63fF
C2370 wbs_adr_i[5] vdda1 0.63fF
C2371 wbs_dat_o[4] vdda1 0.63fF
C2372 wbs_dat_i[4] vdda1 0.63fF
C2373 wbs_adr_i[4] vdda1 0.63fF
C2374 wbs_sel_i[3] vdda1 0.63fF
C2375 wbs_dat_o[3] vdda1 0.63fF
C2376 wbs_dat_i[3] vdda1 0.63fF
C2377 wbs_adr_i[3] vdda1 0.63fF
C2378 wbs_sel_i[2] vdda1 0.63fF
C2379 wbs_dat_o[2] vdda1 0.63fF
C2380 wbs_dat_i[2] vdda1 0.63fF
C2381 wbs_adr_i[2] vdda1 0.63fF
C2382 wbs_sel_i[1] vdda1 0.63fF
C2383 wbs_dat_o[1] vdda1 0.63fF
C2384 wbs_dat_i[1] vdda1 0.63fF
C2385 wbs_adr_i[1] vdda1 0.63fF
C2386 wbs_sel_i[0] vdda1 0.63fF
C2387 wbs_dat_o[0] vdda1 0.63fF
C2388 wbs_dat_i[0] vdda1 0.63fF
C2389 wbs_adr_i[0] vdda1 0.63fF
C2390 wbs_we_i vdda1 0.63fF
C2391 wbs_stb_i vdda1 0.63fF
C2392 wbs_cyc_i vdda1 0.63fF
C2393 wbs_ack_o vdda1 0.63fF
C2394 wb_rst_i vdda1 0.63fF
C2395 wb_clk_i vdda1 0.63fF
C2396 divider_0/and_0/Z1 vdda1 0.33fF
C2397 divider_0/and_0/B vdda1 1.79fF
C2398 divider_0/and_0/A vdda1 1.66fF
C2399 divider_0/and_0/out1 vdda1 2.71fF
C2400 divider_0/tspc_2/Z4 vdda1 0.42fF
C2401 divider_0/Out vdda1 1.31fF
C2402 divider_0/tspc_2/Z3 vdda1 2.00fF
C2403 divider_0/tspc_2/Z2 vdda1 1.29fF
C2404 divider_0/tspc_2/Z1 vdda1 0.99fF
C2405 divider_0/nor_0/B vdda1 5.25fF
C2406 divider_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C2407 divider_0/tspc_1/Z4 vdda1 0.42fF
C2408 divider_0/tspc_1/Q vdda1 2.79fF
C2409 divider_0/tspc_1/Z3 vdda1 2.00fF
C2410 divider_0/tspc_1/Z2 vdda1 1.29fF
C2411 divider_0/tspc_1/Z1 vdda1 0.99fF
C2412 divider_0/nor_1/B vdda1 5.95fF
C2413 divider_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C2414 divider_0/tspc_0/Z4 vdda1 0.42fF
C2415 divider_0/tspc_0/Q vdda1 2.81fF
C2416 divider_0/tspc_0/Z3 vdda1 2.00fF
C2417 divider_0/tspc_0/Z2 vdda1 1.30fF
C2418 divider_0/tspc_0/Z1 vdda1 0.99fF
C2419 divider_0/nor_1/A vdda1 6.02fF
C2420 divider_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C2421 divider_0/clk vdda1 5.56fF
C2422 divider_0/prescaler_0/Out vdda1 4.13fF
C2423 divider_0/prescaler_0/nand_1/z1 vdda1 0.20fF
C2424 gnd vdda1 21.94fF
C2425 divider_0/prescaler_0/tspc_2/D vdda1 2.59fF
C2426 divider_0/prescaler_0/tspc_0/Q vdda1 3.30fF
C2427 divider_0/prescaler_0/tspc_1/Q vdda1 2.78fF
C2428 divider_0/prescaler_0/nand_0/z1 vdda1 0.20fF
C2429 divider_0/prescaler_0/tspc_0/D vdda1 3.07fF
C2430 divider_0/and_0/OUT vdda1 5.35fF
C2431 divider_0/prescaler_0/tspc_2/Z4 vdda1 0.42fF
C2432 divider_0/prescaler_0/tspc_2/Z3 vdda1 2.00fF
C2433 divider_0/prescaler_0/tspc_2/Z2 vdda1 1.30fF
C2434 divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C2435 divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C2436 divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 1.89fF **FLOATING
C2437 divider_0/prescaler_0/tspc_1/Z4 vdda1 0.42fF
C2438 divider_0/prescaler_0/tspc_1/Z3 vdda1 2.00fF
C2439 divider_0/prescaler_0/tspc_1/Z2 vdda1 1.31fF
C2440 divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C2441 divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C2442 divider_0/prescaler_0/m1_2700_2190# vdda1 3.99fF **FLOATING
C2443 divider_0/prescaler_0/tspc_0/Z4 vdda1 0.42fF
C2444 divider_0/prescaler_0/tspc_0/Z3 vdda1 2.00fF
C2445 divider_0/prescaler_0/tspc_0/Z2 vdda1 1.30fF
C2446 divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C2447 divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C2448 divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 1.89fF **FLOATING
C2449 divider_0/nor_1/Z1 vdda1 1.33fF
C2450 divider_0/nor_0/Z1 vdda1 1.33fF
C2451 divider_0/mc2 vdda1 3.93fF
C2452 divbuf_0/OUT vdda1 3.28fF
C2453 divbuf_0/OUT5 vdda1 16.40fF
C2454 divbuf_0/OUT4 vdda1 100.06fF
C2455 divbuf_0/OUT3 vdda1 27.01fF
C2456 divbuf_0/OUT2 vdda1 8.71fF
C2457 divbuf_0/IN vdda1 0.89fF
C2458 divbuf_0/a_60990_n1540# vdda1 1.57fF **FLOATING
C2459 divbuf_0/a_60510_n1540# vdda1 1.62fF **FLOATING
C2460 divbuf_0/a_60030_n1540# vdda1 1.62fF **FLOATING
C2461 divbuf_0/a_59550_n1540# vdda1 1.62fF **FLOATING
C2462 divbuf_0/a_59070_n1540# vdda1 1.62fF **FLOATING
C2463 divbuf_0/a_58590_n1540# vdda1 1.62fF **FLOATING
C2464 divbuf_0/a_58110_n1540# vdda1 1.62fF **FLOATING
C2465 divbuf_0/a_57630_n1540# vdda1 1.62fF **FLOATING
C2466 divbuf_0/a_57150_n1540# vdda1 1.62fF **FLOATING
C2467 divbuf_0/a_56670_n1540# vdda1 1.62fF **FLOATING
C2468 divbuf_0/a_56190_n1540# vdda1 1.62fF **FLOATING
C2469 divbuf_0/a_55710_n1540# vdda1 1.62fF **FLOATING
C2470 divbuf_0/a_55230_n1540# vdda1 1.62fF **FLOATING
C2471 divbuf_0/a_54750_n1540# vdda1 1.62fF **FLOATING
C2472 divbuf_0/a_54270_n1540# vdda1 1.62fF **FLOATING
C2473 divbuf_0/a_53790_n1540# vdda1 1.62fF **FLOATING
C2474 divbuf_0/a_53310_n1540# vdda1 1.62fF **FLOATING
C2475 divbuf_0/a_52830_n1540# vdda1 1.62fF **FLOATING
C2476 divbuf_0/a_52350_n1540# vdda1 1.62fF **FLOATING
C2477 divbuf_0/a_51870_n1540# vdda1 1.62fF **FLOATING
C2478 divbuf_0/a_51390_n1540# vdda1 1.62fF **FLOATING
C2479 divbuf_0/a_50910_n1540# vdda1 1.62fF **FLOATING
C2480 divbuf_0/a_50430_n1540# vdda1 1.62fF **FLOATING
C2481 divbuf_0/a_49950_n1540# vdda1 1.62fF **FLOATING
C2482 divbuf_0/a_49470_n1540# vdda1 1.62fF **FLOATING
C2483 divbuf_0/a_48990_n1540# vdda1 1.62fF **FLOATING
C2484 divbuf_0/a_48510_n1540# vdda1 1.62fF **FLOATING
C2485 divbuf_0/a_48030_n1540# vdda1 1.62fF **FLOATING
C2486 divbuf_0/a_47550_n1540# vdda1 1.62fF **FLOATING
C2487 divbuf_0/a_47070_n1540# vdda1 1.62fF **FLOATING
C2488 divbuf_0/a_46590_n1540# vdda1 1.62fF **FLOATING
C2489 divbuf_0/a_46110_n1540# vdda1 1.62fF **FLOATING
C2490 divbuf_0/a_45630_n1540# vdda1 1.62fF **FLOATING
C2491 divbuf_0/a_45150_n1540# vdda1 1.62fF **FLOATING
C2492 divbuf_0/a_44670_n1540# vdda1 1.62fF **FLOATING
C2493 divbuf_0/a_44190_n1540# vdda1 1.62fF **FLOATING
C2494 divbuf_0/a_43710_n1540# vdda1 1.62fF **FLOATING
C2495 divbuf_0/a_43230_n1540# vdda1 1.62fF **FLOATING
C2496 divbuf_0/a_42750_n1540# vdda1 1.62fF **FLOATING
C2497 divbuf_0/a_42270_n1540# vdda1 1.62fF **FLOATING
C2498 divbuf_0/a_41790_n1540# vdda1 1.62fF **FLOATING
C2499 divbuf_0/a_41310_n1540# vdda1 1.62fF **FLOATING
C2500 divbuf_0/a_40830_n1540# vdda1 1.62fF **FLOATING
C2501 divbuf_0/a_40350_n1540# vdda1 1.62fF **FLOATING
C2502 divbuf_0/a_39870_n1540# vdda1 1.62fF **FLOATING
C2503 divbuf_0/a_39390_n1540# vdda1 1.62fF **FLOATING
C2504 divbuf_0/a_38910_n1540# vdda1 1.62fF **FLOATING
C2505 divbuf_0/a_38430_n1540# vdda1 1.62fF **FLOATING
C2506 divbuf_0/a_37950_n1540# vdda1 1.62fF **FLOATING
C2507 divbuf_0/a_37470_n1540# vdda1 1.62fF **FLOATING
C2508 divbuf_0/a_36990_n1540# vdda1 1.62fF **FLOATING
C2509 divbuf_0/a_36510_n1540# vdda1 1.62fF **FLOATING
C2510 divbuf_0/a_36030_n1540# vdda1 1.62fF **FLOATING
C2511 divbuf_0/a_35550_n1540# vdda1 1.62fF **FLOATING
C2512 divbuf_0/a_35070_n1540# vdda1 1.62fF **FLOATING
C2513 divbuf_0/a_34590_n1540# vdda1 1.62fF **FLOATING
C2514 divbuf_0/a_34110_n1540# vdda1 1.62fF **FLOATING
C2515 divbuf_0/a_33630_n1540# vdda1 1.62fF **FLOATING
C2516 divbuf_0/a_33150_n1540# vdda1 1.62fF **FLOATING
C2517 divbuf_0/a_32670_n1540# vdda1 1.62fF **FLOATING
C2518 divbuf_0/a_32190_n1540# vdda1 1.62fF **FLOATING
C2519 divbuf_0/a_31710_n1540# vdda1 1.62fF **FLOATING
C2520 divbuf_0/a_31230_n1540# vdda1 1.62fF **FLOATING
C2521 divbuf_0/a_30750_n1540# vdda1 1.62fF **FLOATING
C2522 divbuf_0/a_30270_n1540# vdda1 1.62fF **FLOATING
C2523 divbuf_0/a_29790_n1540# vdda1 1.62fF **FLOATING
C2524 divbuf_0/a_29310_n1540# vdda1 1.62fF **FLOATING
C2525 divbuf_0/a_28830_n1540# vdda1 1.62fF **FLOATING
C2526 divbuf_0/a_28350_n1540# vdda1 1.62fF **FLOATING
C2527 divbuf_0/a_27870_n1540# vdda1 1.62fF **FLOATING
C2528 divbuf_0/a_27390_n1540# vdda1 1.62fF **FLOATING
C2529 divbuf_0/a_26910_n1540# vdda1 1.62fF **FLOATING
C2530 divbuf_0/a_26430_n1540# vdda1 1.62fF **FLOATING
C2531 divbuf_0/a_25950_n1540# vdda1 1.62fF **FLOATING
C2532 divbuf_0/a_25470_n1540# vdda1 1.62fF **FLOATING
C2533 divbuf_0/a_24990_n1540# vdda1 1.62fF **FLOATING
C2534 divbuf_0/a_24510_n1540# vdda1 1.62fF **FLOATING
C2535 divbuf_0/a_24030_n1540# vdda1 1.62fF **FLOATING
C2536 divbuf_0/a_23550_n1540# vdda1 1.62fF **FLOATING
C2537 divbuf_0/a_23070_n1540# vdda1 1.62fF **FLOATING
C2538 divbuf_0/a_22590_n1540# vdda1 1.62fF **FLOATING
C2539 divbuf_0/a_22110_n1540# vdda1 1.62fF **FLOATING
C2540 divbuf_0/a_21630_n1540# vdda1 1.62fF **FLOATING
C2541 divbuf_0/a_21150_n1540# vdda1 1.62fF **FLOATING
C2542 divbuf_0/a_20670_n1540# vdda1 1.62fF **FLOATING
C2543 divbuf_0/a_20190_n1540# vdda1 1.62fF **FLOATING
C2544 divbuf_0/a_19710_n1540# vdda1 1.62fF **FLOATING
C2545 divbuf_0/a_19230_n1540# vdda1 1.62fF **FLOATING
C2546 divbuf_0/a_18750_n1540# vdda1 1.62fF **FLOATING
C2547 divbuf_0/a_18270_n1540# vdda1 1.62fF **FLOATING
C2548 divbuf_0/a_17790_n1540# vdda1 1.62fF **FLOATING
C2549 divbuf_0/a_17310_n1540# vdda1 1.62fF **FLOATING
C2550 divbuf_0/a_16830_n1540# vdda1 1.62fF **FLOATING
C2551 divbuf_0/a_16350_n1540# vdda1 1.62fF **FLOATING
C2552 divbuf_0/a_15870_n1540# vdda1 1.62fF **FLOATING
C2553 divbuf_0/a_15390_n1540# vdda1 1.62fF **FLOATING
C2554 divbuf_0/a_14910_n1540# vdda1 1.62fF **FLOATING
C2555 divbuf_0/a_14430_n1540# vdda1 1.62fF **FLOATING
C2556 divbuf_0/a_13950_n1540# vdda1 1.62fF **FLOATING
C2557 divbuf_0/a_13470_n1540# vdda1 1.62fF **FLOATING
C2558 divbuf_0/a_12990_n1540# vdda1 1.62fF **FLOATING
C2559 divbuf_0/a_12510_n1540# vdda1 1.62fF **FLOATING
C2560 divbuf_0/a_12030_n1540# vdda1 1.62fF **FLOATING
C2561 divbuf_0/a_11550_n1540# vdda1 1.62fF **FLOATING
C2562 divbuf_0/a_11070_n1540# vdda1 1.62fF **FLOATING
C2563 divbuf_0/a_10590_n1540# vdda1 1.62fF **FLOATING
C2564 divbuf_0/a_10110_n1540# vdda1 1.62fF **FLOATING
C2565 divbuf_0/a_9630_n1540# vdda1 1.62fF **FLOATING
C2566 divbuf_0/a_9150_n1540# vdda1 1.62fF **FLOATING
C2567 divbuf_0/a_8670_n1540# vdda1 1.62fF **FLOATING
C2568 divbuf_0/a_8190_n1540# vdda1 1.62fF **FLOATING
C2569 divbuf_0/a_7710_n1540# vdda1 1.62fF **FLOATING
C2570 divbuf_0/a_7230_n1540# vdda1 1.62fF **FLOATING
C2571 divbuf_0/a_6750_n1540# vdda1 1.62fF **FLOATING
C2572 divbuf_0/a_6270_n1540# vdda1 1.62fF **FLOATING
C2573 divbuf_0/a_5790_n1540# vdda1 1.62fF **FLOATING
C2574 divbuf_0/a_5310_n1540# vdda1 1.62fF **FLOATING
C2575 divbuf_0/a_4830_n1540# vdda1 1.62fF **FLOATING
C2576 divbuf_0/a_4350_n1540# vdda1 1.62fF **FLOATING
C2577 divbuf_0/a_3870_n1540# vdda1 1.62fF **FLOATING
C2578 divbuf_0/a_3390_n1540# vdda1 1.62fF **FLOATING
C2579 divbuf_0/a_2910_n1540# vdda1 1.62fF **FLOATING
C2580 divbuf_0/a_2430_n1540# vdda1 1.62fF **FLOATING
C2581 divbuf_0/a_1950_n1540# vdda1 1.62fF **FLOATING
C2582 divbuf_0/a_1470_n1540# vdda1 1.62fF **FLOATING
C2583 divbuf_0/a_990_n1540# vdda1 1.62fF **FLOATING
C2584 divbuf_0/a_510_n1540# vdda1 1.62fF **FLOATING
C2585 divbuf_0/a_60990_n840# vdda1 1.06fF **FLOATING
C2586 divbuf_0/a_60510_n840# vdda1 1.09fF **FLOATING
C2587 divbuf_0/a_60030_n840# vdda1 1.09fF **FLOATING
C2588 divbuf_0/a_59550_n840# vdda1 1.09fF **FLOATING
C2589 divbuf_0/a_59070_n840# vdda1 1.09fF **FLOATING
C2590 divbuf_0/a_58590_n840# vdda1 1.09fF **FLOATING
C2591 divbuf_0/a_58110_n840# vdda1 1.09fF **FLOATING
C2592 divbuf_0/a_57630_n840# vdda1 1.09fF **FLOATING
C2593 divbuf_0/a_57150_n840# vdda1 1.09fF **FLOATING
C2594 divbuf_0/a_56670_n840# vdda1 1.09fF **FLOATING
C2595 divbuf_0/a_56190_n840# vdda1 1.09fF **FLOATING
C2596 divbuf_0/a_55710_n840# vdda1 1.09fF **FLOATING
C2597 divbuf_0/a_55230_n840# vdda1 1.09fF **FLOATING
C2598 divbuf_0/a_54750_n840# vdda1 1.09fF **FLOATING
C2599 divbuf_0/a_54270_n840# vdda1 1.09fF **FLOATING
C2600 divbuf_0/a_53790_n840# vdda1 1.09fF **FLOATING
C2601 divbuf_0/a_53310_n840# vdda1 1.09fF **FLOATING
C2602 divbuf_0/a_52830_n840# vdda1 1.09fF **FLOATING
C2603 divbuf_0/a_52350_n840# vdda1 1.09fF **FLOATING
C2604 divbuf_0/a_51870_n840# vdda1 1.09fF **FLOATING
C2605 divbuf_0/a_51390_n840# vdda1 1.09fF **FLOATING
C2606 divbuf_0/a_50910_n840# vdda1 1.09fF **FLOATING
C2607 divbuf_0/a_50430_n840# vdda1 1.09fF **FLOATING
C2608 divbuf_0/a_49950_n840# vdda1 1.09fF **FLOATING
C2609 divbuf_0/a_49470_n840# vdda1 1.09fF **FLOATING
C2610 divbuf_0/a_48990_n840# vdda1 1.09fF **FLOATING
C2611 divbuf_0/a_48510_n840# vdda1 1.09fF **FLOATING
C2612 divbuf_0/a_48030_n840# vdda1 1.09fF **FLOATING
C2613 divbuf_0/a_47550_n840# vdda1 1.09fF **FLOATING
C2614 divbuf_0/a_47070_n840# vdda1 1.09fF **FLOATING
C2615 divbuf_0/a_46590_n840# vdda1 1.09fF **FLOATING
C2616 divbuf_0/a_46110_n840# vdda1 1.09fF **FLOATING
C2617 divbuf_0/a_45630_n840# vdda1 1.09fF **FLOATING
C2618 divbuf_0/a_45150_n840# vdda1 1.09fF **FLOATING
C2619 divbuf_0/a_44670_n840# vdda1 1.09fF **FLOATING
C2620 divbuf_0/a_44190_n840# vdda1 1.09fF **FLOATING
C2621 divbuf_0/a_43710_n840# vdda1 1.09fF **FLOATING
C2622 divbuf_0/a_43230_n840# vdda1 1.09fF **FLOATING
C2623 divbuf_0/a_42750_n840# vdda1 1.08fF **FLOATING
C2624 divbuf_0/a_42270_n840# vdda1 1.08fF **FLOATING
C2625 divbuf_0/a_41790_n840# vdda1 1.10fF **FLOATING
C2626 divbuf_0/a_41310_n840# vdda1 1.09fF **FLOATING
C2627 divbuf_0/a_40830_n840# vdda1 1.09fF **FLOATING
C2628 divbuf_0/a_40350_n840# vdda1 1.09fF **FLOATING
C2629 divbuf_0/a_39870_n840# vdda1 1.09fF **FLOATING
C2630 divbuf_0/a_39390_n840# vdda1 1.09fF **FLOATING
C2631 divbuf_0/a_38910_n840# vdda1 1.09fF **FLOATING
C2632 divbuf_0/a_38430_n840# vdda1 1.09fF **FLOATING
C2633 divbuf_0/a_37950_n840# vdda1 1.09fF **FLOATING
C2634 divbuf_0/a_37470_n840# vdda1 1.09fF **FLOATING
C2635 divbuf_0/a_36990_n840# vdda1 1.09fF **FLOATING
C2636 divbuf_0/a_36510_n840# vdda1 1.09fF **FLOATING
C2637 divbuf_0/a_36030_n840# vdda1 1.09fF **FLOATING
C2638 divbuf_0/a_35550_n840# vdda1 1.09fF **FLOATING
C2639 divbuf_0/a_35070_n840# vdda1 1.09fF **FLOATING
C2640 divbuf_0/a_34590_n840# vdda1 1.09fF **FLOATING
C2641 divbuf_0/a_34110_n840# vdda1 1.09fF **FLOATING
C2642 divbuf_0/a_33630_n840# vdda1 1.09fF **FLOATING
C2643 divbuf_0/a_33150_n840# vdda1 1.09fF **FLOATING
C2644 divbuf_0/a_32670_n840# vdda1 1.09fF **FLOATING
C2645 divbuf_0/a_32190_n840# vdda1 1.09fF **FLOATING
C2646 divbuf_0/a_31710_n840# vdda1 1.11fF **FLOATING
C2647 divbuf_0/a_31230_n840# vdda1 1.13fF **FLOATING
C2648 divbuf_0/a_30750_n840# vdda1 1.09fF **FLOATING
C2649 divbuf_0/a_30270_n840# vdda1 1.09fF **FLOATING
C2650 divbuf_0/a_29790_n840# vdda1 1.09fF **FLOATING
C2651 divbuf_0/a_29310_n840# vdda1 1.09fF **FLOATING
C2652 divbuf_0/a_28830_n840# vdda1 1.09fF **FLOATING
C2653 divbuf_0/a_28350_n840# vdda1 1.09fF **FLOATING
C2654 divbuf_0/a_27870_n840# vdda1 1.08fF **FLOATING
C2655 divbuf_0/a_27390_n840# vdda1 1.11fF **FLOATING
C2656 divbuf_0/a_26910_n840# vdda1 1.10fF **FLOATING
C2657 divbuf_0/a_26430_n840# vdda1 1.10fF **FLOATING
C2658 divbuf_0/a_25950_n840# vdda1 1.10fF **FLOATING
C2659 divbuf_0/a_25470_n840# vdda1 1.10fF **FLOATING
C2660 divbuf_0/a_24990_n840# vdda1 1.10fF **FLOATING
C2661 divbuf_0/a_24510_n840# vdda1 1.10fF **FLOATING
C2662 divbuf_0/a_24030_n840# vdda1 1.09fF **FLOATING
C2663 divbuf_0/a_23550_n840# vdda1 1.11fF **FLOATING
C2664 divbuf_0/a_23070_n840# vdda1 1.10fF **FLOATING
C2665 divbuf_0/a_22590_n840# vdda1 1.10fF **FLOATING
C2666 divbuf_0/a_22110_n840# vdda1 1.10fF **FLOATING
C2667 divbuf_0/a_21630_n840# vdda1 1.10fF **FLOATING
C2668 divbuf_0/a_21150_n840# vdda1 1.10fF **FLOATING
C2669 divbuf_0/a_20670_n840# vdda1 1.10fF **FLOATING
C2670 divbuf_0/a_20190_n840# vdda1 1.09fF **FLOATING
C2671 divbuf_0/a_19710_n840# vdda1 1.09fF **FLOATING
C2672 divbuf_0/a_19230_n840# vdda1 1.09fF **FLOATING
C2673 divbuf_0/a_18750_n840# vdda1 1.09fF **FLOATING
C2674 divbuf_0/a_18270_n840# vdda1 1.08fF **FLOATING
C2675 divbuf_0/a_17790_n840# vdda1 1.08fF **FLOATING
C2676 divbuf_0/a_17310_n840# vdda1 1.07fF **FLOATING
C2677 divbuf_0/a_16830_n840# vdda1 1.07fF **FLOATING
C2678 divbuf_0/a_16350_n840# vdda1 1.07fF **FLOATING
C2679 divbuf_0/a_15870_n840# vdda1 1.07fF **FLOATING
C2680 divbuf_0/a_15390_n840# vdda1 1.08fF **FLOATING
C2681 divbuf_0/a_14910_n840# vdda1 1.07fF **FLOATING
C2682 divbuf_0/a_14430_n840# vdda1 1.07fF **FLOATING
C2683 divbuf_0/a_13950_n840# vdda1 1.07fF **FLOATING
C2684 divbuf_0/a_13470_n840# vdda1 1.07fF **FLOATING
C2685 divbuf_0/a_12990_n840# vdda1 1.10fF **FLOATING
C2686 divbuf_0/a_12510_n840# vdda1 1.08fF **FLOATING
C2687 divbuf_0/a_12030_n840# vdda1 1.07fF **FLOATING
C2688 divbuf_0/a_11550_n840# vdda1 1.07fF **FLOATING
C2689 divbuf_0/a_11070_n840# vdda1 1.08fF **FLOATING
C2690 divbuf_0/a_10590_n840# vdda1 1.10fF **FLOATING
C2691 divbuf_0/a_10110_n840# vdda1 1.10fF **FLOATING
C2692 divbuf_0/a_9630_n840# vdda1 1.10fF **FLOATING
C2693 divbuf_0/a_9150_n840# vdda1 1.10fF **FLOATING
C2694 divbuf_0/a_8670_n840# vdda1 1.10fF **FLOATING
C2695 divbuf_0/a_8190_n840# vdda1 1.12fF **FLOATING
C2696 divbuf_0/a_7710_n840# vdda1 1.10fF **FLOATING
C2697 divbuf_0/a_7230_n840# vdda1 1.09fF **FLOATING
C2698 divbuf_0/a_6750_n840# vdda1 1.09fF **FLOATING
C2699 divbuf_0/a_6270_n840# vdda1 1.09fF **FLOATING
C2700 divbuf_0/a_5790_n840# vdda1 1.09fF **FLOATING
C2701 divbuf_0/a_5310_n840# vdda1 1.09fF **FLOATING
C2702 divbuf_0/a_4830_n840# vdda1 1.09fF **FLOATING
C2703 divbuf_0/a_4350_n840# vdda1 1.09fF **FLOATING
C2704 divbuf_0/a_3870_n840# vdda1 1.09fF **FLOATING
C2705 divbuf_0/a_3390_n840# vdda1 1.09fF **FLOATING
C2706 divbuf_0/a_2910_n840# vdda1 1.10fF **FLOATING
C2707 divbuf_0/a_2430_n840# vdda1 1.10fF **FLOATING
C2708 divbuf_0/a_1950_n840# vdda1 1.10fF **FLOATING
C2709 divbuf_0/a_1470_n840# vdda1 1.10fF **FLOATING
C2710 divbuf_0/a_990_n840# vdda1 1.08fF **FLOATING
C2711 divbuf_0/a_510_n840# vdda1 1.07fF **FLOATING
C2712 divbuf_0/a_60480_n1600# vdda1 1.48fF **FLOATING
C2713 divbuf_0/a_60000_n1600# vdda1 1.48fF **FLOATING
C2714 divbuf_0/a_59520_n1600# vdda1 1.48fF **FLOATING
C2715 divbuf_0/a_59040_n1600# vdda1 1.48fF **FLOATING
C2716 divbuf_0/a_58560_n1600# vdda1 1.48fF **FLOATING
C2717 divbuf_0/a_58080_n1600# vdda1 1.48fF **FLOATING
C2718 divbuf_0/a_57600_n1600# vdda1 1.48fF **FLOATING
C2719 divbuf_0/a_57120_n1600# vdda1 1.48fF **FLOATING
C2720 divbuf_0/a_56640_n1600# vdda1 1.48fF **FLOATING
C2721 divbuf_0/a_56160_n1600# vdda1 1.48fF **FLOATING
C2722 divbuf_0/a_55680_n1600# vdda1 1.48fF **FLOATING
C2723 divbuf_0/a_55200_n1600# vdda1 1.48fF **FLOATING
C2724 divbuf_0/a_54720_n1600# vdda1 1.48fF **FLOATING
C2725 divbuf_0/a_54240_n1600# vdda1 1.48fF **FLOATING
C2726 divbuf_0/a_53760_n1600# vdda1 1.48fF **FLOATING
C2727 divbuf_0/a_53280_n1600# vdda1 1.48fF **FLOATING
C2728 divbuf_0/a_52800_n1600# vdda1 1.48fF **FLOATING
C2729 divbuf_0/a_52320_n1600# vdda1 1.48fF **FLOATING
C2730 divbuf_0/a_51840_n1600# vdda1 1.48fF **FLOATING
C2731 divbuf_0/a_51360_n1600# vdda1 1.48fF **FLOATING
C2732 divbuf_0/a_50880_n1600# vdda1 1.48fF **FLOATING
C2733 divbuf_0/a_50400_n1600# vdda1 1.48fF **FLOATING
C2734 divbuf_0/a_49920_n1600# vdda1 1.48fF **FLOATING
C2735 divbuf_0/a_49440_n1600# vdda1 1.48fF **FLOATING
C2736 divbuf_0/a_48960_n1600# vdda1 1.48fF **FLOATING
C2737 divbuf_0/a_48480_n1600# vdda1 1.48fF **FLOATING
C2738 divbuf_0/a_48000_n1600# vdda1 1.48fF **FLOATING
C2739 divbuf_0/a_47520_n1600# vdda1 1.48fF **FLOATING
C2740 divbuf_0/a_47040_n1600# vdda1 1.48fF **FLOATING
C2741 divbuf_0/a_46560_n1600# vdda1 1.48fF **FLOATING
C2742 divbuf_0/a_46080_n1600# vdda1 1.48fF **FLOATING
C2743 divbuf_0/a_45600_n1600# vdda1 1.48fF **FLOATING
C2744 divbuf_0/a_45120_n1600# vdda1 1.48fF **FLOATING
C2745 divbuf_0/a_44640_n1600# vdda1 1.48fF **FLOATING
C2746 divbuf_0/a_44160_n1600# vdda1 1.48fF **FLOATING
C2747 divbuf_0/a_43680_n1600# vdda1 1.48fF **FLOATING
C2748 divbuf_0/a_43200_n1600# vdda1 1.48fF **FLOATING
C2749 divbuf_0/a_42720_n1600# vdda1 1.48fF **FLOATING
C2750 divbuf_0/a_42240_n1600# vdda1 1.48fF **FLOATING
C2751 divbuf_0/a_41760_n1600# vdda1 1.48fF **FLOATING
C2752 divbuf_0/a_41280_n1600# vdda1 1.48fF **FLOATING
C2753 divbuf_0/a_40800_n1600# vdda1 1.48fF **FLOATING
C2754 divbuf_0/a_40320_n1600# vdda1 1.48fF **FLOATING
C2755 divbuf_0/a_39840_n1600# vdda1 1.48fF **FLOATING
C2756 divbuf_0/a_39360_n1600# vdda1 1.48fF **FLOATING
C2757 divbuf_0/a_38880_n1600# vdda1 1.48fF **FLOATING
C2758 divbuf_0/a_38400_n1600# vdda1 1.48fF **FLOATING
C2759 divbuf_0/a_37920_n1600# vdda1 1.48fF **FLOATING
C2760 divbuf_0/a_37440_n1600# vdda1 1.48fF **FLOATING
C2761 divbuf_0/a_36960_n1600# vdda1 1.48fF **FLOATING
C2762 divbuf_0/a_36480_n1600# vdda1 1.48fF **FLOATING
C2763 divbuf_0/a_36000_n1600# vdda1 1.48fF **FLOATING
C2764 divbuf_0/a_35520_n1600# vdda1 1.48fF **FLOATING
C2765 divbuf_0/a_35040_n1600# vdda1 1.48fF **FLOATING
C2766 divbuf_0/a_34560_n1600# vdda1 1.48fF **FLOATING
C2767 divbuf_0/a_34080_n1600# vdda1 1.48fF **FLOATING
C2768 divbuf_0/a_33600_n1600# vdda1 1.48fF **FLOATING
C2769 divbuf_0/a_33120_n1600# vdda1 1.48fF **FLOATING
C2770 divbuf_0/a_32640_n1600# vdda1 1.48fF **FLOATING
C2771 divbuf_0/a_32160_n1600# vdda1 1.48fF **FLOATING
C2772 divbuf_0/a_31680_n1600# vdda1 1.48fF **FLOATING
C2773 divbuf_0/a_31200_n1600# vdda1 1.48fF **FLOATING
C2774 divbuf_0/a_30720_n1600# vdda1 1.48fF **FLOATING
C2775 divbuf_0/a_30240_n1600# vdda1 1.48fF **FLOATING
C2776 divbuf_0/a_29760_n1600# vdda1 1.48fF **FLOATING
C2777 divbuf_0/a_29280_n1600# vdda1 1.48fF **FLOATING
C2778 divbuf_0/a_28800_n1600# vdda1 1.48fF **FLOATING
C2779 divbuf_0/a_28320_n1600# vdda1 1.48fF **FLOATING
C2780 divbuf_0/a_27840_n1600# vdda1 1.48fF **FLOATING
C2781 divbuf_0/a_27360_n1600# vdda1 1.48fF **FLOATING
C2782 divbuf_0/a_26880_n1600# vdda1 1.48fF **FLOATING
C2783 divbuf_0/a_26400_n1600# vdda1 1.48fF **FLOATING
C2784 divbuf_0/a_25920_n1600# vdda1 1.48fF **FLOATING
C2785 divbuf_0/a_25440_n1600# vdda1 1.48fF **FLOATING
C2786 divbuf_0/a_24960_n1600# vdda1 1.48fF **FLOATING
C2787 divbuf_0/a_24480_n1600# vdda1 1.48fF **FLOATING
C2788 divbuf_0/a_24000_n1600# vdda1 1.48fF **FLOATING
C2789 divbuf_0/a_23520_n1600# vdda1 1.48fF **FLOATING
C2790 divbuf_0/a_23040_n1600# vdda1 1.48fF **FLOATING
C2791 divbuf_0/a_22560_n1600# vdda1 1.48fF **FLOATING
C2792 divbuf_0/a_22080_n1600# vdda1 1.48fF **FLOATING
C2793 divbuf_0/a_21600_n1600# vdda1 1.48fF **FLOATING
C2794 divbuf_0/a_21120_n1600# vdda1 1.48fF **FLOATING
C2795 divbuf_0/a_20640_n1600# vdda1 1.48fF **FLOATING
C2796 divbuf_0/a_20160_n1600# vdda1 1.48fF **FLOATING
C2797 divbuf_0/a_19680_n1600# vdda1 1.48fF **FLOATING
C2798 divbuf_0/a_19200_n1600# vdda1 1.48fF **FLOATING
C2799 divbuf_0/a_18720_n1600# vdda1 1.48fF **FLOATING
C2800 divbuf_0/a_18240_n1600# vdda1 1.48fF **FLOATING
C2801 divbuf_0/a_17760_n1600# vdda1 1.48fF **FLOATING
C2802 divbuf_0/a_17280_n1600# vdda1 1.48fF **FLOATING
C2803 divbuf_0/a_16800_n1600# vdda1 1.48fF **FLOATING
C2804 divbuf_0/a_16320_n1600# vdda1 1.48fF **FLOATING
C2805 divbuf_0/a_15840_n1600# vdda1 1.48fF **FLOATING
C2806 divbuf_0/a_15360_n1600# vdda1 1.48fF **FLOATING
C2807 divbuf_0/a_14880_n1600# vdda1 1.48fF **FLOATING
C2808 divbuf_0/a_14400_n1600# vdda1 1.48fF **FLOATING
C2809 divbuf_0/a_13920_n1600# vdda1 1.48fF **FLOATING
C2810 divbuf_0/a_13440_n1600# vdda1 1.48fF **FLOATING
C2811 divbuf_0/a_12960_n1600# vdda1 1.48fF **FLOATING
C2812 divbuf_0/a_12480_n1600# vdda1 1.48fF **FLOATING
C2813 divbuf_0/a_12000_n1600# vdda1 1.48fF **FLOATING
C2814 divbuf_0/a_11520_n1600# vdda1 1.48fF **FLOATING
C2815 divbuf_0/a_11040_n1600# vdda1 1.48fF **FLOATING
C2816 divbuf_0/a_10560_n1600# vdda1 1.48fF **FLOATING
C2817 divbuf_0/a_10080_n1600# vdda1 1.48fF **FLOATING
C2818 divbuf_0/a_9600_n1600# vdda1 1.48fF **FLOATING
C2819 divbuf_0/a_9120_n1600# vdda1 1.48fF **FLOATING
C2820 divbuf_0/a_8640_n1600# vdda1 1.48fF **FLOATING
C2821 divbuf_0/a_8160_n1600# vdda1 1.48fF **FLOATING
C2822 divbuf_0/a_7680_n1600# vdda1 1.48fF **FLOATING
C2823 divbuf_0/a_7200_n1600# vdda1 1.48fF **FLOATING
C2824 divbuf_0/a_6720_n1600# vdda1 1.48fF **FLOATING
C2825 divbuf_0/a_6240_n1600# vdda1 1.48fF **FLOATING
C2826 divbuf_0/a_5760_n1600# vdda1 1.48fF **FLOATING
C2827 divbuf_0/a_5280_n1600# vdda1 1.48fF **FLOATING
C2828 divbuf_0/a_4800_n1600# vdda1 1.48fF **FLOATING
C2829 divbuf_0/a_4320_n1600# vdda1 1.48fF **FLOATING
C2830 divbuf_0/a_3840_n1600# vdda1 1.48fF **FLOATING
C2831 divbuf_0/a_3360_n1600# vdda1 1.48fF **FLOATING
C2832 divbuf_0/a_2880_n1600# vdda1 1.48fF **FLOATING
C2833 divbuf_0/a_2400_n1600# vdda1 1.48fF **FLOATING
C2834 divbuf_0/a_1920_n1600# vdda1 1.48fF **FLOATING
C2835 divbuf_0/a_1440_n1600# vdda1 1.48fF **FLOATING
C2836 divbuf_0/a_960_n1600# vdda1 1.48fF **FLOATING
C2837 divbuf_0/a_480_n1600# vdda1 1.48fF **FLOATING
C2838 divbuf_0/a_0_n1600# vdda1 1.48fF **FLOATING
C2839 divbuf_0/a_41382_n240# vdda1 0.90fF **FLOATING
C2840 divbuf_0/a_40902_n240# vdda1 0.90fF **FLOATING
C2841 divbuf_0/a_40412_n240# vdda1 0.90fF **FLOATING
C2842 divbuf_0/a_39932_n240# vdda1 0.90fF **FLOATING
C2843 divbuf_0/a_39442_n240# vdda1 0.90fF **FLOATING
C2844 divbuf_0/a_38962_n240# vdda1 0.91fF **FLOATING
C2845 divbuf_0/a_38472_n240# vdda1 0.90fF **FLOATING
C2846 divbuf_0/a_37992_n240# vdda1 0.90fF **FLOATING
C2847 divbuf_0/a_37502_n240# vdda1 0.90fF **FLOATING
C2848 divbuf_0/a_37022_n240# vdda1 0.90fF **FLOATING
C2849 divbuf_0/a_36532_n240# vdda1 0.90fF **FLOATING
C2850 divbuf_0/a_36052_n240# vdda1 0.90fF **FLOATING
C2851 divbuf_0/a_35562_n240# vdda1 0.90fF **FLOATING
C2852 divbuf_0/a_35082_n240# vdda1 0.91fF **FLOATING
C2853 divbuf_0/a_34592_n240# vdda1 0.90fF **FLOATING
C2854 divbuf_0/a_34112_n240# vdda1 0.90fF **FLOATING
C2855 divbuf_0/a_33622_n240# vdda1 0.90fF **FLOATING
C2856 divbuf_0/a_33142_n240# vdda1 0.90fF **FLOATING
C2857 divbuf_0/a_32652_n240# vdda1 0.90fF **FLOATING
C2858 divbuf_0/a_32172_n240# vdda1 0.90fF **FLOATING
C2859 divbuf_0/a_31682_n240# vdda1 0.89fF **FLOATING
C2860 divbuf_0/a_31202_n240# vdda1 0.92fF **FLOATING
C2861 divbuf_0/a_30712_n240# vdda1 0.90fF **FLOATING
C2862 divbuf_0/a_30232_n240# vdda1 0.90fF **FLOATING
C2863 divbuf_0/a_29742_n240# vdda1 0.90fF **FLOATING
C2864 divbuf_0/a_29262_n240# vdda1 0.90fF **FLOATING
C2865 divbuf_0/a_28772_n240# vdda1 0.90fF **FLOATING
C2866 divbuf_0/a_28292_n240# vdda1 0.90fF **FLOATING
C2867 divbuf_0/a_27802_n240# vdda1 0.89fF **FLOATING
C2868 divbuf_0/a_27322_n240# vdda1 0.95fF **FLOATING
C2869 divbuf_0/a_26832_n240# vdda1 0.91fF **FLOATING
C2870 divbuf_0/a_26352_n240# vdda1 0.91fF **FLOATING
C2871 divbuf_0/a_25862_n240# vdda1 0.91fF **FLOATING
C2872 divbuf_0/a_25382_n240# vdda1 0.91fF **FLOATING
C2873 divbuf_0/a_24892_n240# vdda1 0.91fF **FLOATING
C2874 divbuf_0/a_24412_n240# vdda1 0.91fF **FLOATING
C2875 divbuf_0/a_23922_n240# vdda1 0.92fF **FLOATING
C2876 divbuf_0/a_23442_n240# vdda1 0.94fF **FLOATING
C2877 divbuf_0/a_22952_n240# vdda1 0.91fF **FLOATING
C2878 divbuf_0/a_22472_n240# vdda1 0.91fF **FLOATING
C2879 divbuf_0/a_21982_n240# vdda1 0.91fF **FLOATING
C2880 divbuf_0/a_21502_n240# vdda1 0.91fF **FLOATING
C2881 divbuf_0/a_21012_n240# vdda1 0.91fF **FLOATING
C2882 divbuf_0/a_20532_n240# vdda1 0.91fF **FLOATING
C2883 divbuf_0/a_20042_n240# vdda1 0.90fF **FLOATING
C2884 divbuf_0/a_19562_n240# vdda1 0.90fF **FLOATING
C2885 divbuf_0/a_19072_n240# vdda1 0.90fF **FLOATING
C2886 divbuf_0/a_18582_n240# vdda1 0.89fF **FLOATING
C2887 divbuf_0/a_18092_n240# vdda1 0.89fF **FLOATING
C2888 divbuf_0/a_17612_n240# vdda1 0.89fF **FLOATING
C2889 divbuf_0/a_17122_n240# vdda1 0.88fF **FLOATING
C2890 divbuf_0/a_16642_n240# vdda1 0.88fF **FLOATING
C2891 divbuf_0/a_16152_n240# vdda1 0.88fF **FLOATING
C2892 divbuf_0/a_15672_n240# vdda1 0.90fF **FLOATING
C2893 divbuf_0/a_15182_n240# vdda1 0.88fF **FLOATING
C2894 divbuf_0/a_14702_n240# vdda1 0.88fF **FLOATING
C2895 divbuf_0/a_14222_n240# vdda1 0.88fF **FLOATING
C2896 divbuf_0/a_13742_n240# vdda1 0.88fF **FLOATING
C2897 divbuf_0/a_13252_n240# vdda1 0.88fF **FLOATING
C2898 divbuf_0/a_12772_n240# vdda1 0.88fF **FLOATING
C2899 divbuf_0/a_12282_n240# vdda1 0.88fF **FLOATING
C2900 divbuf_0/a_11802_n240# vdda1 0.88fF **FLOATING
C2901 divbuf_0/a_11312_n240# vdda1 0.89fF **FLOATING
C2902 divbuf_0/a_10212_n240# vdda1 0.91fF **FLOATING
C2903 divbuf_0/a_9732_n240# vdda1 0.91fF **FLOATING
C2904 divbuf_0/a_9242_n240# vdda1 0.91fF **FLOATING
C2905 divbuf_0/a_8762_n240# vdda1 0.91fF **FLOATING
C2906 divbuf_0/a_8272_n240# vdda1 0.91fF **FLOATING
C2907 divbuf_0/a_7792_n240# vdda1 0.92fF **FLOATING
C2908 divbuf_0/a_7302_n240# vdda1 0.90fF **FLOATING
C2909 divbuf_0/a_6822_n240# vdda1 0.90fF **FLOATING
C2910 divbuf_0/a_6332_n240# vdda1 0.90fF **FLOATING
C2911 divbuf_0/a_5852_n240# vdda1 0.90fF **FLOATING
C2912 divbuf_0/a_5362_n240# vdda1 0.90fF **FLOATING
C2913 divbuf_0/a_4882_n240# vdda1 0.90fF **FLOATING
C2914 divbuf_0/a_4392_n240# vdda1 0.90fF **FLOATING
C2915 divbuf_0/a_3912_n240# vdda1 0.90fF **FLOATING
C2916 divbuf_0/a_3422_n240# vdda1 0.90fF **FLOATING
C2917 divbuf_0/a_2322_n240# vdda1 0.91fF **FLOATING
C2918 divbuf_0/a_1842_n240# vdda1 0.91fF **FLOATING
C2919 divbuf_0/a_1352_n240# vdda1 0.91fF **FLOATING
C2920 divbuf_0/a_41382_170# vdda1 1.07fF **FLOATING
C2921 divbuf_0/a_40902_170# vdda1 1.09fF **FLOATING
C2922 divbuf_0/a_40412_170# vdda1 1.09fF **FLOATING
C2923 divbuf_0/a_39932_170# vdda1 1.09fF **FLOATING
C2924 divbuf_0/a_39442_170# vdda1 1.09fF **FLOATING
C2925 divbuf_0/a_38962_170# vdda1 1.07fF **FLOATING
C2926 divbuf_0/a_38472_170# vdda1 1.09fF **FLOATING
C2927 divbuf_0/a_37992_170# vdda1 1.09fF **FLOATING
C2928 divbuf_0/a_37502_170# vdda1 1.09fF **FLOATING
C2929 divbuf_0/a_37022_170# vdda1 1.09fF **FLOATING
C2930 divbuf_0/a_36532_170# vdda1 1.09fF **FLOATING
C2931 divbuf_0/a_36052_170# vdda1 1.09fF **FLOATING
C2932 divbuf_0/a_35562_170# vdda1 1.09fF **FLOATING
C2933 divbuf_0/a_35082_170# vdda1 1.09fF **FLOATING
C2934 divbuf_0/a_34592_170# vdda1 1.07fF **FLOATING
C2935 divbuf_0/a_34112_170# vdda1 1.09fF **FLOATING
C2936 divbuf_0/a_33622_170# vdda1 1.09fF **FLOATING
C2937 divbuf_0/a_33142_170# vdda1 1.09fF **FLOATING
C2938 divbuf_0/a_32652_170# vdda1 1.09fF **FLOATING
C2939 divbuf_0/a_32172_170# vdda1 1.09fF **FLOATING
C2940 divbuf_0/a_31682_170# vdda1 1.09fF **FLOATING
C2941 divbuf_0/a_31202_170# vdda1 1.09fF **FLOATING
C2942 divbuf_0/a_30712_170# vdda1 1.09fF **FLOATING
C2943 divbuf_0/a_30232_170# vdda1 1.07fF **FLOATING
C2944 divbuf_0/a_29742_170# vdda1 1.09fF **FLOATING
C2945 divbuf_0/a_29262_170# vdda1 1.09fF **FLOATING
C2946 divbuf_0/a_28772_170# vdda1 1.09fF **FLOATING
C2947 divbuf_0/a_28292_170# vdda1 1.09fF **FLOATING
C2948 divbuf_0/a_27802_170# vdda1 1.09fF **FLOATING
C2949 divbuf_0/a_27322_170# vdda1 1.09fF **FLOATING
C2950 divbuf_0/a_26832_170# vdda1 1.09fF **FLOATING
C2951 divbuf_0/a_26352_170# vdda1 1.09fF **FLOATING
C2952 divbuf_0/a_25862_170# vdda1 1.07fF **FLOATING
C2953 divbuf_0/a_25382_170# vdda1 1.09fF **FLOATING
C2954 divbuf_0/a_24892_170# vdda1 1.09fF **FLOATING
C2955 divbuf_0/a_24412_170# vdda1 1.09fF **FLOATING
C2956 divbuf_0/a_23922_170# vdda1 1.09fF **FLOATING
C2957 divbuf_0/a_23442_170# vdda1 1.09fF **FLOATING
C2958 divbuf_0/a_22952_170# vdda1 1.09fF **FLOATING
C2959 divbuf_0/a_22472_170# vdda1 1.07fF **FLOATING
C2960 divbuf_0/a_21982_170# vdda1 1.09fF **FLOATING
C2961 divbuf_0/a_21502_170# vdda1 1.09fF **FLOATING
C2962 divbuf_0/a_21012_170# vdda1 1.09fF **FLOATING
C2963 divbuf_0/a_20532_170# vdda1 1.09fF **FLOATING
C2964 divbuf_0/a_20042_170# vdda1 1.09fF **FLOATING
C2965 divbuf_0/a_19562_170# vdda1 1.09fF **FLOATING
C2966 divbuf_0/a_19072_170# vdda1 1.09fF **FLOATING
C2967 divbuf_0/a_18582_170# vdda1 1.07fF **FLOATING
C2968 divbuf_0/a_18092_170# vdda1 1.09fF **FLOATING
C2969 divbuf_0/a_17612_170# vdda1 1.09fF **FLOATING
C2970 divbuf_0/a_17122_170# vdda1 1.09fF **FLOATING
C2971 divbuf_0/a_16642_170# vdda1 1.09fF **FLOATING
C2972 divbuf_0/a_16152_170# vdda1 1.09fF **FLOATING
C2973 divbuf_0/a_15672_170# vdda1 1.09fF **FLOATING
C2974 divbuf_0/a_15182_170# vdda1 1.09fF **FLOATING
C2975 divbuf_0/a_14702_170# vdda1 1.10fF **FLOATING
C2976 divbuf_0/a_14222_170# vdda1 1.10fF **FLOATING
C2977 divbuf_0/a_13742_170# vdda1 1.09fF **FLOATING
C2978 divbuf_0/a_13252_170# vdda1 1.09fF **FLOATING
C2979 divbuf_0/a_12772_170# vdda1 1.07fF **FLOATING
C2980 divbuf_0/a_12282_170# vdda1 1.09fF **FLOATING
C2981 divbuf_0/a_11802_170# vdda1 1.09fF **FLOATING
C2982 divbuf_0/a_11312_170# vdda1 1.10fF **FLOATING
C2983 divbuf_0/a_10212_170# vdda1 1.09fF **FLOATING
C2984 divbuf_0/a_9732_170# vdda1 1.09fF **FLOATING
C2985 divbuf_0/a_9242_170# vdda1 1.09fF **FLOATING
C2986 divbuf_0/a_8762_170# vdda1 1.09fF **FLOATING
C2987 divbuf_0/a_8272_170# vdda1 1.07fF **FLOATING
C2988 divbuf_0/a_7792_170# vdda1 1.09fF **FLOATING
C2989 divbuf_0/a_7302_170# vdda1 1.09fF **FLOATING
C2990 divbuf_0/a_6822_170# vdda1 1.09fF **FLOATING
C2991 divbuf_0/a_6332_170# vdda1 1.09fF **FLOATING
C2992 divbuf_0/a_5852_170# vdda1 1.09fF **FLOATING
C2993 divbuf_0/a_5362_170# vdda1 1.09fF **FLOATING
C2994 divbuf_0/a_4882_170# vdda1 1.09fF **FLOATING
C2995 divbuf_0/a_4392_170# vdda1 1.07fF **FLOATING
C2996 divbuf_0/a_3912_170# vdda1 1.09fF **FLOATING
C2997 divbuf_0/a_3422_170# vdda1 1.10fF **FLOATING
C2998 divbuf_0/a_2322_170# vdda1 1.09fF **FLOATING
C2999 divbuf_0/a_1842_170# vdda1 1.09fF **FLOATING
C3000 divbuf_0/a_1352_170# vdda1 1.10fF **FLOATING
C3001 divbuf_0/a_492_n240# vdda1 2.46fF **FLOATING
C3002 ro_complete_0/cbank_2/v vdda1 17.84fF
C3003 ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C3004 ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C3005 ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C3006 ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C3007 ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C3008 ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C3009 ro_complete_0/cbank_1/v vdda1 16.34fF
C3010 ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C3011 ro_complete_0/a0 vdda1 7.88fF
C3012 ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C3013 ro_complete_0/a1 vdda1 5.39fF
C3014 ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C3015 ro_complete_0/a3 vdda1 6.85fF
C3016 ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C3017 ro_complete_0/a2 vdda1 5.48fF
C3018 ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C3019 ro_complete_0/a4 vdda1 5.36fF
C3020 ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C3021 ro_complete_0/a5 vdda1 5.19fF
C3022 ro_complete_0/cbank_0/v vdda1 14.98fF
C3023 ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C3024 ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C3025 ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C3026 ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C3027 ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C3028 ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C3029 ro_complete_0/ro_var_extend_0/vcont vdda1 0.27fF
C3030 filter_0/v vdda1 85.69fF
C3031 filter_0/a_4216_n5230# vdda1 418.47fF **FLOATING
C3032 filter_0/a_4216_n2998# vdda1 1.03fF **FLOATING
C3033 cp_1/down vdda1 1.54fF
C3034 cp_1/vbias vdda1 2.41fF
C3035 cp_1/out vdda1 5.26fF
C3036 cp_1/upbar vdda1 1.50fF
C3037 cp_1/a_7110_n2840# vdda1 0.17fF **FLOATING
C3038 cp_1/a_3060_n2840# vdda1 1.71fF **FLOATING
C3039 cp_1/a_7110_0# vdda1 0.17fF **FLOATING
C3040 cp_1/a_6370_0# vdda1 0.40fF **FLOATING
C3041 cp_1/a_3060_0# vdda1 1.65fF **FLOATING
C3042 cp_1/a_1710_0# vdda1 5.76fF **FLOATING
C3043 cp_1/a_1710_n2840# vdda1 4.89fF **FLOATING
C3044 cp_1/a_10_n50# vdda1 2.96fF **FLOATING
C3045 io_analog[1] vdda1 108.63fF
C3046 io_analog[3] vdda1 197.37fF
C3047 io_analog[0] vdda1 74.25fF
C3048 io_analog[2] vdda1 108.15fF
C3049 cp_0/a_7110_n2840# vdda1 0.17fF **FLOATING
C3050 cp_0/a_3060_n2840# vdda1 1.71fF **FLOATING
C3051 cp_0/a_7110_0# vdda1 0.17fF **FLOATING
C3052 cp_0/a_6370_0# vdda1 0.40fF **FLOATING
C3053 cp_0/a_3060_0# vdda1 4.15fF **FLOATING
C3054 cp_0/a_1710_0# vdda1 6.63fF **FLOATING
C3055 cp_0/a_10_n50# vdda1 2.96fF **FLOATING
C3056 pd_0/and_pd_0/Z1 vdda1 0.39fF
C3057 pd_0/and_pd_0/Out1 vdda1 2.22fF
C3058 pd_0/tspc_r_1/z5 vdda1 1.10fF
C3059 pd_0/tspc_r_1/Z4 vdda1 1.07fF
C3060 pd_0/tspc_r_1/Qbar vdda1 0.88fF
C3061 pd_0/tspc_r_1/Z2 vdda1 1.22fF
C3062 pd_0/tspc_r_1/Z1 vdda1 0.67fF
C3063 pd_0/UP vdda1 2.21fF
C3064 pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C3065 pd_0/tspc_r_1/Z3 vdda1 2.12fF
C3066 pd_0/REF vdda1 1.80fF
C3067 pd_0/tspc_r_0/z5 vdda1 1.10fF
C3068 pd_0/tspc_r_0/Z4 vdda1 1.07fF
C3069 pd_0/R vdda1 3.05fF
C3070 pd_0/tspc_r_0/Qbar vdda1 0.79fF
C3071 pd_0/tspc_r_0/Z2 vdda1 1.22fF
C3072 pd_0/tspc_r_0/Z1 vdda1 0.67fF
C3073 pd_0/DOWN vdda1 3.08fF
C3074 pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C3075 pd_0/tspc_r_0/Z3 vdda1 2.12fF
C3076 pd_0/DIV vdda1 1.82fF
.ends
