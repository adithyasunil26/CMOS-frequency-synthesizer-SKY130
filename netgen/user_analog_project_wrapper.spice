* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[5] io_analog[6] io_analog[7] io_analog[8]
+ io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vssa1 vdda2 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 0.36fF
C1 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6720_n1600# 0.26fF
C2 divbuf_1/a_4800_n1600# divbuf_1/a_5280_n1600# 0.26fF
C3 divbuf_5/a_35562_n240# divbuf_5/a_36052_n240# 0.04fF
C4 divbuf_3/a_7792_170# divbuf_3/OUT3 0.19fF
C5 ro_div_0/divbuf_0/a_29310_n840# ro_div_0/divbuf_0/a_29310_n1540# 0.01fF
C6 ro_div_0/divbuf_0/a_59550_n840# ro_div_0/divbuf_0/a_60030_n840# 0.07fF
C7 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_59550_n1540# 0.19fF
C8 divbuf_1/a_58080_n1600# divbuf_1/a_58110_n1540# 0.19fF
C9 divbuf_1/a_58110_n840# divbuf_1/a_58590_n840# 0.07fF
C10 divbuf_1/a_27870_n840# divbuf_1/a_27870_n1540# 0.01fF
C11 divbuf_5/a_47040_n1600# divbuf_5/a_47070_n1540# 0.19fF
C12 divbuf_5/a_47070_n840# divbuf_5/a_47550_n840# 0.07fF
C13 divbuf_5/a_16830_n840# divbuf_5/a_16830_n1540# 0.01fF
C14 divbuf_3/a_14702_n240# divbuf_3/a_14430_n840# 0.01fF
C15 divbuf_0/a_3422_170# divbuf_0/a_3422_n240# 0.01fF
C16 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C17 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_57630_n840# 0.04fF
C18 divbuf_2/a_28772_170# divbuf_2/a_28772_n240# 0.01fF
C19 divbuf_2/a_8272_n240# divbuf_2/a_8762_n240# 0.04fF
C20 divbuf_4/a_21120_n1600# divbuf_4/a_21150_n840# 0.04fF
C21 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C22 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/a_14222_170# 0.07fF
C23 divbuf_0/a_33142_n240# divbuf_0/a_33150_n840# 0.06fF
C24 divbuf_0/a_42240_n1600# divbuf_0/a_42720_n1600# 0.26fF
C25 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/a_630_n680# 0.12fF
C26 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C27 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C28 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_35040_n1600# 0.26fF
C29 divbuf_2/a_20640_n1600# divbuf_2/a_20670_n1540# 0.19fF
C30 divbuf_2/a_20670_n840# divbuf_2/a_21150_n840# 0.07fF
C31 divbuf_2/a_19072_n240# divbuf_2/OUT4 0.04fF
C32 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/a_25470_n840# 0.03fF
C33 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/a_21502_170# 0.07fF
C34 divbuf_0/a_34590_n1540# divbuf_0/a_35070_n1540# 0.11fF
C35 divbuf_1/a_15672_n240# divbuf_1/a_15390_n840# 0.01fF
C36 divbuf_3/a_9732_170# divbuf_3/a_10212_170# 0.07fF
C37 pll_full_0/divbuf_0/a_57630_n840# pll_full_0/divbuf_0/a_57630_n1540# 0.01fF
C38 pll_full_0/divbuf_0/a_26910_n1540# pll_full_0/divbuf_0/a_27390_n1540# 0.11fF
C39 divbuf_3/a_8762_n240# divbuf_3/OUT3 0.04fF
C40 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/a_36052_n240# 0.04fF
C41 divbuf_4/a_18582_170# divbuf_4/a_18582_n240# 0.01fF
C42 divbuf_4/a_37992_170# divbuf_4/a_38472_170# 0.07fF
C43 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/a_39442_n240# 0.05fF
C44 divbuf_3/a_43680_n1600# divbuf_3/a_44160_n1600# 0.26fF
C45 divbuf_3/a_34592_n240# divbuf_3/a_34590_n840# 0.06fF
C46 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47070_n1540# 0.19fF
C47 pd_div_0/divbuf_0/a_47070_n840# pd_div_0/divbuf_0/a_47550_n840# 0.07fF
C48 pd_div_0/divbuf_0/a_16830_n840# pd_div_0/divbuf_0/a_16830_n1540# 0.01fF
C49 pd_0/REF divbuf_4/a_510_n840# 0.07fF
C50 divbuf_4/a_10560_n1600# divbuf_4/a_10590_n1540# 0.19fF
C51 divbuf_4/a_37992_170# divbuf_4/OUT4 0.19fF
C52 divbuf_4/a_10590_n840# divbuf_4/a_11070_n840# 0.07fF
C53 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50430_n1540# 0.19fF
C54 pll_full_0/divbuf_1/a_20190_n840# pll_full_0/divbuf_1/a_20190_n1540# 0.01fF
C55 pll_full_0/divbuf_1/a_50430_n840# pll_full_0/divbuf_1/a_50910_n840# 0.07fF
C56 divbuf_3/a_36030_n1540# divbuf_3/a_36510_n1540# 0.11fF
C57 io_analog[9] gpio_analog[7] 2.37fF
C58 divbuf_0/a_20042_170# divbuf_0/OUT4 0.19fF
C59 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n840# 0.04fF
C60 divbuf_4/OUT3 divbuf_4/OUT4 0.36fF
C61 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24510_n840# 0.04fF
C62 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46560_n1600# 0.26fF
C63 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/a_36990_n840# 0.05fF
C64 divbuf_1/a_44640_n1600# divbuf_1/a_45120_n1600# 0.26fF
C65 divbuf_1/a_35562_n240# divbuf_1/a_35550_n840# 0.05fF
C66 divbuf_5/a_24412_n240# divbuf_5/a_24510_n840# 0.03fF
C67 divbuf_5/a_33600_n1600# divbuf_5/a_34080_n1600# 0.26fF
C68 ro_div_0/divbuf_0/a_38430_n1540# ro_div_0/divbuf_0/a_38910_n1540# 0.11fF
C69 divbuf_1/a_36990_n1540# divbuf_1/a_37470_n1540# 0.11fF
C70 divbuf_3/a_33600_n1600# divbuf_3/a_33630_n840# 0.04fF
C71 divbuf_5/a_56670_n840# divbuf_5/a_56670_n1540# 0.01fF
C72 divbuf_5/a_25950_n1540# divbuf_5/a_26430_n1540# 0.11fF
C73 divbuf_0/a_9242_n240# divbuf_0/a_9732_n240# 0.04fF
C74 divbuf_0/a_29742_170# divbuf_0/a_29742_n240# 0.01fF
C75 divbuf_4/a_38962_n240# divbuf_4/OUT4 0.04fF
C76 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/a_21982_n240# 0.01fF
C77 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/OUT4 0.19fF
C78 divbuf_2/a_7200_n1600# divbuf_2/a_7680_n1600# 0.26fF
C79 divbuf_0/a_21012_n240# divbuf_0/OUT4 0.04fF
C80 divbuf_0/a_21630_n840# divbuf_0/a_22110_n840# 0.07fF
C81 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n1540# 0.19fF
C82 divbuf_1/a_12772_170# divbuf_1/a_12772_n240# 0.01fF
C83 pll_full_0/divbuf_0/a_13950_n840# pll_full_0/divbuf_0/a_14430_n840# 0.07fF
C84 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_13950_n1540# 0.19fF
C85 divbuf_2/a_60510_n840# divbuf_2/a_60990_n840# 0.07fF
C86 divbuf_2/a_30270_n840# divbuf_2/a_30270_n1540# 0.01fF
C87 divbuf_2/a_60480_n1600# divbuf_2/a_60510_n1540# 0.19fF
C88 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C89 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36030_n840# 0.04fF
C90 ro_div_0/divider_0/prescaler_0/m1_2700_2190# gnd 0.22fF
C91 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Qbar1 0.38fF
C92 divbuf_1/a_21502_170# divbuf_1/OUT4 0.19fF
C93 divbuf_1/a_34560_n1600# divbuf_1/a_34590_n840# 0.04fF
C94 divbuf_3/a_31202_170# divbuf_3/a_31202_n240# 0.01fF
C95 divbuf_3/a_11312_n240# divbuf_3/a_11802_n240# 0.04fF
C96 divbuf_5/a_2322_170# divbuf_5/OUT2 0.19fF
C97 divbuf_5/a_23520_n1600# divbuf_5/a_23550_n840# 0.04fF
C98 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/a_24510_n840# 0.03fF
C99 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_34080_n1600# 0.26fF
C100 divbuf_4/a_38962_n240# divbuf_4/a_39442_n240# 0.05fF
C101 divbuf_3/a_23040_n1600# divbuf_3/a_23070_n1540# 0.19fF
C102 divbuf_3/a_23070_n840# divbuf_3/a_23550_n840# 0.07fF
C103 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_37440_n1600# 0.26fF
C104 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/a_27870_n840# 0.04fF
C105 pd_div_0/divbuf_0/a_56670_n840# pd_div_0/divbuf_0/a_56670_n1540# 0.01fF
C106 pd_div_0/divbuf_0/a_25950_n1540# pd_div_0/divbuf_0/a_26430_n1540# 0.11fF
C107 divbuf_2/a_18092_n240# divbuf_2/a_17790_n840# 0.00fF
C108 divbuf_4/a_50430_n840# divbuf_4/a_50910_n840# 0.07fF
C109 divbuf_4/a_20190_n840# divbuf_4/a_20190_n1540# 0.01fF
C110 divbuf_4/a_50400_n1600# divbuf_4/a_50430_n1540# 0.19fF
C111 pll_full_0/divbuf_1/a_29310_n1540# pll_full_0/divbuf_1/a_29790_n1540# 0.11fF
C112 pll_full_0/divbuf_1/a_60030_n840# pll_full_0/divbuf_1/a_60030_n1540# 0.01fF
C113 divbuf_0/a_19200_n1600# divbuf_0/OUT4 0.00fF
C114 divbuf_1/a_12282_n240# divbuf_1/a_12772_n240# 0.04fF
C115 divbuf_5/a_40412_170# divbuf_5/a_40902_170# 0.07fF
C116 divbuf_5/a_21012_170# divbuf_5/a_21012_n240# 0.01fF
C117 ro_div_0/divbuf_0/a_25470_n840# ro_div_0/divbuf_0/a_25950_n840# 0.07fF
C118 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25470_n1540# 0.19fF
C119 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C120 divbuf_1/a_25862_n240# divbuf_1/OUT4 0.04fF
C121 divbuf_1/a_24000_n1600# divbuf_1/a_24030_n1540# 0.19fF
C122 divbuf_1/a_24030_n840# divbuf_1/a_24510_n840# 0.07fF
C123 divbuf_5/a_3422_n240# divbuf_5/OUT3 0.07fF
C124 divbuf_5/a_12960_n1600# divbuf_5/a_12990_n1540# 0.19fF
C125 divbuf_5/a_12990_n840# divbuf_5/a_13470_n840# 0.07fF
C126 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C127 pd_0/DOWN divbuf_2/a_492_n240# 0.13fF
C128 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_23550_n840# 0.04fF
C129 divbuf_2/a_13742_170# divbuf_2/a_14222_170# 0.07fF
C130 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/OUT3 0.19fF
C131 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_26910_n840# 0.04fF
C132 divbuf_0/a_8160_n1600# divbuf_0/a_8640_n1600# 0.26fF
C133 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_960_n1600# 0.26fF
C134 divbuf_2/a_37992_n240# divbuf_2/a_37950_n840# 0.04fF
C135 divbuf_2/a_47040_n1600# divbuf_2/a_47520_n1600# 0.26fF
C136 divbuf_0/a_510_n1540# divbuf_0/a_990_n1540# 0.11fF
C137 divbuf_0/a_31230_n840# divbuf_0/a_31230_n1540# 0.01fF
C138 divbuf_2/a_39390_n1540# divbuf_2/a_39870_n1540# 0.11fF
C139 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_53790_n1540# 0.19fF
C140 pll_full_0/divbuf_0/a_53790_n840# pll_full_0/divbuf_0/a_54270_n840# 0.07fF
C141 pll_full_0/divbuf_0/a_23550_n840# pll_full_0/divbuf_0/a_23550_n1540# 0.01fF
C142 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/a_40902_170# 0.07fF
C143 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/a_21012_n240# 0.01fF
C144 divbuf_1/a_24000_n1600# divbuf_1/OUT4 0.00fF
C145 divbuf_3/a_9600_n1600# divbuf_3/a_10080_n1600# 0.26fF
C146 divbuf_5/a_2880_n1600# divbuf_5/OUT2 0.00fF
C147 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/a_24412_n240# 0.01fF
C148 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/a_4392_n240# 0.05fF
C149 ro_div_0/divider_0/prescaler_0/tspc_2/D ro_div_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C150 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/OUT3 0.07fF
C151 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_12990_n1540# 0.19fF
C152 pd_div_0/divbuf_0/a_12990_n840# pd_div_0/divbuf_0/a_13470_n840# 0.07fF
C153 divbuf_4/a_27802_n240# divbuf_4/a_27870_n840# 0.04fF
C154 divbuf_4/a_36960_n1600# divbuf_4/a_37440_n1600# 0.26fF
C155 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16350_n1540# 0.19fF
C156 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C157 pll_full_0/divbuf_1/a_16350_n840# pll_full_0/divbuf_1/a_16830_n840# 0.07fF
C158 divbuf_3/a_32670_n840# divbuf_3/a_32670_n1540# 0.01fF
C159 divbuf_3/a_1950_n1540# divbuf_3/a_2430_n1540# 0.11fF
C160 divbuf_1/a_17122_170# divbuf_1/a_17612_170# 0.07fF
C161 divbuf_2/a_36960_n1600# divbuf_2/a_36990_n840# 0.04fF
C162 divbuf_2/a_29742_170# divbuf_2/OUT4 0.19fF
C163 divbuf_4/a_60030_n840# divbuf_4/a_60030_n1540# 0.01fF
C164 divbuf_4/a_29310_n1540# divbuf_4/a_29790_n1540# 0.11fF
C165 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11070_n840# 0.02fF
C166 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12480_n1600# 0.26fF
C167 divbuf_1/a_10560_n1600# divbuf_1/a_11040_n1600# 0.26fF
C168 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C169 divbuf_3/a_19562_170# divbuf_3/OUT4 0.19fF
C170 ro_div_0/divbuf_0/a_4350_n1540# ro_div_0/divbuf_0/a_4830_n1540# 0.11fF
C171 ro_div_0/divbuf_0/a_35070_n840# ro_div_0/divbuf_0/a_35070_n1540# 0.01fF
C172 divbuf_1/a_33630_n840# divbuf_1/a_33630_n1540# 0.01fF
C173 divbuf_1/a_2910_n1540# divbuf_1/a_3390_n1540# 0.11fF
C174 divbuf_5/a_52800_n1600# divbuf_5/a_52830_n1540# 0.19fF
C175 divbuf_5/a_52830_n840# divbuf_5/a_53310_n840# 0.07fF
C176 divbuf_5/a_22590_n840# divbuf_5/a_22590_n1540# 0.01fF
C177 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C178 divbuf_2/a_14702_n240# divbuf_2/a_15182_n240# 0.05fF
C179 divbuf_2/a_34592_170# divbuf_2/a_34592_n240# 0.01fF
C180 divbuf_4/a_26880_n1600# divbuf_4/a_26910_n840# 0.04fF
C181 divbuf_4/a_9242_170# divbuf_4/OUT3 0.19fF
C182 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C183 divbuf_0/a_48000_n1600# divbuf_0/a_48480_n1600# 0.26fF
C184 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C185 divbuf_0/a_38962_n240# divbuf_0/a_38910_n840# 0.04fF
C186 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/a_9242_170# 0.07fF
C187 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C188 pd_div_0/divider_0/tspc_0/Z4 gnd 0.44fF
C189 divbuf_1/a_7302_170# divbuf_1/a_6822_170# 0.07fF
C190 divbuf_2/a_26430_n840# divbuf_2/a_26910_n840# 0.07fF
C191 divbuf_2/a_30712_n240# divbuf_2/OUT4 0.04fF
C192 divbuf_2/a_26400_n1600# divbuf_2/a_26430_n1540# 0.19fF
C193 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C194 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/a_31230_n840# 0.05fF
C195 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40800_n1600# 0.26fF
C196 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/a_13742_n240# 0.01fF
C197 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/a_27322_170# 0.07fF
C198 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/a_6332_n240# 0.01fF
C199 divbuf_0/a_40350_n1540# divbuf_0/a_40830_n1540# 0.11fF
C200 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_1950_n840# 0.04fF
C201 divbuf_1/a_480_n1600# divbuf_1/a_510_n840# 0.04fF
C202 divbuf_3/a_16152_170# divbuf_3/a_16642_170# 0.07fF
C203 pll_full_0/divbuf_0/a_32670_n1540# pll_full_0/divbuf_0/a_33150_n1540# 0.11fF
C204 divbuf_3/a_20532_n240# divbuf_3/OUT4 0.04fF
C205 divbuf_4/a_3912_n240# divbuf_4/a_4392_n240# 0.05fF
C206 divbuf_4/a_24412_170# divbuf_4/a_24412_n240# 0.01fF
C207 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_3360_n1600# 0.26fF
C208 divbuf_3/a_49440_n1600# divbuf_3/a_49920_n1600# 0.26fF
C209 divbuf_3/a_40412_n240# divbuf_3/a_40350_n840# 0.04fF
C210 divbuf_0/a_14222_170# divbuf_0/a_14222_n240# 0.01fF
C211 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_52830_n1540# 0.19fF
C212 pd_div_0/divbuf_0/a_52830_n840# pd_div_0/divbuf_0/a_53310_n840# 0.07fF
C213 pd_div_0/divbuf_0/a_22590_n840# pd_div_0/divbuf_0/a_22590_n1540# 0.01fF
C214 divbuf_4/a_16350_n840# divbuf_4/a_16830_n840# 0.07fF
C215 divbuf_4/a_10212_n240# divbuf_4/OUT3 0.04fF
C216 divbuf_4/a_16320_n1600# divbuf_4/a_16350_n1540# 0.19fF
C217 pll_full_0/divbuf_1/a_25950_n840# pll_full_0/divbuf_1/a_25950_n1540# 0.01fF
C218 pll_full_0/divbuf_1/a_56190_n840# pll_full_0/divbuf_1/a_56670_n840# 0.07fF
C219 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56190_n1540# 0.19fF
C220 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/OUT3 0.19fF
C221 divbuf_3/a_41790_n1540# divbuf_3/a_42270_n1540# 0.11fF
C222 divbuf_0/a_31682_170# divbuf_0/OUT4 0.19fF
C223 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n840# 0.04fF
C224 divbuf_1/a_2322_170# divbuf_1/a_2322_n240# 0.01fF
C225 divbuf_5/a_5362_170# divbuf_5/a_5852_170# 0.07fF
C226 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30270_n840# 0.04fF
C227 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/OUT4 0.19fF
C228 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_52320_n1600# 0.26fF
C229 divbuf_1/a_50400_n1600# divbuf_1/a_50880_n1600# 0.26fF
C230 divbuf_1/a_41382_n240# divbuf_1/a_41310_n840# 0.03fF
C231 divbuf_5/a_39360_n1600# divbuf_5/a_39840_n1600# 0.26fF
C232 divbuf_5/a_30232_n240# divbuf_5/a_30270_n840# 0.05fF
C233 ro_div_0/divbuf_0/a_44190_n1540# ro_div_0/divbuf_0/a_44670_n1540# 0.11fF
C234 divbuf_1/a_42750_n1540# divbuf_1/a_43230_n1540# 0.11fF
C235 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_13470_n840# 0.01fF
C236 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/a_23442_n240# 0.01fF
C237 divbuf_3/a_39360_n1600# divbuf_3/a_39390_n840# 0.04fF
C238 divbuf_5/a_31710_n1540# divbuf_5/a_32190_n1540# 0.11fF
C239 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/OUT4 0.19fF
C240 divbuf_0/a_35562_170# divbuf_0/a_35562_n240# 0.01fF
C241 divbuf_0/a_15672_n240# divbuf_0/a_16152_n240# 0.05fF
C242 divbuf_4/a_9120_n1600# divbuf_4/OUT3 0.00fF
C243 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/a_7792_n240# 0.04fF
C244 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C245 ro_div_0/ro_complete_0/cbank_1/switch_4/vin ro_div_0/divider_0/clk 1.30fF
C246 divbuf_2/a_3422_n240# divbuf_2/a_3390_n840# 0.05fF
C247 divbuf_2/a_12960_n1600# divbuf_2/a_13440_n1600# 0.26fF
C248 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/a_27802_n240# 0.01fF
C249 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n1540# 0.19fF
C250 divbuf_0/a_32652_n240# divbuf_0/OUT4 0.04fF
C251 divbuf_0/a_27390_n840# divbuf_0/a_27870_n840# 0.07fF
C252 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C253 divbuf_2/a_36030_n840# divbuf_2/a_36030_n1540# 0.01fF
C254 divbuf_2/a_5310_n1540# divbuf_2/a_5790_n1540# 0.11fF
C255 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_19710_n1540# 0.19fF
C256 pll_full_0/divbuf_0/a_19710_n840# pll_full_0/divbuf_0/a_20190_n840# 0.07fF
C257 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_41790_n840# 0.04fF
C258 pd_div_0/pd_0/tspc_r_1/Qbar pd_div_0/pd_0/and_pd_0/Z1 0.02fF
C259 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_3912_170# 0.07fF
C260 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/a_13742_170# 0.07fF
C261 divbuf_1/a_40320_n1600# divbuf_1/a_40350_n840# 0.04fF
C262 divbuf_1/a_36532_170# divbuf_1/OUT4 0.19fF
C263 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/a_9242_170# 0.07fF
C264 divbuf_3/a_37022_170# divbuf_3/a_37022_n240# 0.01fF
C265 divbuf_3/a_17122_n240# divbuf_3/a_17612_n240# 0.04fF
C266 divbuf_5/a_29280_n1600# divbuf_5/a_29310_n840# 0.04fF
C267 divbuf_5/a_14222_170# divbuf_5/OUT4 0.19fF
C268 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39840_n1600# 0.26fF
C269 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/a_30270_n840# 0.05fF
C270 divbuf_4/a_2880_n1600# divbuf_4/a_3360_n1600# 0.26fF
C271 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/a_33630_n840# 0.06fF
C272 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_43200_n1600# 0.26fF
C273 divbuf_3/a_28830_n840# divbuf_3/a_29310_n840# 0.07fF
C274 divbuf_3/a_28800_n1600# divbuf_3/a_28830_n1540# 0.19fF
C275 pd_div_0/divbuf_0/a_31710_n1540# pd_div_0/divbuf_0/a_32190_n1540# 0.11fF
C276 divbuf_4/a_56160_n1600# divbuf_4/a_56190_n1540# 0.19fF
C277 divbuf_4/a_56190_n840# divbuf_4/a_56670_n840# 0.07fF
C278 divbuf_4/a_25950_n840# divbuf_4/a_25950_n1540# 0.01fF
C279 divbuf_2/a_2880_n1600# divbuf_2/a_2910_n840# 0.04fF
C280 pll_full_0/divbuf_1/a_35070_n1540# pll_full_0/divbuf_1/a_35550_n1540# 0.11fF
C281 divbuf_1/a_37992_170# divbuf_1/a_37992_n240# 0.01fF
C282 divbuf_1/a_18092_n240# divbuf_1/a_18582_n240# 0.04fF
C283 divbuf_1/a_492_n240# divbuf_1/a_510_n840# 0.00fF
C284 divbuf_5/a_26832_170# divbuf_5/a_26832_n240# 0.01fF
C285 divbuf_5/a_6332_n240# divbuf_5/a_6822_n240# 0.04fF
C286 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C287 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/a_990_n1540# 0.01fF
C288 ro_div_0/divbuf_0/a_31230_n840# ro_div_0/divbuf_0/a_31710_n840# 0.07fF
C289 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31230_n1540# 0.19fF
C290 pd_div_0/divbuf_0/a_3912_170# pd_div_0/divbuf_0/a_3912_n240# 0.01fF
C291 divbuf_1/a_29760_n1600# divbuf_1/a_29790_n1540# 0.19fF
C292 divbuf_1/a_29790_n840# divbuf_1/a_30270_n840# 0.07fF
C293 divbuf_1/a_37502_n240# divbuf_1/OUT4 0.04fF
C294 divbuf_5/a_18720_n1600# divbuf_5/a_18750_n1540# 0.19fF
C295 divbuf_5/a_18750_n840# divbuf_5/a_19230_n840# 0.07fF
C296 divbuf_5/a_15182_n240# divbuf_5/OUT4 0.04fF
C297 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/OUT4 0.19fF
C298 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29310_n840# 0.04fF
C299 divbuf_4/a_13742_n240# divbuf_4/a_13470_n840# 0.01fF
C300 divbuf_2/a_19562_170# divbuf_2/a_20042_170# 0.07fF
C301 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C302 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C303 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/OUT4 0.19fF
C304 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_32670_n840# 0.04fF
C305 divbuf_0/a_13920_n1600# divbuf_0/a_14400_n1600# 0.26fF
C306 divbuf_0/a_4392_n240# divbuf_0/a_4350_n840# 0.04fF
C307 divbuf_2/a_52800_n1600# divbuf_2/a_53280_n1600# 0.26fF
C308 divbuf_2/a_492_n240# divbuf_2/OUT2 0.42fF
C309 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6720_n1600# 0.26fF
C310 divbuf_0/a_6270_n1540# divbuf_0/a_6750_n1540# 0.11fF
C311 divbuf_0/a_36990_n840# divbuf_0/a_36990_n1540# 0.01fF
C312 pll_full_0/divbuf_0/a_29310_n840# pll_full_0/divbuf_0/a_29310_n1540# 0.01fF
C313 pll_full_0/divbuf_0/a_59550_n840# pll_full_0/divbuf_0/a_60030_n840# 0.07fF
C314 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_59550_n1540# 0.19fF
C315 divbuf_2/a_45150_n1540# divbuf_2/a_45630_n1540# 0.11fF
C316 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/a_26832_n240# 0.01fF
C317 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/a_6822_n240# 0.04fF
C318 divbuf_4/a_8762_170# divbuf_4/a_9242_170# 0.07fF
C319 divbuf_1/a_35520_n1600# divbuf_1/OUT4 0.00fF
C320 divbuf_3/a_15360_n1600# divbuf_3/a_15840_n1600# 0.26fF
C321 divbuf_3/a_5852_n240# divbuf_3/a_5790_n840# 0.04fF
C322 divbuf_5/a_13440_n1600# divbuf_5/OUT4 0.00fF
C323 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/a_10212_n240# 0.05fF
C324 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/a_30232_n240# 0.01fF
C325 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_18750_n1540# 0.19fF
C326 pd_div_0/divbuf_0/a_18750_n840# pd_div_0/divbuf_0/a_19230_n840# 0.07fF
C327 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C328 divbuf_3/a_38430_n840# divbuf_3/a_38430_n1540# 0.01fF
C329 divbuf_3/a_7710_n1540# divbuf_3/a_8190_n1540# 0.11fF
C330 divbuf_4/a_42720_n1600# divbuf_4/a_43200_n1600# 0.26fF
C331 divbuf_4/a_33622_n240# divbuf_4/a_33630_n840# 0.06fF
C332 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C333 pll_full_0/divbuf_1/a_22110_n840# pll_full_0/divbuf_1/a_22590_n840# 0.07fF
C334 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22110_n1540# 0.19fF
C335 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_12510_n840# 0.01fF
C336 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n840# 0.04fF
C337 divbuf_2/a_42720_n1600# divbuf_2/a_42750_n840# 0.04fF
C338 divbuf_2/a_41382_170# divbuf_2/OUT4 0.19fF
C339 divbuf_2/a_1842_n240# divbuf_2/OUT2 0.04fF
C340 divbuf_4/a_35070_n1540# divbuf_4/a_35550_n1540# 0.11fF
C341 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_16830_n840# 0.00fF
C342 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/a_1842_170# 0.07fF
C343 ro_div_0/ro_complete_0/cbank_0/v ro_div_0/ro_complete_0/cbank_2/v 0.04fF
C344 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_18240_n1600# 0.26fF
C345 ashish_0/a_150_0# ashish_0/von 9.14fF
C346 divbuf_1/a_16320_n1600# divbuf_1/a_16800_n1600# 0.26fF
C347 divbuf_1/a_6822_n240# divbuf_1/a_6750_n840# 0.03fF
C348 divbuf_5/a_5280_n1600# divbuf_5/a_5760_n1600# 0.26fF
C349 divbuf_3/a_31202_170# divbuf_3/OUT4 0.19fF
C350 ro_div_0/divbuf_0/a_10110_n1540# ro_div_0/divbuf_0/a_10590_n1540# 0.11fF
C351 ro_div_0/divbuf_0/a_40830_n840# ro_div_0/divbuf_0/a_40830_n1540# 0.01fF
C352 divbuf_1/a_39390_n840# divbuf_1/a_39390_n1540# 0.01fF
C353 divbuf_1/a_8670_n1540# divbuf_1/a_9150_n1540# 0.11fF
C354 divbuf_3/a_5280_n1600# divbuf_3/a_5310_n840# 0.04fF
C355 divbuf_5/a_58560_n1600# divbuf_5/a_58590_n1540# 0.19fF
C356 divbuf_5/a_58590_n840# divbuf_5/a_59070_n840# 0.07fF
C357 divbuf_5/a_28350_n840# divbuf_5/a_28350_n1540# 0.01fF
C358 divbuf_0/a_20532_170# divbuf_0/a_21012_170# 0.07fF
C359 divbuf_0/a_4392_170# divbuf_0/a_4392_n240# 0.01fF
C360 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C361 divbuf_2/a_40412_170# divbuf_2/a_40412_n240# 0.01fF
C362 divbuf_2/a_20532_n240# divbuf_2/a_21012_n240# 0.05fF
C363 divbuf_4/a_32640_n1600# divbuf_4/a_32670_n840# 0.04fF
C364 divbuf_4/a_21012_170# divbuf_4/OUT4 0.19fF
C365 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C366 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C367 divbuf_0/a_53760_n1600# divbuf_0/a_54240_n1600# 0.26fF
C368 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/clk 0.11fF
C369 pd_div_0/divider_0/tspc_1/Z2 gnd 0.16fF
C370 divbuf_2/a_1440_n1600# divbuf_2/OUT2 0.01fF
C371 divbuf_2/a_32160_n1600# divbuf_2/a_32190_n1540# 0.19fF
C372 divbuf_2/a_32190_n840# divbuf_2/a_32670_n840# 0.07fF
C373 divbuf_2/a_1950_n840# divbuf_2/a_1950_n1540# 0.01fF
C374 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C375 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C376 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46560_n1600# 0.26fF
C377 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/a_36990_n840# 0.05fF
C378 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/a_33142_170# 0.07fF
C379 divbuf_0/a_46110_n1540# divbuf_0/a_46590_n1540# 0.11fF
C380 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_7710_n840# 0.04fF
C381 divbuf_1/a_6240_n1600# divbuf_1/a_6270_n840# 0.04fF
C382 divbuf_3/a_21982_170# divbuf_3/a_22472_170# 0.07fF
C383 divbuf_3/a_1352_170# divbuf_3/a_1352_n240# 0.01fF
C384 divbuf_5/a_16152_n240# divbuf_5/a_15870_n840# 0.01fF
C385 pll_full_0/divbuf_0/a_38430_n1540# pll_full_0/divbuf_0/a_38910_n1540# 0.11fF
C386 divbuf_3/a_32172_n240# divbuf_3/OUT4 0.04fF
C387 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5760_n1600# 0.26fF
C388 divbuf_4/a_30232_170# divbuf_4/a_30232_n240# 0.01fF
C389 divbuf_4/a_9732_n240# divbuf_4/a_10212_n240# 0.05fF
C390 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_9120_n1600# 0.26fF
C391 divbuf_3/a_55200_n1600# divbuf_3/a_55680_n1600# 0.26fF
C392 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C393 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C394 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_58590_n1540# 0.19fF
C395 pd_div_0/divbuf_0/a_58590_n840# pd_div_0/divbuf_0/a_59070_n840# 0.07fF
C396 pd_div_0/divbuf_0/a_28350_n840# pd_div_0/divbuf_0/a_28350_n1540# 0.01fF
C397 divbuf_4/a_22080_n1600# divbuf_4/a_22110_n1540# 0.19fF
C398 divbuf_4/a_22110_n840# divbuf_4/a_22590_n840# 0.07fF
C399 divbuf_4/a_21982_n240# divbuf_4/OUT4 0.04fF
C400 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/OUT2 0.02fF
C401 pll_full_0/divbuf_1/a_990_n1540# pll_full_0/divbuf_1/a_1470_n1540# 0.11fF
C402 pll_full_0/divbuf_1/a_31710_n840# pll_full_0/divbuf_1/a_31710_n1540# 0.01fF
C403 divbuf_3/a_47550_n1540# divbuf_3/a_48030_n1540# 0.11fF
C404 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n840# 0.04fF
C405 divbuf_0/a_3912_n240# divbuf_0/OUT3 0.04fF
C406 divbuf_1/a_19562_170# divbuf_1/a_20042_170# 0.07fF
C407 divbuf_5/a_11802_170# divbuf_5/a_12282_170# 0.07fF
C408 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/OUT4 0.19fF
C409 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36030_n840# 0.04fF
C410 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_58080_n1600# 0.26fF
C411 divbuf_1/a_56160_n1600# divbuf_1/a_56640_n1600# 0.26fF
C412 divbuf_5/a_36052_n240# divbuf_5/a_36030_n840# 0.05fF
C413 divbuf_5/a_45120_n1600# divbuf_5/a_45600_n1600# 0.26fF
C414 ro_div_0/divbuf_0/a_49950_n1540# ro_div_0/divbuf_0/a_50430_n1540# 0.11fF
C415 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_15870_n840# 0.01fF
C416 divbuf_1/a_48510_n1540# divbuf_1/a_48990_n1540# 0.11fF
C417 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/a_29262_n240# 0.01fF
C418 divbuf_3/a_45120_n1600# divbuf_3/a_45150_n840# 0.04fF
C419 divbuf_5/a_37470_n1540# divbuf_5/a_37950_n1540# 0.11fF
C420 divbuf_0/a_21502_n240# divbuf_0/a_21982_n240# 0.05fF
C421 divbuf_0/a_41382_170# divbuf_0/a_41382_n240# 0.01fF
C422 divbuf_2/a_18720_n1600# divbuf_2/a_19200_n1600# 0.26fF
C423 divbuf_2/a_9242_n240# divbuf_2/a_9150_n840# 0.03fF
C424 divbuf_4/a_20160_n1600# divbuf_4/OUT4 0.00fF
C425 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/a_33622_n240# 0.01fF
C426 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C427 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_14222_n240# 0.05fF
C428 divbuf_0/a_2910_n840# divbuf_0/a_2910_n1540# 0.01fF
C429 divbuf_0/a_33150_n840# divbuf_0/a_33630_n840# 0.07fF
C430 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n1540# 0.19fF
C431 divbuf_1/a_21982_170# divbuf_1/a_21982_n240# 0.01fF
C432 pll_full_0/divbuf_0/a_25470_n840# pll_full_0/divbuf_0/a_25950_n840# 0.07fF
C433 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25470_n1540# 0.19fF
C434 divbuf_2/a_41790_n840# divbuf_2/a_41790_n1540# 0.01fF
C435 divbuf_2/a_11070_n1540# divbuf_2/a_11550_n1540# 0.11fF
C436 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C437 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_47550_n840# 0.04fF
C438 ro_div_0/divbuf_0/IN gnd 0.29fF
C439 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/a_9242_170# 0.07fF
C440 divbuf_1/a_8762_n240# divbuf_1/OUT3 0.04fF
C441 divbuf_1/a_46080_n1600# divbuf_1/a_46110_n840# 0.04fF
C442 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/a_15672_170# 0.07fF
C443 divbuf_3/a_22952_n240# divbuf_3/a_23442_n240# 0.04fF
C444 divbuf_5/a_35040_n1600# divbuf_5/a_35070_n840# 0.04fF
C445 divbuf_5/a_25862_170# divbuf_5/OUT4 0.19fF
C446 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/a_36030_n840# 0.05fF
C447 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45600_n1600# 0.26fF
C448 divbuf_4/a_8640_n1600# divbuf_4/a_9120_n1600# 0.26fF
C449 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48960_n1600# 0.26fF
C450 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/a_39390_n840# 0.04fF
C451 divbuf_3/a_34560_n1600# divbuf_3/a_34590_n1540# 0.19fF
C452 divbuf_3/a_34590_n840# divbuf_3/a_35070_n840# 0.07fF
C453 divbuf_3/a_4350_n840# divbuf_3/a_4350_n1540# 0.01fF
C454 pd_div_0/divbuf_0/a_37470_n1540# pd_div_0/divbuf_0/a_37950_n1540# 0.11fF
C455 divbuf_4/a_31710_n840# divbuf_4/a_31710_n1540# 0.01fF
C456 divbuf_4/a_990_n1540# divbuf_4/a_1470_n1540# 0.11fF
C457 divbuf_4/a_510_n840# divbuf_4/OUT2 0.02fF
C458 pll_full_0/divbuf_1/a_40830_n1540# pll_full_0/divbuf_1/a_41310_n1540# 0.11fF
C459 divbuf_2/a_8640_n1600# divbuf_2/a_8670_n840# 0.04fF
C460 gnd pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C461 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/a_25862_n240# 0.05fF
C462 divbuf_1/a_23922_n240# divbuf_1/a_24412_n240# 0.04fF
C463 divbuf_5/a_12772_n240# divbuf_5/a_13252_n240# 0.05fF
C464 divbuf_5/a_32652_170# divbuf_5/a_32652_n240# 0.01fF
C465 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_36990_n1540# 0.19fF
C466 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/OUT3 0.01fF
C467 ro_div_0/divbuf_0/a_6750_n840# ro_div_0/divbuf_0/a_6750_n1540# 0.01fF
C468 ro_div_0/divbuf_0/a_36990_n840# ro_div_0/divbuf_0/a_37470_n840# 0.07fF
C469 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/a_11312_n240# 0.01fF
C470 divbuf_1/a_35520_n1600# divbuf_1/a_35550_n1540# 0.19fF
C471 divbuf_1/a_35550_n840# divbuf_1/a_36030_n840# 0.07fF
C472 divbuf_1/a_5310_n840# divbuf_1/a_5310_n1540# 0.01fF
C473 divbuf_5/a_26832_n240# divbuf_5/OUT4 0.04fF
C474 divbuf_5/a_24480_n1600# divbuf_5/a_24510_n1540# 0.19fF
C475 divbuf_5/a_24510_n840# divbuf_5/a_24990_n840# 0.07fF
C476 divbuf_3/a_56670_n840# divbuf_3/a_56670_n1540# 0.01fF
C477 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/switch_1/vin 0.19fF
C478 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C479 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/and_0/A 0.80fF
C480 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35070_n840# 0.04fF
C481 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/OUT4 0.19fF
C482 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/OUT4 0.19fF
C483 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38430_n840# 0.04fF
C484 divbuf_2/a_5362_170# divbuf_2/a_5362_n240# 0.01fF
C485 divbuf_2/a_25382_170# divbuf_2/a_25862_170# 0.07fF
C486 divbuf_0/a_10212_n240# divbuf_0/a_10110_n840# 0.03fF
C487 divbuf_0/a_19680_n1600# divbuf_0/a_20160_n1600# 0.26fF
C488 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12480_n1600# 0.26fF
C489 divbuf_2/a_12772_170# divbuf_2/OUT4 0.19fF
C490 divbuf_2/a_58560_n1600# divbuf_2/a_59040_n1600# 0.26fF
C491 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C492 divbuf_0/a_12030_n1540# divbuf_0/a_12510_n1540# 0.11fF
C493 divbuf_0/a_42750_n840# divbuf_0/a_42750_n1540# 0.01fF
C494 divbuf_2/a_50910_n1540# divbuf_2/a_51390_n1540# 0.11fF
C495 divbuf_5/a_492_n240# divbuf_5/a_510_n840# 0.00fF
C496 pll_full_0/divbuf_0/a_35070_n840# pll_full_0/divbuf_0/a_35070_n1540# 0.01fF
C497 pll_full_0/divbuf_0/a_4350_n1540# pll_full_0/divbuf_0/a_4830_n1540# 0.11fF
C498 divbuf_3/a_2322_170# divbuf_3/OUT2 0.19fF
C499 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_13252_n240# 0.05fF
C500 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/a_32652_n240# 0.01fF
C501 divbuf_4/a_15182_170# divbuf_4/a_15672_170# 0.07fF
C502 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/a_36052_n240# 0.01fF
C503 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_16642_n240# 0.04fF
C504 divbuf_3/a_21120_n1600# divbuf_3/a_21600_n1600# 0.26fF
C505 divbuf_3/a_11802_n240# divbuf_3/a_12030_n840# 0.02fF
C506 divbuf_5/a_24960_n1600# divbuf_5/OUT4 0.00fF
C507 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C508 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24510_n1540# 0.19fF
C509 pd_div_0/divbuf_0/a_24510_n840# pd_div_0/divbuf_0/a_24990_n840# 0.07fF
C510 divbuf_3/a_44190_n840# divbuf_3/a_44190_n1540# 0.01fF
C511 divbuf_3/a_13470_n1540# divbuf_3/a_13950_n1540# 0.11fF
C512 divbuf_4/a_39442_n240# divbuf_4/a_39390_n840# 0.04fF
C513 divbuf_4/a_48480_n1600# divbuf_4/a_48960_n1600# 0.26fF
C514 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C515 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_27870_n1540# 0.19fF
C516 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C517 pll_full_0/divbuf_1/a_27870_n840# pll_full_0/divbuf_1/a_28350_n840# 0.07fF
C518 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n840# 0.04fF
C519 divbuf_0/a_3422_170# divbuf_0/OUT3 0.23fF
C520 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C521 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/nor_1/B 0.35fF
C522 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_1950_n840# 0.04fF
C523 divbuf_2/a_13742_n240# divbuf_2/OUT4 0.04fF
C524 divbuf_2/a_48480_n1600# divbuf_2/a_48510_n840# 0.04fF
C525 divbuf_4/a_40830_n1540# divbuf_4/a_41310_n1540# 0.11fF
C526 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.04fF
C527 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C528 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C529 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_24000_n1600# 0.26fF
C530 divbuf_0/a_60990_n840# divbuf_0/OUT5 0.04fF
C531 divbuf_1/a_22080_n1600# divbuf_1/a_22560_n1600# 0.26fF
C532 divbuf_1/a_12772_n240# divbuf_1/a_12990_n840# 0.02fF
C533 divbuf_5/a_11040_n1600# divbuf_5/a_11520_n1600# 0.26fF
C534 divbuf_3/a_3422_n240# divbuf_3/OUT3 0.07fF
C535 ro_div_0/divbuf_0/a_15870_n1540# ro_div_0/divbuf_0/a_16350_n1540# 0.11fF
C536 ro_div_0/divbuf_0/a_46590_n840# ro_div_0/divbuf_0/a_46590_n1540# 0.01fF
C537 divbuf_1/a_45150_n840# divbuf_1/a_45150_n1540# 0.01fF
C538 divbuf_1/a_14430_n1540# divbuf_1/a_14910_n1540# 0.11fF
C539 divbuf_3/a_11040_n1600# divbuf_3/a_11070_n840# 0.04fF
C540 divbuf_5/a_34110_n840# divbuf_5/a_34110_n1540# 0.01fF
C541 divbuf_5/a_3390_n1540# divbuf_5/a_3870_n1540# 0.11fF
C542 divbuf_0/a_26352_170# divbuf_0/a_26832_170# 0.07fF
C543 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C544 divbuf_2/a_26352_n240# divbuf_2/a_26832_n240# 0.05fF
C545 divbuf_4/a_38400_n1600# divbuf_4/a_38430_n840# 0.04fF
C546 divbuf_4/a_32652_170# divbuf_4/OUT4 0.19fF
C547 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/a_5362_n240# 0.01fF
C548 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C549 divbuf_0/a_59520_n1600# divbuf_0/a_60000_n1600# 0.26fF
C550 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C551 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C552 divbuf_1/a_4392_170# divbuf_1/a_4392_n240# 0.01fF
C553 divbuf_2/a_37950_n840# divbuf_2/a_38430_n840# 0.07fF
C554 divbuf_2/a_7710_n840# divbuf_2/a_7710_n1540# 0.01fF
C555 divbuf_2/a_12000_n1600# divbuf_2/OUT4 0.00fF
C556 divbuf_2/a_37920_n1600# divbuf_2/a_37950_n1540# 0.19fF
C557 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_52320_n1600# 0.26fF
C558 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C559 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/a_38962_170# 0.07fF
C560 divbuf_0/a_51870_n1540# divbuf_0/a_52350_n1540# 0.11fF
C561 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13470_n840# 0.04fF
C562 divbuf_1/a_30712_170# divbuf_1/OUT4 0.19fF
C563 divbuf_1/a_12000_n1600# divbuf_1/a_12030_n840# 0.04fF
C564 divbuf_3/a_27802_170# divbuf_3/a_28292_170# 0.07fF
C565 divbuf_3/a_7792_170# divbuf_3/a_7792_n240# 0.01fF
C566 divbuf_5/a_960_n1600# divbuf_5/a_990_n840# 0.04fF
C567 pll_full_0/divbuf_0/a_44190_n1540# pll_full_0/divbuf_0/a_44670_n1540# 0.11fF
C568 divbuf_3/a_2880_n1600# divbuf_3/OUT2 0.00fF
C569 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11520_n1600# 0.26fF
C570 divbuf_4/a_16152_n240# divbuf_4/a_16642_n240# 0.04fF
C571 divbuf_4/a_36052_170# divbuf_4/a_36052_n240# 0.01fF
C572 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14880_n1600# 0.26fF
C573 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/a_4830_n840# 0.04fF
C574 divbuf_3/a_480_n1600# divbuf_3/a_510_n1540# 0.19fF
C575 divbuf_3/a_510_n840# divbuf_3/a_990_n840# 0.07fF
C576 pd_div_0/divbuf_0/a_34110_n840# pd_div_0/divbuf_0/a_34110_n1540# 0.01fF
C577 pd_div_0/divbuf_0/a_3390_n1540# pd_div_0/divbuf_0/a_3870_n1540# 0.11fF
C578 divbuf_4/a_27870_n840# divbuf_4/a_28350_n840# 0.07fF
C579 divbuf_4/a_33622_n240# divbuf_4/OUT4 0.04fF
C580 divbuf_4/a_27840_n1600# divbuf_4/a_27870_n1540# 0.19fF
C581 pll_full_0/divbuf_1/a_6750_n1540# pll_full_0/divbuf_1/a_7230_n1540# 0.11fF
C582 pll_full_0/divbuf_1/a_37470_n840# pll_full_0/divbuf_1/a_37470_n1540# 0.01fF
C583 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/OUT4 0.19fF
C584 divbuf_0/a_15672_n240# divbuf_0/OUT4 0.04fF
C585 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n840# 0.04fF
C586 divbuf_1/a_15182_170# divbuf_1/a_15182_n240# 0.01fF
C587 divbuf_1/a_25382_170# divbuf_1/a_25862_170# 0.07fF
C588 divbuf_5/a_17612_170# divbuf_5/a_18092_170# 0.07fF
C589 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_41790_n840# 0.04fF
C590 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/OUT4 0.19fF
C591 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 0.94fF
C592 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/a_3390_n840# 0.07fF
C593 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_2910_n1540# 0.19fF
C594 divbuf_1/a_1440_n1600# divbuf_1/a_1470_n1540# 0.19fF
C595 divbuf_1/a_1470_n840# divbuf_1/a_1950_n840# 0.07fF
C596 divbuf_5/a_50880_n1600# divbuf_5/a_51360_n1600# 0.26fF
C597 divbuf_3/a_52800_n1600# divbuf_3/a_52830_n1540# 0.19fF
C598 ro_div_0/divbuf_0/a_55710_n1540# ro_div_0/divbuf_0/a_56190_n1540# 0.11fF
C599 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_990_n840# 0.04fF
C600 divbuf_1/a_54270_n1540# divbuf_1/a_54750_n1540# 0.11fF
C601 divbuf_5/a_43230_n1540# divbuf_5/a_43710_n1540# 0.11fF
C602 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4350_n840# 0.04fF
C603 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/a_35082_n240# 0.01fF
C604 divbuf_3/a_50880_n1600# divbuf_3/a_50910_n840# 0.04fF
C605 divbuf_0/a_27322_n240# divbuf_0/a_27802_n240# 0.05fF
C606 divbuf_2/a_15182_n240# divbuf_2/a_15390_n840# 0.02fF
C607 divbuf_2/a_24480_n1600# divbuf_2/a_24960_n1600# 0.26fF
C608 divbuf_4/a_31680_n1600# divbuf_4/OUT4 0.00fF
C609 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/a_20042_n240# 0.05fF
C610 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/a_39442_n240# 0.01fF
C611 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n1540# 0.19fF
C612 divbuf_0/a_8670_n840# divbuf_0/a_8670_n1540# 0.01fF
C613 divbuf_0/a_38910_n840# divbuf_0/a_39390_n840# 0.07fF
C614 divbuf_1/a_27802_170# divbuf_1/a_27802_n240# 0.01fF
C615 divbuf_2/a_47550_n840# divbuf_2/a_47550_n1540# 0.01fF
C616 divbuf_2/a_16830_n1540# divbuf_2/a_17310_n1540# 0.11fF
C617 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C618 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31230_n1540# 0.19fF
C619 pll_full_0/divbuf_0/a_31230_n840# pll_full_0/divbuf_0/a_31710_n840# 0.07fF
C620 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/a_990_n1540# 0.01fF
C621 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C622 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53310_n840# 0.04fF
C623 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/a_18092_170# 0.07fF
C624 divbuf_1/a_51840_n1600# divbuf_1/a_51870_n840# 0.04fF
C625 divbuf_1/a_20532_n240# divbuf_1/OUT4 0.04fF
C626 divbuf_5/a_40800_n1600# divbuf_5/a_40830_n840# 0.04fF
C627 divbuf_5/a_37502_170# divbuf_5/OUT4 0.19fF
C628 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/a_21502_170# 0.07fF
C629 divbuf_3/a_28772_n240# divbuf_3/a_29262_n240# 0.04fF
C630 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C631 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_51360_n1600# 0.26fF
C632 divbuf_4/a_4882_n240# divbuf_4/a_4830_n840# 0.04fF
C633 divbuf_4/a_14400_n1600# divbuf_4/a_14880_n1600# 0.26fF
C634 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54720_n1600# 0.26fF
C635 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/OUT3 0.19fF
C636 divbuf_3/a_40350_n840# divbuf_3/a_40830_n840# 0.07fF
C637 divbuf_3/a_10110_n840# divbuf_3/a_10110_n1540# 0.01fF
C638 divbuf_3/a_40320_n1600# divbuf_3/a_40350_n1540# 0.19fF
C639 pd_div_0/divbuf_0/a_43230_n1540# pd_div_0/divbuf_0/a_43710_n1540# 0.11fF
C640 divbuf_2/a_14400_n1600# divbuf_2/a_14430_n840# 0.04fF
C641 divbuf_4/a_37470_n840# divbuf_4/a_37470_n1540# 0.01fF
C642 divbuf_4/a_6750_n1540# divbuf_4/a_7230_n1540# 0.11fF
C643 pll_full_0/divbuf_1/a_46590_n1540# pll_full_0/divbuf_1/a_47070_n1540# 0.11fF
C644 gnd pll_full_0/divider_0/and_0/out1 0.29fF
C645 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/a_31682_n240# 0.05fF
C646 divbuf_1/a_29742_n240# divbuf_1/a_30232_n240# 0.04fF
C647 divbuf_5/a_38472_170# divbuf_5/a_38472_n240# 0.01fF
C648 divbuf_5/a_18582_n240# divbuf_5/a_19072_n240# 0.04fF
C649 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C650 ro_div_0/divbuf_0/a_12510_n840# ro_div_0/divbuf_0/a_12510_n1540# 0.01fF
C651 ro_div_0/divbuf_0/a_42750_n840# ro_div_0/divbuf_0/a_43230_n840# 0.07fF
C652 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_42750_n1540# 0.19fF
C653 divbuf_1/a_41280_n1600# divbuf_1/a_41310_n1540# 0.19fF
C654 divbuf_1/a_41310_n840# divbuf_1/a_41790_n840# 0.07fF
C655 divbuf_1/a_11070_n840# divbuf_1/a_11070_n1540# 0.01fF
C656 divbuf_5/a_30240_n1600# divbuf_5/a_30270_n1540# 0.19fF
C657 divbuf_5/a_30270_n840# divbuf_5/a_30750_n840# 0.07fF
C658 divbuf_5/a_38472_n240# divbuf_5/OUT4 0.04fF
C659 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C660 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_40830_n840# 0.04fF
C661 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/OUT4 0.19fF
C662 divbuf_2/a_31202_170# divbuf_2/a_31682_170# 0.07fF
C663 divbuf_2/a_11802_170# divbuf_2/a_11802_n240# 0.01fF
C664 divbuf_4/a_4320_n1600# divbuf_4/a_4350_n840# 0.04fF
C665 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44190_n840# 0.04fF
C666 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C667 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/a_3870_n840# 0.04fF
C668 divbuf_0/a_25440_n1600# divbuf_0/a_25920_n1600# 0.26fF
C669 divbuf_0/a_16152_n240# divbuf_0/a_16350_n840# 0.02fF
C670 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/a_8190_n840# 0.03fF
C671 divbuf_2/a_3870_n840# divbuf_2/a_4350_n840# 0.07fF
C672 divbuf_2/a_3840_n1600# divbuf_2/a_3870_n1540# 0.19fF
C673 divbuf_2/a_24412_170# divbuf_2/OUT4 0.19fF
C674 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_18240_n1600# 0.26fF
C675 divbuf_0/a_17790_n1540# divbuf_0/a_18270_n1540# 0.11fF
C676 divbuf_0/a_48510_n840# divbuf_0/a_48510_n1540# 0.01fF
C677 divbuf_2/a_56670_n1540# divbuf_2/a_57150_n1540# 0.11fF
C678 pll_full_0/divbuf_0/a_40830_n840# pll_full_0/divbuf_0/a_40830_n1540# 0.01fF
C679 pll_full_0/divbuf_0/a_10110_n1540# pll_full_0/divbuf_0/a_10590_n1540# 0.11fF
C680 divbuf_3/a_14222_170# divbuf_3/OUT4 0.19fF
C681 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/a_38472_n240# 0.01fF
C682 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/a_19072_n240# 0.04fF
C683 divbuf_4/a_21012_170# divbuf_4/a_21502_170# 0.07fF
C684 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/a_22472_n240# 0.04fF
C685 divbuf_3/a_26880_n1600# divbuf_3/a_27360_n1600# 0.26fF
C686 divbuf_3/a_17612_n240# divbuf_3/a_17790_n840# 0.02fF
C687 divbuf_5/a_36480_n1600# divbuf_5/OUT4 0.00fF
C688 divbuf_0/a_19072_170# divbuf_0/a_19072_n240# 0.01fF
C689 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30270_n1540# 0.19fF
C690 pd_div_0/divbuf_0/a_30270_n840# pd_div_0/divbuf_0/a_30750_n840# 0.07fF
C691 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C692 divbuf_4/a_3912_170# divbuf_4/OUT3 0.19fF
C693 divbuf_4/a_54240_n1600# divbuf_4/a_54720_n1600# 0.26fF
C694 pll_full_0/divbuf_1/a_3390_n840# pll_full_0/divbuf_1/a_3390_n1540# 0.01fF
C695 pll_full_0/divbuf_1/a_33630_n840# pll_full_0/divbuf_1/a_34110_n840# 0.07fF
C696 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_33630_n1540# 0.19fF
C697 divbuf_3/a_49950_n840# divbuf_3/a_49950_n1540# 0.01fF
C698 divbuf_3/a_19230_n1540# divbuf_3/a_19710_n1540# 0.11fF
C699 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n840# 0.04fF
C700 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C701 divbuf_2/a_54240_n1600# divbuf_2/a_54270_n840# 0.04fF
C702 divbuf_2/a_25382_n240# divbuf_2/OUT4 0.04fF
C703 divbuf_4/a_46590_n1540# divbuf_4/a_47070_n1540# 0.11fF
C704 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_7710_n840# 0.04fF
C705 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C706 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29760_n1600# 0.26fF
C707 divbuf_1/a_27840_n1600# divbuf_1/a_28320_n1600# 0.26fF
C708 divbuf_1/a_18582_n240# divbuf_1/a_18750_n840# 0.02fF
C709 divbuf_5/a_16800_n1600# divbuf_5/a_17280_n1600# 0.26fF
C710 divbuf_5/a_7302_n240# divbuf_5/a_7230_n840# 0.03fF
C711 divbuf_3/a_15182_n240# divbuf_3/OUT4 0.04fF
C712 ro_div_0/divbuf_0/a_21630_n1540# ro_div_0/divbuf_0/a_22110_n1540# 0.11fF
C713 ro_div_0/divbuf_0/a_52350_n840# ro_div_0/divbuf_0/a_52350_n1540# 0.01fF
C714 divbuf_1/a_50910_n840# divbuf_1/a_50910_n1540# 0.01fF
C715 divbuf_1/a_20190_n1540# divbuf_1/a_20670_n1540# 0.11fF
C716 divbuf_3/a_16800_n1600# divbuf_3/a_16830_n840# 0.04fF
C717 divbuf_5/a_39870_n840# divbuf_5/a_39870_n1540# 0.01fF
C718 divbuf_5/a_9150_n1540# divbuf_5/a_9630_n1540# 0.11fF
C719 divbuf_0/a_32172_170# divbuf_0/a_32652_170# 0.07fF
C720 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C721 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/a_24892_170# 0.07fF
C722 divbuf_2/a_32172_n240# divbuf_2/a_32652_n240# 0.05fF
C723 divbuf_4/a_4882_n240# divbuf_4/OUT3 0.04fF
C724 divbuf_4/a_44160_n1600# divbuf_4/a_44190_n840# 0.04fF
C725 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/OUT2 0.42fF
C726 divbuf_0/a_26352_170# divbuf_0/OUT4 0.19fF
C727 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n1540# 0.19fF
C728 divbuf_0/a_4830_n840# divbuf_0/a_5310_n840# 0.07fF
C729 pd_div_0/divider_0/tspc_2/Z3 pd_div_0/divider_0/tspc_2/Z4 0.65fF
C730 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_58080_n1600# 0.26fF
C731 divbuf_2/a_43680_n1600# divbuf_2/a_43710_n1540# 0.19fF
C732 divbuf_2/a_43710_n840# divbuf_2/a_44190_n840# 0.07fF
C733 divbuf_2/a_13470_n840# divbuf_2/a_13470_n1540# 0.01fF
C734 divbuf_2/a_23520_n1600# divbuf_2/OUT4 0.00fF
C735 pll_full_0/divbuf_0/a_12282_170# pll_full_0/divbuf_0/OUT4 0.19fF
C736 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z2 0.11fF
C737 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/a_4882_n240# 0.04fF
C738 divbuf_0/a_57630_n1540# divbuf_0/a_58110_n1540# 0.11fF
C739 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19230_n840# 0.04fF
C740 divbuf_1/a_2322_170# divbuf_1/OUT2 0.19fF
C741 divbuf_1/a_17760_n1600# divbuf_1/a_17790_n840# 0.04fF
C742 divbuf_3/a_14222_170# divbuf_3/a_14222_n240# 0.01fF
C743 divbuf_3/a_33622_170# divbuf_3/a_34112_170# 0.07fF
C744 divbuf_5/a_6720_n1600# divbuf_5/a_6750_n840# 0.04fF
C745 pll_full_0/divbuf_0/a_49950_n1540# pll_full_0/divbuf_0/a_50430_n1540# 0.11fF
C746 divbuf_3/a_13440_n1600# divbuf_3/OUT4 0.00fF
C747 pd_div_0/div pd_div_0/divbuf_0/a_510_n1540# 0.11fF
C748 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_17280_n1600# 0.26fF
C749 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/a_7230_n840# 0.03fF
C750 divbuf_3/a_6270_n840# divbuf_3/a_6750_n840# 0.07fF
C751 divbuf_3/a_6240_n1600# divbuf_3/a_6270_n1540# 0.19fF
C752 divbuf_4/a_21982_n240# divbuf_4/a_22472_n240# 0.04fF
C753 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20640_n1600# 0.26fF
C754 pd_div_0/divbuf_0/a_39870_n840# pd_div_0/divbuf_0/a_39870_n1540# 0.01fF
C755 pd_div_0/divbuf_0/a_9150_n1540# pd_div_0/divbuf_0/a_9630_n1540# 0.11fF
C756 divbuf_4/a_33600_n1600# divbuf_4/a_33630_n1540# 0.19fF
C757 divbuf_4/a_33630_n840# divbuf_4/a_34110_n840# 0.07fF
C758 divbuf_4/a_3390_n840# divbuf_4/a_3390_n1540# 0.01fF
C759 pll_full_0/divbuf_1/a_12510_n1540# pll_full_0/divbuf_1/a_12990_n1540# 0.11fF
C760 pll_full_0/divbuf_1/a_43230_n840# pll_full_0/divbuf_1/a_43230_n1540# 0.01fF
C761 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C762 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n840# 0.04fF
C763 divbuf_0/a_27322_n240# divbuf_0/OUT4 0.04fF
C764 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_47550_n840# 0.04fF
C765 divbuf_1/a_8762_170# divbuf_1/a_8762_n240# 0.01fF
C766 divbuf_1/a_34592_170# divbuf_1/a_35082_170# 0.07fF
C767 divbuf_5/a_3422_170# divbuf_5/a_3422_n240# 0.01fF
C768 divbuf_5/a_23442_170# divbuf_5/a_23922_170# 0.07fF
C769 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C770 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 0.22fF
C771 ro_div_0/divbuf_0/a_8670_n840# ro_div_0/divbuf_0/a_9150_n840# 0.07fF
C772 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_8670_n1540# 0.19fF
C773 pd_div_0/pd_0/tspc_r_1/Z2 pd_div_0/pd_0/tspc_r_1/Z4 0.14fF
C774 divbuf_1/a_7200_n1600# divbuf_1/a_7230_n1540# 0.19fF
C775 divbuf_1/a_7230_n840# divbuf_1/a_7710_n840# 0.07fF
C776 divbuf_1/a_27802_170# divbuf_1/OUT4 0.19fF
C777 divbuf_5/a_8762_170# divbuf_5/OUT3 0.19fF
C778 divbuf_5/a_56640_n1600# divbuf_5/a_57120_n1600# 0.26fF
C779 divbuf_3/a_58560_n1600# divbuf_3/a_58590_n1540# 0.19fF
C780 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_6750_n840# 0.04fF
C781 divbuf_1/a_60030_n1540# divbuf_1/a_60510_n1540# 0.11fF
C782 divbuf_5/a_48990_n1540# divbuf_5/a_49470_n1540# 0.11fF
C783 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10110_n840# 0.04fF
C784 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/a_40902_n240# 0.01fF
C785 divbuf_3/a_56640_n1600# divbuf_3/a_56670_n840# 0.04fF
C786 divbuf_0/a_33142_n240# divbuf_0/a_33622_n240# 0.05fF
C787 divbuf_2/a_30240_n1600# divbuf_2/a_30720_n1600# 0.26fF
C788 divbuf_2/a_21012_n240# divbuf_2/a_21150_n840# 0.03fF
C789 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/a_25862_n240# 0.05fF
C790 pll_full_0/divbuf_1/a_510_n1540# pll_full_0/divbuf_1/OUT 0.11fF
C791 gnd pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.27fF
C792 divbuf_0/a_14430_n840# divbuf_0/a_14430_n1540# 0.01fF
C793 divbuf_0/a_44670_n840# divbuf_0/a_45150_n840# 0.07fF
C794 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n1540# 0.19fF
C795 divbuf_2/a_53310_n840# divbuf_2/a_53310_n1540# 0.01fF
C796 divbuf_2/a_22590_n1540# divbuf_2/a_23070_n1540# 0.11fF
C797 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_36990_n1540# 0.19fF
C798 pll_full_0/divbuf_0/a_36990_n840# pll_full_0/divbuf_0/a_37470_n840# 0.07fF
C799 pll_full_0/divbuf_0/a_6750_n840# pll_full_0/divbuf_0/a_6750_n1540# 0.01fF
C800 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/OUT3 0.01fF
C801 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59070_n840# 0.04fF
C802 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C803 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/a_23922_170# 0.07fF
C804 divbuf_1/a_32172_n240# divbuf_1/OUT4 0.04fF
C805 divbuf_1/a_57600_n1600# divbuf_1/a_57630_n840# 0.04fF
C806 divbuf_5/a_9732_n240# divbuf_5/OUT3 0.04fF
C807 divbuf_5/a_46560_n1600# divbuf_5/a_46590_n840# 0.04fF
C808 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/a_27322_170# 0.07fF
C809 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/a_6822_n240# 0.01fF
C810 divbuf_3/a_34592_n240# divbuf_3/a_35082_n240# 0.04fF
C811 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/nor_1/A 0.55fF
C812 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_57120_n1600# 0.26fF
C813 divbuf_4/a_20160_n1600# divbuf_4/a_20640_n1600# 0.26fF
C814 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C815 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C816 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C817 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60480_n1600# 0.26fF
C818 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/OUT4 0.19fF
C819 divbuf_3/a_46080_n1600# divbuf_3/a_46110_n1540# 0.19fF
C820 divbuf_3/a_46110_n840# divbuf_3/a_46590_n840# 0.07fF
C821 divbuf_3/a_15870_n840# divbuf_3/a_15870_n1540# 0.01fF
C822 divbuf_0/a_1352_n240# divbuf_0/a_1470_n840# 0.03fF
C823 pd_div_0/divbuf_0/a_48990_n1540# pd_div_0/divbuf_0/a_49470_n1540# 0.11fF
C824 divbuf_2/a_20160_n1600# divbuf_2/a_20190_n840# 0.04fF
C825 divbuf_4/a_43230_n840# divbuf_4/a_43230_n1540# 0.01fF
C826 divbuf_4/a_12510_n1540# divbuf_4/a_12990_n1540# 0.11fF
C827 pll_full_0/divbuf_1/a_52350_n1540# pll_full_0/divbuf_1/a_52830_n1540# 0.11fF
C828 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/a_37502_n240# 0.05fF
C829 divbuf_1/a_35562_n240# divbuf_1/a_36052_n240# 0.04fF
C830 divbuf_5/a_24412_n240# divbuf_5/a_24892_n240# 0.05fF
C831 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48510_n1540# 0.19fF
C832 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C833 ro_div_0/divbuf_0/a_18270_n840# ro_div_0/divbuf_0/a_18270_n1540# 0.01fF
C834 ro_div_0/divbuf_0/a_48510_n840# ro_div_0/divbuf_0/a_48990_n840# 0.07fF
C835 divbuf_1/a_47040_n1600# divbuf_1/a_47070_n1540# 0.19fF
C836 divbuf_1/a_47070_n840# divbuf_1/a_47550_n840# 0.07fF
C837 divbuf_1/a_16830_n840# divbuf_1/a_16830_n1540# 0.01fF
C838 divbuf_5/a_8640_n1600# divbuf_5/OUT3 0.00fF
C839 divbuf_5/a_36000_n1600# divbuf_5/a_36030_n1540# 0.19fF
C840 divbuf_5/a_36030_n840# divbuf_5/a_36510_n840# 0.07fF
C841 divbuf_5/a_5790_n840# divbuf_5/a_5790_n1540# 0.01fF
C842 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z1 0.03fF
C843 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z3 0.05fF
C844 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C845 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_46590_n840# 0.04fF
C846 divbuf_2/a_17612_170# divbuf_2/a_17612_n240# 0.01fF
C847 divbuf_2/a_37022_170# divbuf_2/a_37502_170# 0.07fF
C848 divbuf_4/a_10080_n1600# divbuf_4/a_10110_n840# 0.04fF
C849 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C850 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_49950_n840# 0.04fF
C851 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/a_9630_n840# 0.03fF
C852 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/a_9732_170# 0.07fF
C853 divbuf_0/a_21982_n240# divbuf_0/a_22110_n840# 0.03fF
C854 divbuf_0/a_31200_n1600# divbuf_0/a_31680_n1600# 0.26fF
C855 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_24000_n1600# 0.26fF
C856 divbuf_2/a_9600_n1600# divbuf_2/a_9630_n1540# 0.19fF
C857 divbuf_2/a_36052_170# divbuf_2/OUT4 0.19fF
C858 divbuf_2/a_9630_n840# divbuf_2/a_10110_n840# 0.07fF
C859 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_14430_n840# 0.02fF
C860 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/a_9732_170# 0.07fF
C861 divbuf_0/a_23550_n1540# divbuf_0/a_24030_n1540# 0.11fF
C862 divbuf_0/a_54270_n840# divbuf_0/a_54270_n1540# 0.01fF
C863 divbuf_2/a_60990_n1540# divbuf_2/OUT5 0.19fF
C864 pll_full_0/divbuf_0/a_46590_n840# pll_full_0/divbuf_0/a_46590_n1540# 0.01fF
C865 pll_full_0/divbuf_0/a_15870_n1540# pll_full_0/divbuf_0/a_16350_n1540# 0.11fF
C866 divbuf_3/a_25862_170# divbuf_3/OUT4 0.19fF
C867 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/a_24892_n240# 0.05fF
C868 divbuf_4/a_6822_170# divbuf_4/a_6822_n240# 0.01fF
C869 divbuf_4/a_26832_170# divbuf_4/a_27322_170# 0.07fF
C870 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/a_28292_n240# 0.04fF
C871 divbuf_3/a_32640_n1600# divbuf_3/a_33120_n1600# 0.26fF
C872 divbuf_3/a_23442_n240# divbuf_3/a_23550_n840# 0.03fF
C873 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C874 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36030_n1540# 0.19fF
C875 pd_div_0/divbuf_0/a_36030_n840# pd_div_0/divbuf_0/a_36510_n840# 0.07fF
C876 pd_div_0/divbuf_0/a_5790_n840# pd_div_0/divbuf_0/a_5790_n1540# 0.01fF
C877 divbuf_4/a_15672_170# divbuf_4/OUT4 0.19fF
C878 divbuf_4/a_60000_n1600# divbuf_4/a_60480_n1600# 0.26fF
C879 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39390_n1540# 0.19fF
C880 pll_full_0/divbuf_1/a_9150_n840# pll_full_0/divbuf_1/a_9150_n1540# 0.01fF
C881 pll_full_0/divbuf_1/a_39390_n840# pll_full_0/divbuf_1/a_39870_n840# 0.07fF
C882 divbuf_3/a_24990_n1540# divbuf_3/a_25470_n1540# 0.11fF
C883 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n840# 0.04fF
C884 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C885 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C886 divbuf_1/a_18582_170# divbuf_1/a_19072_170# 0.07fF
C887 divbuf_4/a_52350_n1540# divbuf_4/a_52830_n1540# 0.11fF
C888 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13470_n840# 0.04fF
C889 divbuf_2/a_37022_n240# divbuf_2/OUT4 0.04fF
C890 divbuf_2/a_60000_n1600# divbuf_2/a_60030_n840# 0.04fF
C891 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C892 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C893 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35520_n1600# 0.26fF
C894 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/a_25950_n840# 0.03fF
C895 divbuf_1/a_24412_n240# divbuf_1/a_24510_n840# 0.03fF
C896 divbuf_1/a_33600_n1600# divbuf_1/a_34080_n1600# 0.26fF
C897 divbuf_5/a_13252_n240# divbuf_5/a_13470_n840# 0.02fF
C898 divbuf_5/a_22560_n1600# divbuf_5/a_23040_n1600# 0.26fF
C899 divbuf_3/a_26832_n240# divbuf_3/OUT4 0.04fF
C900 ro_div_0/divbuf_0/a_27390_n1540# ro_div_0/divbuf_0/a_27870_n1540# 0.11fF
C901 ro_div_0/divbuf_0/a_58110_n840# ro_div_0/divbuf_0/a_58110_n1540# 0.01fF
C902 divbuf_1/a_56670_n840# divbuf_1/a_56670_n1540# 0.01fF
C903 divbuf_1/a_25950_n1540# divbuf_1/a_26430_n1540# 0.11fF
C904 divbuf_3/a_22560_n1600# divbuf_3/a_22590_n840# 0.04fF
C905 divbuf_5/a_45630_n840# divbuf_5/a_45630_n1540# 0.01fF
C906 divbuf_5/a_14910_n1540# divbuf_5/a_15390_n1540# 0.11fF
C907 divbuf_0/a_37992_170# divbuf_0/a_38472_170# 0.07fF
C908 divbuf_4/a_49920_n1600# divbuf_4/a_49950_n840# 0.04fF
C909 divbuf_4/a_16642_n240# divbuf_4/OUT4 0.04fF
C910 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/OUT4 0.19fF
C911 divbuf_2/a_37992_n240# divbuf_2/a_38472_n240# 0.05fF
C912 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/a_30712_170# 0.07fF
C913 divbuf_0/a_10590_n840# divbuf_0/a_11070_n840# 0.07fF
C914 divbuf_0/a_37992_170# divbuf_0/OUT4 0.19fF
C915 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n1540# 0.19fF
C916 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/a_3390_n840# 0.07fF
C917 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/OUT4 0.19fF
C918 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_2910_n1540# 0.19fF
C919 divbuf_2/a_49470_n840# divbuf_2/a_49950_n840# 0.07fF
C920 divbuf_2/a_19230_n840# divbuf_2/a_19230_n1540# 0.01fF
C921 divbuf_2/a_35040_n1600# divbuf_2/OUT4 0.00fF
C922 divbuf_2/a_49440_n1600# divbuf_2/a_49470_n1540# 0.19fF
C923 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_24990_n840# 0.04fF
C924 divbuf_0/OUT3 divbuf_0/OUT4 0.36fF
C925 divbuf_1/a_23520_n1600# divbuf_1/a_23550_n840# 0.04fF
C926 divbuf_3/a_39442_170# divbuf_3/a_39932_170# 0.07fF
C927 divbuf_3/a_20042_170# divbuf_3/a_20042_n240# 0.01fF
C928 divbuf_5/a_12480_n1600# divbuf_5/a_12510_n840# 0.04fF
C929 pll_full_0/divbuf_0/a_55710_n1540# pll_full_0/divbuf_0/a_56190_n1540# 0.11fF
C930 divbuf_3/a_24960_n1600# divbuf_3/OUT4 0.00fF
C931 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_13470_n840# 0.02fF
C932 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_23040_n1600# 0.26fF
C933 divbuf_4/a_27802_n240# divbuf_4/a_28292_n240# 0.04fF
C934 divbuf_3/a_12000_n1600# divbuf_3/a_12030_n1540# 0.19fF
C935 divbuf_3/a_12030_n840# divbuf_3/a_12510_n840# 0.07fF
C936 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_26400_n1600# 0.26fF
C937 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_16830_n840# 0.02fF
C938 pd_div_0/divbuf_0/a_45630_n840# pd_div_0/divbuf_0/a_45630_n1540# 0.01fF
C939 pd_div_0/divbuf_0/a_14910_n1540# pd_div_0/divbuf_0/a_15390_n1540# 0.11fF
C940 divbuf_4/a_39390_n840# divbuf_4/a_39870_n840# 0.07fF
C941 divbuf_4/a_9150_n840# divbuf_4/a_9150_n1540# 0.01fF
C942 divbuf_4/a_39360_n1600# divbuf_4/a_39390_n1540# 0.19fF
C943 pll_full_0/divbuf_1/a_18270_n1540# pll_full_0/divbuf_1/a_18750_n1540# 0.11fF
C944 pll_full_0/divbuf_1/a_48990_n840# pll_full_0/divbuf_1/a_48990_n1540# 0.01fF
C945 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C946 divbuf_0/a_38962_n240# divbuf_0/OUT4 0.04fF
C947 divbuf_1/a_40412_170# divbuf_1/a_40902_170# 0.07fF
C948 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C949 divbuf_5/a_29262_170# divbuf_5/a_29742_170# 0.07fF
C950 divbuf_5/a_9242_170# divbuf_5/a_9242_n240# 0.01fF
C951 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53310_n840# 0.04fF
C952 ro_div_0/divider_0/prescaler_0/tspc_2/D gnd 0.05fF
C953 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14430_n1540# 0.19fF
C954 ro_div_0/divbuf_0/a_14430_n840# ro_div_0/divbuf_0/a_14910_n840# 0.07fF
C955 divbuf_1/a_3422_n240# divbuf_1/OUT3 0.07fF
C956 divbuf_1/a_12960_n1600# divbuf_1/a_12990_n1540# 0.19fF
C957 divbuf_1/a_12990_n840# divbuf_1/a_13470_n840# 0.07fF
C958 divbuf_5/a_1920_n1600# divbuf_5/a_1950_n1540# 0.19fF
C959 divbuf_5/a_20532_170# divbuf_5/OUT4 0.19fF
C960 divbuf_5/a_1950_n840# divbuf_5/a_2430_n840# 0.07fF
C961 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12510_n840# 0.04fF
C962 divbuf_2/a_1352_170# divbuf_2/a_1842_170# 0.07fF
C963 divbuf_5/a_54750_n1540# divbuf_5/a_55230_n1540# 0.11fF
C964 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_15870_n840# 0.04fF
C965 divbuf_0/a_38962_n240# divbuf_0/a_39442_n240# 0.05fF
C966 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/a_31682_n240# 0.05fF
C967 divbuf_2/a_26832_n240# divbuf_2/a_26910_n840# 0.04fF
C968 divbuf_2/a_36000_n1600# divbuf_2/a_36480_n1600# 0.26fF
C969 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n1540# 0.19fF
C970 divbuf_0/a_20190_n840# divbuf_0/a_20190_n1540# 0.01fF
C971 divbuf_0/a_50430_n840# divbuf_0/a_50910_n840# 0.07fF
C972 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C973 divbuf_2/a_59070_n840# divbuf_2/a_59070_n1540# 0.01fF
C974 divbuf_2/a_28350_n1540# divbuf_2/a_28830_n1540# 0.11fF
C975 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_42750_n1540# 0.19fF
C976 pll_full_0/divbuf_0/a_42750_n840# pll_full_0/divbuf_0/a_43230_n840# 0.07fF
C977 pll_full_0/divbuf_0/a_12510_n840# pll_full_0/divbuf_0/a_12510_n1540# 0.01fF
C978 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/a_29742_170# 0.07fF
C979 divbuf_1/a_2880_n1600# divbuf_1/OUT2 0.00fF
C980 divbuf_3/a_55710_n1540# divbuf_3/a_56190_n1540# 0.11fF
C981 divbuf_3/a_40412_n240# divbuf_3/a_40902_n240# 0.04fF
C982 divbuf_5/a_52320_n1600# divbuf_5/a_52350_n840# 0.04fF
C983 divbuf_5/a_21502_n240# divbuf_5/OUT4 0.04fF
C984 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/a_13252_n240# 0.01fF
C985 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/a_33142_170# 0.07fF
C986 divbuf_0/a_6332_170# divbuf_0/a_5852_170# 0.07fF
C987 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_1950_n1540# 0.19fF
C988 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/OUT4 0.19fF
C989 pd_div_0/divbuf_0/a_1950_n840# pd_div_0/divbuf_0/a_2430_n840# 0.07fF
C990 divbuf_4/a_16642_n240# divbuf_4/a_16830_n840# 0.02fF
C991 divbuf_4/a_25920_n1600# divbuf_4/a_26400_n1600# 0.26fF
C992 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C993 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/OUT4 0.19fF
C994 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5310_n1540# 0.19fF
C995 pll_full_0/divbuf_1/a_5310_n840# pll_full_0/divbuf_1/a_5790_n840# 0.07fF
C996 divbuf_3/a_51870_n840# divbuf_3/a_52350_n840# 0.07fF
C997 divbuf_3/a_21630_n840# divbuf_3/a_21630_n1540# 0.01fF
C998 pd_div_0/divbuf_0/a_54750_n1540# pd_div_0/divbuf_0/a_55230_n1540# 0.11fF
C999 divbuf_2/a_7302_170# divbuf_2/OUT3 0.19fF
C1000 divbuf_2/a_25920_n1600# divbuf_2/a_25950_n840# 0.04fF
C1001 divbuf_4/a_48990_n840# divbuf_4/a_48990_n1540# 0.01fF
C1002 divbuf_4/a_18270_n1540# divbuf_4/a_18750_n1540# 0.11fF
C1003 pll_full_0/divbuf_1/a_58110_n1540# pll_full_0/divbuf_1/a_58590_n1540# 0.11fF
C1004 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_1440_n1600# 0.26fF
C1005 divbuf_5/a_30232_n240# divbuf_5/a_30712_n240# 0.05fF
C1006 ro_div_0/divbuf_0/a_24030_n840# ro_div_0/divbuf_0/a_24030_n1540# 0.01fF
C1007 ro_div_0/divbuf_0/a_54270_n840# ro_div_0/divbuf_0/a_54750_n840# 0.07fF
C1008 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54270_n1540# 0.19fF
C1009 divbuf_1/a_52800_n1600# divbuf_1/a_52830_n1540# 0.19fF
C1010 divbuf_1/a_52830_n840# divbuf_1/a_53310_n840# 0.07fF
C1011 divbuf_1/a_22590_n840# divbuf_1/a_22590_n1540# 0.01fF
C1012 divbuf_5/a_41760_n1600# divbuf_5/a_41790_n1540# 0.19fF
C1013 divbuf_5/a_41790_n840# divbuf_5/a_42270_n840# 0.07fF
C1014 divbuf_5/a_11550_n840# divbuf_5/a_11550_n1540# 0.01fF
C1015 divbuf_5/a_19680_n1600# divbuf_5/OUT4 0.00fF
C1016 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_3/vin 0.20fF
C1017 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/B 0.18fF
C1018 ro_div_0/divider_0/tspc_0/Z2 ro_div_0/divider_0/tspc_0/Z3 0.16fF
C1019 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52350_n840# 0.04fF
C1020 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1021 divbuf_2/a_23442_170# divbuf_2/a_23442_n240# 0.01fF
C1022 divbuf_4/a_15840_n1600# divbuf_4/a_15870_n840# 0.04fF
C1023 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_55710_n840# 0.04fF
C1024 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1025 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_15870_n840# 0.02fF
C1026 divbuf_0/a_36960_n1600# divbuf_0/a_37440_n1600# 0.26fF
C1027 divbuf_0/a_27802_n240# divbuf_0/a_27870_n840# 0.04fF
C1028 divbuf_2/a_15390_n840# divbuf_2/a_15870_n840# 0.07fF
C1029 divbuf_2/a_8272_n240# divbuf_2/OUT3 0.04fF
C1030 divbuf_2/a_15360_n1600# divbuf_2/a_15390_n1540# 0.19fF
C1031 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/a_20190_n840# 0.03fF
C1032 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29760_n1600# 0.26fF
C1033 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/a_17612_170# 0.07fF
C1034 ro_div_0/ro_complete_0/cbank_2/switch_0/vin ro_div_0/ro_complete_0/cbank_2/v 1.44fF
C1035 divbuf_0/a_29310_n1540# divbuf_0/a_29790_n1540# 0.11fF
C1036 divbuf_0/a_60030_n840# divbuf_0/a_60030_n1540# 0.01fF
C1037 divbuf_3/a_4392_170# divbuf_3/a_4882_170# 0.07fF
C1038 pll_full_0/divbuf_0/a_52350_n840# pll_full_0/divbuf_0/a_52350_n1540# 0.01fF
C1039 pll_full_0/divbuf_0/a_21630_n1540# pll_full_0/divbuf_0/a_22110_n1540# 0.11fF
C1040 divbuf_3/a_37502_170# divbuf_3/OUT4 0.19fF
C1041 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/a_30712_n240# 0.05fF
C1042 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_510_n840# 0.00fF
C1043 divbuf_4/a_32652_170# divbuf_4/a_33142_170# 0.07fF
C1044 divbuf_4/a_13252_170# divbuf_4/a_13252_n240# 0.01fF
C1045 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/a_34112_n240# 0.04fF
C1046 divbuf_3/a_38400_n1600# divbuf_3/a_38880_n1600# 0.26fF
C1047 divbuf_3/a_29262_n240# divbuf_3/a_29310_n840# 0.04fF
C1048 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_41790_n1540# 0.19fF
C1049 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/a_42270_n840# 0.07fF
C1050 pd_div_0/divbuf_0/a_11550_n840# pd_div_0/divbuf_0/a_11550_n1540# 0.01fF
C1051 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C1052 divbuf_4/a_5310_n840# divbuf_4/a_5790_n840# 0.07fF
C1053 divbuf_4/a_5280_n1600# divbuf_4/a_5310_n1540# 0.19fF
C1054 divbuf_4/a_27322_170# divbuf_4/OUT4 0.19fF
C1055 pll_full_0/divbuf_1/a_14910_n840# pll_full_0/divbuf_1/a_14910_n1540# 0.01fF
C1056 pll_full_0/divbuf_1/a_45150_n840# pll_full_0/divbuf_1/a_45630_n840# 0.07fF
C1057 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45150_n1540# 0.19fF
C1058 divbuf_3/a_30750_n1540# divbuf_3/a_31230_n1540# 0.11fF
C1059 divbuf_0/a_5852_170# divbuf_0/OUT3 0.19fF
C1060 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n840# 0.04fF
C1061 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/clk 0.11fF
C1062 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/Out 0.11fF
C1063 pd_div_0/divider_0/tspc_1/Z4 gnd 0.44fF
C1064 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z4 0.15fF
C1065 divbuf_4/a_58110_n1540# divbuf_4/a_58590_n1540# 0.11fF
C1066 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/Out 0.15fF
C1067 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.64fF
C1068 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19230_n840# 0.04fF
C1069 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/a_17122_n240# 0.01fF
C1070 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/a_31710_n840# 0.05fF
C1071 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_41280_n1600# 0.26fF
C1072 divbuf_1/a_39360_n1600# divbuf_1/a_39840_n1600# 0.26fF
C1073 divbuf_1/a_30232_n240# divbuf_1/a_30270_n840# 0.05fF
C1074 divbuf_5/a_28320_n1600# divbuf_5/a_28800_n1600# 0.26fF
C1075 divbuf_5/a_19072_n240# divbuf_5/a_19230_n840# 0.02fF
C1076 divbuf_3/a_38472_n240# divbuf_3/OUT4 0.04fF
C1077 ro_div_0/divbuf_0/a_33150_n1540# ro_div_0/divbuf_0/a_33630_n1540# 0.11fF
C1078 divbuf_1/a_31710_n1540# divbuf_1/a_32190_n1540# 0.11fF
C1079 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/a_1950_n840# 0.03fF
C1080 divbuf_3/a_28320_n1600# divbuf_3/a_28350_n840# 0.04fF
C1081 divbuf_5/a_51390_n840# divbuf_5/a_51390_n1540# 0.01fF
C1082 divbuf_5/a_20670_n1540# divbuf_5/a_21150_n1540# 0.11fF
C1083 divbuf_0/a_24412_170# divbuf_0/a_24412_n240# 0.01fF
C1084 divbuf_0/a_3912_n240# divbuf_0/a_4392_n240# 0.05fF
C1085 divbuf_4/a_28292_n240# divbuf_4/OUT4 0.04fF
C1086 divbuf_4/a_55680_n1600# divbuf_4/a_55710_n840# 0.04fF
C1087 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/a_36532_170# 0.07fF
C1088 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1089 divbuf_2/a_1920_n1600# divbuf_2/a_2400_n1600# 0.26fF
C1090 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n1540# 0.19fF
C1091 divbuf_0/a_10212_n240# divbuf_0/OUT3 0.04fF
C1092 divbuf_0/a_16350_n840# divbuf_0/a_16830_n840# 0.07fF
C1093 divbuf_2/a_55200_n1600# divbuf_2/a_55230_n1540# 0.19fF
C1094 divbuf_2/a_55230_n840# divbuf_2/a_55710_n840# 0.07fF
C1095 divbuf_2/a_24990_n840# divbuf_2/a_24990_n1540# 0.01fF
C1096 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_8670_n1540# 0.19fF
C1097 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1098 pll_full_0/divbuf_0/a_8670_n840# pll_full_0/divbuf_0/a_9150_n840# 0.07fF
C1099 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_17122_n240# 0.05fF
C1100 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_30750_n840# 0.04fF
C1101 pd_div_0/pd_0/tspc_r_0/Z1 pd_div_0/pd_0/tspc_r_0/Z2 0.71fF
C1102 pd_div_0/div pd_div_0/pd_0/tspc_r_0/z5 0.04fF
C1103 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z4 0.20fF
C1104 pd_div_0/pd_0/DOWN pd_div_0/pd_0/R 0.36fF
C1105 divbuf_1/a_29280_n1600# divbuf_1/a_29310_n840# 0.04fF
C1106 divbuf_3/a_25862_170# divbuf_3/a_25862_n240# 0.01fF
C1107 divbuf_3/a_5362_n240# divbuf_3/a_5852_n240# 0.04fF
C1108 divbuf_5/a_18240_n1600# divbuf_5/a_18270_n840# 0.04fF
C1109 divbuf_3/a_36480_n1600# divbuf_3/OUT4 0.00fF
C1110 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28800_n1600# 0.26fF
C1111 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/a_19230_n840# 0.02fF
C1112 divbuf_4/a_33622_n240# divbuf_4/a_34112_n240# 0.04fF
C1113 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/a_22590_n840# 0.03fF
C1114 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_32160_n1600# 0.26fF
C1115 divbuf_3/a_17790_n840# divbuf_3/a_18270_n840# 0.07fF
C1116 divbuf_3/a_17760_n1600# divbuf_3/a_17790_n1540# 0.19fF
C1117 pd_div_0/divbuf_0/a_51390_n840# pd_div_0/divbuf_0/a_51390_n1540# 0.01fF
C1118 pd_div_0/divbuf_0/a_20670_n1540# pd_div_0/divbuf_0/a_21150_n1540# 0.11fF
C1119 divbuf_4/a_45120_n1600# divbuf_4/a_45150_n1540# 0.19fF
C1120 divbuf_4/a_45150_n840# divbuf_4/a_45630_n840# 0.07fF
C1121 divbuf_4/a_14910_n840# divbuf_4/a_14910_n1540# 0.01fF
C1122 divbuf_2/a_12772_n240# divbuf_2/a_12510_n840# 0.01fF
C1123 pll_full_0/divbuf_1/a_24030_n1540# pll_full_0/divbuf_1/a_24510_n1540# 0.11fF
C1124 pll_full_0/divbuf_1/a_54750_n840# pll_full_0/divbuf_1/a_54750_n1540# 0.01fF
C1125 divbuf_0/a_9120_n1600# divbuf_0/OUT3 0.00fF
C1126 divbuf_1/a_6332_n240# divbuf_1/a_6822_n240# 0.04fF
C1127 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59070_n840# 0.04fF
C1128 divbuf_5/a_15672_170# divbuf_5/a_15672_n240# 0.01fF
C1129 divbuf_5/a_35082_170# divbuf_5/a_35562_170# 0.07fF
C1130 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1131 cp_0/a_1710_0# io_analog[1] 0.32fF
C1132 ro_div_0/divbuf_0/a_20190_n840# ro_div_0/divbuf_0/a_20670_n840# 0.07fF
C1133 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20190_n1540# 0.19fF
C1134 divbuf_1/a_18720_n1600# divbuf_1/a_18750_n1540# 0.19fF
C1135 divbuf_1/a_18750_n840# divbuf_1/a_19230_n840# 0.07fF
C1136 divbuf_1/a_15182_n240# divbuf_1/OUT4 0.04fF
C1137 divbuf_5/a_7680_n1600# divbuf_5/a_7710_n1540# 0.19fF
C1138 divbuf_5/a_32172_170# divbuf_5/OUT4 0.19fF
C1139 divbuf_5/a_7710_n840# divbuf_5/a_8190_n840# 0.07fF
C1140 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18270_n840# 0.04fF
C1141 divbuf_4/a_1842_n240# divbuf_4/a_1950_n840# 0.03fF
C1142 divbuf_2/a_7792_170# divbuf_2/a_8272_170# 0.07fF
C1143 divbuf_5/a_60510_n1540# divbuf_5/a_60990_n1540# 0.11fF
C1144 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_21630_n840# 0.04fF
C1145 divbuf_0/a_2880_n1600# divbuf_0/a_3360_n1600# 0.26fF
C1146 divbuf_2/a_41760_n1600# divbuf_2/a_42240_n1600# 0.26fF
C1147 divbuf_2/a_32652_n240# divbuf_2/a_32670_n840# 0.06fF
C1148 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/a_37502_n240# 0.05fF
C1149 gnd pll_full_0/divider_0/tspc_2/a_630_n680# 0.61fF
C1150 divbuf_0/a_25950_n840# divbuf_0/a_25950_n1540# 0.01fF
C1151 divbuf_0/a_56190_n840# divbuf_0/a_56670_n840# 0.07fF
C1152 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n1540# 0.19fF
C1153 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48510_n1540# 0.19fF
C1154 divbuf_2/a_34110_n1540# divbuf_2/a_34590_n1540# 0.11fF
C1155 pll_full_0/divbuf_0/a_48510_n840# pll_full_0/divbuf_0/a_48990_n840# 0.07fF
C1156 pll_full_0/divbuf_0/a_18270_n840# pll_full_0/divbuf_0/a_18270_n1540# 0.01fF
C1157 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C1158 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/a_15672_n240# 0.01fF
C1159 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/a_35562_170# 0.07fF
C1160 divbuf_1/a_13440_n1600# divbuf_1/OUT4 0.00fF
C1161 divbuf_3/a_4320_n1600# divbuf_3/a_4800_n1600# 0.26fF
C1162 divbuf_5/a_33142_n240# divbuf_5/OUT4 0.04fF
C1163 divbuf_5/a_58080_n1600# divbuf_5/a_58110_n840# 0.04fF
C1164 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/a_38962_170# 0.07fF
C1165 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/a_19072_n240# 0.01fF
C1166 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C1167 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1168 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1169 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/Out 0.11fF
C1170 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_7710_n1540# 0.19fF
C1171 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1172 pd_div_0/divbuf_0/a_7710_n840# pd_div_0/divbuf_0/a_8190_n840# 0.07fF
C1173 pd_div_0/div pd_div_0/bufin 0.26fF
C1174 divbuf_3/a_57630_n840# divbuf_3/a_58110_n840# 0.07fF
C1175 divbuf_3/a_27390_n840# divbuf_3/a_27390_n1540# 0.01fF
C1176 divbuf_4/a_31680_n1600# divbuf_4/a_32160_n1600# 0.26fF
C1177 divbuf_4/a_22472_n240# divbuf_4/a_22590_n840# 0.03fF
C1178 pll_full_0/divbuf_1/a_11070_n840# pll_full_0/divbuf_1/a_11550_n840# 0.07fF
C1179 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1180 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11070_n1540# 0.19fF
C1181 divbuf_0/a_13742_n240# divbuf_0/a_13470_n840# 0.01fF
C1182 pd_div_0/divbuf_0/a_60510_n1540# pd_div_0/divbuf_0/a_60990_n1540# 0.11fF
C1183 divbuf_2/a_31680_n1600# divbuf_2/a_31710_n840# 0.04fF
C1184 divbuf_2/a_19072_170# divbuf_2/OUT4 0.19fF
C1185 divbuf_4/a_54750_n840# divbuf_4/a_54750_n1540# 0.01fF
C1186 divbuf_4/a_24030_n1540# divbuf_4/a_24510_n1540# 0.11fF
C1187 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 0.26fF
C1188 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1189 ro_div_0/ro_complete_0/cbank_0/switch_2/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C1190 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_7200_n1600# 0.26fF
C1191 divbuf_1/a_5280_n1600# divbuf_1/a_5760_n1600# 0.26fF
C1192 divbuf_5/a_36052_n240# divbuf_5/a_36532_n240# 0.05fF
C1193 divbuf_3/a_8762_170# divbuf_3/OUT3 0.19fF
C1194 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60030_n1540# 0.19fF
C1195 ro_div_0/divbuf_0/a_29790_n840# ro_div_0/divbuf_0/a_29790_n1540# 0.01fF
C1196 ro_div_0/divbuf_0/a_60030_n840# ro_div_0/divbuf_0/a_60510_n840# 0.07fF
C1197 divbuf_1/a_58560_n1600# divbuf_1/a_58590_n1540# 0.19fF
C1198 divbuf_1/a_58590_n840# divbuf_1/a_59070_n840# 0.07fF
C1199 divbuf_1/a_28350_n840# divbuf_1/a_28350_n1540# 0.01fF
C1200 divbuf_3/a_15182_n240# divbuf_3/a_14910_n840# 0.01fF
C1201 divbuf_5/a_31200_n1600# divbuf_5/OUT4 0.00fF
C1202 divbuf_5/a_47520_n1600# divbuf_5/a_47550_n1540# 0.19fF
C1203 divbuf_5/a_47550_n840# divbuf_5/a_48030_n840# 0.07fF
C1204 divbuf_5/a_17310_n840# divbuf_5/a_17310_n1540# 0.01fF
C1205 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C1206 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1207 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58110_n840# 0.04fF
C1208 divbuf_2/a_29262_170# divbuf_2/a_29262_n240# 0.01fF
C1209 divbuf_2/a_8762_n240# divbuf_2/a_9242_n240# 0.05fF
C1210 divbuf_4/a_21600_n1600# divbuf_4/a_21630_n840# 0.04fF
C1211 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1212 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1213 divbuf_0/a_33622_n240# divbuf_0/a_33630_n840# 0.06fF
C1214 divbuf_0/a_42720_n1600# divbuf_0/a_43200_n1600# 0.26fF
C1215 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1216 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z3 0.05fF
C1217 divbuf_2/a_21120_n1600# divbuf_2/a_21150_n1540# 0.19fF
C1218 divbuf_2/a_21150_n840# divbuf_2/a_21630_n840# 0.07fF
C1219 divbuf_2/a_20042_n240# divbuf_2/OUT4 0.04fF
C1220 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/A 0.03fF
C1221 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1222 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35520_n1600# 0.26fF
C1223 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/a_25950_n840# 0.03fF
C1224 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/a_21982_170# 0.07fF
C1225 divbuf_0/a_35070_n1540# divbuf_0/a_35550_n1540# 0.11fF
C1226 divbuf_1/a_16152_n240# divbuf_1/a_15870_n840# 0.01fF
C1227 pll_full_0/divbuf_0/a_58110_n840# pll_full_0/divbuf_0/a_58110_n1540# 0.01fF
C1228 pll_full_0/divbuf_0/a_27390_n1540# pll_full_0/divbuf_0/a_27870_n1540# 0.11fF
C1229 divbuf_3/a_9732_n240# divbuf_3/OUT3 0.04fF
C1230 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/a_36532_n240# 0.05fF
C1231 divbuf_4/a_19072_170# divbuf_4/a_19072_n240# 0.01fF
C1232 divbuf_4/a_38472_170# divbuf_4/a_38962_170# 0.07fF
C1233 divbuf_5/a_10590_n840# divbuf_5/OUT4 0.03fF
C1234 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/a_39932_n240# 0.04fF
C1235 divbuf_3/a_44160_n1600# divbuf_3/a_44640_n1600# 0.26fF
C1236 divbuf_3/a_35082_n240# divbuf_3/a_35070_n840# 0.05fF
C1237 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C1238 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_47550_n1540# 0.19fF
C1239 pd_div_0/divbuf_0/a_47550_n840# pd_div_0/divbuf_0/a_48030_n840# 0.07fF
C1240 pd_div_0/divbuf_0/a_17310_n840# pd_div_0/divbuf_0/a_17310_n1540# 0.01fF
C1241 divbuf_4/a_11040_n1600# divbuf_4/a_11070_n1540# 0.19fF
C1242 divbuf_4/a_38962_170# divbuf_4/OUT4 0.19fF
C1243 divbuf_4/a_11070_n840# divbuf_4/a_11550_n840# 0.07fF
C1244 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_50910_n1540# 0.19fF
C1245 pll_full_0/divbuf_1/a_20670_n840# pll_full_0/divbuf_1/a_20670_n1540# 0.01fF
C1246 pll_full_0/divbuf_1/a_50910_n840# pll_full_0/divbuf_1/a_51390_n840# 0.07fF
C1247 divbuf_3/a_36510_n1540# divbuf_3/a_36990_n1540# 0.11fF
C1248 divbuf_0/a_21012_170# divbuf_0/OUT4 0.19fF
C1249 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n840# 0.04fF
C1250 gnd pd_div_0/divider_0/tspc_2/Z3 0.27fF
C1251 divbuf_4/OUT4 divbuf_4/OUT5 0.26fF
C1252 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_24990_n840# 0.04fF
C1253 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/OUT2 0.23fF
C1254 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_47040_n1600# 0.26fF
C1255 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/a_37470_n840# 0.05fF
C1256 divbuf_1/a_36052_n240# divbuf_1/a_36030_n840# 0.05fF
C1257 divbuf_1/a_45120_n1600# divbuf_1/a_45600_n1600# 0.26fF
C1258 divbuf_5/a_24892_n240# divbuf_5/a_24990_n840# 0.03fF
C1259 divbuf_5/a_34080_n1600# divbuf_5/a_34560_n1600# 0.26fF
C1260 divbuf_3/a_8640_n1600# divbuf_3/OUT3 0.00fF
C1261 ro_div_0/divbuf_0/a_38910_n1540# ro_div_0/divbuf_0/a_39390_n1540# 0.11fF
C1262 divbuf_1/a_37470_n1540# divbuf_1/a_37950_n1540# 0.11fF
C1263 divbuf_5/a_57150_n840# divbuf_5/a_57150_n1540# 0.01fF
C1264 divbuf_5/a_26430_n1540# divbuf_5/a_26910_n1540# 0.11fF
C1265 divbuf_3/a_34080_n1600# divbuf_3/a_34110_n840# 0.04fF
C1266 divbuf_0/a_9732_n240# divbuf_0/a_10212_n240# 0.05fF
C1267 divbuf_0/a_30232_170# divbuf_0/a_30232_n240# 0.01fF
C1268 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/OUT4 0.03fF
C1269 divbuf_2/a_7680_n1600# divbuf_2/a_8160_n1600# 0.26fF
C1270 divbuf_4/a_39932_n240# divbuf_4/OUT4 0.04fF
C1271 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/a_22472_n240# 0.01fF
C1272 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1273 ro_div_0/ro_complete_0/a2 ro_div_0/divider_0/clk 0.05fF
C1274 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/a_1842_n240# 0.04fF
C1275 divbuf_0/a_21982_n240# divbuf_0/OUT4 0.04fF
C1276 divbuf_0/a_22110_n840# divbuf_0/a_22590_n840# 0.07fF
C1277 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n1540# 0.19fF
C1278 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14430_n1540# 0.19fF
C1279 divbuf_2/a_30750_n840# divbuf_2/a_30750_n1540# 0.01fF
C1280 pll_full_0/divbuf_0/a_14430_n840# pll_full_0/divbuf_0/a_14910_n840# 0.07fF
C1281 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C1282 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36510_n840# 0.04fF
C1283 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 0.61fF
C1284 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/UP 0.11fF
C1285 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z1 0.17fF
C1286 pd_div_0/pd_0/DOWN pd_div_0/pd_0/and_pd_0/Out1 0.12fF
C1287 pd_div_0/pd_0/tspc_r_0/Z4 pd_div_0/pd_0/tspc_r_1/Z4 0.02fF
C1288 divbuf_1/a_22472_170# divbuf_1/OUT4 0.19fF
C1289 divbuf_1/a_35040_n1600# divbuf_1/a_35070_n840# 0.04fF
C1290 divbuf_5/a_3422_170# divbuf_5/OUT3 0.23fF
C1291 divbuf_5/a_24000_n1600# divbuf_5/a_24030_n840# 0.04fF
C1292 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/a_3912_170# 0.07fF
C1293 divbuf_3/a_11802_n240# divbuf_3/a_12282_n240# 0.05fF
C1294 divbuf_3/a_31682_170# divbuf_3/a_31682_n240# 0.01fF
C1295 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/a_24990_n840# 0.03fF
C1296 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34560_n1600# 0.26fF
C1297 divbuf_4/a_39442_n240# divbuf_4/a_39932_n240# 0.04fF
C1298 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37920_n1600# 0.26fF
C1299 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/a_28350_n840# 0.04fF
C1300 divbuf_3/a_23520_n1600# divbuf_3/a_23550_n1540# 0.19fF
C1301 divbuf_3/a_23550_n840# divbuf_3/a_24030_n840# 0.07fF
C1302 pd_div_0/divbuf_0/a_57150_n840# pd_div_0/divbuf_0/a_57150_n1540# 0.01fF
C1303 pd_div_0/divbuf_0/a_26430_n1540# pd_div_0/divbuf_0/a_26910_n1540# 0.11fF
C1304 divbuf_4/a_50910_n840# divbuf_4/a_51390_n840# 0.07fF
C1305 divbuf_4/a_20670_n840# divbuf_4/a_20670_n1540# 0.01fF
C1306 divbuf_4/a_50880_n1600# divbuf_4/a_50910_n1540# 0.19fF
C1307 pll_full_0/divbuf_1/a_29790_n1540# pll_full_0/divbuf_1/a_30270_n1540# 0.11fF
C1308 pll_full_0/divbuf_1/a_60510_n840# pll_full_0/divbuf_1/a_60510_n1540# 0.01fF
C1309 divbuf_0/a_20160_n1600# divbuf_0/OUT4 0.00fF
C1310 divbuf_1/a_12772_n240# divbuf_1/a_13252_n240# 0.05fF
C1311 divbuf_5/a_40902_170# divbuf_5/a_41382_170# 0.07fF
C1312 divbuf_5/a_21502_170# divbuf_5/a_21502_n240# 0.01fF
C1313 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_25950_n1540# 0.19fF
C1314 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1315 ro_div_0/divbuf_0/a_25950_n840# ro_div_0/divbuf_0/a_26430_n840# 0.07fF
C1316 divbuf_1/a_26832_n240# divbuf_1/OUT4 0.04fF
C1317 divbuf_1/a_24480_n1600# divbuf_1/a_24510_n1540# 0.19fF
C1318 divbuf_1/a_24510_n840# divbuf_1/a_24990_n840# 0.07fF
C1319 divbuf_5/a_4392_n240# divbuf_5/OUT3 0.04fF
C1320 divbuf_5/a_13440_n1600# divbuf_5/a_13470_n1540# 0.19fF
C1321 divbuf_5/a_13470_n840# divbuf_5/a_13950_n840# 0.07fF
C1322 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z2 0.14fF
C1323 pd_div_0/divbuf_0/a_4882_170# pd_div_0/divbuf_0/OUT3 0.19fF
C1324 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24030_n840# 0.04fF
C1325 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/OUT3 0.19fF
C1326 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27390_n840# 0.04fF
C1327 divbuf_2/a_14222_170# divbuf_2/a_14702_170# 0.07fF
C1328 divbuf_0/a_8640_n1600# divbuf_0/a_9120_n1600# 0.26fF
C1329 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_1440_n1600# 0.26fF
C1330 divbuf_2/a_38472_n240# divbuf_2/a_38430_n840# 0.04fF
C1331 divbuf_2/a_47520_n1600# divbuf_2/a_48000_n1600# 0.26fF
C1332 divbuf_0/a_510_n840# divbuf_0/OUT2 0.02fF
C1333 divbuf_0/a_990_n1540# divbuf_0/a_1470_n1540# 0.11fF
C1334 divbuf_0/a_31710_n840# divbuf_0/a_31710_n1540# 0.01fF
C1335 divbuf_2/a_39870_n1540# divbuf_2/a_40350_n1540# 0.11fF
C1336 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54270_n1540# 0.19fF
C1337 pll_full_0/divbuf_0/a_54270_n840# pll_full_0/divbuf_0/a_54750_n840# 0.07fF
C1338 pll_full_0/divbuf_0/a_24030_n840# pll_full_0/divbuf_0/a_24030_n1540# 0.01fF
C1339 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/a_41382_170# 0.07fF
C1340 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/a_21502_n240# 0.01fF
C1341 divbuf_4/a_3422_170# divbuf_4/a_3912_170# 0.07fF
C1342 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/a_24892_n240# 0.01fF
C1343 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/a_4882_n240# 0.04fF
C1344 divbuf_1/a_24960_n1600# divbuf_1/OUT4 0.00fF
C1345 divbuf_3/a_10080_n1600# divbuf_3/a_10560_n1600# 0.26fF
C1346 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1347 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_0/Z3 0.38fF
C1348 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C1349 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13470_n1540# 0.19fF
C1350 pd_div_0/divbuf_0/a_13470_n840# pd_div_0/divbuf_0/a_13950_n840# 0.07fF
C1351 divbuf_4/a_28292_n240# divbuf_4/a_28350_n840# 0.04fF
C1352 divbuf_4/a_37440_n1600# divbuf_4/a_37920_n1600# 0.26fF
C1353 divbuf_3/a_33150_n840# divbuf_3/a_33150_n1540# 0.01fF
C1354 divbuf_3/a_2430_n1540# divbuf_3/a_2910_n1540# 0.11fF
C1355 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_16830_n1540# 0.19fF
C1356 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/OUT4 0.07fF
C1357 pll_full_0/divbuf_1/a_16830_n840# pll_full_0/divbuf_1/a_17310_n840# 0.07fF
C1358 divbuf_1/a_17612_170# divbuf_1/a_18092_170# 0.07fF
C1359 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_11550_n840# 0.02fF
C1360 divbuf_2/a_30712_170# divbuf_2/OUT4 0.19fF
C1361 divbuf_2/a_37440_n1600# divbuf_2/a_37470_n840# 0.04fF
C1362 divbuf_4/a_60510_n840# divbuf_4/a_60510_n1540# 0.01fF
C1363 divbuf_4/a_29790_n1540# divbuf_4/a_30270_n1540# 0.11fF
C1364 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/a_14702_170# 0.07fF
C1365 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12960_n1600# 0.26fF
C1366 pd_0/REF gpio_analog[7] 2.26fF
C1367 divbuf_1/a_11040_n1600# divbuf_1/a_11520_n1600# 0.26fF
C1368 divbuf_5/a_0_n1600# divbuf_5/a_480_n1600# 0.26fF
C1369 divbuf_3/a_20532_170# divbuf_3/OUT4 0.19fF
C1370 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C1371 ro_div_0/divbuf_0/a_4830_n1540# ro_div_0/divbuf_0/a_5310_n1540# 0.11fF
C1372 ro_div_0/divbuf_0/a_35550_n840# ro_div_0/divbuf_0/a_35550_n1540# 0.01fF
C1373 divbuf_1/a_34110_n840# divbuf_1/a_34110_n1540# 0.01fF
C1374 divbuf_1/a_3390_n1540# divbuf_1/a_3870_n1540# 0.11fF
C1375 divbuf_5/a_53280_n1600# divbuf_5/a_53310_n1540# 0.19fF
C1376 divbuf_5/a_53310_n840# divbuf_5/a_53790_n840# 0.07fF
C1377 divbuf_5/a_23070_n840# divbuf_5/a_23070_n1540# 0.01fF
C1378 divbuf_0/a_13742_170# divbuf_0/a_14222_170# 0.07fF
C1379 divbuf_2/a_15182_n240# divbuf_2/a_15672_n240# 0.04fF
C1380 divbuf_2/a_35082_170# divbuf_2/a_35082_n240# 0.01fF
C1381 divbuf_4/a_27360_n1600# divbuf_4/a_27390_n840# 0.04fF
C1382 divbuf_4/a_10212_170# divbuf_4/OUT3 0.19fF
C1383 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C1384 divbuf_0/a_48480_n1600# divbuf_0/a_48960_n1600# 0.26fF
C1385 divbuf_0/a_39442_n240# divbuf_0/a_39390_n840# 0.04fF
C1386 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/a_31710_n840# 0.05fF
C1387 divbuf_2/a_26910_n840# divbuf_2/a_27390_n840# 0.07fF
C1388 divbuf_2/a_31682_n240# divbuf_2/OUT4 0.04fF
C1389 divbuf_2/a_26880_n1600# divbuf_2/a_26910_n1540# 0.19fF
C1390 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_41280_n1600# 0.26fF
C1391 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/Out 0.12fF
C1392 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1393 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1394 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/a_6822_n240# 0.01fF
C1395 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/a_14222_n240# 0.01fF
C1396 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/a_27802_170# 0.07fF
C1397 divbuf_0/a_40830_n1540# divbuf_0/a_41310_n1540# 0.11fF
C1398 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2430_n840# 0.04fF
C1399 divbuf_1/a_960_n1600# divbuf_1/a_990_n840# 0.04fF
C1400 divbuf_3/a_16642_170# divbuf_3/a_17122_170# 0.07fF
C1401 pll_full_0/divbuf_0/a_33150_n1540# pll_full_0/divbuf_0/a_33630_n1540# 0.11fF
C1402 divbuf_3/a_21502_n240# divbuf_3/OUT4 0.04fF
C1403 pd_div_0/divbuf_0/a_0_n1600# pd_div_0/divbuf_0/a_480_n1600# 0.26fF
C1404 divbuf_3/a_49920_n1600# divbuf_3/a_50400_n1600# 0.26fF
C1405 divbuf_3/a_40902_n240# divbuf_3/a_40830_n840# 0.03fF
C1406 divbuf_4/a_4392_n240# divbuf_4/a_4882_n240# 0.04fF
C1407 divbuf_4/a_24892_170# divbuf_4/a_24892_n240# 0.01fF
C1408 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3840_n1600# 0.26fF
C1409 divbuf_0/a_14702_170# divbuf_0/a_14702_n240# 0.01fF
C1410 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53310_n1540# 0.19fF
C1411 pd_div_0/divbuf_0/a_53310_n840# pd_div_0/divbuf_0/a_53790_n840# 0.07fF
C1412 pd_div_0/divbuf_0/a_23070_n840# pd_div_0/divbuf_0/a_23070_n1540# 0.01fF
C1413 divbuf_4/a_16830_n840# divbuf_4/a_17310_n840# 0.07fF
C1414 divbuf_4/a_11312_n240# divbuf_4/OUT4 0.07fF
C1415 divbuf_4/a_16800_n1600# divbuf_4/a_16830_n1540# 0.19fF
C1416 pll_full_0/divbuf_1/a_26430_n840# pll_full_0/divbuf_1/a_26430_n1540# 0.01fF
C1417 pll_full_0/divbuf_1/a_56670_n840# pll_full_0/divbuf_1/a_57150_n840# 0.07fF
C1418 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_56670_n1540# 0.19fF
C1419 ro_div_0/divbuf_0/a_7302_170# ro_div_0/divbuf_0/OUT3 0.19fF
C1420 divbuf_3/a_42270_n1540# divbuf_3/a_42750_n1540# 0.11fF
C1421 divbuf_0/a_32652_170# divbuf_0/OUT4 0.19fF
C1422 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n840# 0.04fF
C1423 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/clk 0.51fF
C1424 divbuf_5/a_5852_170# divbuf_5/a_6332_170# 0.07fF
C1425 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C1426 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_30750_n840# 0.04fF
C1427 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1428 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52800_n1600# 0.26fF
C1429 divbuf_1/a_50880_n1600# divbuf_1/a_51360_n1600# 0.26fF
C1430 divbuf_5/a_39840_n1600# divbuf_5/a_40320_n1600# 0.26fF
C1431 divbuf_5/a_30712_n240# divbuf_5/a_30750_n840# 0.05fF
C1432 divbuf_3/a_19680_n1600# divbuf_3/OUT4 0.00fF
C1433 ro_div_0/divbuf_0/a_44670_n1540# ro_div_0/divbuf_0/a_45150_n1540# 0.11fF
C1434 divbuf_1/a_43230_n1540# divbuf_1/a_43710_n1540# 0.11fF
C1435 divbuf_5/a_32190_n1540# divbuf_5/a_32670_n1540# 0.11fF
C1436 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_13950_n840# 0.01fF
C1437 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/a_23922_n240# 0.01fF
C1438 divbuf_3/a_39840_n1600# divbuf_3/a_39870_n840# 0.04fF
C1439 divbuf_0/a_36052_170# divbuf_0/a_36052_n240# 0.01fF
C1440 divbuf_0/a_16152_n240# divbuf_0/a_16642_n240# 0.04fF
C1441 divbuf_2/a_3912_n240# divbuf_2/a_3870_n840# 0.04fF
C1442 divbuf_2/a_13440_n1600# divbuf_2/a_13920_n1600# 0.26fF
C1443 divbuf_4/a_10080_n1600# divbuf_4/OUT3 0.00fF
C1444 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/a_8272_n240# 0.05fF
C1445 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C1446 ro_div_0/ro_complete_0/cbank_1/switch_0/vin ro_div_0/divider_0/clk 1.45fF
C1447 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/a_28292_n240# 0.01fF
C1448 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n1540# 0.19fF
C1449 divbuf_0/a_33622_n240# divbuf_0/OUT4 0.04fF
C1450 divbuf_0/a_27870_n840# divbuf_0/a_28350_n840# 0.07fF
C1451 divbuf_2/a_36510_n840# divbuf_2/a_36510_n1540# 0.01fF
C1452 divbuf_2/a_5790_n1540# divbuf_2/a_6270_n1540# 0.11fF
C1453 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1454 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20190_n1540# 0.19fF
C1455 pll_full_0/divbuf_0/a_20190_n840# pll_full_0/divbuf_0/a_20670_n840# 0.07fF
C1456 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42270_n840# 0.04fF
C1457 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/a_14222_170# 0.07fF
C1458 divbuf_1/a_40800_n1600# divbuf_1/a_40830_n840# 0.04fF
C1459 divbuf_1/a_37502_170# divbuf_1/OUT4 0.19fF
C1460 divbuf_5/a_29760_n1600# divbuf_5/a_29790_n840# 0.04fF
C1461 divbuf_5/a_15182_170# divbuf_5/OUT4 0.19fF
C1462 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/a_9732_170# 0.07fF
C1463 divbuf_3/a_37502_170# divbuf_3/a_37502_n240# 0.01fF
C1464 divbuf_3/a_17612_n240# divbuf_3/a_18092_n240# 0.05fF
C1465 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_40320_n1600# 0.26fF
C1466 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/a_30750_n840# 0.05fF
C1467 divbuf_4/a_3360_n1600# divbuf_4/a_3840_n1600# 0.26fF
C1468 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/a_34110_n840# 0.06fF
C1469 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43680_n1600# 0.26fF
C1470 divbuf_3/a_29310_n840# divbuf_3/a_29790_n840# 0.07fF
C1471 divbuf_3/a_29280_n1600# divbuf_3/a_29310_n1540# 0.19fF
C1472 pd_div_0/divbuf_0/a_32190_n1540# pd_div_0/divbuf_0/a_32670_n1540# 0.11fF
C1473 divbuf_2/a_3360_n1600# divbuf_2/a_3390_n840# 0.04fF
C1474 divbuf_4/a_56640_n1600# divbuf_4/a_56670_n1540# 0.19fF
C1475 divbuf_4/a_56670_n840# divbuf_4/a_57150_n840# 0.07fF
C1476 divbuf_4/a_26430_n840# divbuf_4/a_26430_n1540# 0.01fF
C1477 pll_full_0/divbuf_1/a_35550_n1540# pll_full_0/divbuf_1/a_36030_n1540# 0.11fF
C1478 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.27fF
C1479 divbuf_0/a_31680_n1600# divbuf_0/OUT4 0.00fF
C1480 divbuf_1/a_38472_170# divbuf_1/a_38472_n240# 0.01fF
C1481 divbuf_1/a_18582_n240# divbuf_1/a_19072_n240# 0.04fF
C1482 divbuf_5/a_27322_170# divbuf_5/a_27322_n240# 0.01fF
C1483 divbuf_5/a_6822_n240# divbuf_5/a_7302_n240# 0.05fF
C1484 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1485 ro_div_0/divbuf_0/a_1470_n840# ro_div_0/divbuf_0/a_1470_n1540# 0.01fF
C1486 ro_div_0/divbuf_0/a_31710_n840# ro_div_0/divbuf_0/a_32190_n840# 0.07fF
C1487 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_31710_n1540# 0.19fF
C1488 divbuf_1/a_30240_n1600# divbuf_1/a_30270_n1540# 0.19fF
C1489 divbuf_1/a_30270_n840# divbuf_1/a_30750_n840# 0.07fF
C1490 divbuf_1/a_38472_n240# divbuf_1/OUT4 0.04fF
C1491 divbuf_5/a_19200_n1600# divbuf_5/a_19230_n1540# 0.19fF
C1492 divbuf_5/a_19230_n840# divbuf_5/a_19710_n840# 0.07fF
C1493 divbuf_5/a_16152_n240# divbuf_5/OUT4 0.04fF
C1494 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C1495 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/nor_1/A 1.21fF
C1496 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_29790_n840# 0.04fF
C1497 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1498 divbuf_2/a_20042_170# divbuf_2/a_20532_170# 0.07fF
C1499 divbuf_4/a_14222_n240# divbuf_4/a_13950_n840# 0.01fF
C1500 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1501 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33150_n840# 0.04fF
C1502 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C1503 divbuf_0/a_14400_n1600# divbuf_0/a_14880_n1600# 0.26fF
C1504 divbuf_0/a_4882_n240# divbuf_0/a_4830_n840# 0.04fF
C1505 divbuf_2/a_1842_170# divbuf_2/OUT2 0.19fF
C1506 divbuf_2/a_53280_n1600# divbuf_2/a_53760_n1600# 0.26fF
C1507 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_7200_n1600# 0.26fF
C1508 divbuf_0/a_6750_n1540# divbuf_0/a_7230_n1540# 0.11fF
C1509 divbuf_0/a_37470_n840# divbuf_0/a_37470_n1540# 0.01fF
C1510 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60030_n1540# 0.19fF
C1511 divbuf_2/a_45630_n1540# divbuf_2/a_46110_n1540# 0.11fF
C1512 pll_full_0/divbuf_0/a_60030_n840# pll_full_0/divbuf_0/a_60510_n840# 0.07fF
C1513 pll_full_0/divbuf_0/a_29790_n840# pll_full_0/divbuf_0/a_29790_n1540# 0.01fF
C1514 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/a_27322_n240# 0.01fF
C1515 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/a_7302_n240# 0.05fF
C1516 divbuf_1/a_36480_n1600# divbuf_1/OUT4 0.00fF
C1517 divbuf_4/a_9242_170# divbuf_4/a_9732_170# 0.07fF
C1518 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/a_30712_n240# 0.01fF
C1519 divbuf_3/a_15840_n1600# divbuf_3/a_16320_n1600# 0.26fF
C1520 divbuf_3/a_6332_n240# divbuf_3/a_6270_n840# 0.04fF
C1521 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19230_n1540# 0.19fF
C1522 pd_div_0/divbuf_0/a_19230_n840# pd_div_0/divbuf_0/a_19710_n840# 0.07fF
C1523 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1524 divbuf_4/a_43200_n1600# divbuf_4/a_43680_n1600# 0.26fF
C1525 divbuf_4/a_34112_n240# divbuf_4/a_34110_n840# 0.06fF
C1526 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1527 pll_full_0/divbuf_1/a_22590_n840# pll_full_0/divbuf_1/a_23070_n840# 0.07fF
C1528 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_22590_n1540# 0.19fF
C1529 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_12990_n840# 0.01fF
C1530 divbuf_3/a_38910_n840# divbuf_3/a_38910_n1540# 0.01fF
C1531 divbuf_3/a_8190_n1540# divbuf_3/a_8670_n1540# 0.11fF
C1532 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n840# 0.04fF
C1533 divbuf_1/a_7792_170# divbuf_1/a_8272_170# 0.07fF
C1534 divbuf_4/a_35550_n1540# divbuf_4/a_36030_n1540# 0.11fF
C1535 divbuf_2/a_2322_n240# divbuf_2/OUT3 0.04fF
C1536 divbuf_2/a_43200_n1600# divbuf_2/a_43230_n840# 0.04fF
C1537 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_17310_n840# 0.00fF
C1538 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C1539 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1540 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18720_n1600# 0.26fF
C1541 divbuf_1/a_16800_n1600# divbuf_1/a_17280_n1600# 0.26fF
C1542 divbuf_1/a_7302_n240# divbuf_1/a_7230_n840# 0.03fF
C1543 divbuf_5/a_5760_n1600# divbuf_5/a_6240_n1600# 0.26fF
C1544 divbuf_3/a_32172_170# divbuf_3/OUT4 0.19fF
C1545 ro_div_0/divbuf_0/a_10590_n1540# ro_div_0/divbuf_0/a_11070_n1540# 0.11fF
C1546 ro_div_0/divbuf_0/a_41310_n840# ro_div_0/divbuf_0/a_41310_n1540# 0.01fF
C1547 divbuf_1/a_39870_n840# divbuf_1/a_39870_n1540# 0.01fF
C1548 divbuf_1/a_9150_n1540# divbuf_1/a_9630_n1540# 0.11fF
C1549 divbuf_3/a_5760_n1600# divbuf_3/a_5790_n840# 0.04fF
C1550 divbuf_5/a_59040_n1600# divbuf_5/a_59070_n1540# 0.19fF
C1551 divbuf_5/a_59070_n840# divbuf_5/a_59550_n840# 0.07fF
C1552 divbuf_5/a_28830_n840# divbuf_5/a_28830_n1540# 0.01fF
C1553 divbuf_0/a_21012_170# divbuf_0/a_21502_170# 0.07fF
C1554 divbuf_4/a_33120_n1600# divbuf_4/a_33150_n840# 0.04fF
C1555 divbuf_4/a_21982_170# divbuf_4/OUT4 0.19fF
C1556 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/a_15182_170# 0.07fF
C1557 divbuf_2/a_40902_170# divbuf_2/a_40902_n240# 0.01fF
C1558 divbuf_2/a_21012_n240# divbuf_2/a_21502_n240# 0.04fF
C1559 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1560 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1561 divbuf_0/a_54240_n1600# divbuf_0/a_54720_n1600# 0.26fF
C1562 divbuf_0/a_5362_170# divbuf_0/OUT3 0.19fF
C1563 pd_div_0/divider_0/tspc_1/Q gnd 0.33fF
C1564 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_47040_n1600# 0.26fF
C1565 divbuf_2/a_2400_n1600# divbuf_2/OUT2 0.00fF
C1566 divbuf_2/a_32640_n1600# divbuf_2/a_32670_n1540# 0.19fF
C1567 divbuf_2/a_32670_n840# divbuf_2/a_33150_n840# 0.07fF
C1568 divbuf_2/a_2430_n840# divbuf_2/a_2430_n1540# 0.01fF
C1569 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/a_37470_n840# 0.05fF
C1570 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C1571 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/a_33622_170# 0.07fF
C1572 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8190_n840# 0.04fF
C1573 divbuf_0/a_46590_n1540# divbuf_0/a_47070_n1540# 0.11fF
C1574 divbuf_1/a_6720_n1600# divbuf_1/a_6750_n840# 0.04fF
C1575 divbuf_3/a_22472_170# divbuf_3/a_22952_170# 0.07fF
C1576 divbuf_3/a_1842_170# divbuf_3/a_1842_n240# 0.01fF
C1577 divbuf_5/a_16642_n240# divbuf_5/a_16350_n840# 0.00fF
C1578 pll_full_0/divbuf_0/a_38910_n1540# pll_full_0/divbuf_0/a_39390_n1540# 0.11fF
C1579 divbuf_3/a_33142_n240# divbuf_3/OUT4 0.04fF
C1580 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_6240_n1600# 0.26fF
C1581 divbuf_4/a_30712_170# divbuf_4/a_30712_n240# 0.01fF
C1582 divbuf_3/a_55680_n1600# divbuf_3/a_56160_n1600# 0.26fF
C1583 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9600_n1600# 0.26fF
C1584 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1585 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59070_n1540# 0.19fF
C1586 pd_div_0/divbuf_0/a_59070_n840# pd_div_0/divbuf_0/a_59550_n840# 0.07fF
C1587 pd_div_0/divbuf_0/a_28830_n840# pd_div_0/divbuf_0/a_28830_n1540# 0.01fF
C1588 divbuf_3/a_48030_n1540# divbuf_3/a_48510_n1540# 0.11fF
C1589 divbuf_4/a_22560_n1600# divbuf_4/a_22590_n1540# 0.19fF
C1590 divbuf_4/a_22590_n840# divbuf_4/a_23070_n840# 0.07fF
C1591 divbuf_4/a_22952_n240# divbuf_4/OUT4 0.04fF
C1592 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/a_14702_n240# 0.01fF
C1593 pll_full_0/divbuf_1/a_1470_n1540# pll_full_0/divbuf_1/a_1950_n1540# 0.11fF
C1594 pll_full_0/divbuf_1/a_32190_n840# pll_full_0/divbuf_1/a_32190_n1540# 0.01fF
C1595 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/OUT5 0.26fF
C1596 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1597 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n840# 0.04fF
C1598 divbuf_0/a_4882_n240# divbuf_0/OUT3 0.04fF
C1599 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1600 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36510_n840# 0.04fF
C1601 divbuf_1/a_20042_170# divbuf_1/a_20532_170# 0.07fF
C1602 divbuf_5/a_12282_170# divbuf_5/a_12772_170# 0.07fF
C1603 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58560_n1600# 0.26fF
C1604 divbuf_1/a_56640_n1600# divbuf_1/a_57120_n1600# 0.26fF
C1605 divbuf_5/a_36532_n240# divbuf_5/a_36510_n840# 0.05fF
C1606 divbuf_5/a_45600_n1600# divbuf_5/a_46080_n1600# 0.26fF
C1607 divbuf_3/a_31200_n1600# divbuf_3/OUT4 0.00fF
C1608 ro_div_0/divbuf_0/a_50430_n1540# ro_div_0/divbuf_0/a_50910_n1540# 0.11fF
C1609 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_16350_n840# 0.00fF
C1610 divbuf_1/a_48990_n1540# divbuf_1/a_49470_n1540# 0.11fF
C1611 divbuf_3/a_45600_n1600# divbuf_3/a_45630_n840# 0.04fF
C1612 divbuf_5/a_37950_n1540# divbuf_5/a_38430_n1540# 0.11fF
C1613 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/a_29742_n240# 0.01fF
C1614 divbuf_0/a_21982_n240# divbuf_0/a_22472_n240# 0.04fF
C1615 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/a_34112_n240# 0.01fF
C1616 divbuf_2/a_19200_n1600# divbuf_2/a_19680_n1600# 0.26fF
C1617 divbuf_2/a_9732_n240# divbuf_2/a_9630_n840# 0.03fF
C1618 divbuf_4/a_21120_n1600# divbuf_4/OUT4 0.00fF
C1619 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_14702_n240# 0.05fF
C1620 divbuf_0/a_3390_n840# divbuf_0/a_3390_n1540# 0.01fF
C1621 divbuf_0/a_33630_n840# divbuf_0/a_34110_n840# 0.07fF
C1622 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n1540# 0.19fF
C1623 divbuf_1/a_22472_170# divbuf_1/a_22472_n240# 0.01fF
C1624 divbuf_2/a_42270_n840# divbuf_2/a_42270_n1540# 0.01fF
C1625 divbuf_2/a_11550_n1540# divbuf_2/a_12030_n1540# 0.11fF
C1626 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_25950_n1540# 0.19fF
C1627 pll_full_0/divbuf_0/a_25950_n840# pll_full_0/divbuf_0/a_26430_n840# 0.07fF
C1628 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1629 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48030_n840# 0.04fF
C1630 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/a_9732_170# 0.07fF
C1631 divbuf_1/a_9732_n240# divbuf_1/OUT3 0.04fF
C1632 divbuf_1/a_46560_n1600# divbuf_1/a_46590_n840# 0.04fF
C1633 divbuf_3/a_23442_n240# divbuf_3/a_23922_n240# 0.05fF
C1634 divbuf_5/a_35520_n1600# divbuf_5/a_35550_n840# 0.04fF
C1635 divbuf_5/a_26832_170# divbuf_5/OUT4 0.19fF
C1636 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/a_16152_170# 0.07fF
C1637 divbuf_3/a_10590_n840# divbuf_3/OUT4 0.03fF
C1638 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/a_36510_n840# 0.05fF
C1639 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_46080_n1600# 0.26fF
C1640 divbuf_4/a_9120_n1600# divbuf_4/a_9600_n1600# 0.26fF
C1641 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_49440_n1600# 0.26fF
C1642 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/a_39870_n840# 0.04fF
C1643 divbuf_3/a_35040_n1600# divbuf_3/a_35070_n1540# 0.19fF
C1644 divbuf_3/a_35070_n840# divbuf_3/a_35550_n840# 0.07fF
C1645 divbuf_3/a_4830_n840# divbuf_3/a_4830_n1540# 0.01fF
C1646 pd_div_0/divbuf_0/a_37950_n1540# pd_div_0/divbuf_0/a_38430_n1540# 0.11fF
C1647 divbuf_2/a_9120_n1600# divbuf_2/a_9150_n840# 0.04fF
C1648 divbuf_4/a_60480_n1600# divbuf_4/OUT5 0.26fF
C1649 divbuf_4/a_32190_n840# divbuf_4/a_32190_n1540# 0.01fF
C1650 divbuf_4/a_1470_n1540# divbuf_4/a_1950_n1540# 0.11fF
C1651 pll_full_0/divbuf_1/a_41310_n1540# pll_full_0/divbuf_1/a_41790_n1540# 0.11fF
C1652 gnd pll_full_0/divider_0/prescaler_0/nand_0/z1 0.16fF
C1653 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/a_26352_n240# 0.04fF
C1654 divbuf_1/a_24412_n240# divbuf_1/a_24892_n240# 0.05fF
C1655 divbuf_5/a_13252_n240# divbuf_5/a_13742_n240# 0.04fF
C1656 divbuf_5/a_33142_170# divbuf_5/a_33142_n240# 0.01fF
C1657 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37470_n1540# 0.19fF
C1658 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C1659 ro_div_0/divbuf_0/a_7230_n840# ro_div_0/divbuf_0/a_7230_n1540# 0.01fF
C1660 ro_div_0/divbuf_0/a_37470_n840# ro_div_0/divbuf_0/a_37950_n840# 0.07fF
C1661 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/a_11802_n240# 0.01fF
C1662 divbuf_1/a_8640_n1600# divbuf_1/OUT3 0.00fF
C1663 divbuf_1/a_36000_n1600# divbuf_1/a_36030_n1540# 0.19fF
C1664 divbuf_1/a_36030_n840# divbuf_1/a_36510_n840# 0.07fF
C1665 divbuf_1/a_5790_n840# divbuf_1/a_5790_n1540# 0.01fF
C1666 divbuf_5/a_27802_n240# divbuf_5/OUT4 0.04fF
C1667 divbuf_5/a_24960_n1600# divbuf_5/a_24990_n1540# 0.19fF
C1668 divbuf_5/a_24990_n840# divbuf_5/a_25470_n840# 0.07fF
C1669 divbuf_3/a_57150_n840# divbuf_3/a_57150_n1540# 0.01fF
C1670 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z3 0.65fF
C1671 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_35550_n840# 0.04fF
C1672 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1673 divbuf_2/a_5852_170# divbuf_2/a_5852_n240# 0.01fF
C1674 divbuf_2/a_25862_170# divbuf_2/a_26352_170# 0.07fF
C1675 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1676 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_38910_n840# 0.04fF
C1677 divbuf_0/a_20160_n1600# divbuf_0/a_20640_n1600# 0.26fF
C1678 divbuf_2/a_13742_170# divbuf_2/OUT4 0.19fF
C1679 divbuf_2/a_59040_n1600# divbuf_2/a_59520_n1600# 0.26fF
C1680 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12960_n1600# 0.26fF
C1681 divbuf_0/a_12510_n1540# divbuf_0/a_12990_n1540# 0.11fF
C1682 divbuf_0/a_43230_n840# divbuf_0/a_43230_n1540# 0.01fF
C1683 divbuf_2/a_51390_n1540# divbuf_2/a_51870_n1540# 0.11fF
C1684 pll_full_0/divbuf_0/a_35550_n840# pll_full_0/divbuf_0/a_35550_n1540# 0.01fF
C1685 pll_full_0/divbuf_0/a_4830_n1540# pll_full_0/divbuf_0/a_5310_n1540# 0.11fF
C1686 divbuf_3/a_3422_170# divbuf_3/OUT3 0.23fF
C1687 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_13742_n240# 0.04fF
C1688 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/a_33142_n240# 0.01fF
C1689 divbuf_4/a_15672_170# divbuf_4/a_16152_170# 0.07fF
C1690 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/a_36532_n240# 0.01fF
C1691 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_17122_n240# 0.05fF
C1692 divbuf_3/a_21600_n1600# divbuf_3/a_22080_n1600# 0.26fF
C1693 divbuf_3/a_12282_n240# divbuf_3/a_12510_n840# 0.02fF
C1694 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1695 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_24990_n1540# 0.19fF
C1696 pd_div_0/divbuf_0/a_24990_n840# pd_div_0/divbuf_0/a_25470_n840# 0.07fF
C1697 divbuf_4/a_39932_n240# divbuf_4/a_39870_n840# 0.04fF
C1698 divbuf_4/a_48960_n1600# divbuf_4/a_49440_n1600# 0.26fF
C1699 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28350_n1540# 0.19fF
C1700 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1701 pll_full_0/divbuf_1/a_28350_n840# pll_full_0/divbuf_1/a_28830_n840# 0.07fF
C1702 divbuf_3/a_44670_n840# divbuf_3/a_44670_n1540# 0.01fF
C1703 divbuf_3/a_13950_n1540# divbuf_3/a_14430_n1540# 0.11fF
C1704 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n840# 0.04fF
C1705 divbuf_1/a_4392_170# divbuf_1/a_3912_170# 0.07fF
C1706 divbuf_4/a_41310_n1540# divbuf_4/a_41790_n1540# 0.11fF
C1707 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2430_n840# 0.04fF
C1708 divbuf_2/a_48960_n1600# divbuf_2/a_48990_n840# 0.04fF
C1709 divbuf_2/a_14702_n240# divbuf_2/OUT4 0.04fF
C1710 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/a_20042_170# 0.07fF
C1711 ro_div_0/ro_complete_0/cbank_2/switch_5/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C1712 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1713 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24480_n1600# 0.26fF
C1714 divbuf_0/a_510_n1540# divbuf_0/OUT 0.11fF
C1715 divbuf_1/a_13252_n240# divbuf_1/a_13470_n840# 0.02fF
C1716 divbuf_1/a_22560_n1600# divbuf_1/a_23040_n1600# 0.26fF
C1717 divbuf_5/a_11520_n1600# divbuf_5/a_12000_n1600# 0.26fF
C1718 divbuf_3/a_4392_n240# divbuf_3/OUT3 0.04fF
C1719 ro_div_0/divbuf_0/a_16350_n1540# ro_div_0/divbuf_0/a_16830_n1540# 0.11fF
C1720 ro_div_0/divbuf_0/a_47070_n840# ro_div_0/divbuf_0/a_47070_n1540# 0.01fF
C1721 divbuf_1/a_45630_n840# divbuf_1/a_45630_n1540# 0.01fF
C1722 divbuf_1/a_14910_n1540# divbuf_1/a_15390_n1540# 0.11fF
C1723 divbuf_3/a_11520_n1600# divbuf_3/a_11550_n840# 0.04fF
C1724 divbuf_5/a_34590_n840# divbuf_5/a_34590_n1540# 0.01fF
C1725 divbuf_5/a_3870_n1540# divbuf_5/a_4350_n1540# 0.11fF
C1726 divbuf_0/a_26832_170# divbuf_0/a_27322_170# 0.07fF
C1727 divbuf_0/a_8272_170# divbuf_0/a_8272_n240# 0.01fF
C1728 divbuf_4/a_38880_n1600# divbuf_4/a_38910_n840# 0.04fF
C1729 divbuf_4/a_33622_170# divbuf_4/OUT4 0.19fF
C1730 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1731 divbuf_2/a_26832_n240# divbuf_2/a_27322_n240# 0.04fF
C1732 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/a_5852_n240# 0.01fF
C1733 divbuf_0/a_60000_n1600# divbuf_0/a_60480_n1600# 0.26fF
C1734 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/Out 0.05fF
C1735 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/clk 0.11fF
C1736 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1737 divbuf_2/a_38430_n840# divbuf_2/a_38910_n840# 0.07fF
C1738 divbuf_2/a_8190_n840# divbuf_2/a_8190_n1540# 0.01fF
C1739 divbuf_2/a_12960_n1600# divbuf_2/OUT4 0.00fF
C1740 divbuf_2/a_38400_n1600# divbuf_2/a_38430_n1540# 0.19fF
C1741 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1742 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52800_n1600# 0.26fF
C1743 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1744 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C1745 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/a_39442_170# 0.07fF
C1746 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_13950_n840# 0.04fF
C1747 divbuf_0/a_52350_n1540# divbuf_0/a_52830_n1540# 0.11fF
C1748 divbuf_1/a_31682_170# divbuf_1/OUT4 0.19fF
C1749 divbuf_1/a_12480_n1600# divbuf_1/a_12510_n840# 0.04fF
C1750 divbuf_3/a_28292_170# divbuf_3/a_28772_170# 0.07fF
C1751 divbuf_3/a_8272_170# divbuf_3/a_8272_n240# 0.01fF
C1752 divbuf_5/a_1440_n1600# divbuf_5/a_1470_n840# 0.04fF
C1753 pll_full_0/divbuf_0/a_44670_n1540# pll_full_0/divbuf_0/a_45150_n1540# 0.11fF
C1754 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_12000_n1600# 0.26fF
C1755 divbuf_4/a_16642_n240# divbuf_4/a_17122_n240# 0.05fF
C1756 divbuf_4/a_36532_170# divbuf_4/a_36532_n240# 0.01fF
C1757 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_15360_n1600# 0.26fF
C1758 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/a_5310_n840# 0.04fF
C1759 divbuf_3/a_960_n1600# divbuf_3/a_990_n1540# 0.19fF
C1760 divbuf_3/a_990_n840# divbuf_3/a_1470_n840# 0.07fF
C1761 pd_div_0/divbuf_0/a_34590_n840# pd_div_0/divbuf_0/a_34590_n1540# 0.01fF
C1762 pd_div_0/divbuf_0/a_3870_n1540# pd_div_0/divbuf_0/a_4350_n1540# 0.11fF
C1763 divbuf_4/a_28350_n840# divbuf_4/a_28830_n840# 0.07fF
C1764 divbuf_4/a_34592_n240# divbuf_4/OUT4 0.04fF
C1765 divbuf_4/a_28320_n1600# divbuf_4/a_28350_n1540# 0.19fF
C1766 pll_full_0/divbuf_1/a_7230_n1540# pll_full_0/divbuf_1/a_7710_n1540# 0.11fF
C1767 pll_full_0/divbuf_1/a_37950_n840# pll_full_0/divbuf_1/a_37950_n1540# 0.01fF
C1768 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1769 divbuf_0/a_16642_n240# divbuf_0/OUT4 0.04fF
C1770 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n840# 0.04fF
C1771 divbuf_1/a_15672_170# divbuf_1/a_15672_n240# 0.01fF
C1772 divbuf_1/a_25862_170# divbuf_1/a_26352_170# 0.07fF
C1773 divbuf_5/a_18092_170# divbuf_5/a_18582_170# 0.07fF
C1774 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42270_n840# 0.04fF
C1775 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1776 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3390_n1540# 0.19fF
C1777 ro_div_0/divbuf_0/a_3390_n840# ro_div_0/divbuf_0/a_3870_n840# 0.07fF
C1778 ro_div_0/divider_0/tspc_1/a_630_n680# gnd 0.62fF
C1779 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Z3 0.29fF
C1780 divbuf_1/a_8762_170# divbuf_1/OUT3 0.19fF
C1781 divbuf_1/a_1920_n1600# divbuf_1/a_1950_n1540# 0.19fF
C1782 divbuf_1/a_1950_n840# divbuf_1/a_2430_n840# 0.07fF
C1783 divbuf_5/a_51360_n1600# divbuf_5/a_51840_n1600# 0.26fF
C1784 divbuf_3/a_53280_n1600# divbuf_3/a_53310_n1540# 0.19fF
C1785 ro_div_0/divbuf_0/a_56190_n1540# ro_div_0/divbuf_0/a_56670_n1540# 0.11fF
C1786 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1470_n840# 0.04fF
C1787 divbuf_1/a_54750_n1540# divbuf_1/a_55230_n1540# 0.11fF
C1788 divbuf_3/a_51360_n1600# divbuf_3/a_51390_n840# 0.04fF
C1789 divbuf_5/a_43710_n1540# divbuf_5/a_44190_n1540# 0.11fF
C1790 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_4830_n840# 0.04fF
C1791 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/a_35562_n240# 0.01fF
C1792 divbuf_0/a_27802_n240# divbuf_0/a_28292_n240# 0.04fF
C1793 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/a_20532_n240# 0.04fF
C1794 divbuf_2/a_15672_n240# divbuf_2/a_15870_n840# 0.02fF
C1795 divbuf_2/a_24960_n1600# divbuf_2/a_25440_n1600# 0.26fF
C1796 divbuf_4/a_32640_n1600# divbuf_4/OUT4 0.00fF
C1797 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/a_39932_n240# 0.01fF
C1798 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n1540# 0.19fF
C1799 divbuf_0/a_9150_n840# divbuf_0/a_9150_n1540# 0.01fF
C1800 divbuf_0/a_39390_n840# divbuf_0/a_39870_n840# 0.07fF
C1801 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1802 divbuf_1/a_28292_170# divbuf_1/a_28292_n240# 0.01fF
C1803 divbuf_2/a_48030_n840# divbuf_2/a_48030_n1540# 0.01fF
C1804 divbuf_2/a_17310_n1540# divbuf_2/a_17790_n1540# 0.11fF
C1805 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_31710_n1540# 0.19fF
C1806 pll_full_0/divbuf_0/a_31710_n840# pll_full_0/divbuf_0/a_32190_n840# 0.07fF
C1807 pll_full_0/divbuf_0/a_1470_n840# pll_full_0/divbuf_0/a_1470_n1540# 0.01fF
C1808 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1809 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_53790_n840# 0.04fF
C1810 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/a_18582_170# 0.07fF
C1811 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/a_1842_n240# 0.01fF
C1812 divbuf_1/a_52320_n1600# divbuf_1/a_52350_n840# 0.04fF
C1813 divbuf_1/a_21502_n240# divbuf_1/OUT4 0.04fF
C1814 divbuf_3/a_29262_n240# divbuf_3/a_29742_n240# 0.05fF
C1815 divbuf_5/a_41280_n1600# divbuf_5/a_41310_n840# 0.04fF
C1816 divbuf_5/a_38472_170# divbuf_5/OUT4 0.19fF
C1817 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/a_21982_170# 0.07fF
C1818 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C1819 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C1820 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z1 0.01fF
C1821 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51840_n1600# 0.26fF
C1822 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/OUT3 0.19fF
C1823 divbuf_4/a_5362_n240# divbuf_4/a_5310_n840# 0.04fF
C1824 divbuf_4/a_14880_n1600# divbuf_4/a_15360_n1600# 0.26fF
C1825 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_55200_n1600# 0.26fF
C1826 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/OUT3 0.19fF
C1827 divbuf_3/a_40830_n840# divbuf_3/a_41310_n840# 0.07fF
C1828 divbuf_3/a_10590_n840# divbuf_3/a_10590_n1540# 0.01fF
C1829 divbuf_3/a_40800_n1600# divbuf_3/a_40830_n1540# 0.19fF
C1830 pd_div_0/divbuf_0/a_43710_n1540# pd_div_0/divbuf_0/a_44190_n1540# 0.11fF
C1831 divbuf_2/a_14880_n1600# divbuf_2/a_14910_n840# 0.04fF
C1832 divbuf_4/a_37950_n840# divbuf_4/a_37950_n1540# 0.01fF
C1833 divbuf_4/a_7230_n1540# divbuf_4/a_7710_n1540# 0.11fF
C1834 pll_full_0/divbuf_1/a_47070_n1540# pll_full_0/divbuf_1/a_47550_n1540# 0.11fF
C1835 gnd pll_full_0/divider_0/clk 0.08fF
C1836 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/a_32172_n240# 0.04fF
C1837 divbuf_1/a_30232_n240# divbuf_1/a_30712_n240# 0.05fF
C1838 divbuf_5/a_38962_170# divbuf_5/a_38962_n240# 0.01fF
C1839 divbuf_5/a_19072_n240# divbuf_5/a_19562_n240# 0.04fF
C1840 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C1841 ro_div_0/divbuf_0/a_12990_n840# ro_div_0/divbuf_0/a_12990_n1540# 0.01fF
C1842 ro_div_0/divbuf_0/a_43230_n840# ro_div_0/divbuf_0/a_43710_n840# 0.07fF
C1843 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43230_n1540# 0.19fF
C1844 divbuf_1/a_41760_n1600# divbuf_1/a_41790_n1540# 0.19fF
C1845 divbuf_1/a_41790_n840# divbuf_1/a_42270_n840# 0.07fF
C1846 divbuf_1/a_11550_n840# divbuf_1/a_11550_n1540# 0.01fF
C1847 divbuf_1/a_19680_n1600# divbuf_1/OUT4 0.00fF
C1848 divbuf_5/a_30720_n1600# divbuf_5/a_30750_n1540# 0.19fF
C1849 divbuf_5/a_510_n840# divbuf_5/a_510_n1540# 0.01fF
C1850 divbuf_5/a_30750_n840# divbuf_5/a_31230_n840# 0.07fF
C1851 divbuf_5/a_39442_n240# divbuf_5/OUT4 0.04fF
C1852 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_480_n1600# 0.00fF
C1853 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1854 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/Out 0.21fF
C1855 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41310_n840# 0.04fF
C1856 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1857 divbuf_2/a_31682_170# divbuf_2/a_32172_170# 0.07fF
C1858 divbuf_2/a_12282_170# divbuf_2/a_12282_n240# 0.01fF
C1859 divbuf_4/a_4800_n1600# divbuf_4/a_4830_n840# 0.04fF
C1860 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_44670_n840# 0.04fF
C1861 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C1862 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/a_4350_n840# 0.04fF
C1863 divbuf_0/a_16642_n240# divbuf_0/a_16830_n840# 0.02fF
C1864 divbuf_0/a_25920_n1600# divbuf_0/a_26400_n1600# 0.26fF
C1865 divbuf_2/a_4350_n840# divbuf_2/a_4830_n840# 0.07fF
C1866 divbuf_2/a_4320_n1600# divbuf_2/a_4350_n1540# 0.19fF
C1867 divbuf_2/a_25382_170# divbuf_2/OUT4 0.19fF
C1868 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/a_8670_n840# 0.03fF
C1869 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18720_n1600# 0.26fF
C1870 divbuf_0/a_18270_n1540# divbuf_0/a_18750_n1540# 0.11fF
C1871 divbuf_0/a_48990_n840# divbuf_0/a_48990_n1540# 0.01fF
C1872 divbuf_2/a_57150_n1540# divbuf_2/a_57630_n1540# 0.11fF
C1873 pll_full_0/divbuf_0/a_41310_n840# pll_full_0/divbuf_0/a_41310_n1540# 0.01fF
C1874 pll_full_0/divbuf_0/a_10590_n1540# pll_full_0/divbuf_0/a_11070_n1540# 0.11fF
C1875 divbuf_3/a_15182_170# divbuf_3/OUT4 0.19fF
C1876 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/a_38962_n240# 0.01fF
C1877 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/a_19562_n240# 0.04fF
C1878 divbuf_4/a_21502_170# divbuf_4/a_21982_170# 0.07fF
C1879 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/a_22952_n240# 0.05fF
C1880 divbuf_3/a_27360_n1600# divbuf_3/a_27840_n1600# 0.26fF
C1881 divbuf_3/a_18092_n240# divbuf_3/a_18270_n840# 0.02fF
C1882 divbuf_0/a_12282_170# divbuf_0/a_12772_170# 0.07fF
C1883 divbuf_0/a_19562_170# divbuf_0/a_19562_n240# 0.01fF
C1884 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1885 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C1886 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_30750_n1540# 0.19fF
C1887 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/a_510_n1540# 0.01fF
C1888 pd_div_0/divbuf_0/a_30750_n840# pd_div_0/divbuf_0/a_31230_n840# 0.07fF
C1889 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1890 divbuf_4/a_4882_170# divbuf_4/OUT3 0.19fF
C1891 divbuf_4/a_54720_n1600# divbuf_4/a_55200_n1600# 0.26fF
C1892 pll_full_0/divbuf_1/a_3870_n840# pll_full_0/divbuf_1/a_3870_n1540# 0.01fF
C1893 pll_full_0/divbuf_1/a_34110_n840# pll_full_0/divbuf_1/a_34590_n840# 0.07fF
C1894 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34110_n1540# 0.19fF
C1895 divbuf_3/a_50430_n840# divbuf_3/a_50430_n1540# 0.01fF
C1896 divbuf_3/a_19710_n1540# divbuf_3/a_20190_n1540# 0.11fF
C1897 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1898 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n840# 0.04fF
C1899 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1900 divbuf_2/a_26352_n240# divbuf_2/OUT4 0.04fF
C1901 divbuf_2/a_54720_n1600# divbuf_2/a_54750_n840# 0.04fF
C1902 divbuf_4/a_47070_n1540# divbuf_4/a_47550_n1540# 0.11fF
C1903 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C1904 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C1905 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8190_n840# 0.04fF
C1906 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/a_20670_n840# 0.03fF
C1907 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_30240_n1600# 0.26fF
C1908 divbuf_1/a_28320_n1600# divbuf_1/a_28800_n1600# 0.26fF
C1909 divbuf_1/a_19072_n240# divbuf_1/a_19230_n840# 0.02fF
C1910 divbuf_5/a_17280_n1600# divbuf_5/a_17760_n1600# 0.26fF
C1911 divbuf_5/a_7792_n240# divbuf_5/a_7710_n840# 0.03fF
C1912 divbuf_3/a_16152_n240# divbuf_3/OUT4 0.04fF
C1913 ro_div_0/divbuf_0/a_22110_n1540# ro_div_0/divbuf_0/a_22590_n1540# 0.11fF
C1914 ro_div_0/divbuf_0/a_52830_n840# ro_div_0/divbuf_0/a_52830_n1540# 0.01fF
C1915 divbuf_1/a_51390_n840# divbuf_1/a_51390_n1540# 0.01fF
C1916 divbuf_1/a_20670_n1540# divbuf_1/a_21150_n1540# 0.11fF
C1917 divbuf_4/a_492_n240# divbuf_4/a_480_n1600# 0.00fF
C1918 divbuf_3/a_17280_n1600# divbuf_3/a_17310_n840# 0.04fF
C1919 divbuf_5/a_40350_n840# divbuf_5/a_40350_n1540# 0.01fF
C1920 divbuf_5/a_9630_n1540# divbuf_5/a_10110_n1540# 0.11fF
C1921 divbuf_0/a_32652_170# divbuf_0/a_33142_170# 0.07fF
C1922 divbuf_2/a_32652_n240# divbuf_2/a_33142_n240# 0.04fF
C1923 divbuf_4/a_5852_n240# divbuf_4/OUT3 0.04fF
C1924 divbuf_4/a_44640_n1600# divbuf_4/a_44670_n840# 0.04fF
C1925 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/a_25382_170# 0.07fF
C1926 divbuf_0/a_27322_170# divbuf_0/OUT4 0.19fF
C1927 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n1540# 0.19fF
C1928 divbuf_0/a_5310_n840# divbuf_0/a_5790_n840# 0.07fF
C1929 gnd pd_div_0/divider_0/and_0/B 0.66fF
C1930 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1931 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58560_n1600# 0.26fF
C1932 divbuf_2/a_44160_n1600# divbuf_2/a_44190_n1540# 0.19fF
C1933 divbuf_2/a_44190_n840# divbuf_2/a_44670_n840# 0.07fF
C1934 divbuf_2/a_13950_n840# divbuf_2/a_13950_n1540# 0.01fF
C1935 divbuf_2/a_24480_n1600# divbuf_2/OUT4 0.00fF
C1936 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/a_5362_n240# 0.05fF
C1937 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_19710_n840# 0.04fF
C1938 divbuf_0/a_58110_n1540# divbuf_0/a_58590_n1540# 0.11fF
C1939 divbuf_1/a_18240_n1600# divbuf_1/a_18270_n840# 0.04fF
C1940 pll_full_0/divbuf_0/a_50430_n1540# pll_full_0/divbuf_0/a_50910_n1540# 0.11fF
C1941 divbuf_3/a_14702_170# divbuf_3/a_14702_n240# 0.01fF
C1942 divbuf_3/a_34112_170# divbuf_3/a_34592_170# 0.07fF
C1943 divbuf_5/a_7200_n1600# divbuf_5/a_7230_n840# 0.04fF
C1944 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17760_n1600# 0.26fF
C1945 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/a_7710_n840# 0.03fF
C1946 divbuf_4/a_22472_n240# divbuf_4/a_22952_n240# 0.05fF
C1947 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11550_n840# 0.02fF
C1948 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_21120_n1600# 0.26fF
C1949 divbuf_3/a_6750_n840# divbuf_3/a_7230_n840# 0.07fF
C1950 divbuf_3/a_6720_n1600# divbuf_3/a_6750_n1540# 0.19fF
C1951 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/OUT3 0.19fF
C1952 pd_div_0/divbuf_0/a_40350_n840# pd_div_0/divbuf_0/a_40350_n1540# 0.01fF
C1953 pd_div_0/divbuf_0/a_9630_n1540# pd_div_0/divbuf_0/a_10110_n1540# 0.11fF
C1954 divbuf_4/a_34080_n1600# divbuf_4/a_34110_n1540# 0.19fF
C1955 divbuf_4/a_34110_n840# divbuf_4/a_34590_n840# 0.07fF
C1956 divbuf_4/a_3870_n840# divbuf_4/a_3870_n1540# 0.01fF
C1957 pll_full_0/divbuf_1/a_12990_n1540# pll_full_0/divbuf_1/a_13470_n1540# 0.11fF
C1958 pll_full_0/divbuf_1/a_43710_n840# pll_full_0/divbuf_1/a_43710_n1540# 0.01fF
C1959 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C1960 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n840# 0.04fF
C1961 divbuf_0/a_28292_n240# divbuf_0/OUT4 0.04fF
C1962 divbuf_1/a_9242_170# divbuf_1/a_9242_n240# 0.01fF
C1963 divbuf_1/a_35082_170# divbuf_1/a_35562_170# 0.07fF
C1964 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48030_n840# 0.04fF
C1965 divbuf_5/a_3912_170# divbuf_5/a_3912_n240# 0.01fF
C1966 divbuf_5/a_23922_170# divbuf_5/a_24412_170# 0.07fF
C1967 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1968 ro_div_0/divbuf_0/a_9150_n840# ro_div_0/divbuf_0/a_9630_n840# 0.07fF
C1969 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9150_n1540# 0.19fF
C1970 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 0.63fF
C1971 divbuf_1/a_7680_n1600# divbuf_1/a_7710_n1540# 0.19fF
C1972 divbuf_1/a_7710_n840# divbuf_1/a_8190_n840# 0.07fF
C1973 divbuf_1/a_28772_170# divbuf_1/OUT4 0.19fF
C1974 divbuf_5/a_9732_170# divbuf_5/OUT3 0.19fF
C1975 divbuf_5/a_57120_n1600# divbuf_5/a_57600_n1600# 0.26fF
C1976 divbuf_3/a_59040_n1600# divbuf_3/a_59070_n1540# 0.19fF
C1977 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7230_n840# 0.04fF
C1978 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_10590_n840# 0.04fF
C1979 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/a_41382_n240# 0.01fF
C1980 divbuf_1/a_60510_n1540# divbuf_1/a_60990_n1540# 0.11fF
C1981 divbuf_3/a_57120_n1600# divbuf_3/a_57150_n840# 0.04fF
C1982 divbuf_5/a_49470_n1540# divbuf_5/a_49950_n1540# 0.11fF
C1983 divbuf_0/a_33622_n240# divbuf_0/a_34112_n240# 0.04fF
C1984 divbuf_2/a_30720_n1600# divbuf_2/a_31200_n1600# 0.26fF
C1985 divbuf_2/a_21502_n240# divbuf_2/a_21630_n840# 0.03fF
C1986 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/a_26352_n240# 0.04fF
C1987 gnd pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.44fF
C1988 divbuf_0/a_14910_n840# divbuf_0/a_14910_n1540# 0.01fF
C1989 divbuf_0/a_45150_n840# divbuf_0/a_45630_n840# 0.07fF
C1990 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n1540# 0.19fF
C1991 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37470_n1540# 0.19fF
C1992 divbuf_2/a_53790_n840# divbuf_2/a_53790_n1540# 0.01fF
C1993 divbuf_2/a_23070_n1540# divbuf_2/a_23550_n1540# 0.11fF
C1994 pll_full_0/divbuf_0/a_37470_n840# pll_full_0/divbuf_0/a_37950_n840# 0.07fF
C1995 pll_full_0/divbuf_0/a_7230_n840# pll_full_0/divbuf_0/a_7230_n1540# 0.01fF
C1996 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C1997 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_59550_n840# 0.04fF
C1998 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1999 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/a_24412_170# 0.07fF
C2000 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/a_7302_n240# 0.01fF
C2001 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/a_27802_170# 0.07fF
C2002 divbuf_1/a_33142_n240# divbuf_1/OUT4 0.04fF
C2003 divbuf_1/a_58080_n1600# divbuf_1/a_58110_n840# 0.04fF
C2004 divbuf_3/a_35082_n240# divbuf_3/a_35562_n240# 0.05fF
C2005 divbuf_5/a_10212_n240# divbuf_5/OUT4 0.04fF
C2006 divbuf_5/a_47040_n1600# divbuf_5/a_47070_n840# 0.04fF
C2007 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z2 0.30fF
C2008 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z4 0.15fF
C2009 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C2010 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/OUT3 0.19fF
C2011 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57600_n1600# 0.26fF
C2012 divbuf_3/a_46560_n1600# divbuf_3/a_46590_n1540# 0.19fF
C2013 divbuf_3/a_46590_n840# divbuf_3/a_47070_n840# 0.07fF
C2014 divbuf_3/a_16350_n840# divbuf_3/a_16350_n1540# 0.01fF
C2015 divbuf_4/a_20640_n1600# divbuf_4/a_21120_n1600# 0.26fF
C2016 divbuf_4/a_11312_n240# divbuf_4/a_11550_n840# 0.02fF
C2017 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C2018 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2019 divbuf_0/a_1842_n240# divbuf_0/a_1950_n840# 0.03fF
C2020 pd_div_0/divbuf_0/a_49470_n1540# pd_div_0/divbuf_0/a_49950_n1540# 0.11fF
C2021 divbuf_2/a_20640_n1600# divbuf_2/a_20670_n840# 0.04fF
C2022 divbuf_4/a_43710_n840# divbuf_4/a_43710_n1540# 0.01fF
C2023 divbuf_4/a_12990_n1540# divbuf_4/a_13470_n1540# 0.11fF
C2024 pll_full_0/divbuf_1/a_52830_n1540# pll_full_0/divbuf_1/a_53310_n1540# 0.11fF
C2025 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/a_37992_n240# 0.04fF
C2026 divbuf_1/a_36052_n240# divbuf_1/a_36532_n240# 0.05fF
C2027 divbuf_5/a_24892_n240# divbuf_5/a_25382_n240# 0.04fF
C2028 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_48990_n1540# 0.19fF
C2029 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C2030 ro_div_0/divbuf_0/a_18750_n840# ro_div_0/divbuf_0/a_18750_n1540# 0.01fF
C2031 ro_div_0/divbuf_0/a_48990_n840# ro_div_0/divbuf_0/a_49470_n840# 0.07fF
C2032 divbuf_1/a_31200_n1600# divbuf_1/OUT4 0.00fF
C2033 divbuf_1/a_47520_n1600# divbuf_1/a_47550_n1540# 0.19fF
C2034 divbuf_1/a_47550_n840# divbuf_1/a_48030_n840# 0.07fF
C2035 divbuf_1/a_17310_n840# divbuf_1/a_17310_n1540# 0.01fF
C2036 divbuf_5/a_9600_n1600# divbuf_5/OUT3 0.00fF
C2037 divbuf_5/a_36480_n1600# divbuf_5/a_36510_n1540# 0.19fF
C2038 divbuf_5/a_36510_n840# divbuf_5/a_36990_n840# 0.07fF
C2039 divbuf_5/a_6270_n840# divbuf_5/a_6270_n1540# 0.01fF
C2040 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z2 1.07fF
C2041 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z3 0.38fF
C2042 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z4 0.12fF
C2043 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2044 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47070_n840# 0.04fF
C2045 pd_0/REF divbuf_4/a_0_n1600# 0.26fF
C2046 divbuf_2/a_18092_170# divbuf_2/a_18092_n240# 0.01fF
C2047 divbuf_2/a_37502_170# divbuf_2/a_37992_170# 0.07fF
C2048 divbuf_4/a_10560_n1600# divbuf_4/a_10590_n840# 0.04fF
C2049 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/a_10212_170# 0.07fF
C2050 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2051 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50430_n840# 0.04fF
C2052 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/a_10110_n840# 0.03fF
C2053 divbuf_0/a_22472_n240# divbuf_0/a_22590_n840# 0.03fF
C2054 divbuf_0/a_31680_n1600# divbuf_0/a_32160_n1600# 0.26fF
C2055 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24480_n1600# 0.26fF
C2056 divbuf_2/a_10080_n1600# divbuf_2/a_10110_n1540# 0.19fF
C2057 divbuf_2/a_37022_170# divbuf_2/OUT4 0.19fF
C2058 divbuf_2/a_10110_n840# divbuf_2/a_10590_n840# 0.07fF
C2059 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_14910_n840# 0.02fF
C2060 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/a_10212_170# 0.07fF
C2061 divbuf_0/a_24030_n1540# divbuf_0/a_24510_n1540# 0.11fF
C2062 divbuf_0/a_54750_n840# divbuf_0/a_54750_n1540# 0.01fF
C2063 divbuf_2/OUT2 divbuf_2/OUT3 0.36fF
C2064 pll_full_0/divbuf_0/a_47070_n840# pll_full_0/divbuf_0/a_47070_n1540# 0.01fF
C2065 pll_full_0/divbuf_0/a_16350_n1540# pll_full_0/divbuf_0/a_16830_n1540# 0.11fF
C2066 divbuf_3/a_26832_170# divbuf_3/OUT4 0.19fF
C2067 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/a_25382_n240# 0.04fF
C2068 divbuf_1/a_10590_n840# divbuf_1/OUT4 0.03fF
C2069 divbuf_4/a_27322_170# divbuf_4/a_27802_170# 0.07fF
C2070 divbuf_4/a_7302_170# divbuf_4/a_7302_n240# 0.01fF
C2071 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/a_28772_n240# 0.05fF
C2072 divbuf_3/a_33120_n1600# divbuf_3/a_33600_n1600# 0.26fF
C2073 divbuf_3/a_23922_n240# divbuf_3/a_24030_n840# 0.03fF
C2074 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C2075 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36510_n1540# 0.19fF
C2076 pd_div_0/divbuf_0/a_36510_n840# pd_div_0/divbuf_0/a_36990_n840# 0.07fF
C2077 pd_div_0/divbuf_0/a_6270_n840# pd_div_0/divbuf_0/a_6270_n1540# 0.01fF
C2078 divbuf_4/a_16642_170# divbuf_4/OUT4 0.19fF
C2079 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C2080 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_39870_n1540# 0.19fF
C2081 pll_full_0/divbuf_1/a_9630_n840# pll_full_0/divbuf_1/a_9630_n1540# 0.01fF
C2082 pll_full_0/divbuf_1/a_39870_n840# pll_full_0/divbuf_1/a_40350_n840# 0.07fF
C2083 divbuf_3/a_25470_n1540# divbuf_3/a_25950_n1540# 0.11fF
C2084 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n840# 0.04fF
C2085 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/a_1842_170# 0.07fF
C2086 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C2087 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C2088 divbuf_2/a_60480_n1600# divbuf_2/a_60510_n840# 0.04fF
C2089 divbuf_2/a_37992_n240# divbuf_2/OUT4 0.04fF
C2090 divbuf_4/a_52830_n1540# divbuf_4/a_53310_n1540# 0.11fF
C2091 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C2092 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_13950_n840# 0.04fF
C2093 ro_div_0/divbuf_0/a_1842_170# ro_div_0/divbuf_0/a_1842_n240# 0.01fF
C2094 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_36000_n1600# 0.26fF
C2095 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/a_26430_n840# 0.04fF
C2096 divbuf_1/a_24892_n240# divbuf_1/a_24990_n840# 0.03fF
C2097 divbuf_1/a_34080_n1600# divbuf_1/a_34560_n1600# 0.26fF
C2098 divbuf_5/a_13742_n240# divbuf_5/a_13950_n840# 0.02fF
C2099 divbuf_5/a_23040_n1600# divbuf_5/a_23520_n1600# 0.26fF
C2100 divbuf_3/a_27802_n240# divbuf_3/OUT4 0.04fF
C2101 ro_div_0/divbuf_0/a_27870_n1540# ro_div_0/divbuf_0/a_28350_n1540# 0.11fF
C2102 ro_div_0/divbuf_0/a_58590_n840# ro_div_0/divbuf_0/a_58590_n1540# 0.01fF
C2103 divbuf_1/a_57150_n840# divbuf_1/a_57150_n1540# 0.01fF
C2104 divbuf_1/a_26430_n1540# divbuf_1/a_26910_n1540# 0.11fF
C2105 divbuf_5/a_46110_n840# divbuf_5/a_46110_n1540# 0.01fF
C2106 divbuf_5/a_15390_n1540# divbuf_5/a_15870_n1540# 0.11fF
C2107 divbuf_3/a_23040_n1600# divbuf_3/a_23070_n840# 0.04fF
C2108 divbuf_0/a_38472_170# divbuf_0/a_38962_170# 0.07fF
C2109 divbuf_2/a_38472_n240# divbuf_2/a_38962_n240# 0.04fF
C2110 divbuf_4/a_50400_n1600# divbuf_4/a_50430_n840# 0.04fF
C2111 divbuf_4/a_17612_n240# divbuf_4/OUT4 0.04fF
C2112 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2113 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/a_31202_170# 0.07fF
C2114 divbuf_0/a_11070_n840# divbuf_0/a_11550_n840# 0.07fF
C2115 divbuf_0/a_38962_170# divbuf_0/OUT4 0.19fF
C2116 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n1540# 0.19fF
C2117 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2118 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3390_n1540# 0.19fF
C2119 divbuf_2/a_49950_n840# divbuf_2/a_50430_n840# 0.07fF
C2120 divbuf_2/a_19710_n840# divbuf_2/a_19710_n1540# 0.01fF
C2121 divbuf_2/a_36000_n1600# divbuf_2/OUT4 0.00fF
C2122 divbuf_2/a_49920_n1600# divbuf_2/a_49950_n1540# 0.19fF
C2123 pll_full_0/divbuf_0/a_3390_n840# pll_full_0/divbuf_0/a_3870_n840# 0.07fF
C2124 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11802_n240# 0.04fF
C2125 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25470_n840# 0.04fF
C2126 divbuf_0/OUT4 divbuf_0/OUT5 0.26fF
C2127 divbuf_1/a_15182_170# divbuf_1/OUT4 0.19fF
C2128 divbuf_1/a_24000_n1600# divbuf_1/a_24030_n840# 0.04fF
C2129 divbuf_5/a_12960_n1600# divbuf_5/a_12990_n840# 0.04fF
C2130 divbuf_3/a_39932_170# divbuf_3/a_40412_170# 0.07fF
C2131 divbuf_3/a_20532_170# divbuf_3/a_20532_n240# 0.01fF
C2132 pll_full_0/divbuf_0/a_56190_n1540# pll_full_0/divbuf_0/a_56670_n1540# 0.11fF
C2133 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_13950_n840# 0.02fF
C2134 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23520_n1600# 0.26fF
C2135 divbuf_4/a_28292_n240# divbuf_4/a_28772_n240# 0.05fF
C2136 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_17310_n840# 0.02fF
C2137 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26880_n1600# 0.26fF
C2138 divbuf_3/a_12480_n1600# divbuf_3/a_12510_n1540# 0.19fF
C2139 divbuf_3/a_12510_n840# divbuf_3/a_12990_n840# 0.07fF
C2140 pd_div_0/divbuf_0/a_46110_n840# pd_div_0/divbuf_0/a_46110_n1540# 0.01fF
C2141 pd_div_0/divbuf_0/a_15390_n1540# pd_div_0/divbuf_0/a_15870_n1540# 0.11fF
C2142 divbuf_4/a_39870_n840# divbuf_4/a_40350_n840# 0.07fF
C2143 divbuf_4/a_9630_n840# divbuf_4/a_9630_n1540# 0.01fF
C2144 divbuf_4/a_39840_n1600# divbuf_4/a_39870_n1540# 0.19fF
C2145 pll_full_0/divbuf_1/a_18750_n1540# pll_full_0/divbuf_1/a_19230_n1540# 0.11fF
C2146 pll_full_0/divbuf_1/a_49470_n840# pll_full_0/divbuf_1/a_49470_n1540# 0.01fF
C2147 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2148 ro_div_0/ro_complete_0/cbank_1/switch_5/vin ro_div_0/divider_0/clk 1.30fF
C2149 divbuf_0/a_39932_n240# divbuf_0/OUT4 0.04fF
C2150 divbuf_1/a_40902_170# divbuf_1/a_41382_170# 0.07fF
C2151 divbuf_5/a_29742_170# divbuf_5/a_30232_170# 0.07fF
C2152 divbuf_5/a_9732_170# divbuf_5/a_9732_n240# 0.01fF
C2153 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2154 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_53790_n840# 0.04fF
C2155 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_14910_n1540# 0.19fF
C2156 ro_div_0/divbuf_0/a_14910_n840# ro_div_0/divbuf_0/a_15390_n840# 0.07fF
C2157 ro_div_0/divider_0/prescaler_0/nand_1/z1 gnd 0.16fF
C2158 divbuf_1/a_4392_n240# divbuf_1/OUT3 0.04fF
C2159 divbuf_1/a_13440_n1600# divbuf_1/a_13470_n1540# 0.19fF
C2160 divbuf_1/a_13470_n840# divbuf_1/a_13950_n840# 0.07fF
C2161 divbuf_5/a_2400_n1600# divbuf_5/a_2430_n1540# 0.19fF
C2162 divbuf_5/a_21502_170# divbuf_5/OUT4 0.19fF
C2163 divbuf_5/a_2430_n840# divbuf_5/a_2910_n840# 0.07fF
C2164 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_12990_n840# 0.04fF
C2165 divbuf_2/a_1842_170# divbuf_2/a_2322_170# 0.07fF
C2166 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16350_n840# 0.04fF
C2167 divbuf_5/a_55230_n1540# divbuf_5/a_55710_n1540# 0.11fF
C2168 divbuf_0/a_39442_n240# divbuf_0/a_39932_n240# 0.04fF
C2169 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/a_32172_n240# 0.04fF
C2170 divbuf_0/a_1842_170# divbuf_0/a_1842_n240# 0.01fF
C2171 divbuf_2/a_27322_n240# divbuf_2/a_27390_n840# 0.04fF
C2172 divbuf_2/a_36480_n1600# divbuf_2/a_36960_n1600# 0.26fF
C2173 gnd pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.27fF
C2174 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n1540# 0.19fF
C2175 divbuf_0/a_20670_n840# divbuf_0/a_20670_n1540# 0.01fF
C2176 divbuf_0/a_50910_n840# divbuf_0/a_51390_n840# 0.07fF
C2177 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C2178 divbuf_2/a_59550_n840# divbuf_2/a_59550_n1540# 0.01fF
C2179 divbuf_2/a_28830_n1540# divbuf_2/a_29310_n1540# 0.11fF
C2180 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43230_n1540# 0.19fF
C2181 pll_full_0/divbuf_0/a_43230_n840# pll_full_0/divbuf_0/a_43710_n840# 0.07fF
C2182 pll_full_0/divbuf_0/a_12990_n840# pll_full_0/divbuf_0/a_12990_n1540# 0.01fF
C2183 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/a_30232_170# 0.07fF
C2184 divbuf_3/a_56190_n1540# divbuf_3/a_56670_n1540# 0.11fF
C2185 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/a_13742_n240# 0.01fF
C2186 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/a_33622_170# 0.07fF
C2187 divbuf_3/a_40902_n240# divbuf_3/a_41382_n240# 0.05fF
C2188 divbuf_5/a_52800_n1600# divbuf_5/a_52830_n840# 0.04fF
C2189 divbuf_5/a_22472_n240# divbuf_5/OUT4 0.04fF
C2190 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2430_n1540# 0.19fF
C2191 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2192 pd_div_0/divbuf_0/a_2430_n840# pd_div_0/divbuf_0/a_2910_n840# 0.07fF
C2193 divbuf_4/a_26400_n1600# divbuf_4/a_26880_n1600# 0.26fF
C2194 divbuf_4/a_17122_n240# divbuf_4/a_17310_n840# 0.02fF
C2195 divbuf_3/a_52350_n840# divbuf_3/a_52830_n840# 0.07fF
C2196 divbuf_3/a_22110_n840# divbuf_3/a_22110_n1540# 0.01fF
C2197 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C2198 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C2199 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2200 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_5790_n1540# 0.19fF
C2201 pll_full_0/divbuf_1/a_5790_n840# pll_full_0/divbuf_1/a_6270_n840# 0.07fF
C2202 pd_div_0/divbuf_0/a_55230_n1540# pd_div_0/divbuf_0/a_55710_n1540# 0.11fF
C2203 divbuf_2/a_26400_n1600# divbuf_2/a_26430_n840# 0.04fF
C2204 divbuf_2/a_8272_170# divbuf_2/OUT3 0.19fF
C2205 divbuf_4/a_49470_n840# divbuf_4/a_49470_n1540# 0.01fF
C2206 divbuf_4/a_18750_n1540# divbuf_4/a_19230_n1540# 0.11fF
C2207 pll_full_0/divbuf_1/a_58590_n1540# pll_full_0/divbuf_1/a_59070_n1540# 0.11fF
C2208 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/a_4882_170# 0.07fF
C2209 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C2210 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1920_n1600# 0.26fF
C2211 divbuf_1/a_0_n1600# divbuf_1/a_480_n1600# 0.26fF
C2212 divbuf_5/a_30712_n240# divbuf_5/a_31202_n240# 0.04fF
C2213 ro_div_0/divbuf_0/a_24510_n840# ro_div_0/divbuf_0/a_24510_n1540# 0.01fF
C2214 ro_div_0/divbuf_0/a_54750_n840# ro_div_0/divbuf_0/a_55230_n840# 0.07fF
C2215 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_54750_n1540# 0.19fF
C2216 divbuf_1/a_53280_n1600# divbuf_1/a_53310_n1540# 0.19fF
C2217 divbuf_1/a_53310_n840# divbuf_1/a_53790_n840# 0.07fF
C2218 divbuf_1/a_23070_n840# divbuf_1/a_23070_n1540# 0.01fF
C2219 divbuf_5/a_42240_n1600# divbuf_5/a_42270_n1540# 0.19fF
C2220 divbuf_5/a_42270_n840# divbuf_5/a_42750_n840# 0.07fF
C2221 divbuf_5/a_12030_n840# divbuf_5/a_12030_n1540# 0.01fF
C2222 divbuf_5/a_20640_n1600# divbuf_5/OUT4 0.00fF
C2223 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C2224 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_52830_n840# 0.04fF
C2225 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2226 divbuf_2/a_3422_n240# divbuf_2/a_3912_n240# 0.04fF
C2227 divbuf_2/a_23922_170# divbuf_2/a_23922_n240# 0.01fF
C2228 divbuf_4/a_16320_n1600# divbuf_4/a_16350_n840# 0.04fF
C2229 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56190_n840# 0.04fF
C2230 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2231 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_16350_n840# 0.02fF
C2232 divbuf_0/a_28292_n240# divbuf_0/a_28350_n840# 0.04fF
C2233 divbuf_0/a_37440_n1600# divbuf_0/a_37920_n1600# 0.26fF
C2234 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/nor_1/B 0.06fF
C2235 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/a_20670_n840# 0.03fF
C2236 divbuf_2/a_15870_n840# divbuf_2/a_16350_n840# 0.07fF
C2237 divbuf_2/a_9242_n240# divbuf_2/OUT3 0.04fF
C2238 divbuf_2/a_15840_n1600# divbuf_2/a_15870_n1540# 0.19fF
C2239 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_30240_n1600# 0.26fF
C2240 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/a_18092_170# 0.07fF
C2241 divbuf_0/a_29790_n1540# divbuf_0/a_30270_n1540# 0.11fF
C2242 divbuf_0/a_60510_n840# divbuf_0/a_60510_n1540# 0.01fF
C2243 divbuf_3/a_4882_170# divbuf_3/a_5362_170# 0.07fF
C2244 pll_full_0/divbuf_0/a_52830_n840# pll_full_0/divbuf_0/a_52830_n1540# 0.01fF
C2245 pll_full_0/divbuf_0/a_22110_n1540# pll_full_0/divbuf_0/a_22590_n1540# 0.11fF
C2246 divbuf_3/a_38472_170# divbuf_3/OUT4 0.19fF
C2247 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/a_31202_n240# 0.04fF
C2248 divbuf_3/a_38880_n1600# divbuf_3/a_39360_n1600# 0.26fF
C2249 divbuf_3/a_29742_n240# divbuf_3/a_29790_n840# 0.04fF
C2250 divbuf_4/a_33142_170# divbuf_4/a_33622_170# 0.07fF
C2251 divbuf_4/a_13742_170# divbuf_4/a_13742_n240# 0.01fF
C2252 divbuf_5/a_990_n840# divbuf_5/OUT2 0.02fF
C2253 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/a_34592_n240# 0.05fF
C2254 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42270_n1540# 0.19fF
C2255 pd_div_0/divbuf_0/a_42270_n840# pd_div_0/divbuf_0/a_42750_n840# 0.07fF
C2256 pd_div_0/divbuf_0/a_12030_n840# pd_div_0/divbuf_0/a_12030_n1540# 0.01fF
C2257 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C2258 divbuf_4/a_5790_n840# divbuf_4/a_6270_n840# 0.07fF
C2259 divbuf_4/a_5760_n1600# divbuf_4/a_5790_n1540# 0.19fF
C2260 divbuf_4/a_28292_170# divbuf_4/OUT4 0.19fF
C2261 pll_full_0/divbuf_1/a_15390_n840# pll_full_0/divbuf_1/a_15390_n1540# 0.01fF
C2262 pll_full_0/divbuf_1/a_45630_n840# pll_full_0/divbuf_1/a_46110_n840# 0.07fF
C2263 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_45630_n1540# 0.19fF
C2264 divbuf_3/a_31230_n1540# divbuf_3/a_31710_n1540# 0.11fF
C2265 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n840# 0.04fF
C2266 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/prescaler_0/Out 0.28fF
C2267 divbuf_4/a_58590_n1540# divbuf_4/a_59070_n1540# 0.11fF
C2268 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_19710_n840# 0.04fF
C2269 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z2 0.23fF
C2270 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C2271 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/a_17612_n240# 0.01fF
C2272 pd_0/DIV divbuf_5/a_510_n1540# 0.11fF
C2273 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/a_32190_n840# 0.06fF
C2274 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41760_n1600# 0.26fF
C2275 divbuf_1/a_39840_n1600# divbuf_1/a_40320_n1600# 0.26fF
C2276 divbuf_1/a_30712_n240# divbuf_1/a_30750_n840# 0.05fF
C2277 divbuf_5/a_28800_n1600# divbuf_5/a_29280_n1600# 0.26fF
C2278 divbuf_5/a_19562_n240# divbuf_5/a_19710_n840# 0.03fF
C2279 divbuf_3/a_39442_n240# divbuf_3/OUT4 0.04fF
C2280 ro_div_0/divbuf_0/a_33630_n1540# ro_div_0/divbuf_0/a_34110_n1540# 0.11fF
C2281 divbuf_1/a_32190_n1540# divbuf_1/a_32670_n1540# 0.11fF
C2282 divbuf_5/a_51870_n840# divbuf_5/a_51870_n1540# 0.01fF
C2283 divbuf_5/a_21150_n1540# divbuf_5/a_21630_n1540# 0.11fF
C2284 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/a_2430_n840# 0.03fF
C2285 divbuf_3/a_28800_n1600# divbuf_3/a_28830_n840# 0.04fF
C2286 divbuf_0/a_4392_n240# divbuf_0/a_4882_n240# 0.04fF
C2287 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C2288 divbuf_0/a_24892_170# divbuf_0/a_24892_n240# 0.01fF
C2289 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/a_37022_170# 0.07fF
C2290 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/OUT2 0.02fF
C2291 divbuf_2/a_2400_n1600# divbuf_2/a_2880_n1600# 0.26fF
C2292 divbuf_4/a_29262_n240# divbuf_4/OUT4 0.04fF
C2293 divbuf_4/a_56160_n1600# divbuf_4/a_56190_n840# 0.04fF
C2294 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2295 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n1540# 0.19fF
C2296 divbuf_0/a_11312_n240# divbuf_0/OUT4 0.07fF
C2297 divbuf_0/a_16830_n840# divbuf_0/a_17310_n840# 0.07fF
C2298 divbuf_2/a_55680_n1600# divbuf_2/a_55710_n1540# 0.19fF
C2299 divbuf_2/a_55710_n840# divbuf_2/a_56190_n840# 0.07fF
C2300 divbuf_2/a_25470_n840# divbuf_2/a_25470_n1540# 0.01fF
C2301 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9150_n1540# 0.19fF
C2302 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2303 pll_full_0/divbuf_0/a_9150_n840# pll_full_0/divbuf_0/a_9630_n840# 0.07fF
C2304 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_17612_n240# 0.04fF
C2305 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31230_n840# 0.04fF
C2306 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/tspc_r_0/z5 0.20fF
C2307 divbuf_1/a_29760_n1600# divbuf_1/a_29790_n840# 0.04fF
C2308 divbuf_5/a_18720_n1600# divbuf_5/a_18750_n840# 0.04fF
C2309 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C2310 divbuf_3/a_26352_170# divbuf_3/a_26352_n240# 0.01fF
C2311 divbuf_3/a_5852_n240# divbuf_3/a_6332_n240# 0.05fF
C2312 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_29280_n1600# 0.26fF
C2313 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/a_19710_n840# 0.03fF
C2314 divbuf_4/a_34112_n240# divbuf_4/a_34592_n240# 0.05fF
C2315 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/a_23070_n840# 0.03fF
C2316 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32640_n1600# 0.26fF
C2317 divbuf_3/a_18270_n840# divbuf_3/a_18750_n840# 0.07fF
C2318 divbuf_3/a_18240_n1600# divbuf_3/a_18270_n1540# 0.19fF
C2319 pd_div_0/divbuf_0/a_51870_n840# pd_div_0/divbuf_0/a_51870_n1540# 0.01fF
C2320 pd_div_0/divbuf_0/a_21150_n1540# pd_div_0/divbuf_0/a_21630_n1540# 0.11fF
C2321 divbuf_2/a_13252_n240# divbuf_2/a_12990_n840# 0.01fF
C2322 divbuf_4/a_45600_n1600# divbuf_4/a_45630_n1540# 0.19fF
C2323 divbuf_4/a_45630_n840# divbuf_4/a_46110_n840# 0.07fF
C2324 divbuf_4/a_15390_n840# divbuf_4/a_15390_n1540# 0.01fF
C2325 pll_full_0/divbuf_1/a_24510_n1540# pll_full_0/divbuf_1/a_24990_n1540# 0.11fF
C2326 pll_full_0/divbuf_1/a_55230_n840# pll_full_0/divbuf_1/a_55230_n1540# 0.01fF
C2327 divbuf_0/a_10080_n1600# divbuf_0/OUT3 0.00fF
C2328 divbuf_1/a_6822_n240# divbuf_1/a_7302_n240# 0.05fF
C2329 divbuf_5/a_16152_170# divbuf_5/a_16152_n240# 0.01fF
C2330 divbuf_5/a_35562_170# divbuf_5/a_36052_170# 0.07fF
C2331 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_59550_n840# 0.04fF
C2332 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2333 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C2334 ro_div_0/divbuf_0/a_20670_n840# ro_div_0/divbuf_0/a_21150_n840# 0.07fF
C2335 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_20670_n1540# 0.19fF
C2336 ro_div_0/divider_0/and_0/Z1 gnd 0.32fF
C2337 divbuf_1/a_19200_n1600# divbuf_1/a_19230_n1540# 0.19fF
C2338 divbuf_1/a_19230_n840# divbuf_1/a_19710_n840# 0.07fF
C2339 divbuf_1/a_16152_n240# divbuf_1/OUT4 0.04fF
C2340 divbuf_5/a_8160_n1600# divbuf_5/a_8190_n1540# 0.19fF
C2341 divbuf_5/a_33142_170# divbuf_5/OUT4 0.19fF
C2342 divbuf_5/a_8190_n840# divbuf_5/a_8670_n840# 0.07fF
C2343 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.32fF
C2344 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_18750_n840# 0.04fF
C2345 divbuf_2/a_8272_170# divbuf_2/a_8762_170# 0.07fF
C2346 divbuf_4/a_2322_n240# divbuf_4/a_2430_n840# 0.03fF
C2347 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22110_n840# 0.04fF
C2348 divbuf_0/a_3360_n1600# divbuf_0/a_3840_n1600# 0.26fF
C2349 divbuf_2/a_42240_n1600# divbuf_2/a_42720_n1600# 0.26fF
C2350 divbuf_2/a_33142_n240# divbuf_2/a_33150_n840# 0.06fF
C2351 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/a_37992_n240# 0.04fF
C2352 gnd pll_full_0/divider_0/nor_0/B 1.23fF
C2353 divbuf_0/a_26430_n840# divbuf_0/a_26430_n1540# 0.01fF
C2354 divbuf_0/a_56670_n840# divbuf_0/a_57150_n840# 0.07fF
C2355 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n1540# 0.19fF
C2356 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_48990_n1540# 0.19fF
C2357 divbuf_2/a_34590_n1540# divbuf_2/a_35070_n1540# 0.11fF
C2358 pll_full_0/divbuf_0/a_48990_n840# pll_full_0/divbuf_0/a_49470_n840# 0.07fF
C2359 pll_full_0/divbuf_0/a_18750_n840# pll_full_0/divbuf_0/a_18750_n1540# 0.01fF
C2360 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C2361 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/a_16152_n240# 0.01fF
C2362 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/a_36052_170# 0.07fF
C2363 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/a_19562_n240# 0.01fF
C2364 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/a_39442_170# 0.07fF
C2365 divbuf_3/a_4800_n1600# divbuf_3/a_5280_n1600# 0.26fF
C2366 divbuf_5/a_34112_n240# divbuf_5/OUT4 0.04fF
C2367 divbuf_5/a_58560_n1600# divbuf_5/a_58590_n840# 0.04fF
C2368 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C2369 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/nor_0/B 0.22fF
C2370 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C2371 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C2372 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8190_n1540# 0.19fF
C2373 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2374 pd_div_0/divbuf_0/a_8190_n840# pd_div_0/divbuf_0/a_8670_n840# 0.07fF
C2375 divbuf_4/a_32160_n1600# divbuf_4/a_32640_n1600# 0.26fF
C2376 divbuf_4/a_22952_n240# divbuf_4/a_23070_n840# 0.03fF
C2377 pll_full_0/divbuf_1/a_11550_n840# pll_full_0/divbuf_1/a_12030_n840# 0.07fF
C2378 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2379 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_11550_n1540# 0.19fF
C2380 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/a_1470_n840# 0.03fF
C2381 divbuf_3/a_58110_n840# divbuf_3/a_58590_n840# 0.07fF
C2382 divbuf_3/a_27870_n840# divbuf_3/a_27870_n1540# 0.01fF
C2383 divbuf_0/a_14222_n240# divbuf_0/a_13950_n840# 0.01fF
C2384 divbuf_4/a_55230_n840# divbuf_4/a_55230_n1540# 0.01fF
C2385 divbuf_4/a_24510_n1540# divbuf_4/a_24990_n1540# 0.11fF
C2386 divbuf_2/a_32160_n1600# divbuf_2/a_32190_n840# 0.04fF
C2387 divbuf_2/a_20042_170# divbuf_2/OUT4 0.19fF
C2388 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C2389 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7680_n1600# 0.26fF
C2390 divbuf_1/a_5760_n1600# divbuf_1/a_6240_n1600# 0.26fF
C2391 divbuf_5/a_36532_n240# divbuf_5/a_37022_n240# 0.04fF
C2392 divbuf_3/a_9732_170# divbuf_3/OUT3 0.19fF
C2393 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/a_60510_n1540# 0.19fF
C2394 ro_div_0/divbuf_0/a_30270_n840# ro_div_0/divbuf_0/a_30270_n1540# 0.01fF
C2395 ro_div_0/divbuf_0/a_60510_n840# ro_div_0/divbuf_0/a_60990_n840# 0.07fF
C2396 divbuf_1/a_59040_n1600# divbuf_1/a_59070_n1540# 0.19fF
C2397 divbuf_1/a_59070_n840# divbuf_1/a_59550_n840# 0.07fF
C2398 divbuf_1/a_28830_n840# divbuf_1/a_28830_n1540# 0.01fF
C2399 divbuf_3/a_15672_n240# divbuf_3/a_15390_n840# 0.01fF
C2400 divbuf_5/a_32160_n1600# divbuf_5/OUT4 0.00fF
C2401 divbuf_5/a_48000_n1600# divbuf_5/a_48030_n1540# 0.19fF
C2402 divbuf_5/a_48030_n840# divbuf_5/a_48510_n840# 0.07fF
C2403 divbuf_5/a_17790_n840# divbuf_5/a_17790_n1540# 0.01fF
C2404 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2405 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_58590_n840# 0.04fF
C2406 divbuf_4/a_22080_n1600# divbuf_4/a_22110_n840# 0.04fF
C2407 divbuf_2/a_29742_170# divbuf_2/a_29742_n240# 0.01fF
C2408 divbuf_2/a_9242_n240# divbuf_2/a_9732_n240# 0.04fF
C2409 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C2410 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2411 divbuf_0/a_34112_n240# divbuf_0/a_34110_n840# 0.06fF
C2412 divbuf_0/a_43200_n1600# divbuf_0/a_43680_n1600# 0.26fF
C2413 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_36000_n1600# 0.26fF
C2414 divbuf_2/a_21600_n1600# divbuf_2/a_21630_n1540# 0.19fF
C2415 divbuf_2/a_21630_n840# divbuf_2/a_22110_n840# 0.07fF
C2416 divbuf_2/a_21012_n240# divbuf_2/OUT4 0.04fF
C2417 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/a_26430_n840# 0.04fF
C2418 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C2419 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/a_22472_170# 0.07fF
C2420 divbuf_0/a_35550_n1540# divbuf_0/a_36030_n1540# 0.11fF
C2421 pll_full_0/divbuf_0/a_27870_n1540# pll_full_0/divbuf_0/a_28350_n1540# 0.11fF
C2422 pll_full_0/divbuf_0/a_58590_n840# pll_full_0/divbuf_0/a_58590_n1540# 0.01fF
C2423 divbuf_1/a_16642_n240# divbuf_1/a_16350_n840# 0.00fF
C2424 divbuf_3/a_11312_170# divbuf_3/a_11802_170# 0.07fF
C2425 divbuf_3/a_10212_n240# divbuf_3/OUT4 0.04fF
C2426 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/a_37022_n240# 0.04fF
C2427 divbuf_4/a_38962_170# divbuf_4/a_39442_170# 0.07fF
C2428 divbuf_4/a_19562_170# divbuf_4/a_19562_n240# 0.01fF
C2429 divbuf_3/a_44640_n1600# divbuf_3/a_45120_n1600# 0.26fF
C2430 divbuf_3/a_35562_n240# divbuf_3/a_35550_n840# 0.05fF
C2431 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/a_40412_n240# 0.05fF
C2432 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C2433 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48030_n1540# 0.19fF
C2434 pd_div_0/divbuf_0/a_48030_n840# pd_div_0/divbuf_0/a_48510_n840# 0.07fF
C2435 pd_div_0/divbuf_0/a_17790_n840# pd_div_0/divbuf_0/a_17790_n1540# 0.01fF
C2436 divbuf_3/a_36990_n1540# divbuf_3/a_37470_n1540# 0.11fF
C2437 divbuf_4/a_11520_n1600# divbuf_4/a_11550_n1540# 0.19fF
C2438 divbuf_4/a_39932_170# divbuf_4/OUT4 0.19fF
C2439 divbuf_4/a_11550_n840# divbuf_4/a_12030_n840# 0.07fF
C2440 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51390_n1540# 0.19fF
C2441 pll_full_0/divbuf_1/a_21150_n840# pll_full_0/divbuf_1/a_21150_n1540# 0.01fF
C2442 pll_full_0/divbuf_1/a_51390_n840# pll_full_0/divbuf_1/a_51870_n840# 0.07fF
C2443 divbuf_0/a_21982_170# divbuf_0/OUT4 0.19fF
C2444 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n840# 0.04fF
C2445 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/Out 0.91fF
C2446 gnd pd_div_0/divider_0/tspc_2/Z4 0.44fF
C2447 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/B 0.01fF
C2448 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25470_n840# 0.04fF
C2449 divbuf_2/a_19200_n1600# divbuf_2/OUT4 0.00fF
C2450 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47520_n1600# 0.26fF
C2451 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/a_37950_n840# 0.04fF
C2452 divbuf_1/a_36532_n240# divbuf_1/a_36510_n840# 0.05fF
C2453 divbuf_1/a_45600_n1600# divbuf_1/a_46080_n1600# 0.26fF
C2454 divbuf_5/a_25382_n240# divbuf_5/a_25470_n840# 0.03fF
C2455 divbuf_5/a_34560_n1600# divbuf_5/a_35040_n1600# 0.26fF
C2456 divbuf_3/a_9600_n1600# divbuf_3/OUT3 0.00fF
C2457 ro_div_0/divbuf_0/a_39390_n1540# ro_div_0/divbuf_0/a_39870_n1540# 0.11fF
C2458 divbuf_1/a_37950_n1540# divbuf_1/a_38430_n1540# 0.11fF
C2459 divbuf_3/a_34560_n1600# divbuf_3/a_34590_n840# 0.04fF
C2460 divbuf_5/a_57630_n840# divbuf_5/a_57630_n1540# 0.01fF
C2461 divbuf_5/a_26910_n1540# divbuf_5/a_27390_n1540# 0.11fF
C2462 divbuf_0/a_30712_170# divbuf_0/a_30712_n240# 0.01fF
C2463 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/a_2322_n240# 0.05fF
C2464 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/a_22952_n240# 0.01fF
C2465 divbuf_2/a_8160_n1600# divbuf_2/a_8640_n1600# 0.26fF
C2466 divbuf_4/a_40902_n240# divbuf_4/OUT4 0.04fF
C2467 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_960_n1600# 0.00fF
C2468 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2469 divbuf_0/a_22952_n240# divbuf_0/OUT4 0.04fF
C2470 divbuf_0/a_22590_n840# divbuf_0/a_23070_n840# 0.07fF
C2471 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n1540# 0.19fF
C2472 divbuf_2/a_31230_n840# divbuf_2/a_31230_n1540# 0.01fF
C2473 divbuf_2/a_510_n1540# divbuf_2/a_990_n1540# 0.11fF
C2474 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_14910_n1540# 0.19fF
C2475 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C2476 pll_full_0/divbuf_0/a_14910_n840# pll_full_0/divbuf_0/a_15390_n840# 0.07fF
C2477 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_36990_n840# 0.04fF
C2478 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z2 0.25fF
C2479 pd_div_0/pd_0/tspc_r_0/z5 pd_div_0/pd_0/tspc_r_1/z5 0.02fF
C2480 divbuf_1/a_23442_170# divbuf_1/OUT4 0.19fF
C2481 divbuf_1/a_35520_n1600# divbuf_1/a_35550_n840# 0.04fF
C2482 divbuf_3/a_12282_n240# divbuf_3/a_12772_n240# 0.04fF
C2483 divbuf_3/a_32172_170# divbuf_3/a_32172_n240# 0.01fF
C2484 divbuf_5/a_4392_170# divbuf_5/OUT3 0.19fF
C2485 divbuf_5/a_24480_n1600# divbuf_5/a_24510_n840# 0.04fF
C2486 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/a_4392_170# 0.07fF
C2487 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/a_25470_n840# 0.03fF
C2488 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_35040_n1600# 0.26fF
C2489 divbuf_4/a_39932_n240# divbuf_4/a_40412_n240# 0.05fF
C2490 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/a_28830_n840# 0.04fF
C2491 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_38400_n1600# 0.26fF
C2492 divbuf_3/a_24000_n1600# divbuf_3/a_24030_n1540# 0.19fF
C2493 divbuf_3/a_24030_n840# divbuf_3/a_24510_n840# 0.07fF
C2494 pd_div_0/divbuf_0/a_57630_n840# pd_div_0/divbuf_0/a_57630_n1540# 0.01fF
C2495 pd_div_0/divbuf_0/a_26910_n1540# pd_div_0/divbuf_0/a_27390_n1540# 0.11fF
C2496 divbuf_4/a_51390_n840# divbuf_4/a_51870_n840# 0.07fF
C2497 divbuf_4/a_21150_n840# divbuf_4/a_21150_n1540# 0.01fF
C2498 divbuf_4/a_51360_n1600# divbuf_4/a_51390_n1540# 0.19fF
C2499 pll_full_0/divbuf_1/a_30270_n1540# pll_full_0/divbuf_1/a_30750_n1540# 0.11fF
C2500 pll_full_0/divbuf_1/a_60990_n840# pll_full_0/divbuf_1/a_60990_n1540# 0.01fF
C2501 gnd pll_full_0/divider_0/tspc_0/Q 0.33fF
C2502 divbuf_0/a_21120_n1600# divbuf_0/OUT4 0.00fF
C2503 divbuf_1/a_13252_n240# divbuf_1/a_13742_n240# 0.04fF
C2504 divbuf_5/a_21982_170# divbuf_5/a_21982_n240# 0.01fF
C2505 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26430_n1540# 0.19fF
C2506 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2507 ro_div_0/divbuf_0/a_26430_n840# ro_div_0/divbuf_0/a_26910_n840# 0.07fF
C2508 divbuf_1/a_27802_n240# divbuf_1/OUT4 0.04fF
C2509 divbuf_1/a_24960_n1600# divbuf_1/a_24990_n1540# 0.19fF
C2510 divbuf_1/a_24990_n840# divbuf_1/a_25470_n840# 0.07fF
C2511 divbuf_5/a_5362_n240# divbuf_5/OUT3 0.04fF
C2512 divbuf_5/a_13920_n1600# divbuf_5/a_13950_n1540# 0.19fF
C2513 divbuf_5/a_13950_n840# divbuf_5/a_14430_n840# 0.07fF
C2514 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C2515 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z1 0.03fF
C2516 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24510_n840# 0.04fF
C2517 divbuf_2/a_14702_170# divbuf_2/a_15182_170# 0.07fF
C2518 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C2519 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/OUT4 0.23fF
C2520 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_27870_n840# 0.04fF
C2521 io_clamp_high[2] io_analog[6] 0.53fF
C2522 pd_0/tspc_r_0/z5 pd_0/DOWN 0.03fF
C2523 divbuf_0/a_9120_n1600# divbuf_0/a_9600_n1600# 0.26fF
C2524 divbuf_2/a_38962_n240# divbuf_2/a_38910_n840# 0.04fF
C2525 divbuf_2/a_48000_n1600# divbuf_2/a_48480_n1600# 0.26fF
C2526 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1920_n1600# 0.26fF
C2527 divbuf_0/a_1470_n1540# divbuf_0/a_1950_n1540# 0.11fF
C2528 divbuf_0/a_32190_n840# divbuf_0/a_32190_n1540# 0.01fF
C2529 divbuf_0/a_60480_n1600# divbuf_0/OUT5 0.26fF
C2530 divbuf_2/a_40350_n1540# divbuf_2/a_40830_n1540# 0.11fF
C2531 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_54750_n1540# 0.19fF
C2532 pll_full_0/divbuf_0/a_54750_n840# pll_full_0/divbuf_0/a_55230_n840# 0.07fF
C2533 pll_full_0/divbuf_0/a_24510_n840# pll_full_0/divbuf_0/a_24510_n1540# 0.01fF
C2534 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/a_21982_n240# 0.01fF
C2535 divbuf_4/a_3912_170# divbuf_4/a_4392_170# 0.07fF
C2536 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/a_5362_n240# 0.05fF
C2537 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/a_25382_n240# 0.01fF
C2538 divbuf_3/a_10560_n1600# divbuf_3/a_11040_n1600# 0.26fF
C2539 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/out1 0.31fF
C2540 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/and_0/A 0.01fF
C2541 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C2542 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_13950_n1540# 0.19fF
C2543 pd_div_0/divbuf_0/a_13950_n840# pd_div_0/divbuf_0/a_14430_n840# 0.07fF
C2544 divbuf_4/a_37920_n1600# divbuf_4/a_38400_n1600# 0.26fF
C2545 divbuf_4/a_28772_n240# divbuf_4/a_28830_n840# 0.04fF
C2546 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17310_n1540# 0.19fF
C2547 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2548 pll_full_0/divbuf_1/a_17310_n840# pll_full_0/divbuf_1/a_17790_n840# 0.07fF
C2549 divbuf_3/a_33630_n840# divbuf_3/a_33630_n1540# 0.01fF
C2550 divbuf_3/a_2910_n1540# divbuf_3/a_3390_n1540# 0.11fF
C2551 divbuf_1/a_18092_170# divbuf_1/a_18582_170# 0.07fF
C2552 divbuf_4/a_60990_n840# divbuf_4/a_60990_n1540# 0.01fF
C2553 divbuf_4/a_30270_n1540# divbuf_4/a_30750_n1540# 0.11fF
C2554 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12030_n840# 0.02fF
C2555 divbuf_2/a_37920_n1600# divbuf_2/a_37950_n840# 0.04fF
C2556 divbuf_2/a_31682_170# divbuf_2/OUT4 0.19fF
C2557 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C2558 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C2559 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_13440_n1600# 0.26fF
C2560 divbuf_1/a_11520_n1600# divbuf_1/a_12000_n1600# 0.26fF
C2561 divbuf_5/a_480_n1600# divbuf_5/a_960_n1600# 0.26fF
C2562 divbuf_3/a_21502_170# divbuf_3/OUT4 0.19fF
C2563 ro_div_0/divbuf_0/a_5310_n1540# ro_div_0/divbuf_0/a_5790_n1540# 0.11fF
C2564 ro_div_0/divbuf_0/a_36030_n840# ro_div_0/divbuf_0/a_36030_n1540# 0.01fF
C2565 divbuf_1/a_34590_n840# divbuf_1/a_34590_n1540# 0.01fF
C2566 divbuf_1/a_3870_n1540# divbuf_1/a_4350_n1540# 0.11fF
C2567 divbuf_3/a_480_n1600# divbuf_3/a_510_n840# 0.04fF
C2568 divbuf_5/a_53760_n1600# divbuf_5/a_53790_n1540# 0.19fF
C2569 divbuf_5/a_53790_n840# divbuf_5/a_54270_n840# 0.07fF
C2570 divbuf_5/a_23550_n840# divbuf_5/a_23550_n1540# 0.01fF
C2571 divbuf_4/a_27840_n1600# divbuf_4/a_27870_n840# 0.04fF
C2572 divbuf_4/a_11312_170# divbuf_4/OUT4 0.23fF
C2573 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C2574 divbuf_2/a_15672_n240# divbuf_2/a_16152_n240# 0.05fF
C2575 divbuf_2/a_35562_170# divbuf_2/a_35562_n240# 0.01fF
C2576 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C2577 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/a_6822_170# 0.07fF
C2578 divbuf_0/a_39932_n240# divbuf_0/a_39870_n840# 0.04fF
C2579 divbuf_0/a_48960_n1600# divbuf_0/a_49440_n1600# 0.26fF
C2580 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C2581 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/a_32190_n840# 0.06fF
C2582 divbuf_2/a_27390_n840# divbuf_2/a_27870_n840# 0.07fF
C2583 divbuf_2/a_32652_n240# divbuf_2/OUT4 0.04fF
C2584 divbuf_2/a_27360_n1600# divbuf_2/a_27390_n1540# 0.19fF
C2585 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41760_n1600# 0.26fF
C2586 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C2587 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_0/B 0.47fF
C2588 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C2589 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/Z3 0.05fF
C2590 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C2591 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C2592 ro_div_0/divbuf_0/a_7302_170# ro_div_0/divbuf_0/a_7302_n240# 0.01fF
C2593 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/a_28292_170# 0.07fF
C2594 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_2910_n840# 0.04fF
C2595 divbuf_0/a_41310_n1540# divbuf_0/a_41790_n1540# 0.11fF
C2596 divbuf_1/a_1440_n1600# divbuf_1/a_1470_n840# 0.04fF
C2597 divbuf_3/a_17122_170# divbuf_3/a_17612_170# 0.07fF
C2598 divbuf_5/a_11312_n240# divbuf_5/a_11070_n840# 0.02fF
C2599 pll_full_0/divbuf_0/a_33630_n1540# pll_full_0/divbuf_0/a_34110_n1540# 0.11fF
C2600 divbuf_3/a_22472_n240# divbuf_3/OUT4 0.04fF
C2601 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_960_n1600# 0.26fF
C2602 divbuf_4/a_25382_170# divbuf_4/a_25382_n240# 0.01fF
C2603 divbuf_4/a_4882_n240# divbuf_4/a_5362_n240# 0.05fF
C2604 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_4320_n1600# 0.26fF
C2605 divbuf_3/a_50400_n1600# divbuf_3/a_50880_n1600# 0.26fF
C2606 divbuf_3/a_41382_n240# divbuf_3/a_41310_n840# 0.03fF
C2607 divbuf_0/a_15182_170# divbuf_0/a_15182_n240# 0.01fF
C2608 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_53790_n1540# 0.19fF
C2609 pd_div_0/divbuf_0/a_53790_n840# pd_div_0/divbuf_0/a_54270_n840# 0.07fF
C2610 pd_div_0/divbuf_0/a_23550_n840# pd_div_0/divbuf_0/a_23550_n1540# 0.01fF
C2611 divbuf_4/a_17310_n840# divbuf_4/a_17790_n840# 0.07fF
C2612 divbuf_4/a_12282_n240# divbuf_4/OUT4 0.04fF
C2613 divbuf_4/a_17280_n1600# divbuf_4/a_17310_n1540# 0.19fF
C2614 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/OUT3 0.19fF
C2615 divbuf_3/a_42750_n1540# divbuf_3/a_43230_n1540# 0.11fF
C2616 pll_full_0/divbuf_1/a_26910_n840# pll_full_0/divbuf_1/a_26910_n1540# 0.01fF
C2617 pll_full_0/divbuf_1/a_57150_n840# pll_full_0/divbuf_1/a_57630_n840# 0.07fF
C2618 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57150_n1540# 0.19fF
C2619 divbuf_0/a_33622_170# divbuf_0/OUT4 0.19fF
C2620 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n840# 0.04fF
C2621 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/tspc_0/Z3 0.45fF
C2622 divbuf_5/a_6332_170# divbuf_5/a_6822_170# 0.07fF
C2623 pll_full_0/divbuf_0/a_1842_170# pll_full_0/divbuf_0/OUT2 0.19fF
C2624 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31230_n840# 0.04fF
C2625 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2626 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_53280_n1600# 0.26fF
C2627 divbuf_1/a_51360_n1600# divbuf_1/a_51840_n1600# 0.26fF
C2628 divbuf_5/a_40320_n1600# divbuf_5/a_40800_n1600# 0.26fF
C2629 divbuf_5/a_31202_n240# divbuf_5/a_31230_n840# 0.05fF
C2630 divbuf_3/a_20640_n1600# divbuf_3/OUT4 0.00fF
C2631 ro_div_0/divbuf_0/a_45150_n1540# ro_div_0/divbuf_0/a_45630_n1540# 0.11fF
C2632 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11070_n840# 0.02fF
C2633 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/a_24412_n240# 0.01fF
C2634 divbuf_1/a_43710_n1540# divbuf_1/a_44190_n1540# 0.11fF
C2635 divbuf_3/a_40320_n1600# divbuf_3/a_40350_n840# 0.04fF
C2636 divbuf_5/a_32670_n1540# divbuf_5/a_33150_n1540# 0.11fF
C2637 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_14430_n840# 0.01fF
C2638 divbuf_0/a_16642_n240# divbuf_0/a_17122_n240# 0.05fF
C2639 divbuf_0/a_36532_170# divbuf_0/a_36532_n240# 0.01fF
C2640 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/a_8762_n240# 0.04fF
C2641 divbuf_2/a_4392_n240# divbuf_2/a_4350_n840# 0.04fF
C2642 divbuf_2/a_13920_n1600# divbuf_2/a_14400_n1600# 0.26fF
C2643 divbuf_4/a_11040_n1600# divbuf_4/OUT3 0.00fF
C2644 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/a_28772_n240# 0.01fF
C2645 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C2646 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n1540# 0.19fF
C2647 divbuf_0/a_34592_n240# divbuf_0/OUT4 0.04fF
C2648 divbuf_0/a_28350_n840# divbuf_0/a_28830_n840# 0.07fF
C2649 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2650 divbuf_2/a_36990_n840# divbuf_2/a_36990_n1540# 0.01fF
C2651 divbuf_2/a_6270_n1540# divbuf_2/a_6750_n1540# 0.11fF
C2652 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_20670_n1540# 0.19fF
C2653 pll_full_0/divbuf_0/a_20670_n840# pll_full_0/divbuf_0/a_21150_n840# 0.07fF
C2654 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_42750_n840# 0.04fF
C2655 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/a_14702_170# 0.07fF
C2656 divbuf_1/a_41280_n1600# divbuf_1/a_41310_n840# 0.04fF
C2657 divbuf_1/a_38472_170# divbuf_1/OUT4 0.19fF
C2658 divbuf_3/a_37992_170# divbuf_3/a_37992_n240# 0.01fF
C2659 divbuf_3/a_18092_n240# divbuf_3/a_18582_n240# 0.04fF
C2660 divbuf_5/a_30240_n1600# divbuf_5/a_30270_n840# 0.04fF
C2661 divbuf_5/a_16152_170# divbuf_5/OUT4 0.19fF
C2662 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/a_10212_170# 0.07fF
C2663 divbuf_3/a_990_n840# divbuf_3/OUT2 0.02fF
C2664 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40800_n1600# 0.26fF
C2665 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/a_31230_n840# 0.05fF
C2666 divbuf_3/a_29760_n1600# divbuf_3/a_29790_n1540# 0.19fF
C2667 divbuf_3/a_29790_n840# divbuf_3/a_30270_n840# 0.07fF
C2668 divbuf_4/a_3840_n1600# divbuf_4/a_4320_n1600# 0.26fF
C2669 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/a_34590_n840# 0.06fF
C2670 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_44160_n1600# 0.26fF
C2671 pd_div_0/divbuf_0/a_32670_n1540# pd_div_0/divbuf_0/a_33150_n1540# 0.11fF
C2672 divbuf_2/a_3840_n1600# divbuf_2/a_3870_n840# 0.04fF
C2673 divbuf_4/a_57120_n1600# divbuf_4/a_57150_n1540# 0.19fF
C2674 divbuf_4/a_57150_n840# divbuf_4/a_57630_n840# 0.07fF
C2675 divbuf_4/a_26910_n840# divbuf_4/a_26910_n1540# 0.01fF
C2676 pll_full_0/divbuf_1/a_36030_n1540# pll_full_0/divbuf_1/a_36510_n1540# 0.11fF
C2677 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.44fF
C2678 divbuf_0/a_32640_n1600# divbuf_0/OUT4 0.00fF
C2679 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/a_21012_n240# 0.05fF
C2680 divbuf_1/a_38962_170# divbuf_1/a_38962_n240# 0.01fF
C2681 divbuf_1/a_19072_n240# divbuf_1/a_19562_n240# 0.04fF
C2682 divbuf_5/a_27802_170# divbuf_5/a_27802_n240# 0.01fF
C2683 divbuf_5/a_7302_n240# divbuf_5/a_7792_n240# 0.04fF
C2684 ro_div_0/divbuf_0/a_1950_n840# ro_div_0/divbuf_0/a_1950_n1540# 0.01fF
C2685 ro_div_0/divbuf_0/a_32190_n840# ro_div_0/divbuf_0/a_32670_n840# 0.07fF
C2686 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32190_n1540# 0.19fF
C2687 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/OUT2 0.01fF
C2688 divbuf_1/a_30720_n1600# divbuf_1/a_30750_n1540# 0.19fF
C2689 divbuf_1/a_510_n840# divbuf_1/a_510_n1540# 0.01fF
C2690 divbuf_1/a_30750_n840# divbuf_1/a_31230_n840# 0.07fF
C2691 divbuf_1/a_39442_n240# divbuf_1/OUT4 0.04fF
C2692 divbuf_5/a_19680_n1600# divbuf_5/a_19710_n1540# 0.19fF
C2693 divbuf_5/a_19710_n840# divbuf_5/a_20190_n840# 0.07fF
C2694 divbuf_5/a_17122_n240# divbuf_5/OUT4 0.04fF
C2695 divbuf_3/a_51870_n840# divbuf_3/a_51870_n1540# 0.01fF
C2696 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C2697 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/nor_1/A 0.01fF
C2698 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/tspc_1/Z3 0.16fF
C2699 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z4 0.21fF
C2700 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C2701 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30270_n840# 0.04fF
C2702 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2703 divbuf_2/a_20532_170# divbuf_2/a_21012_170# 0.07fF
C2704 divbuf_4/a_14702_n240# divbuf_4/a_14430_n840# 0.01fF
C2705 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C2706 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C2707 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2708 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_33630_n840# 0.04fF
C2709 divbuf_0/a_5362_n240# divbuf_0/a_5310_n840# 0.04fF
C2710 divbuf_0/a_14880_n1600# divbuf_0/a_15360_n1600# 0.26fF
C2711 divbuf_2/a_2322_170# divbuf_2/OUT3 0.07fF
C2712 divbuf_2/a_53760_n1600# divbuf_2/a_54240_n1600# 0.26fF
C2713 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7680_n1600# 0.26fF
C2714 divbuf_0/a_7230_n1540# divbuf_0/a_7710_n1540# 0.11fF
C2715 divbuf_0/a_37950_n840# divbuf_0/a_37950_n1540# 0.01fF
C2716 divbuf_2/a_46110_n1540# divbuf_2/a_46590_n1540# 0.11fF
C2717 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/a_60510_n1540# 0.19fF
C2718 pll_full_0/divbuf_0/a_60510_n840# pll_full_0/divbuf_0/a_60990_n840# 0.07fF
C2719 pll_full_0/divbuf_0/a_30270_n840# pll_full_0/divbuf_0/a_30270_n1540# 0.01fF
C2720 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/a_27802_n240# 0.01fF
C2721 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/a_7792_n240# 0.04fF
C2722 divbuf_4/a_9732_170# divbuf_4/a_10212_170# 0.07fF
C2723 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11802_n240# 0.04fF
C2724 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/a_31202_n240# 0.01fF
C2725 divbuf_3/a_16320_n1600# divbuf_3/a_16800_n1600# 0.26fF
C2726 divbuf_3/a_6822_n240# divbuf_3/a_6750_n840# 0.03fF
C2727 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/and_0/B 0.29fF
C2728 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_19710_n1540# 0.19fF
C2729 pd_div_0/divbuf_0/a_19710_n840# pd_div_0/divbuf_0/a_20190_n840# 0.07fF
C2730 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2731 divbuf_4/a_43680_n1600# divbuf_4/a_44160_n1600# 0.26fF
C2732 divbuf_4/a_34592_n240# divbuf_4/a_34590_n840# 0.06fF
C2733 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2734 pll_full_0/divbuf_1/a_23070_n840# pll_full_0/divbuf_1/a_23550_n840# 0.07fF
C2735 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23070_n1540# 0.19fF
C2736 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_13470_n840# 0.01fF
C2737 divbuf_3/a_39390_n840# divbuf_3/a_39390_n1540# 0.01fF
C2738 divbuf_3/a_8670_n1540# divbuf_3/a_9150_n1540# 0.11fF
C2739 divbuf_0/a_17612_170# divbuf_0/OUT4 0.19fF
C2740 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n840# 0.04fF
C2741 divbuf_2/a_3912_n240# divbuf_2/OUT3 0.04fF
C2742 divbuf_2/a_43680_n1600# divbuf_2/a_43710_n840# 0.04fF
C2743 divbuf_4/a_36030_n1540# divbuf_4/a_36510_n1540# 0.11fF
C2744 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/B 0.22fF
C2745 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C2746 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C2747 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_17790_n840# 0.00fF
C2748 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_19200_n1600# 0.26fF
C2749 divbuf_1/a_17280_n1600# divbuf_1/a_17760_n1600# 0.26fF
C2750 divbuf_1/a_7792_n240# divbuf_1/a_7710_n840# 0.03fF
C2751 divbuf_5/a_6240_n1600# divbuf_5/a_6720_n1600# 0.26fF
C2752 divbuf_3/a_33142_170# divbuf_3/OUT4 0.19fF
C2753 ro_div_0/divbuf_0/a_11070_n1540# ro_div_0/divbuf_0/a_11550_n1540# 0.11fF
C2754 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/a_41790_n1540# 0.01fF
C2755 pd_div_0/div pd_div_0/divbuf_0/a_510_n840# 0.07fF
C2756 divbuf_1/a_40350_n840# divbuf_1/a_40350_n1540# 0.01fF
C2757 divbuf_1/a_9630_n1540# divbuf_1/a_10110_n1540# 0.11fF
C2758 divbuf_3/a_6240_n1600# divbuf_3/a_6270_n840# 0.04fF
C2759 divbuf_5/a_59520_n1600# divbuf_5/a_59550_n1540# 0.19fF
C2760 divbuf_5/a_59550_n840# divbuf_5/a_60030_n840# 0.07fF
C2761 divbuf_5/a_29310_n840# divbuf_5/a_29310_n1540# 0.01fF
C2762 divbuf_0/a_21502_170# divbuf_0/a_21982_170# 0.07fF
C2763 divbuf_2/a_41382_170# divbuf_2/a_41382_n240# 0.01fF
C2764 divbuf_2/a_21502_n240# divbuf_2/a_21982_n240# 0.05fF
C2765 divbuf_4/a_33600_n1600# divbuf_4/a_33630_n840# 0.04fF
C2766 divbuf_4/a_22952_170# divbuf_4/OUT4 0.19fF
C2767 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C2768 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/a_15672_170# 0.07fF
C2769 divbuf_0/a_54720_n1600# divbuf_0/a_55200_n1600# 0.26fF
C2770 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C2771 pd_div_0/divider_0/tspc_0/a_630_n680# gnd 0.62fF
C2772 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/tspc_0/Z3 0.06fF
C2773 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47520_n1600# 0.26fF
C2774 divbuf_2/a_33120_n1600# divbuf_2/a_33150_n1540# 0.19fF
C2775 divbuf_2/a_33150_n840# divbuf_2/a_33630_n840# 0.07fF
C2776 divbuf_2/a_2910_n840# divbuf_2/a_2910_n1540# 0.01fF
C2777 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/a_37950_n840# 0.04fF
C2778 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/OUT3 0.19fF
C2779 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/a_34112_170# 0.07fF
C2780 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_8670_n840# 0.04fF
C2781 divbuf_0/a_47070_n1540# divbuf_0/a_47550_n1540# 0.11fF
C2782 divbuf_1/a_7200_n1600# divbuf_1/a_7230_n840# 0.04fF
C2783 divbuf_5/a_17122_n240# divbuf_5/a_16830_n840# 0.00fF
C2784 pll_full_0/divbuf_0/a_39390_n1540# pll_full_0/divbuf_0/a_39870_n1540# 0.11fF
C2785 divbuf_3/a_2322_170# divbuf_3/a_2322_n240# 0.01fF
C2786 divbuf_3/a_22952_170# divbuf_3/a_23442_170# 0.07fF
C2787 divbuf_3/a_34112_n240# divbuf_3/OUT4 0.04fF
C2788 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6720_n1600# 0.26fF
C2789 divbuf_4/a_31202_170# divbuf_4/a_31202_n240# 0.01fF
C2790 divbuf_4/a_11312_n240# divbuf_4/a_11802_n240# 0.04fF
C2791 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_10080_n1600# 0.26fF
C2792 divbuf_3/a_56160_n1600# divbuf_3/a_56640_n1600# 0.26fF
C2793 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C2794 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_59550_n1540# 0.19fF
C2795 pd_div_0/divbuf_0/a_59550_n840# pd_div_0/divbuf_0/a_60030_n840# 0.07fF
C2796 pd_div_0/divbuf_0/a_29310_n840# pd_div_0/divbuf_0/a_29310_n1540# 0.01fF
C2797 divbuf_4/a_23040_n1600# divbuf_4/a_23070_n1540# 0.19fF
C2798 divbuf_4/a_23070_n840# divbuf_4/a_23550_n840# 0.07fF
C2799 divbuf_4/a_23922_n240# divbuf_4/OUT4 0.04fF
C2800 pll_full_0/divbuf_1/a_1950_n1540# pll_full_0/divbuf_1/a_2430_n1540# 0.11fF
C2801 pll_full_0/divbuf_1/a_32670_n840# pll_full_0/divbuf_1/a_32670_n1540# 0.01fF
C2802 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/OUT 0.07fF
C2803 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2804 divbuf_3/a_48510_n1540# divbuf_3/a_48990_n1540# 0.11fF
C2805 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/a_15182_n240# 0.01fF
C2806 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n840# 0.04fF
C2807 divbuf_0/a_5852_n240# divbuf_0/OUT3 0.04fF
C2808 divbuf_1/a_20532_170# divbuf_1/a_21012_170# 0.07fF
C2809 divbuf_5/a_12772_170# divbuf_5/a_13252_170# 0.07fF
C2810 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2811 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_36990_n840# 0.04fF
C2812 ashish_0/a_150_n710# ashish_0/Gnd 1.71fF
C2813 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_59040_n1600# 0.26fF
C2814 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Qbar1 0.12fF
C2815 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/a_1842_170# 0.07fF
C2816 divbuf_1/a_57120_n1600# divbuf_1/a_57600_n1600# 0.26fF
C2817 divbuf_5/a_37022_n240# divbuf_5/a_36990_n840# 0.05fF
C2818 divbuf_5/a_46080_n1600# divbuf_5/a_46560_n1600# 0.26fF
C2819 divbuf_3/a_32160_n1600# divbuf_3/OUT4 0.00fF
C2820 ro_div_0/divbuf_0/a_50910_n1540# ro_div_0/divbuf_0/a_51390_n1540# 0.11fF
C2821 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_16830_n840# 0.00fF
C2822 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/a_30232_n240# 0.01fF
C2823 divbuf_1/a_49470_n1540# divbuf_1/a_49950_n1540# 0.11fF
C2824 divbuf_3/a_46080_n1600# divbuf_3/a_46110_n840# 0.04fF
C2825 divbuf_5/a_38430_n1540# divbuf_5/a_38910_n1540# 0.11fF
C2826 divbuf_0/a_22472_n240# divbuf_0/a_22952_n240# 0.05fF
C2827 divbuf_4/a_22080_n1600# divbuf_4/OUT4 0.01fF
C2828 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/a_34592_n240# 0.01fF
C2829 divbuf_2/a_19680_n1600# divbuf_2/a_20160_n1600# 0.26fF
C2830 divbuf_2/a_10212_n240# divbuf_2/a_10110_n840# 0.03fF
C2831 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_15182_n240# 0.05fF
C2832 divbuf_0/a_3870_n840# divbuf_0/a_3870_n1540# 0.01fF
C2833 divbuf_0/a_34110_n840# divbuf_0/a_34590_n840# 0.07fF
C2834 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n1540# 0.19fF
C2835 divbuf_1/a_22952_170# divbuf_1/a_22952_n240# 0.01fF
C2836 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26430_n1540# 0.19fF
C2837 divbuf_2/a_42750_n840# divbuf_2/a_42750_n1540# 0.01fF
C2838 divbuf_2/a_12030_n1540# divbuf_2/a_12510_n1540# 0.11fF
C2839 pll_full_0/divbuf_0/a_26430_n840# pll_full_0/divbuf_0/a_26910_n840# 0.07fF
C2840 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2841 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C2842 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48510_n840# 0.04fF
C2843 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/a_10212_170# 0.07fF
C2844 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/a_16642_170# 0.07fF
C2845 divbuf_1/a_10212_n240# divbuf_1/OUT4 0.04fF
C2846 divbuf_1/a_47040_n1600# divbuf_1/a_47070_n840# 0.04fF
C2847 divbuf_3/a_23922_n240# divbuf_3/a_24412_n240# 0.04fF
C2848 divbuf_5/a_36000_n1600# divbuf_5/a_36030_n840# 0.04fF
C2849 divbuf_5/a_27802_170# divbuf_5/OUT4 0.19fF
C2850 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/a_36990_n840# 0.05fF
C2851 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46560_n1600# 0.26fF
C2852 divbuf_4/a_9600_n1600# divbuf_4/a_10080_n1600# 0.26fF
C2853 divbuf_3/a_35520_n1600# divbuf_3/a_35550_n1540# 0.19fF
C2854 divbuf_3/a_35550_n840# divbuf_3/a_36030_n840# 0.07fF
C2855 divbuf_3/a_5310_n840# divbuf_3/a_5310_n1540# 0.01fF
C2856 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/a_40350_n840# 0.04fF
C2857 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49920_n1600# 0.26fF
C2858 pd_div_0/divbuf_0/a_38430_n1540# pd_div_0/divbuf_0/a_38910_n1540# 0.11fF
C2859 divbuf_2/a_9600_n1600# divbuf_2/a_9630_n840# 0.04fF
C2860 divbuf_4/a_32670_n840# divbuf_4/a_32670_n1540# 0.01fF
C2861 divbuf_4/a_1950_n1540# divbuf_4/a_2430_n1540# 0.11fF
C2862 pll_full_0/divbuf_1/a_41790_n1540# pll_full_0/divbuf_1/a_42270_n1540# 0.11fF
C2863 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.83fF
C2864 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/a_26832_n240# 0.05fF
C2865 divbuf_1/a_24892_n240# divbuf_1/a_25382_n240# 0.04fF
C2866 divbuf_2/a_60990_n840# divbuf_2/OUT5 0.04fF
C2867 divbuf_5/a_13742_n240# divbuf_5/a_14222_n240# 0.05fF
C2868 divbuf_5/a_33622_170# divbuf_5/a_33622_n240# 0.01fF
C2869 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_37950_n1540# 0.19fF
C2870 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C2871 ro_div_0/divbuf_0/a_7710_n840# ro_div_0/divbuf_0/a_7710_n1540# 0.01fF
C2872 ro_div_0/divbuf_0/a_37950_n840# ro_div_0/divbuf_0/a_38430_n840# 0.07fF
C2873 pd_div_0/divbuf_0/a_12282_170# pd_div_0/divbuf_0/a_12282_n240# 0.01fF
C2874 divbuf_1/a_9600_n1600# divbuf_1/OUT3 0.00fF
C2875 divbuf_1/a_36480_n1600# divbuf_1/a_36510_n1540# 0.19fF
C2876 divbuf_1/a_36510_n840# divbuf_1/a_36990_n840# 0.07fF
C2877 divbuf_1/a_6270_n840# divbuf_1/a_6270_n1540# 0.01fF
C2878 divbuf_5/a_28772_n240# divbuf_5/OUT4 0.04fF
C2879 divbuf_5/a_25440_n1600# divbuf_5/a_25470_n1540# 0.19fF
C2880 divbuf_5/a_25470_n840# divbuf_5/a_25950_n840# 0.07fF
C2881 divbuf_3/a_57630_n840# divbuf_3/a_57630_n1540# 0.01fF
C2882 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C2883 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36030_n840# 0.04fF
C2884 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2885 divbuf_2/a_6332_170# divbuf_2/a_6332_n240# 0.01fF
C2886 divbuf_2/a_26352_170# divbuf_2/a_26832_170# 0.07fF
C2887 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2888 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39390_n840# 0.04fF
C2889 divbuf_0/a_11312_n240# divbuf_0/a_11550_n840# 0.02fF
C2890 divbuf_0/a_20640_n1600# divbuf_0/a_21120_n1600# 0.26fF
C2891 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_13440_n1600# 0.26fF
C2892 divbuf_2/a_14702_170# divbuf_2/OUT4 0.19fF
C2893 divbuf_2/a_59520_n1600# divbuf_2/a_60000_n1600# 0.26fF
C2894 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/a_3390_n840# 0.05fF
C2895 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C2896 divbuf_0/a_12990_n1540# divbuf_0/a_13470_n1540# 0.11fF
C2897 divbuf_0/a_43710_n840# divbuf_0/a_43710_n1540# 0.01fF
C2898 divbuf_2/a_51870_n1540# divbuf_2/a_52350_n1540# 0.11fF
C2899 pll_full_0/divbuf_0/a_5310_n1540# pll_full_0/divbuf_0/a_5790_n1540# 0.11fF
C2900 pll_full_0/divbuf_0/a_36030_n840# pll_full_0/divbuf_0/a_36030_n1540# 0.01fF
C2901 divbuf_3/a_4392_170# divbuf_3/OUT3 0.19fF
C2902 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_14222_n240# 0.05fF
C2903 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/a_33622_n240# 0.01fF
C2904 divbuf_3/a_22080_n1600# divbuf_3/a_22560_n1600# 0.26fF
C2905 divbuf_3/a_12772_n240# divbuf_3/a_12990_n840# 0.02fF
C2906 divbuf_4/a_16152_170# divbuf_4/a_16642_170# 0.07fF
C2907 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_17612_n240# 0.04fF
C2908 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/a_37022_n240# 0.01fF
C2909 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2910 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25470_n1540# 0.19fF
C2911 pd_div_0/divbuf_0/a_25470_n840# pd_div_0/divbuf_0/a_25950_n840# 0.07fF
C2912 divbuf_4/a_49440_n1600# divbuf_4/a_49920_n1600# 0.26fF
C2913 divbuf_4/a_40412_n240# divbuf_4/a_40350_n840# 0.04fF
C2914 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C2915 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C2916 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C2917 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_28830_n1540# 0.19fF
C2918 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2919 pll_full_0/divbuf_1/a_28830_n840# pll_full_0/divbuf_1/a_29310_n840# 0.07fF
C2920 divbuf_3/a_45150_n840# divbuf_3/a_45150_n1540# 0.01fF
C2921 divbuf_3/a_14430_n1540# divbuf_3/a_14910_n1540# 0.11fF
C2922 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n840# 0.04fF
C2923 divbuf_1/a_4392_170# divbuf_1/a_4882_170# 0.07fF
C2924 divbuf_2/a_49440_n1600# divbuf_2/a_49470_n840# 0.04fF
C2925 divbuf_2/a_15672_n240# divbuf_2/OUT4 0.04fF
C2926 divbuf_4/a_41790_n1540# divbuf_4/a_42270_n1540# 0.11fF
C2927 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/A 0.21fF
C2928 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C2929 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_2910_n840# 0.04fF
C2930 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C2931 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C2932 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24960_n1600# 0.26fF
C2933 divbuf_1/a_13742_n240# divbuf_1/a_13950_n840# 0.02fF
C2934 divbuf_1/a_23040_n1600# divbuf_1/a_23520_n1600# 0.26fF
C2935 divbuf_5/a_12000_n1600# divbuf_5/a_12480_n1600# 0.26fF
C2936 divbuf_3/a_5362_n240# divbuf_3/OUT3 0.04fF
C2937 ro_div_0/divbuf_0/a_16830_n1540# ro_div_0/divbuf_0/a_17310_n1540# 0.11fF
C2938 ro_div_0/divbuf_0/a_47550_n840# ro_div_0/divbuf_0/a_47550_n1540# 0.01fF
C2939 divbuf_1/a_46110_n840# divbuf_1/a_46110_n1540# 0.01fF
C2940 divbuf_1/a_15390_n1540# divbuf_1/a_15870_n1540# 0.11fF
C2941 divbuf_5/a_35070_n840# divbuf_5/a_35070_n1540# 0.01fF
C2942 divbuf_5/a_4350_n1540# divbuf_5/a_4830_n1540# 0.11fF
C2943 divbuf_3/a_12000_n1600# divbuf_3/a_12030_n840# 0.04fF
C2944 divbuf_0/a_27322_170# divbuf_0/a_27802_170# 0.07fF
C2945 divbuf_2/a_27322_n240# divbuf_2/a_27802_n240# 0.05fF
C2946 divbuf_4/a_39360_n1600# divbuf_4/a_39390_n840# 0.04fF
C2947 divbuf_4/a_34592_170# divbuf_4/OUT4 0.19fF
C2948 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C2949 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/a_3912_n240# 0.01fF
C2950 divbuf_0/a_14222_170# divbuf_0/OUT4 0.19fF
C2951 pd_div_0/divider_0/prescaler_0/tspc_2/D pd_div_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C2952 divbuf_1/a_14702_170# divbuf_1/a_14222_170# 0.07fF
C2953 divbuf_2/a_38910_n840# divbuf_2/a_39390_n840# 0.07fF
C2954 divbuf_2/a_8670_n840# divbuf_2/a_8670_n1540# 0.01fF
C2955 divbuf_2/a_38880_n1600# divbuf_2/a_38910_n1540# 0.19fF
C2956 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C2957 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z2 0.40fF
C2958 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C2959 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/clk 0.05fF
C2960 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2961 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_53280_n1600# 0.26fF
C2962 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/a_20042_n240# 0.01fF
C2963 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/a_39932_170# 0.07fF
C2964 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14430_n840# 0.04fF
C2965 divbuf_0/a_52830_n1540# divbuf_0/a_53310_n1540# 0.11fF
C2966 divbuf_1/a_32652_170# divbuf_1/OUT4 0.19fF
C2967 divbuf_1/a_12960_n1600# divbuf_1/a_12990_n840# 0.04fF
C2968 divbuf_5/a_1920_n1600# divbuf_5/a_1950_n840# 0.04fF
C2969 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C2970 divbuf_3/a_28772_170# divbuf_3/a_29262_170# 0.07fF
C2971 divbuf_3/a_8762_170# divbuf_3/a_8762_n240# 0.01fF
C2972 pll_full_0/divbuf_0/a_45150_n1540# pll_full_0/divbuf_0/a_45630_n1540# 0.11fF
C2973 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12480_n1600# 0.26fF
C2974 divbuf_4/a_37022_170# divbuf_4/a_37022_n240# 0.01fF
C2975 divbuf_4/a_17122_n240# divbuf_4/a_17612_n240# 0.04fF
C2976 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/a_5790_n840# 0.04fF
C2977 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15840_n1600# 0.26fF
C2978 divbuf_3/a_1440_n1600# divbuf_3/a_1470_n1540# 0.19fF
C2979 divbuf_3/a_1470_n840# divbuf_3/a_1950_n840# 0.07fF
C2980 pd_div_0/divbuf_0/a_35070_n840# pd_div_0/divbuf_0/a_35070_n1540# 0.01fF
C2981 pd_div_0/divbuf_0/a_4350_n1540# pd_div_0/divbuf_0/a_4830_n1540# 0.11fF
C2982 divbuf_4/a_28830_n840# divbuf_4/a_29310_n840# 0.07fF
C2983 divbuf_4/a_35562_n240# divbuf_4/OUT4 0.04fF
C2984 divbuf_4/a_28800_n1600# divbuf_4/a_28830_n1540# 0.19fF
C2985 pll_full_0/divbuf_1/a_7710_n1540# pll_full_0/divbuf_1/a_8190_n1540# 0.11fF
C2986 pll_full_0/divbuf_1/a_38430_n840# pll_full_0/divbuf_1/a_38430_n1540# 0.01fF
C2987 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2988 divbuf_0/a_17612_n240# divbuf_0/OUT4 0.04fF
C2989 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n840# 0.04fF
C2990 divbuf_1/a_26352_170# divbuf_1/a_26832_170# 0.07fF
C2991 divbuf_5/a_18582_170# divbuf_5/a_19072_170# 0.07fF
C2992 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/OUT2 0.04fF
C2993 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_42750_n840# 0.04fF
C2994 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2995 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_3870_n1540# 0.19fF
C2996 ro_div_0/divbuf_0/a_3870_n840# ro_div_0/divbuf_0/a_4350_n840# 0.07fF
C2997 pd_div_0/pd_0/R pd_div_0/pd_0/UP 0.45fF
C2998 divbuf_1/a_2400_n1600# divbuf_1/a_2430_n1540# 0.19fF
C2999 divbuf_1/a_2430_n840# divbuf_1/a_2910_n840# 0.07fF
C3000 divbuf_5/a_51840_n1600# divbuf_5/a_52320_n1600# 0.26fF
C3001 divbuf_3/a_53760_n1600# divbuf_3/a_53790_n1540# 0.19fF
C3002 ro_div_0/divbuf_0/a_56670_n1540# ro_div_0/divbuf_0/a_57150_n1540# 0.11fF
C3003 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_1950_n840# 0.04fF
C3004 divbuf_1/a_55230_n1540# divbuf_1/a_55710_n1540# 0.11fF
C3005 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5310_n840# 0.04fF
C3006 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/a_36052_n240# 0.01fF
C3007 divbuf_3/a_51840_n1600# divbuf_3/a_51870_n840# 0.04fF
C3008 divbuf_5/a_44190_n1540# divbuf_5/a_44670_n1540# 0.11fF
C3009 divbuf_0/a_492_n240# divbuf_0/a_510_n840# 0.00fF
C3010 divbuf_0/a_28292_n240# divbuf_0/a_28772_n240# 0.05fF
C3011 divbuf_4/a_33600_n1600# divbuf_4/OUT4 0.01fF
C3012 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/a_21012_n240# 0.05fF
C3013 divbuf_2/a_16152_n240# divbuf_2/a_16350_n840# 0.02fF
C3014 divbuf_2/a_25440_n1600# divbuf_2/a_25920_n1600# 0.26fF
C3015 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/a_40412_n240# 0.01fF
C3016 gnd pll_full_0/divider_0/nor_0/Z1 0.01fF
C3017 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n1540# 0.19fF
C3018 divbuf_0/a_9630_n840# divbuf_0/a_9630_n1540# 0.01fF
C3019 divbuf_0/a_39870_n840# divbuf_0/a_40350_n840# 0.07fF
C3020 divbuf_1/a_28772_170# divbuf_1/a_28772_n240# 0.01fF
C3021 pll_full_0/divbuf_0/a_1950_n840# pll_full_0/divbuf_0/a_1950_n1540# 0.01fF
C3022 pll_full_0/divbuf_0/a_32190_n840# pll_full_0/divbuf_0/a_32670_n840# 0.07fF
C3023 divbuf_2/a_48510_n840# divbuf_2/a_48510_n1540# 0.01fF
C3024 divbuf_2/a_17790_n1540# divbuf_2/a_18270_n1540# 0.11fF
C3025 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/OUT2 0.01fF
C3026 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32190_n1540# 0.19fF
C3027 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3028 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54270_n840# 0.04fF
C3029 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/a_19072_170# 0.07fF
C3030 divbuf_1/a_52800_n1600# divbuf_1/a_52830_n840# 0.04fF
C3031 divbuf_1/a_22472_n240# divbuf_1/OUT4 0.04fF
C3032 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/a_1352_n240# 0.01fF
C3033 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/a_22472_170# 0.07fF
C3034 divbuf_3/a_29742_n240# divbuf_3/a_30232_n240# 0.04fF
C3035 divbuf_5/a_41760_n1600# divbuf_5/a_41790_n840# 0.04fF
C3036 divbuf_5/a_39442_170# divbuf_5/OUT4 0.19fF
C3037 divbuf_0/a_8762_170# divbuf_0/a_9242_170# 0.07fF
C3038 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C3039 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_52320_n1600# 0.26fF
C3040 divbuf_4/a_15360_n1600# divbuf_4/a_15840_n1600# 0.26fF
C3041 divbuf_4/a_5852_n240# divbuf_4/a_5790_n840# 0.04fF
C3042 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55680_n1600# 0.26fF
C3043 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/OUT3 0.19fF
C3044 divbuf_3/a_41280_n1600# divbuf_3/a_41310_n1540# 0.19fF
C3045 divbuf_3/a_41310_n840# divbuf_3/a_41790_n840# 0.07fF
C3046 divbuf_3/a_11070_n840# divbuf_3/a_11070_n1540# 0.01fF
C3047 pd_div_0/divbuf_0/a_44190_n1540# pd_div_0/divbuf_0/a_44670_n1540# 0.11fF
C3048 divbuf_2/a_15360_n1600# divbuf_2/a_15390_n840# 0.04fF
C3049 divbuf_4/a_38430_n840# divbuf_4/a_38430_n1540# 0.01fF
C3050 divbuf_4/a_7710_n1540# divbuf_4/a_8190_n1540# 0.11fF
C3051 pll_full_0/divbuf_1/a_47550_n1540# pll_full_0/divbuf_1/a_48030_n1540# 0.11fF
C3052 gnd pll_full_0/divider_0/tspc_0/Z3 0.27fF
C3053 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/a_32652_n240# 0.05fF
C3054 divbuf_1/a_30712_n240# divbuf_1/a_31202_n240# 0.04fF
C3055 divbuf_5/a_39442_170# divbuf_5/a_39442_n240# 0.01fF
C3056 divbuf_5/a_19562_n240# divbuf_5/a_20042_n240# 0.05fF
C3057 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C3058 ro_div_0/divbuf_0/a_13470_n840# ro_div_0/divbuf_0/a_13470_n1540# 0.01fF
C3059 ro_div_0/divbuf_0/a_43710_n840# ro_div_0/divbuf_0/a_44190_n840# 0.07fF
C3060 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_43710_n1540# 0.19fF
C3061 divbuf_1/a_42240_n1600# divbuf_1/a_42270_n1540# 0.19fF
C3062 divbuf_1/a_42270_n840# divbuf_1/a_42750_n840# 0.07fF
C3063 divbuf_1/a_12030_n840# divbuf_1/a_12030_n1540# 0.01fF
C3064 divbuf_1/a_20640_n1600# divbuf_1/OUT4 0.00fF
C3065 divbuf_5/a_31200_n1600# divbuf_5/a_31230_n1540# 0.19fF
C3066 divbuf_5/a_31230_n840# divbuf_5/a_31710_n840# 0.07fF
C3067 divbuf_5/a_990_n840# divbuf_5/a_990_n1540# 0.01fF
C3068 divbuf_5/a_40412_n240# divbuf_5/OUT4 0.04fF
C3069 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/Out 0.04fF
C3070 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_41790_n840# 0.04fF
C3071 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3072 divbuf_4/a_5280_n1600# divbuf_4/a_5310_n840# 0.04fF
C3073 divbuf_2/a_32172_170# divbuf_2/a_32652_170# 0.07fF
C3074 divbuf_2/a_12772_170# divbuf_2/a_12772_n240# 0.01fF
C3075 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45150_n840# 0.04fF
C3076 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C3077 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/a_4830_n840# 0.04fF
C3078 divbuf_0/a_17122_n240# divbuf_0/a_17310_n840# 0.02fF
C3079 divbuf_0/a_26400_n1600# divbuf_0/a_26880_n1600# 0.26fF
C3080 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/a_9150_n840# 0.03fF
C3081 divbuf_2/a_4830_n840# divbuf_2/a_5310_n840# 0.07fF
C3082 divbuf_2/a_4800_n1600# divbuf_2/a_4830_n1540# 0.19fF
C3083 divbuf_2/a_26352_170# divbuf_2/OUT4 0.19fF
C3084 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_19200_n1600# 0.26fF
C3085 divbuf_0/a_18750_n1540# divbuf_0/a_19230_n1540# 0.11fF
C3086 divbuf_0/a_49470_n840# divbuf_0/a_49470_n1540# 0.01fF
C3087 divbuf_2/a_57630_n1540# divbuf_2/a_58110_n1540# 0.11fF
C3088 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/a_41790_n1540# 0.01fF
C3089 pll_full_0/divbuf_0/a_11070_n1540# pll_full_0/divbuf_0/a_11550_n1540# 0.11fF
C3090 divbuf_3/a_16152_170# divbuf_3/OUT4 0.19fF
C3091 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/a_39442_n240# 0.01fF
C3092 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/a_20042_n240# 0.05fF
C3093 divbuf_4/a_21982_170# divbuf_4/a_22472_170# 0.07fF
C3094 divbuf_4/a_1352_170# divbuf_4/a_1352_n240# 0.01fF
C3095 divbuf_1/a_990_n840# divbuf_1/OUT2 0.02fF
C3096 divbuf_3/a_27840_n1600# divbuf_3/a_28320_n1600# 0.26fF
C3097 divbuf_3/a_18582_n240# divbuf_3/a_18750_n840# 0.02fF
C3098 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/a_23442_n240# 0.04fF
C3099 pd_0/UP divbuf_3/a_480_n1600# 0.00fF
C3100 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31230_n1540# 0.19fF
C3101 pd_div_0/divbuf_0/a_31230_n840# pd_div_0/divbuf_0/a_31710_n840# 0.07fF
C3102 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/a_990_n1540# 0.01fF
C3103 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3104 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_12282_170# 0.07fF
C3105 divbuf_4/a_5852_170# divbuf_4/OUT3 0.19fF
C3106 divbuf_4/a_55200_n1600# divbuf_4/a_55680_n1600# 0.26fF
C3107 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C3108 pll_full_0/divbuf_1/a_4350_n840# pll_full_0/divbuf_1/a_4350_n1540# 0.01fF
C3109 pll_full_0/divbuf_1/a_34590_n840# pll_full_0/divbuf_1/a_35070_n840# 0.07fF
C3110 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_34590_n1540# 0.19fF
C3111 divbuf_3/a_50910_n840# divbuf_3/a_50910_n1540# 0.01fF
C3112 divbuf_3/a_20190_n1540# divbuf_3/a_20670_n1540# 0.11fF
C3113 divbuf_0/a_10212_170# divbuf_0/OUT3 0.19fF
C3114 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n840# 0.04fF
C3115 divbuf_2/a_27322_n240# divbuf_2/OUT4 0.04fF
C3116 divbuf_2/a_55200_n1600# divbuf_2/a_55230_n840# 0.04fF
C3117 divbuf_4/a_47550_n1540# divbuf_4/a_48030_n1540# 0.11fF
C3118 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_8670_n840# 0.04fF
C3119 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_1/A 0.15fF
C3120 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C3121 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/a_21150_n840# 0.03fF
C3122 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30720_n1600# 0.26fF
C3123 divbuf_1/a_28800_n1600# divbuf_1/a_29280_n1600# 0.26fF
C3124 divbuf_1/a_19562_n240# divbuf_1/a_19710_n840# 0.03fF
C3125 divbuf_5/a_17760_n1600# divbuf_5/a_18240_n1600# 0.26fF
C3126 divbuf_5/a_8272_n240# divbuf_5/a_8190_n840# 0.03fF
C3127 divbuf_3/a_17122_n240# divbuf_3/OUT4 0.04fF
C3128 ro_div_0/divbuf_0/a_22590_n1540# ro_div_0/divbuf_0/a_23070_n1540# 0.11fF
C3129 ro_div_0/divbuf_0/a_53310_n840# ro_div_0/divbuf_0/a_53310_n1540# 0.01fF
C3130 divbuf_1/a_51870_n840# divbuf_1/a_51870_n1540# 0.01fF
C3131 divbuf_1/a_21150_n1540# divbuf_1/a_21630_n1540# 0.11fF
C3132 divbuf_5/a_40830_n840# divbuf_5/a_40830_n1540# 0.01fF
C3133 divbuf_5/a_10110_n1540# divbuf_5/a_10590_n1540# 0.11fF
C3134 divbuf_3/a_17760_n1600# divbuf_3/a_17790_n840# 0.04fF
C3135 divbuf_0/a_33142_170# divbuf_0/a_33622_170# 0.07fF
C3136 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/a_25862_170# 0.07fF
C3137 divbuf_2/a_33142_n240# divbuf_2/a_33622_n240# 0.05fF
C3138 divbuf_4/a_6822_n240# divbuf_4/OUT3 0.04fF
C3139 divbuf_4/a_45120_n1600# divbuf_4/a_45150_n840# 0.04fF
C3140 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_5852_170# 0.07fF
C3141 divbuf_0/a_28292_170# divbuf_0/OUT4 0.19fF
C3142 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n1540# 0.19fF
C3143 divbuf_0/a_5790_n840# divbuf_0/a_6270_n840# 0.07fF
C3144 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_7792_n240# 0.01fF
C3145 divbuf_1/a_16152_170# divbuf_1/a_16152_n240# 0.01fF
C3146 divbuf_1/a_5852_170# divbuf_1/a_5852_n240# 0.01fF
C3147 divbuf_2/a_44640_n1600# divbuf_2/a_44670_n1540# 0.19fF
C3148 divbuf_2/a_44670_n840# divbuf_2/a_45150_n840# 0.07fF
C3149 divbuf_2/a_14430_n840# divbuf_2/a_14430_n1540# 0.01fF
C3150 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_59040_n1600# 0.26fF
C3151 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/a_5852_n240# 0.04fF
C3152 divbuf_0/a_58590_n1540# divbuf_0/a_59070_n1540# 0.11fF
C3153 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20190_n840# 0.04fF
C3154 divbuf_1/a_18720_n1600# divbuf_1/a_18750_n840# 0.04fF
C3155 divbuf_1/a_10212_170# divbuf_1/OUT3 0.19fF
C3156 divbuf_3/a_15182_170# divbuf_3/a_15182_n240# 0.01fF
C3157 divbuf_3/a_34592_170# divbuf_3/a_35082_170# 0.07fF
C3158 divbuf_5/a_7680_n1600# divbuf_5/a_7710_n840# 0.04fF
C3159 pll_full_0/divbuf_0/a_50910_n1540# pll_full_0/divbuf_0/a_51390_n1540# 0.11fF
C3160 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_18240_n1600# 0.26fF
C3161 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/a_8190_n840# 0.03fF
C3162 divbuf_4/a_22952_n240# divbuf_4/a_23442_n240# 0.04fF
C3163 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_12030_n840# 0.02fF
C3164 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21600_n1600# 0.26fF
C3165 divbuf_3/a_7200_n1600# divbuf_3/a_7230_n1540# 0.19fF
C3166 divbuf_3/a_7230_n840# divbuf_3/a_7710_n840# 0.07fF
C3167 pd_div_0/divbuf_0/a_40830_n840# pd_div_0/divbuf_0/a_40830_n1540# 0.01fF
C3168 pd_div_0/divbuf_0/a_10110_n1540# pd_div_0/divbuf_0/a_10590_n1540# 0.11fF
C3169 divbuf_2/a_1352_n240# divbuf_2/a_1470_n840# 0.03fF
C3170 divbuf_4/a_34560_n1600# divbuf_4/a_34590_n1540# 0.19fF
C3171 divbuf_4/a_34590_n840# divbuf_4/a_35070_n840# 0.07fF
C3172 divbuf_4/a_4350_n840# divbuf_4/a_4350_n1540# 0.01fF
C3173 pll_full_0/divbuf_1/a_13470_n1540# pll_full_0/divbuf_1/a_13950_n1540# 0.11fF
C3174 pll_full_0/divbuf_1/a_44190_n840# pll_full_0/divbuf_1/a_44190_n1540# 0.01fF
C3175 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C3176 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n840# 0.04fF
C3177 divbuf_0/a_29262_n240# divbuf_0/OUT4 0.04fF
C3178 divbuf_1/a_35562_170# divbuf_1/a_36052_170# 0.07fF
C3179 divbuf_5/a_4392_170# divbuf_5/a_4392_n240# 0.01fF
C3180 divbuf_5/a_24412_170# divbuf_5/a_24892_170# 0.07fF
C3181 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48510_n840# 0.04fF
C3182 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3183 ro_div_0/divbuf_0/a_9630_n840# ro_div_0/divbuf_0/a_10110_n840# 0.07fF
C3184 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_9630_n1540# 0.19fF
C3185 pd_div_0/pd_0/UP pd_div_0/pd_0/and_pd_0/Out1 0.33fF
C3186 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/a_6822_170# 0.07fF
C3187 divbuf_1/a_8160_n1600# divbuf_1/a_8190_n1540# 0.19fF
C3188 divbuf_1/a_8190_n840# divbuf_1/a_8670_n840# 0.07fF
C3189 divbuf_1/a_29742_170# divbuf_1/OUT4 0.19fF
C3190 divbuf_5/a_10212_170# divbuf_5/OUT4 0.07fF
C3191 divbuf_5/a_57600_n1600# divbuf_5/a_58080_n1600# 0.26fF
C3192 divbuf_3/a_59520_n1600# divbuf_3/a_59550_n1540# 0.19fF
C3193 ro_div_0/divbuf_0/a_60990_n1540# ro_div_0/divbuf_0/OUT5 0.19fF
C3194 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_7710_n840# 0.04fF
C3195 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11070_n840# 0.04fF
C3196 divbuf_3/a_57600_n1600# divbuf_3/a_57630_n840# 0.04fF
C3197 divbuf_5/a_49950_n1540# divbuf_5/a_50430_n1540# 0.11fF
C3198 divbuf_0/a_34112_n240# divbuf_0/a_34592_n240# 0.05fF
C3199 divbuf_2/a_31200_n1600# divbuf_2/a_31680_n1600# 0.26fF
C3200 divbuf_2/a_21982_n240# divbuf_2/a_22110_n840# 0.03fF
C3201 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/a_26832_n240# 0.05fF
C3202 gnd pll_full_0/divider_0/nor_1/B 1.17fF
C3203 divbuf_0/a_15390_n840# divbuf_0/a_15390_n1540# 0.01fF
C3204 divbuf_0/a_45630_n840# divbuf_0/a_46110_n840# 0.07fF
C3205 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n1540# 0.19fF
C3206 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_37950_n1540# 0.19fF
C3207 divbuf_2/a_54270_n840# divbuf_2/a_54270_n1540# 0.01fF
C3208 divbuf_2/a_23550_n1540# divbuf_2/a_24030_n1540# 0.11fF
C3209 pll_full_0/divbuf_0/a_37950_n840# pll_full_0/divbuf_0/a_38430_n840# 0.07fF
C3210 pll_full_0/divbuf_0/a_7710_n840# pll_full_0/divbuf_0/a_7710_n1540# 0.01fF
C3211 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C3212 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60030_n840# 0.04fF
C3213 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3214 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/a_24892_170# 0.07fF
C3215 divbuf_1/a_34112_n240# divbuf_1/OUT4 0.04fF
C3216 divbuf_1/a_58560_n1600# divbuf_1/a_58590_n840# 0.04fF
C3217 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/a_7792_n240# 0.01fF
C3218 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/a_28292_170# 0.07fF
C3219 divbuf_3/a_35562_n240# divbuf_3/a_36052_n240# 0.04fF
C3220 divbuf_5/a_11802_n240# divbuf_5/OUT4 0.04fF
C3221 divbuf_5/a_47520_n1600# divbuf_5/a_47550_n840# 0.04fF
C3222 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z3 0.06fF
C3223 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Q 0.51fF
C3224 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/OUT3 0.19fF
C3225 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_58080_n1600# 0.26fF
C3226 divbuf_4/a_21120_n1600# divbuf_4/a_21600_n1600# 0.26fF
C3227 divbuf_4/a_11802_n240# divbuf_4/a_12030_n840# 0.02fF
C3228 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3229 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/a_990_n840# 0.07fF
C3230 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_510_n1540# 0.19fF
C3231 divbuf_3/a_47040_n1600# divbuf_3/a_47070_n1540# 0.19fF
C3232 divbuf_3/a_47070_n840# divbuf_3/a_47550_n840# 0.07fF
C3233 divbuf_3/a_16830_n840# divbuf_3/a_16830_n1540# 0.01fF
C3234 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C3235 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C3236 divbuf_0/a_2322_n240# divbuf_0/a_2430_n840# 0.03fF
C3237 pd_div_0/divbuf_0/a_49950_n1540# pd_div_0/divbuf_0/a_50430_n1540# 0.11fF
C3238 divbuf_4/a_44190_n840# divbuf_4/a_44190_n1540# 0.01fF
C3239 divbuf_4/a_13470_n1540# divbuf_4/a_13950_n1540# 0.11fF
C3240 pll_full_0/divbuf_1/a_53310_n1540# pll_full_0/divbuf_1/a_53790_n1540# 0.11fF
C3241 divbuf_2/a_21120_n1600# divbuf_2/a_21150_n840# 0.04fF
C3242 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_510_n1540# 0.11fF
C3243 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/a_38472_n240# 0.05fF
C3244 divbuf_1/a_36532_n240# divbuf_1/a_37022_n240# 0.04fF
C3245 divbuf_5/a_25382_n240# divbuf_5/a_25862_n240# 0.05fF
C3246 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49470_n1540# 0.19fF
C3247 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C3248 ro_div_0/divbuf_0/a_19230_n840# ro_div_0/divbuf_0/a_19230_n1540# 0.01fF
C3249 ro_div_0/divbuf_0/a_49470_n840# ro_div_0/divbuf_0/a_49950_n840# 0.07fF
C3250 divbuf_1/a_32160_n1600# divbuf_1/OUT4 0.00fF
C3251 divbuf_1/a_48000_n1600# divbuf_1/a_48030_n1540# 0.19fF
C3252 divbuf_1/a_48030_n840# divbuf_1/a_48510_n840# 0.07fF
C3253 divbuf_1/a_17790_n840# divbuf_1/a_17790_n1540# 0.01fF
C3254 divbuf_5/a_36990_n840# divbuf_5/a_37470_n840# 0.07fF
C3255 divbuf_5/a_6750_n840# divbuf_5/a_6750_n1540# 0.01fF
C3256 divbuf_5/a_10560_n1600# divbuf_5/OUT3 0.01fF
C3257 divbuf_5/a_36960_n1600# divbuf_5/a_36990_n1540# 0.19fF
C3258 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C3259 ro_div_0/divider_0/tspc_2/Z2 ro_div_0/divider_0/tspc_2/Z3 0.16fF
C3260 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z4 0.22fF
C3261 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3262 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_47550_n840# 0.04fF
C3263 divbuf_4/a_11040_n1600# divbuf_4/a_11070_n840# 0.04fF
C3264 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3265 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_50910_n840# 0.04fF
C3266 divbuf_2/a_18582_170# divbuf_2/a_18582_n240# 0.01fF
C3267 divbuf_2/a_37992_170# divbuf_2/a_38472_170# 0.07fF
C3268 divbuf_0/a_22952_n240# divbuf_0/a_23070_n840# 0.03fF
C3269 divbuf_0/a_32160_n1600# divbuf_0/a_32640_n1600# 0.26fF
C3270 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24960_n1600# 0.26fF
C3271 divbuf_2/a_10560_n1600# divbuf_2/a_10590_n1540# 0.19fF
C3272 divbuf_2/a_37992_170# divbuf_2/OUT4 0.19fF
C3273 divbuf_2/a_10590_n840# divbuf_2/a_11070_n840# 0.07fF
C3274 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_15390_n840# 0.02fF
C3275 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_1/B 0.18fF
C3276 divbuf_0/a_24510_n1540# divbuf_0/a_24990_n1540# 0.11fF
C3277 divbuf_0/a_55230_n840# divbuf_0/a_55230_n1540# 0.01fF
C3278 pll_full_0/divbuf_0/a_16830_n1540# pll_full_0/divbuf_0/a_17310_n1540# 0.11fF
C3279 pll_full_0/divbuf_0/a_47550_n840# pll_full_0/divbuf_0/a_47550_n1540# 0.01fF
C3280 divbuf_2/OUT3 divbuf_2/OUT4 0.36fF
C3281 divbuf_3/a_27802_170# divbuf_3/OUT4 0.19fF
C3282 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/a_25862_n240# 0.05fF
C3283 divbuf_4/a_27802_170# divbuf_4/a_28292_170# 0.07fF
C3284 divbuf_4/a_7792_170# divbuf_4/a_7792_n240# 0.01fF
C3285 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/a_29262_n240# 0.04fF
C3286 divbuf_3/a_24412_n240# divbuf_3/a_24510_n840# 0.03fF
C3287 divbuf_3/a_33600_n1600# divbuf_3/a_34080_n1600# 0.26fF
C3288 pd_div_0/divbuf_0/a_36990_n840# pd_div_0/divbuf_0/a_37470_n840# 0.07fF
C3289 pd_div_0/divbuf_0/a_6750_n840# pd_div_0/divbuf_0/a_6750_n1540# 0.01fF
C3290 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/OUT3 0.01fF
C3291 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_36990_n1540# 0.19fF
C3292 divbuf_3/a_25950_n1540# divbuf_3/a_26430_n1540# 0.11fF
C3293 divbuf_4/a_480_n1600# divbuf_4/a_510_n1540# 0.19fF
C3294 divbuf_4/a_510_n840# divbuf_4/a_990_n840# 0.07fF
C3295 divbuf_4/a_17612_170# divbuf_4/OUT4 0.19fF
C3296 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40350_n1540# 0.19fF
C3297 pll_full_0/divbuf_1/a_10110_n840# pll_full_0/divbuf_1/a_10110_n1540# 0.01fF
C3298 pll_full_0/divbuf_1/a_40350_n840# pll_full_0/divbuf_1/a_40830_n840# 0.07fF
C3299 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n840# 0.04fF
C3300 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/and_0/A 0.80fF
C3301 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C3302 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14430_n840# 0.04fF
C3303 divbuf_2/a_38962_n240# divbuf_2/OUT4 0.04fF
C3304 divbuf_4/a_53310_n1540# divbuf_4/a_53790_n1540# 0.11fF
C3305 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C3306 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C3307 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C3308 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36480_n1600# 0.26fF
C3309 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/a_26910_n840# 0.04fF
C3310 divbuf_1/a_25382_n240# divbuf_1/a_25470_n840# 0.03fF
C3311 divbuf_1/a_34560_n1600# divbuf_1/a_35040_n1600# 0.26fF
C3312 divbuf_5/a_14222_n240# divbuf_5/a_14430_n840# 0.02fF
C3313 divbuf_5/a_23520_n1600# divbuf_5/a_24000_n1600# 0.26fF
C3314 divbuf_3/a_28772_n240# divbuf_3/OUT4 0.04fF
C3315 ro_div_0/divbuf_0/a_28350_n1540# ro_div_0/divbuf_0/a_28830_n1540# 0.11fF
C3316 ro_div_0/divbuf_0/a_59070_n840# ro_div_0/divbuf_0/a_59070_n1540# 0.01fF
C3317 divbuf_1/a_57630_n840# divbuf_1/a_57630_n1540# 0.01fF
C3318 divbuf_1/a_26910_n1540# divbuf_1/a_27390_n1540# 0.11fF
C3319 divbuf_3/a_23520_n1600# divbuf_3/a_23550_n840# 0.04fF
C3320 divbuf_5/a_46590_n840# divbuf_5/a_46590_n1540# 0.01fF
C3321 divbuf_5/a_15870_n1540# divbuf_5/a_16350_n1540# 0.11fF
C3322 divbuf_0/a_38962_170# divbuf_0/a_39442_170# 0.07fF
C3323 divbuf_2/a_38962_n240# divbuf_2/a_39442_n240# 0.05fF
C3324 divbuf_4/a_50880_n1600# divbuf_4/a_50910_n840# 0.04fF
C3325 divbuf_4/a_18582_n240# divbuf_4/OUT4 0.04fF
C3326 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/a_31682_170# 0.07fF
C3327 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3328 divbuf_0/a_11550_n840# divbuf_0/a_12030_n840# 0.07fF
C3329 divbuf_0/a_39932_170# divbuf_0/OUT4 0.19fF
C3330 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n1540# 0.19fF
C3331 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3332 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_3870_n1540# 0.19fF
C3333 divbuf_2/a_50430_n840# divbuf_2/a_50910_n840# 0.07fF
C3334 divbuf_2/a_20190_n840# divbuf_2/a_20190_n1540# 0.01fF
C3335 divbuf_2/a_50400_n1600# divbuf_2/a_50430_n1540# 0.19fF
C3336 pll_full_0/divbuf_0/a_3870_n840# pll_full_0/divbuf_0/a_4350_n840# 0.07fF
C3337 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_12282_n240# 0.05fF
C3338 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_25950_n840# 0.04fF
C3339 divbuf_1/a_3912_170# divbuf_1/OUT3 0.19fF
C3340 divbuf_1/a_24480_n1600# divbuf_1/a_24510_n840# 0.04fF
C3341 divbuf_3/a_40412_170# divbuf_3/a_40902_170# 0.07fF
C3342 divbuf_3/a_21012_170# divbuf_3/a_21012_n240# 0.01fF
C3343 divbuf_5/a_13440_n1600# divbuf_5/a_13470_n840# 0.04fF
C3344 pll_full_0/divbuf_0/a_56670_n1540# pll_full_0/divbuf_0/a_57150_n1540# 0.11fF
C3345 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_14430_n840# 0.02fF
C3346 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_24000_n1600# 0.26fF
C3347 divbuf_4/a_28772_n240# divbuf_4/a_29262_n240# 0.04fF
C3348 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_17790_n840# 0.02fF
C3349 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_27360_n1600# 0.26fF
C3350 divbuf_3/a_12960_n1600# divbuf_3/a_12990_n1540# 0.19fF
C3351 divbuf_3/a_12990_n840# divbuf_3/a_13470_n840# 0.07fF
C3352 pd_div_0/divbuf_0/a_46590_n840# pd_div_0/divbuf_0/a_46590_n1540# 0.01fF
C3353 pd_div_0/divbuf_0/a_15870_n1540# pd_div_0/divbuf_0/a_16350_n1540# 0.11fF
C3354 divbuf_4/a_40350_n840# divbuf_4/a_40830_n840# 0.07fF
C3355 divbuf_4/a_10110_n840# divbuf_4/a_10110_n1540# 0.01fF
C3356 divbuf_4/a_40320_n1600# divbuf_4/a_40350_n1540# 0.19fF
C3357 pll_full_0/divbuf_1/a_19230_n1540# pll_full_0/divbuf_1/a_19710_n1540# 0.11fF
C3358 pll_full_0/divbuf_1/a_49950_n840# pll_full_0/divbuf_1/a_49950_n1540# 0.01fF
C3359 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3360 divbuf_0/a_40902_n240# divbuf_0/OUT4 0.04fF
C3361 divbuf_0/a_480_n1600# divbuf_0/IN 0.00fF
C3362 divbuf_5/a_30232_170# divbuf_5/a_30712_170# 0.07fF
C3363 divbuf_5/a_10212_170# divbuf_5/a_10212_n240# 0.01fF
C3364 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3365 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54270_n840# 0.04fF
C3366 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15390_n1540# 0.19fF
C3367 ro_div_0/divbuf_0/a_15390_n840# ro_div_0/divbuf_0/a_15870_n840# 0.07fF
C3368 divbuf_1/a_5362_n240# divbuf_1/OUT3 0.04fF
C3369 divbuf_1/a_13920_n1600# divbuf_1/a_13950_n1540# 0.19fF
C3370 divbuf_1/a_13950_n840# divbuf_1/a_14430_n840# 0.07fF
C3371 divbuf_5/a_2880_n1600# divbuf_5/a_2910_n1540# 0.19fF
C3372 divbuf_5/a_22472_170# divbuf_5/OUT4 0.19fF
C3373 divbuf_5/a_2910_n840# divbuf_5/a_3390_n840# 0.07fF
C3374 divbuf_0/a_17122_170# divbuf_0/a_17612_170# 0.07fF
C3375 ro_complete_0/a5 ro_complete_0/cbank_0/switch_0/vin 0.09fF
C3376 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13470_n840# 0.04fF
C3377 divbuf_5/a_55710_n1540# divbuf_5/a_56190_n1540# 0.11fF
C3378 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_16830_n840# 0.04fF
C3379 divbuf_0/a_39932_n240# divbuf_0/a_40412_n240# 0.05fF
C3380 divbuf_2/a_27802_n240# divbuf_2/a_27870_n840# 0.04fF
C3381 divbuf_2/a_36960_n1600# divbuf_2/a_37440_n1600# 0.26fF
C3382 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/a_32652_n240# 0.05fF
C3383 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C3384 gnd pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.44fF
C3385 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n1540# 0.19fF
C3386 divbuf_0/a_21150_n840# divbuf_0/a_21150_n1540# 0.01fF
C3387 divbuf_0/a_51390_n840# divbuf_0/a_51870_n840# 0.07fF
C3388 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C3389 pll_full_0/divbuf_0/a_13470_n840# pll_full_0/divbuf_0/a_13470_n1540# 0.01fF
C3390 pll_full_0/divbuf_0/a_43710_n840# pll_full_0/divbuf_0/a_44190_n840# 0.07fF
C3391 divbuf_2/a_60030_n840# divbuf_2/a_60030_n1540# 0.01fF
C3392 divbuf_2/a_29310_n1540# divbuf_2/a_29790_n1540# 0.11fF
C3393 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_43710_n1540# 0.19fF
C3394 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/a_30712_170# 0.07fF
C3395 divbuf_3/a_56670_n1540# divbuf_3/a_57150_n1540# 0.11fF
C3396 divbuf_5/a_53280_n1600# divbuf_5/a_53310_n840# 0.04fF
C3397 divbuf_5/a_23442_n240# divbuf_5/OUT4 0.04fF
C3398 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/a_34112_170# 0.07fF
C3399 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/a_14222_n240# 0.01fF
C3400 ro_complete_0/a1 ro_complete_0/cbank_0/switch_3/vin 0.14fF
C3401 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/a3 0.09fF
C3402 ro_div_0/divider_0/tspc_1/Z3 ro_div_0/divider_0/tspc_1/Z4 0.65fF
C3403 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C3404 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/and_0/B 0.78fF
C3405 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_2910_n1540# 0.19fF
C3406 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3407 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/a_3390_n840# 0.07fF
C3408 divbuf_4/a_26880_n1600# divbuf_4/a_27360_n1600# 0.26fF
C3409 divbuf_4/a_17612_n240# divbuf_4/a_17790_n840# 0.02fF
C3410 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3411 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6270_n1540# 0.19fF
C3412 pll_full_0/divbuf_1/a_6270_n840# pll_full_0/divbuf_1/a_6750_n840# 0.07fF
C3413 divbuf_3/a_52830_n840# divbuf_3/a_53310_n840# 0.07fF
C3414 divbuf_3/a_22590_n840# divbuf_3/a_22590_n1540# 0.01fF
C3415 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C3416 pd_div_0/divbuf_0/a_55710_n1540# pd_div_0/divbuf_0/a_56190_n1540# 0.11fF
C3417 divbuf_4/a_49950_n840# divbuf_4/a_49950_n1540# 0.01fF
C3418 divbuf_4/a_19230_n1540# divbuf_4/a_19710_n1540# 0.11fF
C3419 pll_full_0/divbuf_1/a_59070_n1540# pll_full_0/divbuf_1/a_59550_n1540# 0.11fF
C3420 divbuf_2/a_26880_n1600# divbuf_2/a_26910_n840# 0.04fF
C3421 divbuf_2/a_9242_170# divbuf_2/OUT3 0.19fF
C3422 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_3422_170# 0.07fF
C3423 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_2400_n1600# 0.26fF
C3424 divbuf_1/a_480_n1600# divbuf_1/a_960_n1600# 0.26fF
C3425 divbuf_5/a_31202_n240# divbuf_5/a_31682_n240# 0.05fF
C3426 ro_div_0/divbuf_0/a_24990_n840# ro_div_0/divbuf_0/a_24990_n1540# 0.01fF
C3427 ro_div_0/divbuf_0/a_55230_n840# ro_div_0/divbuf_0/a_55710_n840# 0.07fF
C3428 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55230_n1540# 0.19fF
C3429 divbuf_1/a_53760_n1600# divbuf_1/a_53790_n1540# 0.19fF
C3430 divbuf_1/a_53790_n840# divbuf_1/a_54270_n840# 0.07fF
C3431 divbuf_1/a_23550_n840# divbuf_1/a_23550_n1540# 0.01fF
C3432 divbuf_5/a_42720_n1600# divbuf_5/a_42750_n1540# 0.19fF
C3433 divbuf_5/a_42750_n840# divbuf_5/a_43230_n840# 0.07fF
C3434 divbuf_5/a_12510_n840# divbuf_5/a_12510_n1540# 0.01fF
C3435 divbuf_5/a_21600_n1600# divbuf_5/OUT4 0.01fF
C3436 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C3437 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53310_n840# 0.04fF
C3438 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3439 divbuf_2/a_3912_n240# divbuf_2/a_4392_n240# 0.05fF
C3440 divbuf_2/a_24412_170# divbuf_2/a_24412_n240# 0.01fF
C3441 divbuf_4/a_16800_n1600# divbuf_4/a_16830_n840# 0.04fF
C3442 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_56670_n840# 0.04fF
C3443 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3444 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_16830_n840# 0.02fF
C3445 divbuf_0/a_28772_n240# divbuf_0/a_28830_n840# 0.04fF
C3446 divbuf_0/a_37920_n1600# divbuf_0/a_38400_n1600# 0.26fF
C3447 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C3448 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/a_21150_n840# 0.03fF
C3449 divbuf_2/a_16350_n840# divbuf_2/a_16830_n840# 0.07fF
C3450 divbuf_2/a_10212_n240# divbuf_2/OUT3 0.04fF
C3451 divbuf_2/a_16320_n1600# divbuf_2/a_16350_n1540# 0.19fF
C3452 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30720_n1600# 0.26fF
C3453 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C3454 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/a_18582_170# 0.07fF
C3455 divbuf_0/a_30270_n1540# divbuf_0/a_30750_n1540# 0.11fF
C3456 divbuf_0/a_60990_n840# divbuf_0/a_60990_n1540# 0.01fF
C3457 divbuf_1/a_11312_n240# divbuf_1/a_11070_n840# 0.02fF
C3458 divbuf_3/a_5362_170# divbuf_3/a_5852_170# 0.07fF
C3459 pll_full_0/divbuf_0/a_53310_n840# pll_full_0/divbuf_0/a_53310_n1540# 0.01fF
C3460 pll_full_0/divbuf_0/a_22590_n1540# pll_full_0/divbuf_0/a_23070_n1540# 0.11fF
C3461 divbuf_3/a_39442_170# divbuf_3/OUT4 0.19fF
C3462 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/a_31682_n240# 0.05fF
C3463 divbuf_4/a_14222_170# divbuf_4/a_14222_n240# 0.01fF
C3464 divbuf_4/a_33622_170# divbuf_4/a_34112_170# 0.07fF
C3465 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/a_35082_n240# 0.04fF
C3466 divbuf_3/a_39360_n1600# divbuf_3/a_39840_n1600# 0.26fF
C3467 divbuf_3/a_30232_n240# divbuf_3/a_30270_n840# 0.05fF
C3468 divbuf_0/a_5362_170# divbuf_0/a_5362_n240# 0.01fF
C3469 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_42750_n1540# 0.19fF
C3470 pd_div_0/divbuf_0/a_42750_n840# pd_div_0/divbuf_0/a_43230_n840# 0.07fF
C3471 pd_div_0/divbuf_0/a_12510_n840# pd_div_0/divbuf_0/a_12510_n1540# 0.01fF
C3472 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C3473 divbuf_4/a_6270_n840# divbuf_4/a_6750_n840# 0.07fF
C3474 divbuf_4/a_6240_n1600# divbuf_4/a_6270_n1540# 0.19fF
C3475 divbuf_4/a_29262_170# divbuf_4/OUT4 0.19fF
C3476 divbuf_3/a_31710_n1540# divbuf_3/a_32190_n1540# 0.11fF
C3477 pll_full_0/divbuf_1/a_15870_n840# pll_full_0/divbuf_1/a_15870_n1540# 0.01fF
C3478 pll_full_0/divbuf_1/a_46110_n840# pll_full_0/divbuf_1/a_46590_n840# 0.07fF
C3479 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46110_n1540# 0.19fF
C3480 divbuf_0/a_11312_170# divbuf_0/OUT4 0.23fF
C3481 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n840# 0.04fF
C3482 pd_div_0/divider_0/and_0/OUT gnd 0.32fF
C3483 divbuf_1/a_9732_170# divbuf_1/a_9242_170# 0.07fF
C3484 divbuf_2/a_9120_n1600# divbuf_2/OUT3 0.00fF
C3485 divbuf_4/a_59070_n1540# divbuf_4/a_59550_n1540# 0.11fF
C3486 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20190_n840# 0.04fF
C3487 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/a_18092_n240# 0.01fF
C3488 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/a_32670_n840# 0.06fF
C3489 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_42240_n1600# 0.26fF
C3490 divbuf_1/a_40320_n1600# divbuf_1/a_40800_n1600# 0.26fF
C3491 divbuf_1/a_16152_170# divbuf_1/OUT4 0.19fF
C3492 divbuf_1/a_31202_n240# divbuf_1/a_31230_n840# 0.05fF
C3493 divbuf_5/a_29280_n1600# divbuf_5/a_29760_n1600# 0.26fF
C3494 divbuf_5/a_20042_n240# divbuf_5/a_20190_n840# 0.03fF
C3495 divbuf_3/a_40412_n240# divbuf_3/OUT4 0.04fF
C3496 ro_div_0/divbuf_0/a_34110_n1540# ro_div_0/divbuf_0/a_34590_n1540# 0.11fF
C3497 divbuf_1/a_32670_n1540# divbuf_1/a_33150_n1540# 0.11fF
C3498 divbuf_3/a_29280_n1600# divbuf_3/a_29310_n840# 0.04fF
C3499 divbuf_5/a_52350_n840# divbuf_5/a_52350_n1540# 0.01fF
C3500 divbuf_5/a_21630_n1540# divbuf_5/a_22110_n1540# 0.11fF
C3501 divbuf_0/a_4882_n240# divbuf_0/a_5362_n240# 0.05fF
C3502 divbuf_0/a_25382_170# divbuf_0/a_25382_n240# 0.01fF
C3503 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/a_37502_170# 0.07fF
C3504 divbuf_2/a_2880_n1600# divbuf_2/a_3360_n1600# 0.26fF
C3505 divbuf_4/a_30232_n240# divbuf_4/OUT4 0.04fF
C3506 divbuf_4/a_56640_n1600# divbuf_4/a_56670_n840# 0.04fF
C3507 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3508 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n1540# 0.19fF
C3509 divbuf_0/a_12282_n240# divbuf_0/OUT4 0.04fF
C3510 divbuf_0/a_17310_n840# divbuf_0/a_17790_n840# 0.07fF
C3511 divbuf_1/a_492_n240# divbuf_1/a_960_n1600# 0.00fF
C3512 divbuf_1/a_6822_170# divbuf_1/a_6822_n240# 0.01fF
C3513 divbuf_1/a_1842_170# divbuf_1/a_1842_n240# 0.01fF
C3514 pll_full_0/divbuf_0/a_9630_n840# pll_full_0/divbuf_0/a_10110_n840# 0.07fF
C3515 divbuf_2/a_56160_n1600# divbuf_2/a_56190_n1540# 0.19fF
C3516 divbuf_2/a_56190_n840# divbuf_2/a_56670_n840# 0.07fF
C3517 divbuf_2/a_25950_n840# divbuf_2/a_25950_n1540# 0.01fF
C3518 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_9630_n1540# 0.19fF
C3519 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3520 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_18092_n240# 0.05fF
C3521 ro_div_0/divider_0/nor_1/Z1 gnd 0.01fF
C3522 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_31710_n840# 0.04fF
C3523 pll_full_0/divbuf_0/a_60990_n1540# pll_full_0/divbuf_0/OUT5 0.19fF
C3524 divbuf_1/a_13742_170# divbuf_1/OUT4 0.19fF
C3525 divbuf_1/a_30240_n1600# divbuf_1/a_30270_n840# 0.04fF
C3526 divbuf_3/a_26832_170# divbuf_3/a_26832_n240# 0.01fF
C3527 divbuf_3/a_6332_n240# divbuf_3/a_6822_n240# 0.04fF
C3528 divbuf_5/a_19200_n1600# divbuf_5/a_19230_n840# 0.04fF
C3529 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29760_n1600# 0.26fF
C3530 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/a_20190_n840# 0.03fF
C3531 divbuf_3/a_18720_n1600# divbuf_3/a_18750_n1540# 0.19fF
C3532 divbuf_3/a_18750_n840# divbuf_3/a_19230_n840# 0.07fF
C3533 divbuf_4/a_34592_n240# divbuf_4/a_35082_n240# 0.04fF
C3534 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/a_23550_n840# 0.03fF
C3535 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_33120_n1600# 0.26fF
C3536 pd_div_0/divbuf_0/a_52350_n840# pd_div_0/divbuf_0/a_52350_n1540# 0.01fF
C3537 pd_div_0/divbuf_0/a_21630_n1540# pd_div_0/divbuf_0/a_22110_n1540# 0.11fF
C3538 divbuf_2/a_13742_n240# divbuf_2/a_13470_n840# 0.01fF
C3539 divbuf_4/a_46080_n1600# divbuf_4/a_46110_n1540# 0.19fF
C3540 divbuf_4/a_46110_n840# divbuf_4/a_46590_n840# 0.07fF
C3541 divbuf_4/a_15870_n840# divbuf_4/a_15870_n1540# 0.01fF
C3542 pll_full_0/divbuf_1/a_24990_n1540# pll_full_0/divbuf_1/a_25470_n1540# 0.11fF
C3543 pll_full_0/divbuf_1/a_55710_n840# pll_full_0/divbuf_1/a_55710_n1540# 0.01fF
C3544 divbuf_0/a_11040_n1600# divbuf_0/OUT3 0.00fF
C3545 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60030_n840# 0.04fF
C3546 divbuf_1/a_7302_n240# divbuf_1/a_7792_n240# 0.04fF
C3547 divbuf_5/a_16642_170# divbuf_5/a_16642_n240# 0.01fF
C3548 divbuf_5/a_36052_170# divbuf_5/a_36532_170# 0.07fF
C3549 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3550 ro_div_0/divbuf_0/a_21150_n840# ro_div_0/divbuf_0/a_21630_n840# 0.07fF
C3551 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21150_n1540# 0.19fF
C3552 divbuf_1/a_19680_n1600# divbuf_1/a_19710_n1540# 0.19fF
C3553 divbuf_1/a_19710_n840# divbuf_1/a_20190_n840# 0.07fF
C3554 divbuf_1/a_17122_n240# divbuf_1/OUT4 0.04fF
C3555 divbuf_5/a_8640_n1600# divbuf_5/a_8670_n1540# 0.19fF
C3556 divbuf_5/a_34112_170# divbuf_5/OUT4 0.19fF
C3557 divbuf_5/a_8670_n840# divbuf_5/a_9150_n840# 0.07fF
C3558 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a2 0.09fF
C3559 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19230_n840# 0.04fF
C3560 divbuf_2/a_8762_170# divbuf_2/a_9242_170# 0.07fF
C3561 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_22590_n840# 0.04fF
C3562 divbuf_0/a_3840_n1600# divbuf_0/a_4320_n1600# 0.26fF
C3563 divbuf_2/a_42720_n1600# divbuf_2/a_43200_n1600# 0.26fF
C3564 divbuf_2/a_33622_n240# divbuf_2/a_33630_n840# 0.06fF
C3565 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/a_38472_n240# 0.05fF
C3566 gnd pll_full_0/divider_0/tspc_2/Z2 0.16fF
C3567 divbuf_0/a_26910_n840# divbuf_0/a_26910_n1540# 0.01fF
C3568 divbuf_0/a_57150_n840# divbuf_0/a_57630_n840# 0.07fF
C3569 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n1540# 0.19fF
C3570 divbuf_2/a_35070_n1540# divbuf_2/a_35550_n1540# 0.11fF
C3571 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49470_n1540# 0.19fF
C3572 pll_full_0/divbuf_0/a_49470_n840# pll_full_0/divbuf_0/a_49950_n840# 0.07fF
C3573 pll_full_0/divbuf_0/a_19230_n840# pll_full_0/divbuf_0/a_19230_n1540# 0.01fF
C3574 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C3575 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/a_16642_n240# 0.01fF
C3576 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/a_36532_170# 0.07fF
C3577 divbuf_3/a_60990_n1540# divbuf_3/OUT5 0.19fF
C3578 divbuf_5/a_35082_n240# divbuf_5/OUT4 0.04fF
C3579 divbuf_5/a_59040_n1600# divbuf_5/a_59070_n840# 0.04fF
C3580 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/a_20042_n240# 0.01fF
C3581 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/a_39932_170# 0.07fF
C3582 divbuf_3/a_5280_n1600# divbuf_3/a_5760_n1600# 0.26fF
C3583 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C3584 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/and_0/B 0.31fF
C3585 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z2 0.14fF
C3586 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C3587 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_8670_n1540# 0.19fF
C3588 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3589 pd_div_0/divbuf_0/a_8670_n840# pd_div_0/divbuf_0/a_9150_n840# 0.07fF
C3590 divbuf_4/a_32640_n1600# divbuf_4/a_33120_n1600# 0.26fF
C3591 divbuf_4/a_23442_n240# divbuf_4/a_23550_n840# 0.03fF
C3592 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/OUT2 0.07fF
C3593 pll_full_0/divbuf_1/a_12030_n840# pll_full_0/divbuf_1/a_12510_n840# 0.07fF
C3594 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3595 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12030_n1540# 0.19fF
C3596 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/a_1950_n840# 0.03fF
C3597 divbuf_3/a_58590_n840# divbuf_3/a_59070_n840# 0.07fF
C3598 divbuf_3/a_28350_n840# divbuf_3/a_28350_n1540# 0.01fF
C3599 divbuf_0/a_14702_n240# divbuf_0/a_14430_n840# 0.01fF
C3600 divbuf_2/a_32640_n1600# divbuf_2/a_32670_n840# 0.04fF
C3601 divbuf_2/a_21012_170# divbuf_2/OUT4 0.19fF
C3602 divbuf_4/a_55710_n840# divbuf_4/a_55710_n1540# 0.01fF
C3603 divbuf_4/a_24990_n1540# divbuf_4/a_25470_n1540# 0.11fF
C3604 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C3605 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C3606 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_8160_n1600# 0.26fF
C3607 divbuf_1/a_6240_n1600# divbuf_1/a_6720_n1600# 0.26fF
C3608 divbuf_5/a_37022_n240# divbuf_5/a_37502_n240# 0.05fF
C3609 divbuf_3/a_10212_170# divbuf_3/OUT4 0.07fF
C3610 ro_div_0/divbuf_0/a_30750_n840# ro_div_0/divbuf_0/a_30750_n1540# 0.01fF
C3611 divbuf_1/a_59520_n1600# divbuf_1/a_59550_n1540# 0.19fF
C3612 divbuf_1/a_59550_n840# divbuf_1/a_60030_n840# 0.07fF
C3613 divbuf_1/a_29310_n840# divbuf_1/a_29310_n1540# 0.01fF
C3614 divbuf_5/a_48510_n840# divbuf_5/a_48990_n840# 0.07fF
C3615 divbuf_5/a_18270_n840# divbuf_5/a_18270_n1540# 0.01fF
C3616 divbuf_5/a_33120_n1600# divbuf_5/OUT4 0.01fF
C3617 divbuf_5/a_48480_n1600# divbuf_5/a_48510_n1540# 0.19fF
C3618 divbuf_3/a_16152_n240# divbuf_3/a_15870_n840# 0.01fF
C3619 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3620 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59070_n840# 0.04fF
C3621 divbuf_2/a_30232_170# divbuf_2/a_30232_n240# 0.01fF
C3622 divbuf_2/a_9732_n240# divbuf_2/a_10212_n240# 0.05fF
C3623 divbuf_4/a_22560_n1600# divbuf_4/a_22590_n840# 0.04fF
C3624 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/OUT5 0.04fF
C3625 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C3626 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C3627 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C3628 divbuf_0/a_34592_n240# divbuf_0/a_34590_n840# 0.06fF
C3629 divbuf_0/a_43680_n1600# divbuf_0/a_44160_n1600# 0.26fF
C3630 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/nor_1/A 0.55fF
C3631 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C3632 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36480_n1600# 0.26fF
C3633 divbuf_2/a_22080_n1600# divbuf_2/a_22110_n1540# 0.19fF
C3634 divbuf_2/a_22110_n840# divbuf_2/a_22590_n840# 0.07fF
C3635 divbuf_2/a_21982_n240# divbuf_2/OUT4 0.04fF
C3636 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/a_26910_n840# 0.04fF
C3637 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/a_22952_170# 0.07fF
C3638 divbuf_0/a_36030_n1540# divbuf_0/a_36510_n1540# 0.11fF
C3639 divbuf_1/a_17122_n240# divbuf_1/a_16830_n840# 0.00fF
C3640 pll_full_0/divbuf_0/a_28350_n1540# pll_full_0/divbuf_0/a_28830_n1540# 0.11fF
C3641 pll_full_0/divbuf_0/a_59070_n840# pll_full_0/divbuf_0/a_59070_n1540# 0.01fF
C3642 divbuf_3/a_11802_170# divbuf_3/a_12282_170# 0.07fF
C3643 divbuf_3/a_11802_n240# divbuf_3/OUT4 0.04fF
C3644 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/a_37502_n240# 0.05fF
C3645 divbuf_4/a_39442_170# divbuf_4/a_39932_170# 0.07fF
C3646 divbuf_4/a_20042_170# divbuf_4/a_20042_n240# 0.01fF
C3647 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/a_40902_n240# 0.04fF
C3648 divbuf_3/a_36052_n240# divbuf_3/a_36030_n840# 0.05fF
C3649 divbuf_3/a_45120_n1600# divbuf_3/a_45600_n1600# 0.26fF
C3650 pd_div_0/divbuf_0/a_48510_n840# pd_div_0/divbuf_0/a_48990_n840# 0.07fF
C3651 pd_div_0/divbuf_0/a_18270_n840# pd_div_0/divbuf_0/a_18270_n1540# 0.01fF
C3652 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C3653 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48510_n1540# 0.19fF
C3654 divbuf_4/a_12000_n1600# divbuf_4/a_12030_n1540# 0.19fF
C3655 divbuf_4/a_40902_170# divbuf_4/OUT4 0.19fF
C3656 divbuf_4/a_12030_n840# divbuf_4/a_12510_n840# 0.07fF
C3657 divbuf_4/a_1352_n240# divbuf_4/OUT2 0.07fF
C3658 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_51870_n1540# 0.19fF
C3659 pll_full_0/divbuf_1/a_21630_n840# pll_full_0/divbuf_1/a_21630_n1540# 0.01fF
C3660 pll_full_0/divbuf_1/a_51870_n840# pll_full_0/divbuf_1/a_52350_n840# 0.07fF
C3661 divbuf_3/a_37470_n1540# divbuf_3/a_37950_n1540# 0.11fF
C3662 divbuf_0/a_22952_170# divbuf_0/OUT4 0.19fF
C3663 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n840# 0.04fF
C3664 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z3 0.05fF
C3665 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z1 0.03fF
C3666 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_25950_n840# 0.04fF
C3667 divbuf_2/a_20160_n1600# divbuf_2/OUT4 0.00fF
C3668 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/OUT3 0.19fF
C3669 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_48000_n1600# 0.26fF
C3670 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/a_38430_n840# 0.04fF
C3671 divbuf_1/a_37022_n240# divbuf_1/a_36990_n840# 0.05fF
C3672 divbuf_1/a_46080_n1600# divbuf_1/a_46560_n1600# 0.26fF
C3673 divbuf_5/a_25862_n240# divbuf_5/a_25950_n840# 0.03fF
C3674 divbuf_5/a_35040_n1600# divbuf_5/a_35520_n1600# 0.26fF
C3675 divbuf_3/a_10560_n1600# divbuf_3/OUT3 0.01fF
C3676 ro_div_0/divbuf_0/a_39870_n1540# ro_div_0/divbuf_0/a_40350_n1540# 0.11fF
C3677 divbuf_1/a_38430_n1540# divbuf_1/a_38910_n1540# 0.11fF
C3678 divbuf_3/a_35040_n1600# divbuf_3/a_35070_n840# 0.04fF
C3679 divbuf_5/a_58110_n840# divbuf_5/a_58110_n1540# 0.01fF
C3680 divbuf_5/a_27390_n1540# divbuf_5/a_27870_n1540# 0.11fF
C3681 divbuf_0/a_31202_170# divbuf_0/a_31202_n240# 0.01fF
C3682 divbuf_0/a_11312_n240# divbuf_0/a_11802_n240# 0.04fF
C3683 divbuf_4/a_960_n1600# divbuf_4/OUT2 0.00fF
C3684 divbuf_4/a_41382_n240# divbuf_4/OUT5 0.04fF
C3685 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/a_23442_n240# 0.01fF
C3686 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3687 divbuf_2/a_8640_n1600# divbuf_2/a_9120_n1600# 0.26fF
C3688 divbuf_0/a_23922_n240# divbuf_0/OUT4 0.04fF
C3689 divbuf_0/a_23070_n840# divbuf_0/a_23550_n840# 0.07fF
C3690 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n1540# 0.19fF
C3691 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15390_n1540# 0.19fF
C3692 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C3693 divbuf_2/a_31710_n840# divbuf_2/a_31710_n1540# 0.01fF
C3694 divbuf_2/a_990_n1540# divbuf_2/a_1470_n1540# 0.11fF
C3695 divbuf_2/a_510_n840# divbuf_2/OUT2 0.02fF
C3696 pll_full_0/divbuf_0/a_15390_n840# pll_full_0/divbuf_0/a_15870_n840# 0.07fF
C3697 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37470_n840# 0.04fF
C3698 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 gnd 0.17fF
C3699 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/tspc_r_1/Qbar 0.01fF
C3700 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/a_4882_170# 0.07fF
C3701 divbuf_1/a_24412_170# divbuf_1/OUT4 0.19fF
C3702 divbuf_1/a_36000_n1600# divbuf_1/a_36030_n840# 0.04fF
C3703 divbuf_3/a_12772_n240# divbuf_3/a_13252_n240# 0.05fF
C3704 divbuf_3/a_32652_170# divbuf_3/a_32652_n240# 0.01fF
C3705 divbuf_5/a_5362_170# divbuf_5/OUT3 0.19fF
C3706 divbuf_5/a_24960_n1600# divbuf_5/a_24990_n840# 0.04fF
C3707 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/a_25950_n840# 0.03fF
C3708 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35520_n1600# 0.26fF
C3709 divbuf_4/a_40412_n240# divbuf_4/a_40902_n240# 0.04fF
C3710 divbuf_3/a_24480_n1600# divbuf_3/a_24510_n1540# 0.19fF
C3711 divbuf_3/a_24510_n840# divbuf_3/a_24990_n840# 0.07fF
C3712 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/a_29310_n840# 0.04fF
C3713 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38880_n1600# 0.26fF
C3714 pd_div_0/divbuf_0/a_58110_n840# pd_div_0/divbuf_0/a_58110_n1540# 0.01fF
C3715 pd_div_0/divbuf_0/a_27390_n1540# pd_div_0/divbuf_0/a_27870_n1540# 0.11fF
C3716 divbuf_4/a_51870_n840# divbuf_4/a_52350_n840# 0.07fF
C3717 divbuf_4/a_21630_n840# divbuf_4/a_21630_n1540# 0.01fF
C3718 divbuf_4/a_51840_n1600# divbuf_4/a_51870_n1540# 0.19fF
C3719 pll_full_0/divbuf_1/a_30750_n1540# pll_full_0/divbuf_1/a_31230_n1540# 0.11fF
C3720 gnd pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.22fF
C3721 divbuf_0/a_22080_n1600# divbuf_0/OUT4 0.01fF
C3722 divbuf_1/a_13742_n240# divbuf_1/a_14222_n240# 0.05fF
C3723 divbuf_5/a_492_n240# divbuf_5/a_960_n1600# 0.00fF
C3724 divbuf_5/a_1352_n240# divbuf_5/a_1842_n240# 0.04fF
C3725 divbuf_5/a_22472_170# divbuf_5/a_22472_n240# 0.01fF
C3726 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_26910_n1540# 0.19fF
C3727 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3728 ro_div_0/divbuf_0/a_26910_n840# ro_div_0/divbuf_0/a_27390_n840# 0.07fF
C3729 divbuf_1/a_28772_n240# divbuf_1/OUT4 0.04fF
C3730 divbuf_1/a_25440_n1600# divbuf_1/a_25470_n1540# 0.19fF
C3731 divbuf_1/a_25470_n840# divbuf_1/a_25950_n840# 0.07fF
C3732 divbuf_3/a_492_n240# divbuf_3/a_510_n840# 0.00fF
C3733 divbuf_5/a_14430_n840# divbuf_5/a_14910_n840# 0.07fF
C3734 divbuf_5/a_6332_n240# divbuf_5/OUT3 0.04fF
C3735 divbuf_5/a_14400_n1600# divbuf_5/a_14430_n1540# 0.19fF
C3736 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_0/a_630_n680# 0.04fF
C3737 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3738 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_24990_n840# 0.04fF
C3739 divbuf_2/a_15182_170# divbuf_2/a_15672_170# 0.07fF
C3740 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C3741 io_clamp_low[1] io_analog[5] 0.53fF
C3742 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3743 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28350_n840# 0.04fF
C3744 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/Z2 0.14fF
C3745 divbuf_0/a_9600_n1600# divbuf_0/a_10080_n1600# 0.26fF
C3746 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_2400_n1600# 0.26fF
C3747 divbuf_2/a_39442_n240# divbuf_2/a_39390_n840# 0.04fF
C3748 divbuf_2/a_48480_n1600# divbuf_2/a_48960_n1600# 0.26fF
C3749 divbuf_0/a_1950_n1540# divbuf_0/a_2430_n1540# 0.11fF
C3750 divbuf_0/a_32670_n840# divbuf_0/a_32670_n1540# 0.01fF
C3751 divbuf_0/a_510_n840# divbuf_0/OUT 0.07fF
C3752 divbuf_2/a_40830_n1540# divbuf_2/a_41310_n1540# 0.11fF
C3753 pll_full_0/divbuf_0/a_24990_n840# pll_full_0/divbuf_0/a_24990_n1540# 0.01fF
C3754 pll_full_0/divbuf_0/a_55230_n840# pll_full_0/divbuf_0/a_55710_n840# 0.07fF
C3755 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55230_n1540# 0.19fF
C3756 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/a_1842_n240# 0.04fF
C3757 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/a_22472_n240# 0.01fF
C3758 divbuf_3/a_11040_n1600# divbuf_3/a_11520_n1600# 0.26fF
C3759 divbuf_4/a_4392_170# divbuf_4/a_4882_170# 0.07fF
C3760 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/a_5852_n240# 0.04fF
C3761 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/a_25862_n240# 0.01fF
C3762 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C3763 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/clk 0.04fF
C3764 pd_div_0/divbuf_0/a_14430_n840# pd_div_0/divbuf_0/a_14910_n840# 0.07fF
C3765 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C3766 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14430_n1540# 0.19fF
C3767 divbuf_4/a_38400_n1600# divbuf_4/a_38880_n1600# 0.26fF
C3768 divbuf_4/a_29262_n240# divbuf_4/a_29310_n840# 0.04fF
C3769 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_17790_n1540# 0.19fF
C3770 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3771 pll_full_0/divbuf_1/a_17790_n840# pll_full_0/divbuf_1/a_18270_n840# 0.07fF
C3772 divbuf_3/a_34110_n840# divbuf_3/a_34110_n1540# 0.01fF
C3773 divbuf_3/a_3390_n1540# divbuf_3/a_3870_n1540# 0.11fF
C3774 divbuf_2/a_38400_n1600# divbuf_2/a_38430_n840# 0.04fF
C3775 divbuf_2/a_32652_170# divbuf_2/OUT4 0.19fF
C3776 divbuf_4/a_30750_n1540# divbuf_4/a_31230_n1540# 0.11fF
C3777 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_12510_n840# 0.01fF
C3778 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13920_n1600# 0.26fF
C3779 divbuf_1/a_12000_n1600# divbuf_1/a_12480_n1600# 0.26fF
C3780 divbuf_5/a_960_n1600# divbuf_5/a_1440_n1600# 0.26fF
C3781 divbuf_3/a_22472_170# divbuf_3/OUT4 0.19fF
C3782 ro_div_0/divbuf_0/a_5790_n1540# ro_div_0/divbuf_0/a_6270_n1540# 0.11fF
C3783 ro_div_0/divbuf_0/a_36510_n840# ro_div_0/divbuf_0/a_36510_n1540# 0.01fF
C3784 divbuf_1/a_35070_n840# divbuf_1/a_35070_n1540# 0.01fF
C3785 divbuf_1/a_4350_n1540# divbuf_1/a_4830_n1540# 0.11fF
C3786 divbuf_5/a_54240_n1600# divbuf_5/a_54270_n1540# 0.19fF
C3787 divbuf_5/a_54270_n840# divbuf_5/a_54750_n840# 0.07fF
C3788 divbuf_5/a_24030_n840# divbuf_5/a_24030_n1540# 0.01fF
C3789 divbuf_3/a_960_n1600# divbuf_3/a_990_n840# 0.04fF
C3790 divbuf_2/a_16152_n240# divbuf_2/a_16642_n240# 0.04fF
C3791 divbuf_2/a_36052_170# divbuf_2/a_36052_n240# 0.01fF
C3792 divbuf_4/a_28320_n1600# divbuf_4/a_28350_n840# 0.04fF
C3793 divbuf_4/a_12282_170# divbuf_4/OUT4 0.19fF
C3794 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C3795 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/a_7302_170# 0.07fF
C3796 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C3797 divbuf_0/a_40412_n240# divbuf_0/a_40350_n840# 0.04fF
C3798 divbuf_0/a_49440_n1600# divbuf_0/a_49920_n1600# 0.26fF
C3799 divbuf_2/a_27870_n840# divbuf_2/a_28350_n840# 0.07fF
C3800 divbuf_2/a_33622_n240# divbuf_2/OUT4 0.04fF
C3801 divbuf_2/a_27840_n1600# divbuf_2/a_27870_n1540# 0.19fF
C3802 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z4 0.02fF
C3803 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z2 0.20fF
C3804 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C3805 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/a_32670_n840# 0.06fF
C3806 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_42240_n1600# 0.26fF
C3807 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/a_28772_170# 0.07fF
C3808 divbuf_0/a_41790_n1540# divbuf_0/a_42270_n1540# 0.11fF
C3809 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3390_n840# 0.04fF
C3810 divbuf_1/a_1920_n1600# divbuf_1/a_1950_n840# 0.04fF
C3811 divbuf_5/a_11802_n240# divbuf_5/a_11550_n840# 0.02fF
C3812 divbuf_3/a_17612_170# divbuf_3/a_18092_170# 0.07fF
C3813 pll_full_0/divbuf_0/a_34110_n1540# pll_full_0/divbuf_0/a_34590_n1540# 0.11fF
C3814 divbuf_3/a_23442_n240# divbuf_3/OUT4 0.04fF
C3815 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_1440_n1600# 0.26fF
C3816 divbuf_4/a_25862_170# divbuf_4/a_25862_n240# 0.01fF
C3817 divbuf_4/a_5362_n240# divbuf_4/a_5852_n240# 0.04fF
C3818 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4800_n1600# 0.26fF
C3819 divbuf_3/a_50880_n1600# divbuf_3/a_51360_n1600# 0.26fF
C3820 divbuf_0/a_15672_170# divbuf_0/a_15672_n240# 0.01fF
C3821 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54270_n1540# 0.19fF
C3822 pd_div_0/divbuf_0/a_54270_n840# pd_div_0/divbuf_0/a_54750_n840# 0.07fF
C3823 pd_div_0/divbuf_0/a_24030_n840# pd_div_0/divbuf_0/a_24030_n1540# 0.01fF
C3824 divbuf_4/a_17790_n840# divbuf_4/a_18270_n840# 0.07fF
C3825 divbuf_4/a_13252_n240# divbuf_4/OUT4 0.04fF
C3826 divbuf_4/a_17760_n1600# divbuf_4/a_17790_n1540# 0.19fF
C3827 pll_full_0/divbuf_1/a_27390_n840# pll_full_0/divbuf_1/a_27390_n1540# 0.01fF
C3828 pll_full_0/divbuf_1/a_57630_n840# pll_full_0/divbuf_1/a_58110_n840# 0.07fF
C3829 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_57630_n1540# 0.19fF
C3830 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/OUT3 0.19fF
C3831 divbuf_3/a_43230_n1540# divbuf_3/a_43710_n1540# 0.11fF
C3832 divbuf_0/a_34592_170# divbuf_0/OUT4 0.19fF
C3833 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n840# 0.04fF
C3834 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/a_11312_n240# 0.01fF
C3835 pd_div_0/divider_0/tspc_0/Z2 pd_div_0/divider_0/tspc_0/Z3 0.16fF
C3836 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/B 0.18fF
C3837 divbuf_5/a_6822_170# divbuf_5/a_7302_170# 0.07fF
C3838 divbuf_2/a_31680_n1600# divbuf_2/OUT4 0.00fF
C3839 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_31710_n840# 0.04fF
C3840 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53760_n1600# 0.26fF
C3841 divbuf_1/a_11312_170# divbuf_1/OUT4 0.23fF
C3842 divbuf_1/a_51840_n1600# divbuf_1/a_52320_n1600# 0.26fF
C3843 divbuf_5/a_40800_n1600# divbuf_5/a_41280_n1600# 0.26fF
C3844 divbuf_5/a_31682_n240# divbuf_5/a_31710_n840# 0.05fF
C3845 divbuf_3/a_21600_n1600# divbuf_3/OUT4 0.01fF
C3846 ro_div_0/divbuf_0/a_45630_n1540# ro_div_0/divbuf_0/a_46110_n1540# 0.11fF
C3847 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_11550_n840# 0.02fF
C3848 divbuf_1/a_44190_n1540# divbuf_1/a_44670_n1540# 0.11fF
C3849 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_14910_n840# 0.01fF
C3850 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/a_24892_n240# 0.01fF
C3851 divbuf_3/a_40800_n1600# divbuf_3/a_40830_n840# 0.04fF
C3852 divbuf_5/a_33150_n1540# divbuf_5/a_33630_n1540# 0.11fF
C3853 divbuf_0/a_17122_n240# divbuf_0/a_17612_n240# 0.04fF
C3854 divbuf_0/a_37022_170# divbuf_0/a_37022_n240# 0.01fF
C3855 divbuf_4/a_11520_n1600# divbuf_4/OUT4 0.01fF
C3856 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/a_9242_n240# 0.05fF
C3857 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/OUT4 0.07fF
C3858 ro_div_0/ro_complete_0/a0 ro_div_0/divider_0/clk 0.05fF
C3859 divbuf_2/a_4882_n240# divbuf_2/a_4830_n840# 0.04fF
C3860 divbuf_2/a_14400_n1600# divbuf_2/a_14880_n1600# 0.26fF
C3861 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/a_29262_n240# 0.01fF
C3862 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n1540# 0.19fF
C3863 divbuf_0/a_35562_n240# divbuf_0/OUT4 0.04fF
C3864 divbuf_0/a_28830_n840# divbuf_0/a_29310_n840# 0.07fF
C3865 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3866 pll_full_0/divbuf_0/a_21150_n840# pll_full_0/divbuf_0/a_21630_n840# 0.07fF
C3867 divbuf_2/a_37470_n840# divbuf_2/a_37470_n1540# 0.01fF
C3868 divbuf_2/a_6750_n1540# divbuf_2/a_7230_n1540# 0.11fF
C3869 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21150_n1540# 0.19fF
C3870 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43230_n840# 0.04fF
C3871 divbuf_1/a_41760_n1600# divbuf_1/a_41790_n840# 0.04fF
C3872 divbuf_1/a_39442_170# divbuf_1/OUT4 0.19fF
C3873 divbuf_3/a_38472_170# divbuf_3/a_38472_n240# 0.01fF
C3874 divbuf_3/a_18582_n240# divbuf_3/a_19072_n240# 0.04fF
C3875 divbuf_5/a_30720_n1600# divbuf_5/a_30750_n840# 0.04fF
C3876 divbuf_5/a_17122_170# divbuf_5/OUT4 0.19fF
C3877 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_41280_n1600# 0.26fF
C3878 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/a_31710_n840# 0.05fF
C3879 divbuf_4/a_4320_n1600# divbuf_4/a_4800_n1600# 0.26fF
C3880 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/a_35070_n840# 0.05fF
C3881 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44640_n1600# 0.26fF
C3882 divbuf_3/a_30240_n1600# divbuf_3/a_30270_n1540# 0.19fF
C3883 divbuf_3/a_30270_n840# divbuf_3/a_30750_n840# 0.07fF
C3884 pd_div_0/divbuf_0/a_33150_n1540# pd_div_0/divbuf_0/a_33630_n1540# 0.11fF
C3885 divbuf_4/a_57600_n1600# divbuf_4/a_57630_n1540# 0.19fF
C3886 divbuf_4/a_57630_n840# divbuf_4/a_58110_n840# 0.07fF
C3887 divbuf_4/a_27390_n840# divbuf_4/a_27390_n1540# 0.01fF
C3888 divbuf_2/a_4320_n1600# divbuf_2/a_4350_n840# 0.04fF
C3889 pll_full_0/divbuf_1/a_36510_n1540# pll_full_0/divbuf_1/a_36990_n1540# 0.11fF
C3890 gnd pll_full_0/divider_0/tspc_1/Z3 0.27fF
C3891 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/a_21502_n240# 0.04fF
C3892 divbuf_0/a_33600_n1600# divbuf_0/OUT4 0.01fF
C3893 divbuf_1/a_39442_170# divbuf_1/a_39442_n240# 0.01fF
C3894 divbuf_1/a_19562_n240# divbuf_1/a_20042_n240# 0.05fF
C3895 divbuf_5/a_28292_170# divbuf_5/a_28292_n240# 0.01fF
C3896 divbuf_5/a_7792_n240# divbuf_5/a_8272_n240# 0.05fF
C3897 ro_div_0/divbuf_0/a_2430_n840# ro_div_0/divbuf_0/a_2430_n1540# 0.01fF
C3898 ro_div_0/divbuf_0/a_32670_n840# ro_div_0/divbuf_0/a_33150_n840# 0.07fF
C3899 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_32670_n1540# 0.19fF
C3900 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C3901 divbuf_1/a_31200_n1600# divbuf_1/a_31230_n1540# 0.19fF
C3902 divbuf_1/a_31230_n840# divbuf_1/a_31710_n840# 0.07fF
C3903 divbuf_1/a_990_n840# divbuf_1/a_990_n1540# 0.01fF
C3904 divbuf_1/a_40412_n240# divbuf_1/OUT4 0.04fF
C3905 divbuf_5/a_20160_n1600# divbuf_5/a_20190_n1540# 0.19fF
C3906 divbuf_5/a_20190_n840# divbuf_5/a_20670_n840# 0.07fF
C3907 divbuf_5/a_18092_n240# divbuf_5/OUT4 0.04fF
C3908 divbuf_3/a_52350_n840# divbuf_3/a_52350_n1540# 0.01fF
C3909 ro_div_0/divider_0/tspc_1/Z3 ro_div_0/divider_0/tspc_1/Q 0.05fF
C3910 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C3911 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_30750_n840# 0.04fF
C3912 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3913 divbuf_4/a_15182_n240# divbuf_4/a_14910_n840# 0.01fF
C3914 divbuf_2/a_21012_170# divbuf_2/a_21502_170# 0.07fF
C3915 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3916 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34110_n840# 0.04fF
C3917 divbuf_0/a_5852_n240# divbuf_0/a_5790_n840# 0.04fF
C3918 divbuf_0/a_15360_n1600# divbuf_0/a_15840_n1600# 0.26fF
C3919 divbuf_2/a_3912_170# divbuf_2/OUT3 0.19fF
C3920 divbuf_2/a_54240_n1600# divbuf_2/a_54720_n1600# 0.26fF
C3921 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_8160_n1600# 0.26fF
C3922 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C3923 divbuf_0/a_7710_n1540# divbuf_0/a_8190_n1540# 0.11fF
C3924 divbuf_0/a_38430_n840# divbuf_0/a_38430_n1540# 0.01fF
C3925 divbuf_2/a_46590_n1540# divbuf_2/a_47070_n1540# 0.11fF
C3926 pll_full_0/divbuf_0/a_30750_n840# pll_full_0/divbuf_0/a_30750_n1540# 0.01fF
C3927 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/a_28292_n240# 0.01fF
C3928 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/a_8272_n240# 0.05fF
C3929 divbuf_3/a_16800_n1600# divbuf_3/a_17280_n1600# 0.26fF
C3930 divbuf_3/a_7302_n240# divbuf_3/a_7230_n840# 0.03fF
C3931 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/a_31682_n240# 0.01fF
C3932 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_12282_n240# 0.05fF
C3933 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20190_n1540# 0.19fF
C3934 pd_div_0/divbuf_0/a_20190_n840# pd_div_0/divbuf_0/a_20670_n840# 0.07fF
C3935 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3936 divbuf_3/a_39870_n840# divbuf_3/a_39870_n1540# 0.01fF
C3937 divbuf_3/a_9150_n1540# divbuf_3/a_9630_n1540# 0.11fF
C3938 divbuf_4/a_44160_n1600# divbuf_4/a_44640_n1600# 0.26fF
C3939 divbuf_4/a_35082_n240# divbuf_4/a_35070_n840# 0.05fF
C3940 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_4392_170# 0.07fF
C3941 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3942 pll_full_0/divbuf_1/a_23550_n840# pll_full_0/divbuf_1/a_24030_n840# 0.07fF
C3943 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_23550_n1540# 0.19fF
C3944 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_13950_n840# 0.01fF
C3945 divbuf_0/a_18582_170# divbuf_0/OUT4 0.19fF
C3946 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n840# 0.04fF
C3947 divbuf_2/a_4882_n240# divbuf_2/OUT3 0.04fF
C3948 divbuf_2/a_44160_n1600# divbuf_2/a_44190_n840# 0.04fF
C3949 divbuf_4/a_36510_n1540# divbuf_4/a_36990_n1540# 0.11fF
C3950 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C3951 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C3952 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19680_n1600# 0.26fF
C3953 divbuf_1/a_17760_n1600# divbuf_1/a_18240_n1600# 0.26fF
C3954 divbuf_1/a_8272_n240# divbuf_1/a_8190_n840# 0.03fF
C3955 divbuf_5/a_6720_n1600# divbuf_5/a_7200_n1600# 0.26fF
C3956 divbuf_3/a_34112_170# divbuf_3/OUT4 0.19fF
C3957 ro_div_0/divbuf_0/a_11550_n1540# ro_div_0/divbuf_0/a_12030_n1540# 0.11fF
C3958 ro_div_0/divbuf_0/a_42270_n840# ro_div_0/divbuf_0/a_42270_n1540# 0.01fF
C3959 divbuf_1/a_40830_n840# divbuf_1/a_40830_n1540# 0.01fF
C3960 divbuf_1/a_10110_n1540# divbuf_1/a_10590_n1540# 0.11fF
C3961 divbuf_3/a_6720_n1600# divbuf_3/a_6750_n840# 0.04fF
C3962 divbuf_5/a_60030_n840# divbuf_5/a_60510_n840# 0.07fF
C3963 divbuf_5/a_29790_n840# divbuf_5/a_29790_n1540# 0.01fF
C3964 divbuf_5/a_60000_n1600# divbuf_5/a_60030_n1540# 0.19fF
C3965 divbuf_0/a_21982_170# divbuf_0/a_22472_170# 0.07fF
C3966 divbuf_0/a_2322_170# divbuf_0/a_2322_n240# 0.01fF
C3967 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/a_16152_170# 0.07fF
C3968 divbuf_2/a_21982_n240# divbuf_2/a_22472_n240# 0.04fF
C3969 divbuf_4/a_34080_n1600# divbuf_4/a_34110_n840# 0.04fF
C3970 divbuf_4/a_23922_170# divbuf_4/OUT4 0.19fF
C3971 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C3972 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_7792_n240# 0.01fF
C3973 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C3974 divbuf_0/a_55200_n1600# divbuf_0/a_55680_n1600# 0.26fF
C3975 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/Out 0.11fF
C3976 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/a_630_n680# 0.01fF
C3977 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C3978 divbuf_2/a_33600_n1600# divbuf_2/a_33630_n1540# 0.19fF
C3979 divbuf_2/a_33630_n840# divbuf_2/a_34110_n840# 0.07fF
C3980 divbuf_2/a_3390_n840# divbuf_2/a_3390_n1540# 0.01fF
C3981 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.01fF
C3982 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C3983 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C3984 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_48000_n1600# 0.26fF
C3985 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/a_38430_n840# 0.04fF
C3986 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/OUT3 0.19fF
C3987 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/a_34592_170# 0.07fF
C3988 divbuf_0/a_47550_n1540# divbuf_0/a_48030_n1540# 0.11fF
C3989 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9150_n840# 0.04fF
C3990 divbuf_1/a_7680_n1600# divbuf_1/a_7710_n840# 0.04fF
C3991 divbuf_3/a_3422_170# divbuf_3/a_3422_n240# 0.01fF
C3992 divbuf_3/a_23442_170# divbuf_3/a_23922_170# 0.07fF
C3993 divbuf_5/a_17612_n240# divbuf_5/a_17310_n840# 0.00fF
C3994 pll_full_0/divbuf_0/a_39870_n1540# pll_full_0/divbuf_0/a_40350_n1540# 0.11fF
C3995 divbuf_3/a_35082_n240# divbuf_3/OUT4 0.04fF
C3996 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_7200_n1600# 0.26fF
C3997 divbuf_4/a_11802_n240# divbuf_4/a_12282_n240# 0.05fF
C3998 divbuf_4/a_31682_170# divbuf_4/a_31682_n240# 0.01fF
C3999 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10560_n1600# 0.26fF
C4000 divbuf_3/a_56640_n1600# divbuf_3/a_57120_n1600# 0.26fF
C4001 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C4002 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C4003 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C4004 pd_div_0/divbuf_0/a_60030_n840# pd_div_0/divbuf_0/a_60510_n840# 0.07fF
C4005 pd_div_0/divbuf_0/a_29790_n840# pd_div_0/divbuf_0/a_29790_n1540# 0.01fF
C4006 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60030_n1540# 0.19fF
C4007 divbuf_4/a_23520_n1600# divbuf_4/a_23550_n1540# 0.19fF
C4008 divbuf_4/a_23550_n840# divbuf_4/a_24030_n840# 0.07fF
C4009 divbuf_4/a_24892_n240# divbuf_4/OUT4 0.04fF
C4010 pll_full_0/divbuf_1/a_2430_n1540# pll_full_0/divbuf_1/a_2910_n1540# 0.11fF
C4011 pll_full_0/divbuf_1/a_33150_n840# pll_full_0/divbuf_1/a_33150_n1540# 0.01fF
C4012 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/OUT3 0.03fF
C4013 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4014 divbuf_3/a_48990_n1540# divbuf_3/a_49470_n1540# 0.11fF
C4015 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/a_15672_n240# 0.01fF
C4016 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n840# 0.04fF
C4017 divbuf_0/a_6822_n240# divbuf_0/OUT3 0.04fF
C4018 divbuf_1/a_21012_170# divbuf_1/a_21502_170# 0.07fF
C4019 divbuf_1/a_30712_170# divbuf_1/a_30712_n240# 0.01fF
C4020 divbuf_5/a_13252_170# divbuf_5/a_13742_170# 0.07fF
C4021 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37470_n840# 0.04fF
C4022 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4023 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59520_n1600# 0.26fF
C4024 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/DOWN 0.03fF
C4025 divbuf_1/a_12282_170# divbuf_1/OUT4 0.19fF
C4026 divbuf_1/a_57600_n1600# divbuf_1/a_58080_n1600# 0.26fF
C4027 divbuf_5/a_37502_n240# divbuf_5/a_37470_n840# 0.05fF
C4028 divbuf_5/a_46560_n1600# divbuf_5/a_47040_n1600# 0.26fF
C4029 divbuf_3/a_33120_n1600# divbuf_3/OUT4 0.01fF
C4030 ro_div_0/divbuf_0/a_51390_n1540# ro_div_0/divbuf_0/a_51870_n1540# 0.11fF
C4031 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_17310_n840# 0.00fF
C4032 divbuf_1/a_49950_n1540# divbuf_1/a_50430_n1540# 0.11fF
C4033 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/a_30712_n240# 0.01fF
C4034 divbuf_3/a_46560_n1600# divbuf_3/a_46590_n840# 0.04fF
C4035 divbuf_5/a_38910_n1540# divbuf_5/a_39390_n1540# 0.11fF
C4036 divbuf_0/a_22952_n240# divbuf_0/a_23442_n240# 0.04fF
C4037 divbuf_2/a_20160_n1600# divbuf_2/a_20640_n1600# 0.26fF
C4038 divbuf_4/a_23040_n1600# divbuf_4/OUT4 0.01fF
C4039 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/OUT5 0.03fF
C4040 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/a_35082_n240# 0.01fF
C4041 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_15672_n240# 0.04fF
C4042 divbuf_0/a_4350_n840# divbuf_0/a_4350_n1540# 0.01fF
C4043 divbuf_0/a_34590_n840# divbuf_0/a_35070_n840# 0.07fF
C4044 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n1540# 0.19fF
C4045 divbuf_1/a_23442_170# divbuf_1/a_23442_n240# 0.01fF
C4046 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_26910_n1540# 0.19fF
C4047 divbuf_2/a_43230_n840# divbuf_2/a_43230_n1540# 0.01fF
C4048 divbuf_2/a_12510_n1540# divbuf_2/a_12990_n1540# 0.11fF
C4049 pll_full_0/divbuf_0/a_26910_n840# pll_full_0/divbuf_0/a_27390_n840# 0.07fF
C4050 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4051 pd_0/R pd_0/UP 0.46fF
C4052 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_48990_n840# 0.04fF
C4053 ro_div_0/divider_0/prescaler_0/Out gnd 0.46fF
C4054 divbuf_1/a_11802_n240# divbuf_1/OUT4 0.04fF
C4055 divbuf_1/a_47520_n1600# divbuf_1/a_47550_n840# 0.04fF
C4056 divbuf_5/a_36480_n1600# divbuf_5/a_36510_n840# 0.04fF
C4057 divbuf_5/a_28772_170# divbuf_5/OUT4 0.19fF
C4058 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/a_17122_170# 0.07fF
C4059 divbuf_3/a_24412_n240# divbuf_3/a_24892_n240# 0.05fF
C4060 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C4061 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/a_37470_n840# 0.05fF
C4062 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_47040_n1600# 0.26fF
C4063 divbuf_4/a_10080_n1600# divbuf_4/a_10560_n1600# 0.26fF
C4064 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/a_40830_n840# 0.03fF
C4065 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_50400_n1600# 0.26fF
C4066 divbuf_3/a_36000_n1600# divbuf_3/a_36030_n1540# 0.19fF
C4067 divbuf_3/a_36030_n840# divbuf_3/a_36510_n840# 0.07fF
C4068 divbuf_3/a_5790_n840# divbuf_3/a_5790_n1540# 0.01fF
C4069 pd_div_0/divbuf_0/a_38910_n1540# pd_div_0/divbuf_0/a_39390_n1540# 0.11fF
C4070 divbuf_4/a_2910_n840# divbuf_4/OUT3 0.03fF
C4071 divbuf_4/a_33150_n840# divbuf_4/a_33150_n1540# 0.01fF
C4072 divbuf_4/a_2430_n1540# divbuf_4/a_2910_n1540# 0.11fF
C4073 pll_full_0/divbuf_1/a_42270_n1540# pll_full_0/divbuf_1/a_42750_n1540# 0.11fF
C4074 divbuf_2/a_10080_n1600# divbuf_2/a_10110_n840# 0.04fF
C4075 gnd pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.35fF
C4076 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/a_27322_n240# 0.04fF
C4077 divbuf_1/a_25382_n240# divbuf_1/a_25862_n240# 0.05fF
C4078 divbuf_5/a_14222_n240# divbuf_5/a_14702_n240# 0.05fF
C4079 divbuf_5/a_34112_170# divbuf_5/a_34112_n240# 0.01fF
C4080 divbuf_2/a_510_n1540# io_analog[10] 0.11fF
C4081 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38430_n1540# 0.19fF
C4082 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C4083 ro_div_0/divbuf_0/a_8190_n840# ro_div_0/divbuf_0/a_8190_n1540# 0.01fF
C4084 ro_div_0/divbuf_0/a_38430_n840# ro_div_0/divbuf_0/a_38910_n840# 0.07fF
C4085 divbuf_1/a_36990_n840# divbuf_1/a_37470_n840# 0.07fF
C4086 divbuf_1/a_6750_n840# divbuf_1/a_6750_n1540# 0.01fF
C4087 divbuf_1/a_10560_n1600# divbuf_1/OUT3 0.01fF
C4088 divbuf_1/a_36960_n1600# divbuf_1/a_36990_n1540# 0.19fF
C4089 divbuf_5/a_25950_n840# divbuf_5/a_26430_n840# 0.07fF
C4090 divbuf_5/a_29742_n240# divbuf_5/OUT4 0.04fF
C4091 divbuf_5/a_25920_n1600# divbuf_5/a_25950_n1540# 0.19fF
C4092 pd_0/DOWN pd_0/R 0.38fF
C4093 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C4094 divbuf_3/a_58110_n840# divbuf_3/a_58110_n1540# 0.01fF
C4095 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_2/Z4 0.02fF
C4096 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36510_n840# 0.04fF
C4097 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4098 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4099 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_39870_n840# 0.04fF
C4100 divbuf_2/a_6822_170# divbuf_2/a_6822_n240# 0.01fF
C4101 divbuf_2/a_26832_170# divbuf_2/a_27322_170# 0.07fF
C4102 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C4103 divbuf_0/a_11802_n240# divbuf_0/a_12030_n840# 0.02fF
C4104 divbuf_0/a_21120_n1600# divbuf_0/a_21600_n1600# 0.26fF
C4105 divbuf_4/a_41790_n840# divbuf_4/OUT5 0.03fF
C4106 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13920_n1600# 0.26fF
C4107 divbuf_2/a_15672_170# divbuf_2/OUT4 0.19fF
C4108 divbuf_2/a_60000_n1600# divbuf_2/a_60480_n1600# 0.26fF
C4109 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/a_3870_n840# 0.04fF
C4110 divbuf_0/a_13470_n1540# divbuf_0/a_13950_n1540# 0.11fF
C4111 divbuf_0/a_44190_n840# divbuf_0/a_44190_n1540# 0.01fF
C4112 pll_full_0/divbuf_0/a_5790_n1540# pll_full_0/divbuf_0/a_6270_n1540# 0.11fF
C4113 pll_full_0/divbuf_0/a_36510_n840# pll_full_0/divbuf_0/a_36510_n1540# 0.01fF
C4114 divbuf_2/a_52350_n1540# divbuf_2/a_52830_n1540# 0.11fF
C4115 divbuf_3/a_5362_170# divbuf_3/OUT3 0.19fF
C4116 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_14702_n240# 0.05fF
C4117 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/a_34112_n240# 0.01fF
C4118 divbuf_4/a_16642_170# divbuf_4/a_17122_170# 0.07fF
C4119 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_18092_n240# 0.05fF
C4120 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/a_37502_n240# 0.01fF
C4121 divbuf_3/a_13252_n240# divbuf_3/a_13470_n840# 0.02fF
C4122 divbuf_3/a_22560_n1600# divbuf_3/a_23040_n1600# 0.26fF
C4123 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C4124 pd_div_0/divbuf_0/a_25950_n840# pd_div_0/divbuf_0/a_26430_n840# 0.07fF
C4125 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4126 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_25950_n1540# 0.19fF
C4127 divbuf_4/a_49920_n1600# divbuf_4/a_50400_n1600# 0.26fF
C4128 divbuf_4/a_40902_n240# divbuf_4/a_40830_n840# 0.03fF
C4129 divbuf_3/a_45630_n840# divbuf_3/a_45630_n1540# 0.01fF
C4130 divbuf_3/a_14910_n1540# divbuf_3/a_15390_n1540# 0.11fF
C4131 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C4132 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29310_n1540# 0.19fF
C4133 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4134 pll_full_0/divbuf_1/a_29310_n840# pll_full_0/divbuf_1/a_29790_n840# 0.07fF
C4135 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n840# 0.04fF
C4136 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z2 0.14fF
C4137 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3390_n840# 0.04fF
C4138 divbuf_2/a_49920_n1600# divbuf_2/a_49950_n840# 0.04fF
C4139 divbuf_2/a_16642_n240# divbuf_2/OUT4 0.04fF
C4140 divbuf_4/a_42270_n1540# divbuf_4/a_42750_n1540# 0.11fF
C4141 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C4142 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C4143 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C4144 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C4145 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/a_4392_n240# 0.01fF
C4146 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_25440_n1600# 0.26fF
C4147 divbuf_1/a_14222_n240# divbuf_1/a_14430_n840# 0.02fF
C4148 divbuf_1/a_23520_n1600# divbuf_1/a_24000_n1600# 0.26fF
C4149 divbuf_5/a_12480_n1600# divbuf_5/a_12960_n1600# 0.26fF
C4150 divbuf_3/a_6332_n240# divbuf_3/OUT3 0.04fF
C4151 ro_div_0/divbuf_0/a_17310_n1540# ro_div_0/divbuf_0/a_17790_n1540# 0.11fF
C4152 ro_div_0/divbuf_0/a_48030_n840# ro_div_0/divbuf_0/a_48030_n1540# 0.01fF
C4153 divbuf_1/a_46590_n840# divbuf_1/a_46590_n1540# 0.01fF
C4154 divbuf_1/a_15870_n1540# divbuf_1/a_16350_n1540# 0.11fF
C4155 divbuf_3/a_12480_n1600# divbuf_3/a_12510_n840# 0.04fF
C4156 divbuf_5/a_35550_n840# divbuf_5/a_35550_n1540# 0.01fF
C4157 divbuf_5/a_4830_n1540# divbuf_5/a_5310_n1540# 0.11fF
C4158 divbuf_0/a_27802_170# divbuf_0/a_28292_170# 0.07fF
C4159 divbuf_2/a_27802_n240# divbuf_2/a_28292_n240# 0.04fF
C4160 divbuf_4/a_39840_n1600# divbuf_4/a_39870_n840# 0.04fF
C4161 divbuf_4/a_35562_170# divbuf_4/OUT4 0.19fF
C4162 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/a_20532_170# 0.07fF
C4163 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C4164 divbuf_0/a_510_n840# divbuf_0/a_990_n840# 0.07fF
C4165 divbuf_0/a_480_n1600# divbuf_0/a_510_n1540# 0.19fF
C4166 divbuf_0/a_15182_170# divbuf_0/OUT4 0.19fF
C4167 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_0/Z3 0.38fF
C4168 divbuf_2/a_39390_n840# divbuf_2/a_39870_n840# 0.07fF
C4169 divbuf_2/a_9150_n840# divbuf_2/a_9150_n1540# 0.01fF
C4170 divbuf_2/a_39360_n1600# divbuf_2/a_39390_n1540# 0.19fF
C4171 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53760_n1600# 0.26fF
C4172 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C4173 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C4174 pll_full_0/divider_0/nor_0/B pll_full_0/divbuf_0/IN 0.29fF
C4175 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.29fF
C4176 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/a_40412_170# 0.07fF
C4177 divbuf_0/a_53310_n1540# divbuf_0/a_53790_n1540# 0.11fF
C4178 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_14910_n840# 0.04fF
C4179 divbuf_1/a_33622_170# divbuf_1/OUT4 0.19fF
C4180 divbuf_1/a_13440_n1600# divbuf_1/a_13470_n840# 0.04fF
C4181 divbuf_3/a_29262_170# divbuf_3/a_29742_170# 0.07fF
C4182 divbuf_3/a_9242_170# divbuf_3/a_9242_n240# 0.01fF
C4183 divbuf_5/a_2400_n1600# divbuf_5/a_2430_n840# 0.04fF
C4184 filter_0/a_4216_n2998# filter_0/v 0.31fF
C4185 pll_full_0/divbuf_0/a_45630_n1540# pll_full_0/divbuf_0/a_46110_n1540# 0.11fF
C4186 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12960_n1600# 0.26fF
C4187 divbuf_3/a_1920_n1600# divbuf_3/a_1950_n1540# 0.19fF
C4188 divbuf_3/a_1950_n840# divbuf_3/a_2430_n840# 0.07fF
C4189 divbuf_4/a_37502_170# divbuf_4/a_37502_n240# 0.01fF
C4190 divbuf_4/a_17612_n240# divbuf_4/a_18092_n240# 0.05fF
C4191 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/a_6270_n840# 0.04fF
C4192 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_16320_n1600# 0.26fF
C4193 pd_div_0/divbuf_0/a_35550_n840# pd_div_0/divbuf_0/a_35550_n1540# 0.01fF
C4194 pd_div_0/divbuf_0/a_4830_n1540# pd_div_0/divbuf_0/a_5310_n1540# 0.11fF
C4195 divbuf_4/a_29310_n840# divbuf_4/a_29790_n840# 0.07fF
C4196 divbuf_4/a_36532_n240# divbuf_4/OUT4 0.04fF
C4197 divbuf_4/a_29280_n1600# divbuf_4/a_29310_n1540# 0.19fF
C4198 pll_full_0/divbuf_1/a_8190_n1540# pll_full_0/divbuf_1/a_8670_n1540# 0.11fF
C4199 pll_full_0/divbuf_1/a_38910_n840# pll_full_0/divbuf_1/a_38910_n1540# 0.01fF
C4200 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4201 divbuf_0/a_18582_n240# divbuf_0/OUT4 0.04fF
C4202 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n840# 0.04fF
C4203 divbuf_1/a_26832_170# divbuf_1/a_27322_170# 0.07fF
C4204 divbuf_5/a_19072_170# divbuf_5/a_19562_170# 0.07fF
C4205 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C4206 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43230_n840# 0.04fF
C4207 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4350_n1540# 0.19fF
C4208 ro_div_0/divbuf_0/a_4350_n840# ro_div_0/divbuf_0/a_4830_n840# 0.07fF
C4209 divbuf_1/a_19072_170# divbuf_1/OUT4 0.19fF
C4210 divbuf_1/a_2880_n1600# divbuf_1/a_2910_n1540# 0.19fF
C4211 divbuf_1/a_2910_n840# divbuf_1/a_3390_n840# 0.07fF
C4212 divbuf_5/a_52320_n1600# divbuf_5/a_52800_n1600# 0.26fF
C4213 divbuf_3/a_54240_n1600# divbuf_3/a_54270_n1540# 0.19fF
C4214 ro_div_0/divbuf_0/a_57150_n1540# ro_div_0/divbuf_0/a_57630_n1540# 0.11fF
C4215 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2430_n840# 0.04fF
C4216 divbuf_1/a_55710_n1540# divbuf_1/a_56190_n1540# 0.11fF
C4217 divbuf_5/a_44670_n1540# divbuf_5/a_45150_n1540# 0.11fF
C4218 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_5790_n840# 0.04fF
C4219 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/a_36532_n240# 0.01fF
C4220 divbuf_3/a_52320_n1600# divbuf_3/a_52350_n840# 0.04fF
C4221 divbuf_0/a_28772_n240# divbuf_0/a_29262_n240# 0.04fF
C4222 divbuf_2/a_16642_n240# divbuf_2/a_16830_n840# 0.02fF
C4223 divbuf_2/a_25920_n1600# divbuf_2/a_26400_n1600# 0.26fF
C4224 divbuf_4/a_34560_n1600# divbuf_4/OUT4 0.01fF
C4225 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/a_21502_n240# 0.04fF
C4226 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/a_40902_n240# 0.01fF
C4227 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n1540# 0.19fF
C4228 divbuf_0/a_10110_n840# divbuf_0/a_10110_n1540# 0.01fF
C4229 divbuf_0/a_40350_n840# divbuf_0/a_40830_n840# 0.07fF
C4230 divbuf_1/a_29262_170# divbuf_1/a_29262_n240# 0.01fF
C4231 divbuf_2/a_48990_n840# divbuf_2/a_48990_n1540# 0.01fF
C4232 divbuf_2/a_18270_n1540# divbuf_2/a_18750_n1540# 0.11fF
C4233 pll_full_0/divbuf_0/a_2430_n840# pll_full_0/divbuf_0/a_2430_n1540# 0.01fF
C4234 pll_full_0/divbuf_0/a_32670_n840# pll_full_0/divbuf_0/a_33150_n840# 0.07fF
C4235 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C4236 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_32670_n1540# 0.19fF
C4237 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_54750_n840# 0.04fF
C4238 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4239 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/a_19562_170# 0.07fF
C4240 divbuf_1/a_53280_n1600# divbuf_1/a_53310_n840# 0.04fF
C4241 divbuf_1/a_23442_n240# divbuf_1/OUT4 0.04fF
C4242 divbuf_5/a_42240_n1600# divbuf_5/a_42270_n840# 0.04fF
C4243 divbuf_5/a_40412_170# divbuf_5/OUT4 0.19fF
C4244 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/a_1842_n240# 0.01fF
C4245 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/a_22952_170# 0.07fF
C4246 divbuf_3/a_30232_n240# divbuf_3/a_30712_n240# 0.05fF
C4247 pd_0/UP divbuf_3/a_492_n240# 0.13fF
C4248 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C4249 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52800_n1600# 0.26fF
C4250 divbuf_4/a_15840_n1600# divbuf_4/a_16320_n1600# 0.26fF
C4251 divbuf_4/a_6332_n240# divbuf_4/a_6270_n840# 0.04fF
C4252 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_56160_n1600# 0.26fF
C4253 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/OUT3 0.19fF
C4254 divbuf_3/a_41760_n1600# divbuf_3/a_41790_n1540# 0.19fF
C4255 divbuf_3/a_41790_n840# divbuf_3/a_42270_n840# 0.07fF
C4256 divbuf_3/a_11550_n840# divbuf_3/a_11550_n1540# 0.01fF
C4257 pd_div_0/divbuf_0/a_44670_n1540# pd_div_0/divbuf_0/a_45150_n1540# 0.11fF
C4258 divbuf_2/a_15840_n1600# divbuf_2/a_15870_n840# 0.04fF
C4259 divbuf_4/a_38910_n840# divbuf_4/a_38910_n1540# 0.01fF
C4260 divbuf_4/a_8190_n1540# divbuf_4/a_8670_n1540# 0.11fF
C4261 pll_full_0/divbuf_1/a_48030_n1540# pll_full_0/divbuf_1/a_48510_n1540# 0.11fF
C4262 gnd pll_full_0/divider_0/and_0/A 0.69fF
C4263 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/a_33142_n240# 0.04fF
C4264 divbuf_1/a_31202_n240# divbuf_1/a_31682_n240# 0.05fF
C4265 divbuf_5/a_39932_170# divbuf_5/a_39932_n240# 0.01fF
C4266 divbuf_5/a_20042_n240# divbuf_5/a_20532_n240# 0.04fF
C4267 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C4268 ro_div_0/divbuf_0/a_13950_n840# ro_div_0/divbuf_0/a_13950_n1540# 0.01fF
C4269 ro_div_0/divbuf_0/a_44190_n840# ro_div_0/divbuf_0/a_44670_n840# 0.07fF
C4270 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44190_n1540# 0.19fF
C4271 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_960_n1600# 0.00fF
C4272 divbuf_1/a_42720_n1600# divbuf_1/a_42750_n1540# 0.19fF
C4273 divbuf_1/a_42750_n840# divbuf_1/a_43230_n840# 0.07fF
C4274 divbuf_1/a_12510_n840# divbuf_1/a_12510_n1540# 0.01fF
C4275 divbuf_1/a_21600_n1600# divbuf_1/OUT4 0.01fF
C4276 divbuf_5/a_31680_n1600# divbuf_5/a_31710_n1540# 0.19fF
C4277 divbuf_5/a_31710_n840# divbuf_5/a_32190_n840# 0.07fF
C4278 divbuf_5/a_1470_n840# divbuf_5/a_1470_n1540# 0.01fF
C4279 divbuf_5/a_41382_n240# divbuf_5/OUT4 0.04fF
C4280 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/tspc_0/Z3 0.05fF
C4281 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42270_n840# 0.04fF
C4282 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4283 divbuf_2/a_32652_170# divbuf_2/a_33142_170# 0.07fF
C4284 divbuf_2/a_13252_170# divbuf_2/a_13252_n240# 0.01fF
C4285 divbuf_4/a_5760_n1600# divbuf_4/a_5790_n840# 0.04fF
C4286 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_45630_n840# 0.04fF
C4287 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C4288 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/a_5310_n840# 0.04fF
C4289 divbuf_0/a_17612_n240# divbuf_0/a_17790_n840# 0.02fF
C4290 divbuf_0/a_26880_n1600# divbuf_0/a_27360_n1600# 0.26fF
C4291 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/a_9630_n840# 0.03fF
C4292 divbuf_2/a_5310_n840# divbuf_2/a_5790_n840# 0.07fF
C4293 divbuf_2/a_5280_n1600# divbuf_2/a_5310_n1540# 0.19fF
C4294 divbuf_2/a_27322_170# divbuf_2/OUT4 0.19fF
C4295 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19680_n1600# 0.26fF
C4296 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C4297 pd_0/DIV divbuf_5/a_510_n840# 0.07fF
C4298 divbuf_0/a_19230_n1540# divbuf_0/a_19710_n1540# 0.11fF
C4299 divbuf_0/a_49950_n840# divbuf_0/a_49950_n1540# 0.01fF
C4300 divbuf_2/a_58110_n1540# divbuf_2/a_58590_n1540# 0.11fF
C4301 pll_full_0/divbuf_0/a_42270_n840# pll_full_0/divbuf_0/a_42270_n1540# 0.01fF
C4302 pll_full_0/divbuf_0/a_11550_n1540# pll_full_0/divbuf_0/a_12030_n1540# 0.11fF
C4303 divbuf_3/a_17122_170# divbuf_3/OUT4 0.19fF
C4304 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/a_39932_n240# 0.01fF
C4305 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/a_20532_n240# 0.04fF
C4306 divbuf_4/a_22472_170# divbuf_4/a_22952_170# 0.07fF
C4307 divbuf_4/a_1842_170# divbuf_4/a_1842_n240# 0.01fF
C4308 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/a_23922_n240# 0.05fF
C4309 divbuf_3/a_28320_n1600# divbuf_3/a_28800_n1600# 0.26fF
C4310 divbuf_3/a_19072_n240# divbuf_3/a_19230_n840# 0.02fF
C4311 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C4312 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_31710_n1540# 0.19fF
C4313 pd_div_0/divbuf_0/a_31710_n840# pd_div_0/divbuf_0/a_32190_n840# 0.07fF
C4314 pd_div_0/divbuf_0/a_1470_n840# pd_div_0/divbuf_0/a_1470_n1540# 0.01fF
C4315 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4316 divbuf_4/a_6822_170# divbuf_4/OUT3 0.19fF
C4317 divbuf_4/a_55680_n1600# divbuf_4/a_56160_n1600# 0.26fF
C4318 pll_full_0/divbuf_1/a_4830_n840# pll_full_0/divbuf_1/a_4830_n1540# 0.01fF
C4319 pll_full_0/divbuf_1/a_35070_n840# pll_full_0/divbuf_1/a_35550_n840# 0.07fF
C4320 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35070_n1540# 0.19fF
C4321 divbuf_3/a_51390_n840# divbuf_3/a_51390_n1540# 0.01fF
C4322 divbuf_3/a_20670_n1540# divbuf_3/a_21150_n1540# 0.11fF
C4323 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C4324 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n840# 0.04fF
C4325 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/nor_1/A 1.21fF
C4326 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C4327 divbuf_2/a_28292_n240# divbuf_2/OUT4 0.04fF
C4328 divbuf_2/a_55680_n1600# divbuf_2/a_55710_n840# 0.04fF
C4329 divbuf_4/a_48030_n1540# divbuf_4/a_48510_n1540# 0.11fF
C4330 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9150_n840# 0.04fF
C4331 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C4332 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C4333 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C4334 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C4335 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/a_21630_n840# 0.03fF
C4336 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_31200_n1600# 0.26fF
C4337 divbuf_1/a_29280_n1600# divbuf_1/a_29760_n1600# 0.26fF
C4338 divbuf_1/a_20042_n240# divbuf_1/a_20190_n840# 0.03fF
C4339 divbuf_5/a_18240_n1600# divbuf_5/a_18720_n1600# 0.26fF
C4340 divbuf_5/a_8762_n240# divbuf_5/a_8670_n840# 0.03fF
C4341 divbuf_3/a_18092_n240# divbuf_3/OUT4 0.04fF
C4342 ro_div_0/divbuf_0/a_23070_n1540# ro_div_0/divbuf_0/a_23550_n1540# 0.11fF
C4343 ro_div_0/divbuf_0/a_53790_n840# ro_div_0/divbuf_0/a_53790_n1540# 0.01fF
C4344 divbuf_1/a_52350_n840# divbuf_1/a_52350_n1540# 0.01fF
C4345 divbuf_1/a_21630_n1540# divbuf_1/a_22110_n1540# 0.11fF
C4346 divbuf_3/a_18240_n1600# divbuf_3/a_18270_n840# 0.04fF
C4347 divbuf_5/a_41310_n840# divbuf_5/a_41310_n1540# 0.01fF
C4348 divbuf_5/a_10590_n1540# divbuf_5/a_11070_n1540# 0.11fF
C4349 divbuf_0/a_33622_170# divbuf_0/a_34112_170# 0.07fF
C4350 divbuf_4/a_7792_n240# divbuf_4/OUT3 0.04fF
C4351 divbuf_4/a_45600_n1600# divbuf_4/a_45630_n840# 0.04fF
C4352 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_12772_n240# 0.01fF
C4353 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/a_26352_170# 0.07fF
C4354 divbuf_2/a_33622_n240# divbuf_2/a_34112_n240# 0.04fF
C4355 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/a_8272_n240# 0.01fF
C4356 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n1540# 0.19fF
C4357 divbuf_0/a_6270_n840# divbuf_0/a_6750_n840# 0.07fF
C4358 divbuf_0/a_29262_170# divbuf_0/OUT4 0.19fF
C4359 divbuf_1/a_16642_170# divbuf_1/a_16642_n240# 0.01fF
C4360 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59520_n1600# 0.26fF
C4361 divbuf_2/a_45120_n1600# divbuf_2/a_45150_n1540# 0.19fF
C4362 divbuf_2/a_45150_n840# divbuf_2/a_45630_n840# 0.07fF
C4363 divbuf_2/a_14910_n840# divbuf_2/a_14910_n1540# 0.01fF
C4364 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4365 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C4366 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/a_6332_n240# 0.05fF
C4367 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_20670_n840# 0.04fF
C4368 divbuf_0/a_59070_n1540# divbuf_0/a_59550_n1540# 0.11fF
C4369 pll_full_0/divbuf_0/a_51390_n1540# pll_full_0/divbuf_0/a_51870_n1540# 0.11fF
C4370 divbuf_1/a_19200_n1600# divbuf_1/a_19230_n840# 0.04fF
C4371 divbuf_3/a_15672_170# divbuf_3/a_15672_n240# 0.01fF
C4372 divbuf_3/a_35082_170# divbuf_3/a_35562_170# 0.07fF
C4373 divbuf_5/a_8160_n1600# divbuf_5/a_8190_n840# 0.04fF
C4374 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18720_n1600# 0.26fF
C4375 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/a_8670_n840# 0.03fF
C4376 divbuf_4/a_23442_n240# divbuf_4/a_23922_n240# 0.05fF
C4377 divbuf_3/a_7680_n1600# divbuf_3/a_7710_n1540# 0.19fF
C4378 divbuf_3/a_7710_n840# divbuf_3/a_8190_n840# 0.07fF
C4379 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12510_n840# 0.02fF
C4380 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_22080_n1600# 0.26fF
C4381 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/OUT3 0.19fF
C4382 pd_div_0/divbuf_0/a_41310_n840# pd_div_0/divbuf_0/a_41310_n1540# 0.01fF
C4383 pd_div_0/divbuf_0/a_10590_n1540# pd_div_0/divbuf_0/a_11070_n1540# 0.11fF
C4384 divbuf_2/a_1842_n240# divbuf_2/a_1950_n840# 0.03fF
C4385 divbuf_4/a_35040_n1600# divbuf_4/a_35070_n1540# 0.19fF
C4386 divbuf_4/a_35070_n840# divbuf_4/a_35550_n840# 0.07fF
C4387 divbuf_4/a_4830_n840# divbuf_4/a_4830_n1540# 0.01fF
C4388 pll_full_0/divbuf_1/a_13950_n1540# pll_full_0/divbuf_1/a_14430_n1540# 0.11fF
C4389 pll_full_0/divbuf_1/a_44670_n840# pll_full_0/divbuf_1/a_44670_n1540# 0.01fF
C4390 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C4391 ro_div_0/ro_complete_0/a3 ro_div_0/divider_0/clk 0.05fF
C4392 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n840# 0.04fF
C4393 divbuf_0/a_30232_n240# divbuf_0/OUT4 0.04fF
C4394 divbuf_1/a_36052_170# divbuf_1/a_36532_170# 0.07fF
C4395 divbuf_5/a_4882_170# divbuf_5/a_4882_n240# 0.01fF
C4396 divbuf_5/a_24892_170# divbuf_5/a_25382_170# 0.07fF
C4397 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_48990_n840# 0.04fF
C4398 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4399 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 gnd 0.16fF
C4400 ro_div_0/divbuf_0/a_10110_n840# ro_div_0/divbuf_0/a_10590_n840# 0.07fF
C4401 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10110_n1540# 0.19fF
C4402 divbuf_1/a_8640_n1600# divbuf_1/a_8670_n1540# 0.19fF
C4403 divbuf_1/a_34112_170# divbuf_1/OUT4 0.19fF
C4404 divbuf_1/a_8670_n840# divbuf_1/a_9150_n840# 0.07fF
C4405 divbuf_5/a_11802_170# divbuf_5/OUT4 0.19fF
C4406 divbuf_5/a_58080_n1600# divbuf_5/a_58560_n1600# 0.26fF
C4407 divbuf_3/a_60000_n1600# divbuf_3/a_60030_n1540# 0.19fF
C4408 ro_div_0/divbuf_0/OUT2 ro_div_0/divbuf_0/OUT3 0.36fF
C4409 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8190_n840# 0.04fF
C4410 divbuf_5/a_50430_n1540# divbuf_5/a_50910_n1540# 0.11fF
C4411 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_11550_n840# 0.04fF
C4412 divbuf_3/a_58080_n1600# divbuf_3/a_58110_n840# 0.04fF
C4413 divbuf_0/a_34592_n240# divbuf_0/a_35082_n240# 0.04fF
C4414 divbuf_2/a_31680_n1600# divbuf_2/a_32160_n1600# 0.26fF
C4415 divbuf_2/a_22472_n240# divbuf_2/a_22590_n840# 0.03fF
C4416 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/a_27322_n240# 0.04fF
C4417 gnd pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.22fF
C4418 divbuf_0/a_15870_n840# divbuf_0/a_15870_n1540# 0.01fF
C4419 divbuf_0/a_46110_n840# divbuf_0/a_46590_n840# 0.07fF
C4420 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n1540# 0.19fF
C4421 divbuf_2/a_54750_n840# divbuf_2/a_54750_n1540# 0.01fF
C4422 divbuf_2/a_24030_n1540# divbuf_2/a_24510_n1540# 0.11fF
C4423 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38430_n1540# 0.19fF
C4424 pll_full_0/divbuf_0/a_38430_n840# pll_full_0/divbuf_0/a_38910_n840# 0.07fF
C4425 pll_full_0/divbuf_0/a_8190_n840# pll_full_0/divbuf_0/a_8190_n1540# 0.01fF
C4426 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C4427 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4428 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/a_60510_n840# 0.04fF
C4429 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/a_25382_170# 0.07fF
C4430 divbuf_1/a_35082_n240# divbuf_1/OUT4 0.04fF
C4431 divbuf_1/a_59040_n1600# divbuf_1/a_59070_n840# 0.04fF
C4432 divbuf_5/a_12772_n240# divbuf_5/OUT4 0.04fF
C4433 divbuf_5/a_48000_n1600# divbuf_5/a_48030_n840# 0.04fF
C4434 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/a_8272_n240# 0.01fF
C4435 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/a_28772_170# 0.07fF
C4436 divbuf_3/a_36052_n240# divbuf_3/a_36532_n240# 0.05fF
C4437 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_0/a_630_n680# 0.01fF
C4438 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C4439 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/OUT3 0.19fF
C4440 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58560_n1600# 0.26fF
C4441 divbuf_4/a_21600_n1600# divbuf_4/a_22080_n1600# 0.26fF
C4442 divbuf_4/a_12282_n240# divbuf_4/a_12510_n840# 0.02fF
C4443 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C4444 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/a_1470_n840# 0.07fF
C4445 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4446 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_990_n1540# 0.19fF
C4447 divbuf_3/a_47520_n1600# divbuf_3/a_47550_n1540# 0.19fF
C4448 divbuf_3/a_47550_n840# divbuf_3/a_48030_n840# 0.07fF
C4449 divbuf_3/a_17310_n840# divbuf_3/a_17310_n1540# 0.01fF
C4450 pd_div_0/divbuf_0/a_50430_n1540# pd_div_0/divbuf_0/a_50910_n1540# 0.11fF
C4451 divbuf_2/a_21600_n1600# divbuf_2/a_21630_n840# 0.04fF
C4452 divbuf_4/a_44670_n840# divbuf_4/a_44670_n1540# 0.01fF
C4453 divbuf_4/a_13950_n1540# divbuf_4/a_14430_n1540# 0.11fF
C4454 pll_full_0/divbuf_1/a_53790_n1540# pll_full_0/divbuf_1/a_54270_n1540# 0.11fF
C4455 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/a_38962_n240# 0.04fF
C4456 divbuf_1/a_37022_n240# divbuf_1/a_37502_n240# 0.05fF
C4457 divbuf_5/a_25862_n240# divbuf_5/a_26352_n240# 0.04fF
C4458 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_49950_n1540# 0.19fF
C4459 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C4460 ro_div_0/divbuf_0/a_19710_n840# ro_div_0/divbuf_0/a_19710_n1540# 0.01fF
C4461 ro_div_0/divbuf_0/a_49950_n840# ro_div_0/divbuf_0/a_50430_n840# 0.07fF
C4462 divbuf_1/a_48510_n840# divbuf_1/a_48990_n840# 0.07fF
C4463 divbuf_1/a_18270_n840# divbuf_1/a_18270_n1540# 0.01fF
C4464 divbuf_1/a_33120_n1600# divbuf_1/OUT4 0.01fF
C4465 divbuf_1/a_48480_n1600# divbuf_1/a_48510_n1540# 0.19fF
C4466 divbuf_5/a_37470_n840# divbuf_5/a_37950_n840# 0.07fF
C4467 divbuf_5/a_7230_n840# divbuf_5/a_7230_n1540# 0.01fF
C4468 divbuf_5/a_11040_n1600# divbuf_5/OUT4 0.00fF
C4469 divbuf_5/a_37440_n1600# divbuf_5/a_37470_n1540# 0.19fF
C4470 ro_div_0/divider_0/tspc_2/Z2 ro_div_0/divider_0/tspc_2/Z4 0.36fF
C4471 ro_div_0/divider_0/tspc_2/Z3 ro_div_0/divbuf_0/IN 0.05fF
C4472 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4473 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48030_n840# 0.04fF
C4474 divbuf_2/a_19072_170# divbuf_2/a_19072_n240# 0.01fF
C4475 divbuf_2/a_38472_170# divbuf_2/a_38962_170# 0.07fF
C4476 divbuf_4/a_11520_n1600# divbuf_4/a_11550_n840# 0.04fF
C4477 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4478 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51390_n840# 0.04fF
C4479 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11550_n840# 0.02fF
C4480 divbuf_0/a_23442_n240# divbuf_0/a_23550_n840# 0.03fF
C4481 divbuf_0/a_32640_n1600# divbuf_0/a_33120_n1600# 0.26fF
C4482 divbuf_2/a_11040_n1600# divbuf_2/a_11070_n1540# 0.19fF
C4483 divbuf_2/a_38962_170# divbuf_2/OUT4 0.19fF
C4484 divbuf_2/a_11070_n840# divbuf_2/a_11550_n840# 0.07fF
C4485 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_25440_n1600# 0.26fF
C4486 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_15870_n840# 0.02fF
C4487 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C4488 divbuf_0/a_24990_n1540# divbuf_0/a_25470_n1540# 0.11fF
C4489 divbuf_0/a_55710_n840# divbuf_0/a_55710_n1540# 0.01fF
C4490 pll_full_0/divbuf_0/a_17310_n1540# pll_full_0/divbuf_0/a_17790_n1540# 0.11fF
C4491 pll_full_0/divbuf_0/a_48030_n840# pll_full_0/divbuf_0/a_48030_n1540# 0.01fF
C4492 divbuf_2/OUT4 divbuf_2/OUT5 0.26fF
C4493 divbuf_3/a_28772_170# divbuf_3/OUT4 0.19fF
C4494 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/a_26352_n240# 0.04fF
C4495 divbuf_4/a_28292_170# divbuf_4/a_28772_170# 0.07fF
C4496 divbuf_4/a_8272_170# divbuf_4/a_8272_n240# 0.01fF
C4497 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/a_29742_n240# 0.05fF
C4498 divbuf_3/a_24892_n240# divbuf_3/a_24990_n840# 0.03fF
C4499 divbuf_3/a_34080_n1600# divbuf_3/a_34560_n1600# 0.26fF
C4500 pd_div_0/divbuf_0/a_37470_n840# pd_div_0/divbuf_0/a_37950_n840# 0.07fF
C4501 pd_div_0/divbuf_0/a_7230_n840# pd_div_0/divbuf_0/a_7230_n1540# 0.01fF
C4502 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C4503 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37470_n1540# 0.19fF
C4504 divbuf_4/a_960_n1600# divbuf_4/a_990_n1540# 0.19fF
C4505 divbuf_4/a_18582_170# divbuf_4/OUT4 0.19fF
C4506 divbuf_4/a_990_n840# divbuf_4/a_1470_n840# 0.07fF
C4507 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_40830_n1540# 0.19fF
C4508 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/a_10590_n1540# 0.01fF
C4509 pll_full_0/divbuf_1/a_40830_n840# pll_full_0/divbuf_1/a_41310_n840# 0.07fF
C4510 divbuf_3/a_26430_n1540# divbuf_3/a_26910_n1540# 0.11fF
C4511 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C4512 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n840# 0.04fF
C4513 divbuf_0/a_2322_170# divbuf_0/OUT2 0.19fF
C4514 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z3 0.65fF
C4515 divbuf_4/a_53790_n1540# divbuf_4/a_54270_n1540# 0.11fF
C4516 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z1 0.01fF
C4517 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C4518 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C4519 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/A 0.26fF
C4520 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_14910_n840# 0.04fF
C4521 divbuf_2/a_39932_n240# divbuf_2/OUT4 0.04fF
C4522 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36960_n1600# 0.26fF
C4523 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/a_27390_n840# 0.04fF
C4524 divbuf_1/a_25862_n240# divbuf_1/a_25950_n840# 0.03fF
C4525 divbuf_1/a_35040_n1600# divbuf_1/a_35520_n1600# 0.26fF
C4526 divbuf_5/a_14702_n240# divbuf_5/a_14910_n840# 0.02fF
C4527 divbuf_5/a_24000_n1600# divbuf_5/a_24480_n1600# 0.26fF
C4528 divbuf_3/a_29742_n240# divbuf_3/OUT4 0.04fF
C4529 ro_div_0/divbuf_0/a_28830_n1540# ro_div_0/divbuf_0/a_29310_n1540# 0.11fF
C4530 ro_div_0/divbuf_0/a_59550_n840# ro_div_0/divbuf_0/a_59550_n1540# 0.01fF
C4531 divbuf_1/a_58110_n840# divbuf_1/a_58110_n1540# 0.01fF
C4532 divbuf_1/a_27390_n1540# divbuf_1/a_27870_n1540# 0.11fF
C4533 divbuf_3/a_24000_n1600# divbuf_3/a_24030_n840# 0.04fF
C4534 divbuf_5/a_47070_n840# divbuf_5/a_47070_n1540# 0.01fF
C4535 divbuf_5/a_16350_n1540# divbuf_5/a_16830_n1540# 0.11fF
C4536 divbuf_0/a_20042_170# divbuf_0/a_20042_n240# 0.01fF
C4537 divbuf_0/a_39442_170# divbuf_0/a_39932_170# 0.07fF
C4538 divbuf_4/a_51360_n1600# divbuf_4/a_51390_n840# 0.04fF
C4539 divbuf_4/a_19562_n240# divbuf_4/OUT4 0.04fF
C4540 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4541 divbuf_2/a_39442_n240# divbuf_2/a_39932_n240# 0.04fF
C4542 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/a_32172_170# 0.07fF
C4543 divbuf_0/a_1352_n240# divbuf_0/OUT2 0.07fF
C4544 divbuf_0/a_12030_n840# divbuf_0/a_12510_n840# 0.07fF
C4545 divbuf_0/a_40902_170# divbuf_0/OUT4 0.19fF
C4546 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n1540# 0.19fF
C4547 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4548 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4350_n1540# 0.19fF
C4549 divbuf_2/a_50910_n840# divbuf_2/a_51390_n840# 0.07fF
C4550 divbuf_2/a_20670_n840# divbuf_2/a_20670_n1540# 0.01fF
C4551 divbuf_2/a_50880_n1600# divbuf_2/a_50910_n1540# 0.19fF
C4552 pll_full_0/divbuf_0/a_4350_n840# pll_full_0/divbuf_0/a_4830_n840# 0.07fF
C4553 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12772_n240# 0.04fF
C4554 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26430_n840# 0.04fF
C4555 divbuf_1/a_4882_170# divbuf_1/OUT3 0.19fF
C4556 divbuf_1/a_24960_n1600# divbuf_1/a_24990_n840# 0.04fF
C4557 divbuf_3/a_40902_170# divbuf_3/a_41382_170# 0.07fF
C4558 divbuf_3/a_21502_170# divbuf_3/a_21502_n240# 0.01fF
C4559 divbuf_5/a_13920_n1600# divbuf_5/a_13950_n840# 0.04fF
C4560 pll_full_0/divbuf_0/a_57150_n1540# pll_full_0/divbuf_0/a_57630_n1540# 0.11fF
C4561 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_14910_n840# 0.02fF
C4562 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24480_n1600# 0.26fF
C4563 divbuf_4/a_29262_n240# divbuf_4/a_29742_n240# 0.05fF
C4564 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_18270_n840# 0.02fF
C4565 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27840_n1600# 0.26fF
C4566 divbuf_3/a_13440_n1600# divbuf_3/a_13470_n1540# 0.19fF
C4567 divbuf_3/a_13470_n840# divbuf_3/a_13950_n840# 0.07fF
C4568 pd_div_0/divbuf_0/a_47070_n840# pd_div_0/divbuf_0/a_47070_n1540# 0.01fF
C4569 pd_div_0/divbuf_0/a_16350_n1540# pd_div_0/divbuf_0/a_16830_n1540# 0.11fF
C4570 divbuf_4/a_40830_n840# divbuf_4/a_41310_n840# 0.07fF
C4571 divbuf_4/a_10590_n840# divbuf_4/a_10590_n1540# 0.01fF
C4572 divbuf_4/a_40800_n1600# divbuf_4/a_40830_n1540# 0.19fF
C4573 pll_full_0/divbuf_1/a_19710_n1540# pll_full_0/divbuf_1/a_20190_n1540# 0.11fF
C4574 pll_full_0/divbuf_1/a_50430_n840# pll_full_0/divbuf_1/a_50430_n1540# 0.01fF
C4575 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4576 divbuf_0/a_41382_n240# divbuf_0/OUT5 0.04fF
C4577 divbuf_0/a_960_n1600# divbuf_0/OUT2 0.00fF
C4578 divbuf_1/a_1352_n240# divbuf_1/a_1842_n240# 0.04fF
C4579 divbuf_5/a_30712_170# divbuf_5/a_31202_170# 0.07fF
C4580 divbuf_5/a_11312_170# divbuf_5/a_11312_n240# 0.01fF
C4581 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4582 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_54750_n840# 0.04fF
C4583 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_15870_n1540# 0.19fF
C4584 ro_div_0/divbuf_0/a_15870_n840# ro_div_0/divbuf_0/a_16350_n840# 0.07fF
C4585 divbuf_1/a_14430_n840# divbuf_1/a_14910_n840# 0.07fF
C4586 divbuf_1/a_6332_n240# divbuf_1/OUT3 0.04fF
C4587 divbuf_1/a_14400_n1600# divbuf_1/a_14430_n1540# 0.19fF
C4588 divbuf_5/a_3390_n840# divbuf_5/a_3870_n840# 0.07fF
C4589 divbuf_5/a_3360_n1600# divbuf_5/a_3390_n1540# 0.19fF
C4590 divbuf_5/a_23442_170# divbuf_5/OUT4 0.19fF
C4591 divbuf_0/a_17612_170# divbuf_0/a_18092_170# 0.07fF
C4592 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_13950_n840# 0.04fF
C4593 divbuf_2/a_3422_170# divbuf_2/a_3912_170# 0.07fF
C4594 divbuf_5/a_56190_n1540# divbuf_5/a_56670_n1540# 0.11fF
C4595 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17310_n840# 0.04fF
C4596 divbuf_0/a_40412_n240# divbuf_0/a_40902_n240# 0.04fF
C4597 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/a_33142_n240# 0.04fF
C4598 divbuf_2/a_28292_n240# divbuf_2/a_28350_n840# 0.04fF
C4599 divbuf_2/a_37440_n1600# divbuf_2/a_37920_n1600# 0.26fF
C4600 divbuf_0/a_21630_n840# divbuf_0/a_21630_n1540# 0.01fF
C4601 divbuf_0/a_51870_n840# divbuf_0/a_52350_n840# 0.07fF
C4602 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n1540# 0.19fF
C4603 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C4604 pll_full_0/divbuf_0/a_13950_n840# pll_full_0/divbuf_0/a_13950_n1540# 0.01fF
C4605 pll_full_0/divbuf_0/a_44190_n840# pll_full_0/divbuf_0/a_44670_n840# 0.07fF
C4606 divbuf_2/a_60510_n840# divbuf_2/a_60510_n1540# 0.01fF
C4607 divbuf_2/a_29790_n1540# divbuf_2/a_30270_n1540# 0.11fF
C4608 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44190_n1540# 0.19fF
C4609 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/a_31202_170# 0.07fF
C4610 divbuf_3/a_57150_n1540# divbuf_3/a_57630_n1540# 0.11fF
C4611 divbuf_3/a_0_n1600# divbuf_3/a_480_n1600# 0.26fF
C4612 divbuf_5/a_53760_n1600# divbuf_5/a_53790_n840# 0.04fF
C4613 divbuf_5/a_24412_n240# divbuf_5/OUT4 0.04fF
C4614 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/a_34592_170# 0.07fF
C4615 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/a_14702_n240# 0.01fF
C4616 pd_div_0/divbuf_0/a_3390_n840# pd_div_0/divbuf_0/a_3870_n840# 0.07fF
C4617 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3390_n1540# 0.19fF
C4618 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4619 divbuf_4/a_27360_n1600# divbuf_4/a_27840_n1600# 0.26fF
C4620 divbuf_4/a_18092_n240# divbuf_4/a_18270_n840# 0.02fF
C4621 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C4622 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C4623 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C4624 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_6750_n1540# 0.19fF
C4625 pll_full_0/divbuf_1/a_6750_n840# pll_full_0/divbuf_1/a_7230_n840# 0.07fF
C4626 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4627 divbuf_3/a_53310_n840# divbuf_3/a_53790_n840# 0.07fF
C4628 divbuf_3/a_23070_n840# divbuf_3/a_23070_n1540# 0.01fF
C4629 pd_0/DIV pd_0/REF 2.28fF
C4630 pd_div_0/divbuf_0/a_56190_n1540# pd_div_0/divbuf_0/a_56670_n1540# 0.11fF
C4631 divbuf_2/a_27360_n1600# divbuf_2/a_27390_n840# 0.04fF
C4632 divbuf_2/a_10212_170# divbuf_2/OUT3 0.19fF
C4633 divbuf_4/a_50430_n840# divbuf_4/a_50430_n1540# 0.01fF
C4634 divbuf_4/a_19710_n1540# divbuf_4/a_20190_n1540# 0.11fF
C4635 pll_full_0/divbuf_1/a_59550_n1540# pll_full_0/divbuf_1/a_60030_n1540# 0.11fF
C4636 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C4637 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2880_n1600# 0.26fF
C4638 divbuf_1/a_960_n1600# divbuf_1/a_1440_n1600# 0.26fF
C4639 divbuf_5/a_31682_n240# divbuf_5/a_32172_n240# 0.04fF
C4640 ro_div_0/divbuf_0/a_25470_n840# ro_div_0/divbuf_0/a_25470_n1540# 0.01fF
C4641 ro_div_0/divbuf_0/a_55710_n840# ro_div_0/divbuf_0/a_56190_n840# 0.07fF
C4642 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_55710_n1540# 0.19fF
C4643 divbuf_1/a_54240_n1600# divbuf_1/a_54270_n1540# 0.19fF
C4644 divbuf_1/a_54270_n840# divbuf_1/a_54750_n840# 0.07fF
C4645 divbuf_1/a_24030_n840# divbuf_1/a_24030_n1540# 0.01fF
C4646 divbuf_5/a_43200_n1600# divbuf_5/a_43230_n1540# 0.19fF
C4647 divbuf_5/a_43230_n840# divbuf_5/a_43710_n840# 0.07fF
C4648 divbuf_5/a_12990_n840# divbuf_5/a_12990_n1540# 0.01fF
C4649 divbuf_5/a_22560_n1600# divbuf_5/OUT4 0.01fF
C4650 divbuf_0/a_8762_170# divbuf_0/a_8762_n240# 0.01fF
C4651 divbuf_0/a_1352_170# divbuf_0/a_1352_n240# 0.01fF
C4652 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C4653 ro_div_0/divider_0/and_0/A ro_div_0/divider_0/and_0/B 0.18fF
C4654 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_53790_n840# 0.04fF
C4655 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4656 divbuf_2/a_4392_n240# divbuf_2/a_4882_n240# 0.04fF
C4657 divbuf_2/a_24892_170# divbuf_2/a_24892_n240# 0.01fF
C4658 divbuf_4/a_17280_n1600# divbuf_4/a_17310_n840# 0.04fF
C4659 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57150_n840# 0.04fF
C4660 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4661 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_17310_n840# 0.02fF
C4662 divbuf_0/a_29262_n240# divbuf_0/a_29310_n840# 0.04fF
C4663 divbuf_0/a_38400_n1600# divbuf_0/a_38880_n1600# 0.26fF
C4664 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z1 0.01fF
C4665 divbuf_2/a_16830_n840# divbuf_2/a_17310_n840# 0.07fF
C4666 divbuf_2/a_11312_n240# divbuf_2/OUT4 0.07fF
C4667 divbuf_2/a_16800_n1600# divbuf_2/a_16830_n1540# 0.19fF
C4668 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/a_21630_n840# 0.03fF
C4669 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_31200_n1600# 0.26fF
C4670 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/a_19072_170# 0.07fF
C4671 divbuf_0/a_30750_n1540# divbuf_0/a_31230_n1540# 0.11fF
C4672 divbuf_1/a_11802_n240# divbuf_1/a_11550_n840# 0.02fF
C4673 divbuf_3/a_5852_170# divbuf_3/a_6332_170# 0.07fF
C4674 pll_full_0/divbuf_0/a_53790_n840# pll_full_0/divbuf_0/a_53790_n1540# 0.01fF
C4675 pll_full_0/divbuf_0/a_23070_n1540# pll_full_0/divbuf_0/a_23550_n1540# 0.11fF
C4676 divbuf_3/a_40412_170# divbuf_3/OUT4 0.19fF
C4677 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/a_32172_n240# 0.04fF
C4678 divbuf_4/a_14702_170# divbuf_4/a_14702_n240# 0.01fF
C4679 divbuf_4/a_34112_170# divbuf_4/a_34592_170# 0.07fF
C4680 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/a_35562_n240# 0.05fF
C4681 divbuf_3/a_39840_n1600# divbuf_3/a_40320_n1600# 0.26fF
C4682 divbuf_3/a_30712_n240# divbuf_3/a_30750_n840# 0.05fF
C4683 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43230_n1540# 0.19fF
C4684 pd_div_0/divbuf_0/a_43230_n840# pd_div_0/divbuf_0/a_43710_n840# 0.07fF
C4685 pd_div_0/divbuf_0/a_12990_n840# pd_div_0/divbuf_0/a_12990_n1540# 0.01fF
C4686 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C4687 divbuf_4/a_30232_170# divbuf_4/OUT4 0.19fF
C4688 divbuf_4/a_6750_n840# divbuf_4/a_7230_n840# 0.07fF
C4689 divbuf_4/a_6720_n1600# divbuf_4/a_6750_n1540# 0.19fF
C4690 pll_full_0/divbuf_1/a_16350_n840# pll_full_0/divbuf_1/a_16350_n1540# 0.01fF
C4691 pll_full_0/divbuf_1/a_46590_n840# pll_full_0/divbuf_1/a_47070_n840# 0.07fF
C4692 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_46590_n1540# 0.19fF
C4693 divbuf_3/a_32190_n1540# divbuf_3/a_32670_n1540# 0.11fF
C4694 divbuf_0/a_12282_170# divbuf_0/OUT4 0.19fF
C4695 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n840# 0.04fF
C4696 pd_div_0/divider_0/prescaler_0/tspc_0/D gnd 0.05fF
C4697 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/Out 0.21fF
C4698 divbuf_4/a_59550_n1540# divbuf_4/a_60030_n1540# 0.11fF
C4699 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/B 0.08fF
C4700 divbuf_2/a_10080_n1600# divbuf_2/OUT3 0.00fF
C4701 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_20670_n840# 0.04fF
C4702 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/a_18582_n240# 0.01fF
C4703 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/a_33150_n840# 0.06fF
C4704 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42720_n1600# 0.26fF
C4705 divbuf_1/a_40800_n1600# divbuf_1/a_41280_n1600# 0.26fF
C4706 divbuf_1/a_17122_170# divbuf_1/OUT4 0.19fF
C4707 divbuf_1/a_31682_n240# divbuf_1/a_31710_n840# 0.05fF
C4708 divbuf_5/a_29760_n1600# divbuf_5/a_30240_n1600# 0.26fF
C4709 divbuf_5/a_20532_n240# divbuf_5/a_20670_n840# 0.03fF
C4710 divbuf_3/a_41382_n240# divbuf_3/OUT4 0.04fF
C4711 ro_div_0/divbuf_0/a_34590_n1540# ro_div_0/divbuf_0/a_35070_n1540# 0.11fF
C4712 divbuf_1/a_33150_n1540# divbuf_1/a_33630_n1540# 0.11fF
C4713 divbuf_3/a_29760_n1600# divbuf_3/a_29790_n840# 0.04fF
C4714 divbuf_5/a_52830_n840# divbuf_5/a_52830_n1540# 0.01fF
C4715 divbuf_5/a_22110_n1540# divbuf_5/a_22590_n1540# 0.11fF
C4716 divbuf_0/a_5362_n240# divbuf_0/a_5852_n240# 0.04fF
C4717 divbuf_0/a_25862_170# divbuf_0/a_25862_n240# 0.01fF
C4718 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C4719 divbuf_4/a_31202_n240# divbuf_4/OUT4 0.04fF
C4720 divbuf_4/a_57120_n1600# divbuf_4/a_57150_n840# 0.04fF
C4721 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/a_37992_170# 0.07fF
C4722 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4723 divbuf_2/a_3360_n1600# divbuf_2/a_3840_n1600# 0.26fF
C4724 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n1540# 0.19fF
C4725 divbuf_0/a_13252_n240# divbuf_0/OUT4 0.04fF
C4726 divbuf_0/a_17790_n840# divbuf_0/a_18270_n840# 0.07fF
C4727 pll_full_0/divbuf_0/a_10110_n840# pll_full_0/divbuf_0/a_10590_n840# 0.07fF
C4728 divbuf_2/a_56640_n1600# divbuf_2/a_56670_n1540# 0.19fF
C4729 divbuf_2/a_56670_n840# divbuf_2/a_57150_n840# 0.07fF
C4730 divbuf_2/a_26430_n840# divbuf_2/a_26430_n1540# 0.01fF
C4731 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10110_n1540# 0.19fF
C4732 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4733 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_18582_n240# 0.04fF
C4734 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32190_n840# 0.04fF
C4735 divbuf_1/a_30720_n1600# divbuf_1/a_30750_n840# 0.04fF
C4736 divbuf_3/a_27322_170# divbuf_3/a_27322_n240# 0.01fF
C4737 divbuf_3/a_6822_n240# divbuf_3/a_7302_n240# 0.05fF
C4738 divbuf_5/a_19680_n1600# divbuf_5/a_19710_n840# 0.04fF
C4739 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/OUT3 0.36fF
C4740 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_30240_n1600# 0.26fF
C4741 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/a_20670_n840# 0.03fF
C4742 divbuf_4/a_35082_n240# divbuf_4/a_35562_n240# 0.05fF
C4743 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/a_24030_n840# 0.03fF
C4744 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33600_n1600# 0.26fF
C4745 divbuf_3/a_19200_n1600# divbuf_3/a_19230_n1540# 0.19fF
C4746 divbuf_3/a_19230_n840# divbuf_3/a_19710_n840# 0.07fF
C4747 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C4748 pd_div_0/divbuf_0/a_52830_n840# pd_div_0/divbuf_0/a_52830_n1540# 0.01fF
C4749 pd_div_0/divbuf_0/a_22110_n1540# pd_div_0/divbuf_0/a_22590_n1540# 0.11fF
C4750 divbuf_4/a_46560_n1600# divbuf_4/a_46590_n1540# 0.19fF
C4751 divbuf_4/a_46590_n840# divbuf_4/a_47070_n840# 0.07fF
C4752 divbuf_4/a_16350_n840# divbuf_4/a_16350_n1540# 0.01fF
C4753 divbuf_2/a_14222_n240# divbuf_2/a_13950_n840# 0.01fF
C4754 pll_full_0/divbuf_1/a_25470_n1540# pll_full_0/divbuf_1/a_25950_n1540# 0.11fF
C4755 pll_full_0/divbuf_1/a_56190_n840# pll_full_0/divbuf_1/a_56190_n1540# 0.01fF
C4756 divbuf_0/a_11520_n1600# divbuf_0/OUT4 0.01fF
C4757 divbuf_1/a_7792_n240# divbuf_1/a_8272_n240# 0.05fF
C4758 divbuf_5/a_17122_170# divbuf_5/a_17122_n240# 0.01fF
C4759 divbuf_5/a_36532_170# divbuf_5/a_37022_170# 0.07fF
C4760 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/a_60510_n840# 0.04fF
C4761 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4762 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4763 ro_div_0/divbuf_0/a_21630_n840# ro_div_0/divbuf_0/a_22110_n840# 0.07fF
C4764 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_21630_n1540# 0.19fF
C4765 divbuf_1/a_20160_n1600# divbuf_1/a_20190_n1540# 0.19fF
C4766 divbuf_1/a_20190_n840# divbuf_1/a_20670_n840# 0.07fF
C4767 divbuf_1/a_18092_n240# divbuf_1/OUT4 0.04fF
C4768 divbuf_5/a_9120_n1600# divbuf_5/a_9150_n1540# 0.19fF
C4769 divbuf_5/a_35082_170# divbuf_5/OUT4 0.19fF
C4770 divbuf_5/a_9150_n840# divbuf_5/a_9630_n840# 0.07fF
C4771 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_19710_n840# 0.04fF
C4772 divbuf_2/a_9242_170# divbuf_2/a_9732_170# 0.07fF
C4773 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23070_n840# 0.04fF
C4774 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/OUT2 0.23fF
C4775 divbuf_0/a_4320_n1600# divbuf_0/a_4800_n1600# 0.26fF
C4776 divbuf_2/a_43200_n1600# divbuf_2/a_43680_n1600# 0.26fF
C4777 divbuf_2/a_34112_n240# divbuf_2/a_34110_n840# 0.06fF
C4778 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/a_38962_n240# 0.04fF
C4779 gnd pll_full_0/divbuf_0/IN 3.72fF
C4780 divbuf_0/a_27390_n840# divbuf_0/a_27390_n1540# 0.01fF
C4781 divbuf_0/a_57630_n840# divbuf_0/a_58110_n840# 0.07fF
C4782 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n1540# 0.19fF
C4783 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_49950_n1540# 0.19fF
C4784 divbuf_2/a_35550_n1540# divbuf_2/a_36030_n1540# 0.11fF
C4785 pll_full_0/divbuf_0/a_49950_n840# pll_full_0/divbuf_0/a_50430_n840# 0.07fF
C4786 pll_full_0/divbuf_0/a_19710_n840# pll_full_0/divbuf_0/a_19710_n1540# 0.01fF
C4787 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C4788 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C4789 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/a_17122_n240# 0.01fF
C4790 pd_div_0/div pd_div_0/divbuf_0/a_0_n1600# 0.26fF
C4791 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/a_37022_170# 0.07fF
C4792 divbuf_3/OUT2 divbuf_3/OUT3 0.36fF
C4793 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/a_20532_n240# 0.01fF
C4794 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/a_40412_170# 0.07fF
C4795 divbuf_3/a_5760_n1600# divbuf_3/a_6240_n1600# 0.26fF
C4796 divbuf_5/a_36052_n240# divbuf_5/OUT4 0.04fF
C4797 divbuf_5/a_59520_n1600# divbuf_5/a_59550_n840# 0.04fF
C4798 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C4799 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C4800 ro_div_0/divider_0/prescaler_0/tspc_0/D ro_div_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C4801 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/Out 0.19fF
C4802 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9150_n1540# 0.19fF
C4803 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4804 pd_div_0/divbuf_0/a_9150_n840# pd_div_0/divbuf_0/a_9630_n840# 0.07fF
C4805 divbuf_3/a_59070_n840# divbuf_3/a_59550_n840# 0.07fF
C4806 divbuf_3/a_28830_n840# divbuf_3/a_28830_n1540# 0.01fF
C4807 divbuf_4/a_33120_n1600# divbuf_4/a_33600_n1600# 0.26fF
C4808 divbuf_4/a_23922_n240# divbuf_4/a_24030_n840# 0.03fF
C4809 pll_full_0/divbuf_1/a_12510_n840# pll_full_0/divbuf_1/a_12990_n840# 0.07fF
C4810 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12510_n1540# 0.19fF
C4811 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/OUT2 0.04fF
C4812 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/OUT5 0.07fF
C4813 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/a_2430_n840# 0.03fF
C4814 divbuf_0/a_15182_n240# divbuf_0/a_14910_n840# 0.01fF
C4815 divbuf_2/a_33120_n1600# divbuf_2/a_33150_n840# 0.04fF
C4816 divbuf_2/a_21982_170# divbuf_2/OUT4 0.19fF
C4817 divbuf_4/a_56190_n840# divbuf_4/a_56190_n1540# 0.01fF
C4818 divbuf_4/a_25470_n1540# divbuf_4/a_25950_n1540# 0.11fF
C4819 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8640_n1600# 0.26fF
C4820 divbuf_1/a_6720_n1600# divbuf_1/a_7200_n1600# 0.26fF
C4821 divbuf_5/a_37502_n240# divbuf_5/a_37992_n240# 0.04fF
C4822 divbuf_3/a_11802_170# divbuf_3/OUT4 0.19fF
C4823 ro_div_0/divbuf_0/a_510_n1540# ro_div_0/divbuf_0/a_990_n1540# 0.11fF
C4824 ro_div_0/divbuf_0/a_31230_n840# ro_div_0/divbuf_0/a_31230_n1540# 0.01fF
C4825 divbuf_1/a_60030_n840# divbuf_1/a_60510_n840# 0.07fF
C4826 divbuf_1/a_29790_n840# divbuf_1/a_29790_n1540# 0.01fF
C4827 divbuf_1/a_60000_n1600# divbuf_1/a_60030_n1540# 0.19fF
C4828 divbuf_3/a_16642_n240# divbuf_3/a_16350_n840# 0.00fF
C4829 divbuf_5/a_48990_n840# divbuf_5/a_49470_n840# 0.07fF
C4830 divbuf_5/a_18750_n840# divbuf_5/a_18750_n1540# 0.01fF
C4831 divbuf_5/a_34080_n1600# divbuf_5/OUT4 0.01fF
C4832 divbuf_5/a_48960_n1600# divbuf_5/a_48990_n1540# 0.19fF
C4833 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4834 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_59550_n840# 0.04fF
C4835 divbuf_2/a_30712_170# divbuf_2/a_30712_n240# 0.01fF
C4836 divbuf_4/a_1352_170# divbuf_4/OUT2 0.23fF
C4837 divbuf_4/a_23040_n1600# divbuf_4/a_23070_n840# 0.04fF
C4838 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C4839 pll_full_0/divbuf_1/a_0_n1600# pll_full_0/divbuf_1/OUT 0.26fF
C4840 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C4841 divbuf_0/a_35082_n240# divbuf_0/a_35070_n840# 0.05fF
C4842 divbuf_0/a_44160_n1600# divbuf_0/a_44640_n1600# 0.26fF
C4843 divbuf_0/a_9242_170# divbuf_0/OUT3 0.19fF
C4844 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36960_n1600# 0.26fF
C4845 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C4846 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z4 0.15fF
C4847 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z2 0.30fF
C4848 divbuf_2/a_22560_n1600# divbuf_2/a_22590_n1540# 0.19fF
C4849 divbuf_2/a_22590_n840# divbuf_2/a_23070_n840# 0.07fF
C4850 divbuf_2/a_22952_n240# divbuf_2/OUT4 0.04fF
C4851 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/a_27390_n840# 0.04fF
C4852 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C4853 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C4854 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C4855 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C4856 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/a_23442_170# 0.07fF
C4857 divbuf_0/a_36510_n1540# divbuf_0/a_36990_n1540# 0.11fF
C4858 divbuf_1/a_17612_n240# divbuf_1/a_17310_n840# 0.00fF
C4859 divbuf_3/a_12282_170# divbuf_3/a_12772_170# 0.07fF
C4860 pll_full_0/divbuf_0/a_28830_n1540# pll_full_0/divbuf_0/a_29310_n1540# 0.11fF
C4861 pll_full_0/divbuf_0/a_59550_n840# pll_full_0/divbuf_0/a_59550_n1540# 0.01fF
C4862 divbuf_3/a_12772_n240# divbuf_3/OUT4 0.04fF
C4863 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/a_37992_n240# 0.04fF
C4864 divbuf_4/a_39932_170# divbuf_4/a_40412_170# 0.07fF
C4865 divbuf_4/a_20532_170# divbuf_4/a_20532_n240# 0.01fF
C4866 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/a_41382_n240# 0.05fF
C4867 divbuf_3/a_36532_n240# divbuf_3/a_36510_n840# 0.05fF
C4868 divbuf_3/a_45600_n1600# divbuf_3/a_46080_n1600# 0.26fF
C4869 pd_div_0/divbuf_0/a_48990_n840# pd_div_0/divbuf_0/a_49470_n840# 0.07fF
C4870 pd_div_0/divbuf_0/a_18750_n840# pd_div_0/divbuf_0/a_18750_n1540# 0.01fF
C4871 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C4872 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_48990_n1540# 0.19fF
C4873 divbuf_4/a_41382_170# divbuf_4/OUT5 0.07fF
C4874 divbuf_4/a_2322_n240# divbuf_4/OUT2 0.04fF
C4875 divbuf_4/a_12480_n1600# divbuf_4/a_12510_n1540# 0.19fF
C4876 divbuf_4/a_12510_n840# divbuf_4/a_12990_n840# 0.07fF
C4877 pll_full_0/divbuf_1/a_22110_n840# pll_full_0/divbuf_1/a_22110_n1540# 0.01fF
C4878 pll_full_0/divbuf_1/a_52350_n840# pll_full_0/divbuf_1/a_52830_n840# 0.07fF
C4879 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52350_n1540# 0.19fF
C4880 divbuf_3/a_37950_n1540# divbuf_3/a_38430_n1540# 0.11fF
C4881 divbuf_0/a_23922_170# divbuf_0/OUT4 0.19fF
C4882 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n840# 0.04fF
C4883 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z4 0.12fF
C4884 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z3 0.38fF
C4885 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z2 1.07fF
C4886 gnd pd_div_0/divider_0/and_0/out1 0.29fF
C4887 divbuf_1/a_12772_170# divbuf_1/a_13252_170# 0.07fF
C4888 divbuf_2/a_21120_n1600# divbuf_2/OUT4 0.00fF
C4889 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26430_n840# 0.04fF
C4890 pll_full_0/divbuf_0/a_7302_170# pll_full_0/divbuf_0/OUT3 0.19fF
C4891 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48480_n1600# 0.26fF
C4892 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/a_38910_n840# 0.04fF
C4893 divbuf_1/a_37502_n240# divbuf_1/a_37470_n840# 0.05fF
C4894 divbuf_1/a_46560_n1600# divbuf_1/a_47040_n1600# 0.26fF
C4895 divbuf_5/a_26352_n240# divbuf_5/a_26430_n840# 0.04fF
C4896 divbuf_5/a_35520_n1600# divbuf_5/a_36000_n1600# 0.26fF
C4897 divbuf_3/a_11040_n1600# divbuf_3/OUT4 0.00fF
C4898 ro_div_0/divbuf_0/a_40350_n1540# ro_div_0/divbuf_0/a_40830_n1540# 0.11fF
C4899 divbuf_1/a_38910_n1540# divbuf_1/a_39390_n1540# 0.11fF
C4900 divbuf_5/a_58590_n840# divbuf_5/a_58590_n1540# 0.01fF
C4901 divbuf_5/a_27870_n1540# divbuf_5/a_28350_n1540# 0.11fF
C4902 divbuf_3/a_35520_n1600# divbuf_3/a_35550_n840# 0.04fF
C4903 divbuf_0/a_31682_170# divbuf_0/a_31682_n240# 0.01fF
C4904 divbuf_0/a_11802_n240# divbuf_0/a_12282_n240# 0.05fF
C4905 divbuf_2/a_9120_n1600# divbuf_2/a_9600_n1600# 0.26fF
C4906 divbuf_4/a_1920_n1600# divbuf_4/OUT2 0.00fF
C4907 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/a_23922_n240# 0.01fF
C4908 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4909 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/a_3912_n240# 0.04fF
C4910 divbuf_0/a_23550_n840# divbuf_0/a_24030_n840# 0.07fF
C4911 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n1540# 0.19fF
C4912 divbuf_0/a_24892_n240# divbuf_0/OUT4 0.04fF
C4913 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_15870_n1540# 0.19fF
C4914 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C4915 divbuf_2/a_60480_n1600# divbuf_2/OUT5 0.26fF
C4916 divbuf_2/a_32190_n840# divbuf_2/a_32190_n1540# 0.01fF
C4917 divbuf_2/a_1470_n1540# divbuf_2/a_1950_n1540# 0.11fF
C4918 pll_full_0/divbuf_0/a_15870_n840# pll_full_0/divbuf_0/a_16350_n840# 0.07fF
C4919 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_37950_n840# 0.04fF
C4920 pd_div_0/pd_0/tspc_r_1/Z1 pd_div_0/pd_0/tspc_r_1/Z2 0.71fF
C4921 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/z5 0.04fF
C4922 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z4 0.20fF
C4923 divbuf_1/a_25382_170# divbuf_1/OUT4 0.19fF
C4924 divbuf_1/a_36480_n1600# divbuf_1/a_36510_n840# 0.04fF
C4925 divbuf_5/a_6332_170# divbuf_5/OUT3 0.19fF
C4926 divbuf_5/a_25440_n1600# divbuf_5/a_25470_n840# 0.04fF
C4927 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C4928 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/a_5362_170# 0.07fF
C4929 divbuf_3/a_13252_n240# divbuf_3/a_13742_n240# 0.04fF
C4930 divbuf_3/a_33142_170# divbuf_3/a_33142_n240# 0.01fF
C4931 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/a_26430_n840# 0.04fF
C4932 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_36000_n1600# 0.26fF
C4933 divbuf_4/a_40902_n240# divbuf_4/a_41382_n240# 0.05fF
C4934 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/a_29790_n840# 0.04fF
C4935 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_39360_n1600# 0.26fF
C4936 divbuf_3/a_24960_n1600# divbuf_3/a_24990_n1540# 0.19fF
C4937 divbuf_3/a_24990_n840# divbuf_3/a_25470_n840# 0.07fF
C4938 pd_div_0/divbuf_0/a_58590_n840# pd_div_0/divbuf_0/a_58590_n1540# 0.01fF
C4939 pd_div_0/divbuf_0/a_27870_n1540# pd_div_0/divbuf_0/a_28350_n1540# 0.11fF
C4940 divbuf_4/a_52320_n1600# divbuf_4/a_52350_n1540# 0.19fF
C4941 divbuf_4/a_52350_n840# divbuf_4/a_52830_n840# 0.07fF
C4942 divbuf_4/a_22110_n840# divbuf_4/a_22110_n1540# 0.01fF
C4943 pll_full_0/divbuf_1/a_31230_n1540# pll_full_0/divbuf_1/a_31710_n1540# 0.11fF
C4944 gnd pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.94fF
C4945 divbuf_0/a_23040_n1600# divbuf_0/OUT4 0.01fF
C4946 divbuf_1/a_14222_n240# divbuf_1/a_14702_n240# 0.05fF
C4947 divbuf_1/a_34112_170# divbuf_1/a_34112_n240# 0.01fF
C4948 divbuf_5/a_22952_170# divbuf_5/a_22952_n240# 0.01fF
C4949 divbuf_5/a_1842_n240# divbuf_5/a_2322_n240# 0.05fF
C4950 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27390_n1540# 0.19fF
C4951 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4952 ro_div_0/divbuf_0/a_27390_n840# ro_div_0/divbuf_0/a_27870_n840# 0.07fF
C4953 divbuf_1/a_25950_n840# divbuf_1/a_26430_n840# 0.07fF
C4954 divbuf_1/a_29742_n240# divbuf_1/OUT4 0.04fF
C4955 divbuf_1/a_25920_n1600# divbuf_1/a_25950_n1540# 0.19fF
C4956 divbuf_5/a_14910_n840# divbuf_5/a_15390_n840# 0.07fF
C4957 divbuf_5/a_7302_n240# divbuf_5/OUT3 0.04fF
C4958 divbuf_5/a_14880_n1600# divbuf_5/a_14910_n1540# 0.19fF
C4959 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z2 0.01fF
C4960 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4961 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25470_n840# 0.04fF
C4962 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4963 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_28830_n840# 0.04fF
C4964 divbuf_2/a_15672_170# divbuf_2/a_16152_170# 0.07fF
C4965 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C4966 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C4967 divbuf_0/a_10080_n1600# divbuf_0/a_10560_n1600# 0.26fF
C4968 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2880_n1600# 0.26fF
C4969 divbuf_2/a_39932_n240# divbuf_2/a_39870_n840# 0.04fF
C4970 divbuf_2/a_48960_n1600# divbuf_2/a_49440_n1600# 0.26fF
C4971 divbuf_0/a_2430_n1540# divbuf_0/a_2910_n1540# 0.11fF
C4972 divbuf_0/a_33150_n840# divbuf_0/a_33150_n1540# 0.01fF
C4973 divbuf_0/a_2910_n840# divbuf_0/OUT3 0.03fF
C4974 pll_full_0/divbuf_0/a_25470_n840# pll_full_0/divbuf_0/a_25470_n1540# 0.01fF
C4975 pll_full_0/divbuf_0/a_55710_n840# pll_full_0/divbuf_0/a_56190_n840# 0.07fF
C4976 divbuf_2/a_41310_n1540# divbuf_2/a_41790_n1540# 0.11fF
C4977 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_55710_n1540# 0.19fF
C4978 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/a_22952_n240# 0.01fF
C4979 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/a_2322_n240# 0.05fF
C4980 divbuf_4/a_4882_170# divbuf_4/a_5362_170# 0.07fF
C4981 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/a_6332_n240# 0.05fF
C4982 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/a_26352_n240# 0.01fF
C4983 divbuf_3/a_11520_n1600# divbuf_3/a_12000_n1600# 0.26fF
C4984 ro_div_0/divider_0/prescaler_0/tspc_0/D ro_div_0/divider_0/clk 0.26fF
C4985 pd_div_0/divbuf_0/a_14910_n840# pd_div_0/divbuf_0/a_15390_n840# 0.07fF
C4986 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C4987 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_14910_n1540# 0.19fF
C4988 divbuf_4/a_38880_n1600# divbuf_4/a_39360_n1600# 0.26fF
C4989 divbuf_4/a_29742_n240# divbuf_4/a_29790_n840# 0.04fF
C4990 divbuf_3/a_34590_n840# divbuf_3/a_34590_n1540# 0.01fF
C4991 divbuf_3/a_3870_n1540# divbuf_3/a_4350_n1540# 0.11fF
C4992 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18270_n1540# 0.19fF
C4993 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4994 pll_full_0/divbuf_1/a_18270_n840# pll_full_0/divbuf_1/a_18750_n840# 0.07fF
C4995 divbuf_2/a_38880_n1600# divbuf_2/a_38910_n840# 0.04fF
C4996 divbuf_2/a_33622_170# divbuf_2/OUT4 0.19fF
C4997 divbuf_4/a_31230_n1540# divbuf_4/a_31710_n1540# 0.11fF
C4998 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_12990_n840# 0.01fF
C4999 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_14400_n1600# 0.26fF
C5000 divbuf_0/a_41790_n840# divbuf_0/OUT5 0.03fF
C5001 divbuf_1/a_12480_n1600# divbuf_1/a_12960_n1600# 0.26fF
C5002 divbuf_5/a_1440_n1600# divbuf_5/a_1920_n1600# 0.26fF
C5003 divbuf_3/a_23442_170# divbuf_3/OUT4 0.19fF
C5004 ro_div_0/divbuf_0/a_6270_n1540# ro_div_0/divbuf_0/a_6750_n1540# 0.11fF
C5005 ro_div_0/divbuf_0/a_36990_n840# ro_div_0/divbuf_0/a_36990_n1540# 0.01fF
C5006 divbuf_1/a_35550_n840# divbuf_1/a_35550_n1540# 0.01fF
C5007 divbuf_1/a_4830_n1540# divbuf_1/a_5310_n1540# 0.11fF
C5008 divbuf_3/a_1440_n1600# divbuf_3/a_1470_n840# 0.04fF
C5009 divbuf_5/a_54720_n1600# divbuf_5/a_54750_n1540# 0.19fF
C5010 divbuf_5/a_54750_n840# divbuf_5/a_55230_n840# 0.07fF
C5011 divbuf_5/a_24510_n840# divbuf_5/a_24510_n1540# 0.01fF
C5012 divbuf_0/a_14222_170# divbuf_0/a_14702_170# 0.07fF
C5013 divbuf_2/a_16642_n240# divbuf_2/a_17122_n240# 0.05fF
C5014 divbuf_2/a_36532_170# divbuf_2/a_36532_n240# 0.01fF
C5015 divbuf_4/a_28800_n1600# divbuf_4/a_28830_n840# 0.04fF
C5016 divbuf_4/a_13252_170# divbuf_4/OUT4 0.19fF
C5017 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5018 divbuf_0/a_40902_n240# divbuf_0/a_40830_n840# 0.03fF
C5019 divbuf_0/a_49920_n1600# divbuf_0/a_50400_n1600# 0.26fF
C5020 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 gnd 0.27fF
C5021 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/a_33150_n840# 0.06fF
C5022 divbuf_2/a_28350_n840# divbuf_2/a_28830_n840# 0.07fF
C5023 divbuf_2/a_34592_n240# divbuf_2/OUT4 0.04fF
C5024 divbuf_2/a_28320_n1600# divbuf_2/a_28350_n1540# 0.19fF
C5025 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42720_n1600# 0.26fF
C5026 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C5027 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C5028 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/a_29262_170# 0.07fF
C5029 divbuf_0/a_42270_n1540# divbuf_0/a_42750_n1540# 0.11fF
C5030 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_3870_n840# 0.04fF
C5031 divbuf_1/a_2400_n1600# divbuf_1/a_2430_n840# 0.04fF
C5032 divbuf_3/a_18092_170# divbuf_3/a_18582_170# 0.07fF
C5033 divbuf_5/a_12282_n240# divbuf_5/a_12030_n840# 0.02fF
C5034 pll_full_0/divbuf_0/a_34590_n1540# pll_full_0/divbuf_0/a_35070_n1540# 0.11fF
C5035 divbuf_3/a_24412_n240# divbuf_3/OUT4 0.04fF
C5036 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1920_n1600# 0.26fF
C5037 divbuf_3/a_51360_n1600# divbuf_3/a_51840_n1600# 0.26fF
C5038 divbuf_4/a_26352_170# divbuf_4/a_26352_n240# 0.01fF
C5039 divbuf_4/a_5852_n240# divbuf_4/a_6332_n240# 0.05fF
C5040 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_5280_n1600# 0.26fF
C5041 divbuf_0/a_16152_170# divbuf_0/a_16152_n240# 0.01fF
C5042 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_54750_n1540# 0.19fF
C5043 pd_div_0/divbuf_0/a_54750_n840# pd_div_0/divbuf_0/a_55230_n840# 0.07fF
C5044 pd_div_0/divbuf_0/a_24510_n840# pd_div_0/divbuf_0/a_24510_n1540# 0.01fF
C5045 divbuf_4/a_18270_n840# divbuf_4/a_18750_n840# 0.07fF
C5046 divbuf_4/a_14222_n240# divbuf_4/OUT4 0.04fF
C5047 divbuf_4/a_18240_n1600# divbuf_4/a_18270_n1540# 0.19fF
C5048 pll_full_0/divbuf_1/a_27870_n840# pll_full_0/divbuf_1/a_27870_n1540# 0.01fF
C5049 pll_full_0/divbuf_1/a_58110_n840# pll_full_0/divbuf_1/a_58590_n840# 0.07fF
C5050 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58110_n1540# 0.19fF
C5051 divbuf_3/a_43710_n1540# divbuf_3/a_44190_n1540# 0.11fF
C5052 divbuf_0/a_35562_170# divbuf_0/OUT4 0.19fF
C5053 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n840# 0.04fF
C5054 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/a_11802_n240# 0.01fF
C5055 divbuf_2/a_32640_n1600# divbuf_2/OUT4 0.00fF
C5056 divbuf_5/a_7302_170# divbuf_5/a_7792_170# 0.07fF
C5057 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32190_n840# 0.04fF
C5058 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5059 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_54240_n1600# 0.26fF
C5060 divbuf_1/a_52320_n1600# divbuf_1/a_52800_n1600# 0.26fF
C5061 divbuf_5/a_41280_n1600# divbuf_5/a_41760_n1600# 0.26fF
C5062 divbuf_5/a_32172_n240# divbuf_5/a_32190_n840# 0.06fF
C5063 divbuf_3/a_22560_n1600# divbuf_3/OUT4 0.01fF
C5064 ro_div_0/divbuf_0/a_46110_n1540# ro_div_0/divbuf_0/a_46590_n1540# 0.11fF
C5065 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12030_n840# 0.02fF
C5066 divbuf_1/a_44670_n1540# divbuf_1/a_45150_n1540# 0.11fF
C5067 divbuf_5/a_33630_n1540# divbuf_5/a_34110_n1540# 0.11fF
C5068 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_15390_n840# 0.01fF
C5069 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/a_25382_n240# 0.01fF
C5070 divbuf_3/a_41280_n1600# divbuf_3/a_41310_n840# 0.04fF
C5071 divbuf_0/a_17612_n240# divbuf_0/a_18092_n240# 0.05fF
C5072 divbuf_0/a_37502_170# divbuf_0/a_37502_n240# 0.01fF
C5073 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/a_9732_n240# 0.04fF
C5074 divbuf_2/a_5362_n240# divbuf_2/a_5310_n840# 0.04fF
C5075 divbuf_2/a_14880_n1600# divbuf_2/a_15360_n1600# 0.26fF
C5076 divbuf_4/a_12480_n1600# divbuf_4/OUT4 0.00fF
C5077 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/a_29742_n240# 0.01fF
C5078 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5079 divbuf_0/a_36532_n240# divbuf_0/OUT4 0.04fF
C5080 divbuf_0/a_29310_n840# divbuf_0/a_29790_n840# 0.07fF
C5081 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n1540# 0.19fF
C5082 divbuf_2/a_37950_n840# divbuf_2/a_37950_n1540# 0.01fF
C5083 divbuf_2/a_7230_n1540# divbuf_2/a_7710_n1540# 0.11fF
C5084 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5085 pll_full_0/divbuf_0/a_21630_n840# pll_full_0/divbuf_0/a_22110_n840# 0.07fF
C5086 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_21630_n1540# 0.19fF
C5087 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_43710_n840# 0.04fF
C5088 divbuf_1/a_42240_n1600# divbuf_1/a_42270_n840# 0.04fF
C5089 divbuf_1/a_40412_170# divbuf_1/OUT4 0.19fF
C5090 divbuf_5/a_31200_n1600# divbuf_5/a_31230_n840# 0.04fF
C5091 divbuf_5/a_18092_170# divbuf_5/OUT4 0.19fF
C5092 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/a_11802_170# 0.07fF
C5093 divbuf_3/a_38962_170# divbuf_3/a_38962_n240# 0.01fF
C5094 divbuf_3/a_19072_n240# divbuf_3/a_19562_n240# 0.04fF
C5095 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41760_n1600# 0.26fF
C5096 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/a_32190_n840# 0.06fF
C5097 divbuf_4/a_4800_n1600# divbuf_4/a_5280_n1600# 0.26fF
C5098 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/a_35550_n840# 0.05fF
C5099 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_45120_n1600# 0.26fF
C5100 divbuf_3/a_30720_n1600# divbuf_3/a_30750_n1540# 0.19fF
C5101 divbuf_3/a_510_n840# divbuf_3/a_510_n1540# 0.01fF
C5102 divbuf_3/a_30750_n840# divbuf_3/a_31230_n840# 0.07fF
C5103 pd_div_0/divbuf_0/a_33630_n1540# pd_div_0/divbuf_0/a_34110_n1540# 0.11fF
C5104 divbuf_2/a_4800_n1600# divbuf_2/a_4830_n840# 0.04fF
C5105 divbuf_4/a_58080_n1600# divbuf_4/a_58110_n1540# 0.19fF
C5106 divbuf_4/a_58110_n840# divbuf_4/a_58590_n840# 0.07fF
C5107 divbuf_4/a_27870_n840# divbuf_4/a_27870_n1540# 0.01fF
C5108 pll_full_0/divbuf_1/a_36990_n1540# pll_full_0/divbuf_1/a_37470_n1540# 0.11fF
C5109 gnd pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.22fF
C5110 divbuf_0/a_34560_n1600# divbuf_0/OUT4 0.01fF
C5111 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/a_21982_n240# 0.05fF
C5112 divbuf_1/a_39932_170# divbuf_1/a_39932_n240# 0.01fF
C5113 divbuf_1/a_20042_n240# divbuf_1/a_20532_n240# 0.04fF
C5114 divbuf_5/a_28772_170# divbuf_5/a_28772_n240# 0.01fF
C5115 divbuf_5/a_8272_n240# divbuf_5/a_8762_n240# 0.04fF
C5116 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C5117 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/a_2910_n1540# 0.01fF
C5118 ro_div_0/divbuf_0/a_33150_n840# ro_div_0/divbuf_0/a_33630_n840# 0.07fF
C5119 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33150_n1540# 0.19fF
C5120 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/a_6822_n240# 0.01fF
C5121 divbuf_1/a_31680_n1600# divbuf_1/a_31710_n1540# 0.19fF
C5122 divbuf_1/a_31710_n840# divbuf_1/a_32190_n840# 0.07fF
C5123 divbuf_1/a_1470_n840# divbuf_1/a_1470_n1540# 0.01fF
C5124 divbuf_1/a_41382_n240# divbuf_1/OUT4 0.04fF
C5125 divbuf_5/a_20640_n1600# divbuf_5/a_20670_n1540# 0.19fF
C5126 divbuf_5/a_20670_n840# divbuf_5/a_21150_n840# 0.07fF
C5127 divbuf_5/a_19072_n240# divbuf_5/OUT4 0.04fF
C5128 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C5129 divbuf_3/a_52830_n840# divbuf_3/a_52830_n1540# 0.01fF
C5130 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C5131 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31230_n840# 0.04fF
C5132 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5133 divbuf_2/a_21502_170# divbuf_2/a_21982_170# 0.07fF
C5134 divbuf_4/a_15672_n240# divbuf_4/a_15390_n840# 0.01fF
C5135 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5136 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_34590_n840# 0.04fF
C5137 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C5138 divbuf_0/a_6332_n240# divbuf_0/a_6270_n840# 0.04fF
C5139 divbuf_0/a_15840_n1600# divbuf_0/a_16320_n1600# 0.26fF
C5140 divbuf_2/a_4882_170# divbuf_2/OUT3 0.19fF
C5141 divbuf_2/a_54720_n1600# divbuf_2/a_55200_n1600# 0.26fF
C5142 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8640_n1600# 0.26fF
C5143 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C5144 divbuf_0/a_8190_n1540# divbuf_0/a_8670_n1540# 0.11fF
C5145 divbuf_0/a_38910_n840# divbuf_0/a_38910_n1540# 0.01fF
C5146 divbuf_2/a_47070_n1540# divbuf_2/a_47550_n1540# 0.11fF
C5147 pll_full_0/divbuf_0/a_31230_n840# pll_full_0/divbuf_0/a_31230_n1540# 0.01fF
C5148 pll_full_0/divbuf_0/a_510_n1540# pll_full_0/divbuf_0/a_990_n1540# 0.11fF
C5149 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/a_28772_n240# 0.01fF
C5150 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/a_8762_n240# 0.04fF
C5151 divbuf_4/a_11312_170# divbuf_4/a_11802_170# 0.07fF
C5152 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/a_32172_n240# 0.01fF
C5153 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12772_n240# 0.04fF
C5154 divbuf_3/a_17280_n1600# divbuf_3/a_17760_n1600# 0.26fF
C5155 divbuf_3/a_7792_n240# divbuf_3/a_7710_n840# 0.03fF
C5156 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C5157 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_20670_n1540# 0.19fF
C5158 pd_div_0/divbuf_0/a_20670_n840# pd_div_0/divbuf_0/a_21150_n840# 0.07fF
C5159 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5160 divbuf_4/a_44640_n1600# divbuf_4/a_45120_n1600# 0.26fF
C5161 divbuf_4/a_35562_n240# divbuf_4/a_35550_n840# 0.05fF
C5162 pll_full_0/divbuf_1/a_24030_n840# pll_full_0/divbuf_1/a_24510_n840# 0.07fF
C5163 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24030_n1540# 0.19fF
C5164 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5165 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_14430_n840# 0.01fF
C5166 divbuf_2/a_492_n240# divbuf_2/a_480_n1600# 0.00fF
C5167 divbuf_3/a_40350_n840# divbuf_3/a_40350_n1540# 0.01fF
C5168 divbuf_3/a_9630_n1540# divbuf_3/a_10110_n1540# 0.11fF
C5169 divbuf_0/a_19562_170# divbuf_0/OUT4 0.19fF
C5170 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n840# 0.04fF
C5171 divbuf_1/a_7792_170# divbuf_1/a_7302_170# 0.07fF
C5172 divbuf_4/a_36990_n1540# divbuf_4/a_37470_n1540# 0.11fF
C5173 divbuf_2/a_5852_n240# divbuf_2/OUT3 0.04fF
C5174 divbuf_2/a_44640_n1600# divbuf_2/a_44670_n840# 0.04fF
C5175 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C5176 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_20160_n1600# 0.26fF
C5177 divbuf_1/a_18240_n1600# divbuf_1/a_18720_n1600# 0.26fF
C5178 divbuf_1/a_8762_n240# divbuf_1/a_8670_n840# 0.03fF
C5179 divbuf_5/a_7200_n1600# divbuf_5/a_7680_n1600# 0.26fF
C5180 divbuf_3/a_35082_170# divbuf_3/OUT4 0.19fF
C5181 ro_div_0/divbuf_0/a_12030_n1540# ro_div_0/divbuf_0/a_12510_n1540# 0.11fF
C5182 ro_div_0/divbuf_0/a_42750_n840# ro_div_0/divbuf_0/a_42750_n1540# 0.01fF
C5183 divbuf_1/a_41310_n840# divbuf_1/a_41310_n1540# 0.01fF
C5184 divbuf_1/a_10590_n1540# divbuf_1/a_11070_n1540# 0.11fF
C5185 divbuf_3/a_7200_n1600# divbuf_3/a_7230_n840# 0.04fF
C5186 divbuf_5/a_60510_n840# divbuf_5/a_60990_n840# 0.07fF
C5187 divbuf_5/a_30270_n840# divbuf_5/a_30270_n1540# 0.01fF
C5188 divbuf_5/a_60480_n1600# divbuf_5/a_60510_n1540# 0.19fF
C5189 divbuf_0/a_22472_170# divbuf_0/a_22952_170# 0.07fF
C5190 divbuf_4/a_34560_n1600# divbuf_4/a_34590_n840# 0.04fF
C5191 divbuf_4/a_24892_170# divbuf_4/OUT4 0.19fF
C5192 divbuf_2/a_22472_n240# divbuf_2/a_22952_n240# 0.05fF
C5193 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C5194 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/a_16642_170# 0.07fF
C5195 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/a_8272_n240# 0.01fF
C5196 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5197 divbuf_0/a_55680_n1600# divbuf_0/a_56160_n1600# 0.26fF
C5198 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C5199 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C5200 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/nor_0/B 0.22fF
C5201 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48480_n1600# 0.26fF
C5202 divbuf_2/a_34080_n1600# divbuf_2/a_34110_n1540# 0.19fF
C5203 divbuf_2/a_34110_n840# divbuf_2/a_34590_n840# 0.07fF
C5204 divbuf_2/a_3870_n840# divbuf_2/a_3870_n1540# 0.01fF
C5205 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/OUT3 0.19fF
C5206 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/a_38910_n840# 0.04fF
C5207 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C5208 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C5209 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C5210 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/a_35082_170# 0.07fF
C5211 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_9630_n840# 0.04fF
C5212 divbuf_0/a_48030_n1540# divbuf_0/a_48510_n1540# 0.11fF
C5213 pll_full_0/divbuf_0/a_40350_n1540# pll_full_0/divbuf_0/a_40830_n1540# 0.11fF
C5214 divbuf_1/a_492_n240# divbuf_1/OUT2 0.42fF
C5215 divbuf_1/a_8160_n1600# divbuf_1/a_8190_n840# 0.04fF
C5216 divbuf_3/a_3912_170# divbuf_3/a_3912_n240# 0.01fF
C5217 divbuf_3/a_23922_170# divbuf_3/a_24412_170# 0.07fF
C5218 divbuf_5/a_18092_n240# divbuf_5/a_17790_n840# 0.00fF
C5219 divbuf_3/a_36052_n240# divbuf_3/OUT4 0.04fF
C5220 ro_div_0/divbuf_0/a_60990_n840# ro_div_0/divbuf_0/OUT5 0.04fF
C5221 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7680_n1600# 0.26fF
C5222 divbuf_4/a_12282_n240# divbuf_4/a_12772_n240# 0.04fF
C5223 divbuf_4/a_32172_170# divbuf_4/a_32172_n240# 0.01fF
C5224 divbuf_3/a_57120_n1600# divbuf_3/a_57600_n1600# 0.26fF
C5225 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_11040_n1600# 0.26fF
C5226 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C5227 pd_div_0/divbuf_0/a_60510_n840# pd_div_0/divbuf_0/a_60990_n840# 0.07fF
C5228 pd_div_0/divbuf_0/a_30270_n840# pd_div_0/divbuf_0/a_30270_n1540# 0.01fF
C5229 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/a_60510_n1540# 0.19fF
C5230 divbuf_3/a_49470_n1540# divbuf_3/a_49950_n1540# 0.11fF
C5231 divbuf_4/a_25862_n240# divbuf_4/OUT4 0.04fF
C5232 divbuf_4/a_24000_n1600# divbuf_4/a_24030_n1540# 0.19fF
C5233 divbuf_4/a_24030_n840# divbuf_4/a_24510_n840# 0.07fF
C5234 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/a_16152_n240# 0.01fF
C5235 pll_full_0/divbuf_1/a_2910_n1540# pll_full_0/divbuf_1/a_3390_n1540# 0.11fF
C5236 pll_full_0/divbuf_1/a_33630_n840# pll_full_0/divbuf_1/a_33630_n1540# 0.01fF
C5237 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5238 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n840# 0.04fF
C5239 divbuf_0/a_7792_n240# divbuf_0/OUT3 0.04fF
C5240 divbuf_1/a_21502_170# divbuf_1/a_21982_170# 0.07fF
C5241 divbuf_1/a_31202_170# divbuf_1/a_31202_n240# 0.01fF
C5242 divbuf_5/a_13742_170# divbuf_5/a_14222_170# 0.07fF
C5243 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_37950_n840# 0.04fF
C5244 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5245 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_60000_n1600# 0.26fF
C5246 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z2 0.19fF
C5247 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z1 0.09fF
C5248 divbuf_1/a_58080_n1600# divbuf_1/a_58560_n1600# 0.26fF
C5249 divbuf_5/a_37992_n240# divbuf_5/a_37950_n840# 0.04fF
C5250 divbuf_5/a_47040_n1600# divbuf_5/a_47520_n1600# 0.26fF
C5251 divbuf_3/a_34080_n1600# divbuf_3/OUT4 0.01fF
C5252 ro_div_0/divbuf_0/a_51870_n1540# ro_div_0/divbuf_0/a_52350_n1540# 0.11fF
C5253 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_17790_n840# 0.00fF
C5254 divbuf_1/a_50430_n1540# divbuf_1/a_50910_n1540# 0.11fF
C5255 divbuf_3/a_47040_n1600# divbuf_3/a_47070_n840# 0.04fF
C5256 divbuf_5/a_39390_n1540# divbuf_5/a_39870_n1540# 0.11fF
C5257 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_510_n840# 0.04fF
C5258 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/a_31202_n240# 0.01fF
C5259 divbuf_0/a_23442_n240# divbuf_0/a_23922_n240# 0.05fF
C5260 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/a_35562_n240# 0.01fF
C5261 divbuf_2/a_20640_n1600# divbuf_2/a_21120_n1600# 0.26fF
C5262 divbuf_2/a_11312_n240# divbuf_2/a_11550_n840# 0.02fF
C5263 divbuf_4/a_24000_n1600# divbuf_4/OUT4 0.00fF
C5264 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_510_n840# 0.07fF
C5265 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_16152_n240# 0.05fF
C5266 divbuf_0/a_4830_n840# divbuf_0/a_4830_n1540# 0.01fF
C5267 divbuf_0/a_35070_n840# divbuf_0/a_35550_n840# 0.07fF
C5268 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n1540# 0.19fF
C5269 divbuf_1/a_23922_170# divbuf_1/a_23922_n240# 0.01fF
C5270 divbuf_2/a_43710_n840# divbuf_2/a_43710_n1540# 0.01fF
C5271 divbuf_2/a_12990_n1540# divbuf_2/a_13470_n1540# 0.11fF
C5272 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27390_n1540# 0.19fF
C5273 pll_full_0/divbuf_0/a_27390_n840# pll_full_0/divbuf_0/a_27870_n840# 0.07fF
C5274 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5275 ro_div_0/divider_0/tspc_0/Z2 gnd 0.16fF
C5276 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49470_n840# 0.04fF
C5277 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/a_11802_170# 0.07fF
C5278 divbuf_1/a_12772_n240# divbuf_1/OUT4 0.04fF
C5279 divbuf_1/a_48000_n1600# divbuf_1/a_48030_n840# 0.04fF
C5280 divbuf_3/a_24892_n240# divbuf_3/a_25382_n240# 0.04fF
C5281 divbuf_5/a_36960_n1600# divbuf_5/a_36990_n840# 0.04fF
C5282 divbuf_5/a_29742_170# divbuf_5/OUT4 0.19fF
C5283 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/a_17612_170# 0.07fF
C5284 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/a_37950_n840# 0.04fF
C5285 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47520_n1600# 0.26fF
C5286 divbuf_4/a_10560_n1600# divbuf_4/a_11040_n1600# 0.26fF
C5287 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/a_41310_n840# 0.03fF
C5288 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50880_n1600# 0.26fF
C5289 divbuf_3/a_36480_n1600# divbuf_3/a_36510_n1540# 0.19fF
C5290 divbuf_3/a_36510_n840# divbuf_3/a_36990_n840# 0.07fF
C5291 divbuf_3/a_6270_n840# divbuf_3/a_6270_n1540# 0.01fF
C5292 pd_div_0/divbuf_0/a_39390_n1540# pd_div_0/divbuf_0/a_39870_n1540# 0.11fF
C5293 divbuf_2/a_10560_n1600# divbuf_2/a_10590_n840# 0.04fF
C5294 divbuf_4/a_33630_n840# divbuf_4/a_33630_n1540# 0.01fF
C5295 divbuf_4/a_2910_n1540# divbuf_4/a_3390_n1540# 0.11fF
C5296 pll_full_0/divbuf_1/a_42750_n1540# pll_full_0/divbuf_1/a_43230_n1540# 0.11fF
C5297 gnd pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C5298 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/a_27802_n240# 0.05fF
C5299 divbuf_1/a_25862_n240# divbuf_1/a_26352_n240# 0.04fF
C5300 divbuf_5/a_14702_n240# divbuf_5/a_15182_n240# 0.05fF
C5301 divbuf_5/a_34592_170# divbuf_5/a_34592_n240# 0.01fF
C5302 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_38910_n1540# 0.19fF
C5303 ro_div_0/divbuf_0/a_8670_n840# ro_div_0/divbuf_0/a_8670_n1540# 0.01fF
C5304 ro_div_0/divbuf_0/a_38910_n840# ro_div_0/divbuf_0/a_39390_n840# 0.07fF
C5305 divbuf_1/a_37470_n840# divbuf_1/a_37950_n840# 0.07fF
C5306 divbuf_1/a_7230_n840# divbuf_1/a_7230_n1540# 0.01fF
C5307 divbuf_1/a_11040_n1600# divbuf_1/OUT4 0.00fF
C5308 divbuf_1/a_37440_n1600# divbuf_1/a_37470_n1540# 0.19fF
C5309 divbuf_5/a_26430_n840# divbuf_5/a_26910_n840# 0.07fF
C5310 divbuf_5/a_30712_n240# divbuf_5/OUT4 0.04fF
C5311 divbuf_5/a_26400_n1600# divbuf_5/a_26430_n1540# 0.19fF
C5312 divbuf_3/a_58590_n840# divbuf_3/a_58590_n1540# 0.01fF
C5313 divbuf_0/a_9732_170# divbuf_0/a_10212_170# 0.07fF
C5314 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/clk 0.45fF
C5315 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_36990_n840# 0.04fF
C5316 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5317 divbuf_2/a_27322_170# divbuf_2/a_27802_170# 0.07fF
C5318 divbuf_2/a_7302_170# divbuf_2/a_7302_n240# 0.01fF
C5319 divbuf_4/a_480_n1600# divbuf_4/a_510_n840# 0.04fF
C5320 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5321 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40350_n840# 0.04fF
C5322 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C5323 divbuf_0/a_12282_n240# divbuf_0/a_12510_n840# 0.02fF
C5324 divbuf_0/a_21600_n1600# divbuf_0/a_22080_n1600# 0.26fF
C5325 divbuf_2/a_16642_170# divbuf_2/OUT4 0.19fF
C5326 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_14400_n1600# 0.26fF
C5327 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/a_4350_n840# 0.04fF
C5328 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_13252_170# 0.07fF
C5329 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C5330 divbuf_0/a_13950_n1540# divbuf_0/a_14430_n1540# 0.11fF
C5331 divbuf_0/a_44670_n840# divbuf_0/a_44670_n1540# 0.01fF
C5332 pll_full_0/divbuf_0/a_6270_n1540# pll_full_0/divbuf_0/a_6750_n1540# 0.11fF
C5333 pll_full_0/divbuf_0/a_36990_n840# pll_full_0/divbuf_0/a_36990_n1540# 0.01fF
C5334 divbuf_2/a_52830_n1540# divbuf_2/a_53310_n1540# 0.11fF
C5335 divbuf_3/a_6332_170# divbuf_3/OUT3 0.19fF
C5336 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_15182_n240# 0.05fF
C5337 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/a_34592_n240# 0.01fF
C5338 divbuf_4/a_17122_170# divbuf_4/a_17612_170# 0.07fF
C5339 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_18582_n240# 0.04fF
C5340 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/a_37992_n240# 0.01fF
C5341 divbuf_3/a_13742_n240# divbuf_3/a_13950_n840# 0.02fF
C5342 divbuf_3/a_23040_n1600# divbuf_3/a_23520_n1600# 0.26fF
C5343 ashish_0/von ashish_0/vop 12.87fF
C5344 pd_div_0/divbuf_0/a_26430_n840# pd_div_0/divbuf_0/a_26910_n840# 0.07fF
C5345 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5346 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26430_n1540# 0.19fF
C5347 divbuf_4/a_50400_n1600# divbuf_4/a_50880_n1600# 0.26fF
C5348 divbuf_4/a_41382_n240# divbuf_4/a_41310_n840# 0.03fF
C5349 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5350 pll_full_0/divbuf_1/a_29790_n840# pll_full_0/divbuf_1/a_30270_n840# 0.07fF
C5351 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_29790_n1540# 0.19fF
C5352 divbuf_3/a_46110_n840# divbuf_3/a_46110_n1540# 0.01fF
C5353 divbuf_3/a_15390_n1540# divbuf_3/a_15870_n1540# 0.11fF
C5354 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C5355 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C5356 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n840# 0.04fF
C5357 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z1 0.03fF
C5358 divbuf_4/a_42750_n1540# divbuf_4/a_43230_n1540# 0.11fF
C5359 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C5360 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C5361 divbuf_2/a_50400_n1600# divbuf_2/a_50430_n840# 0.04fF
C5362 divbuf_2/a_17612_n240# divbuf_2/OUT4 0.04fF
C5363 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_3870_n840# 0.04fF
C5364 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25920_n1600# 0.26fF
C5365 divbuf_1/a_14702_n240# divbuf_1/a_14910_n840# 0.02fF
C5366 divbuf_1/a_24000_n1600# divbuf_1/a_24480_n1600# 0.26fF
C5367 divbuf_5/a_3422_n240# divbuf_5/a_3390_n840# 0.05fF
C5368 divbuf_5/a_12960_n1600# divbuf_5/a_13440_n1600# 0.26fF
C5369 divbuf_3/a_7302_n240# divbuf_3/OUT3 0.04fF
C5370 ro_div_0/divbuf_0/a_17790_n1540# ro_div_0/divbuf_0/a_18270_n1540# 0.11fF
C5371 ro_div_0/divbuf_0/a_48510_n840# ro_div_0/divbuf_0/a_48510_n1540# 0.01fF
C5372 divbuf_1/a_47070_n840# divbuf_1/a_47070_n1540# 0.01fF
C5373 divbuf_1/a_16350_n1540# divbuf_1/a_16830_n1540# 0.11fF
C5374 divbuf_3/a_12960_n1600# divbuf_3/a_12990_n840# 0.04fF
C5375 divbuf_5/a_36030_n840# divbuf_5/a_36030_n1540# 0.01fF
C5376 divbuf_5/a_5310_n1540# divbuf_5/a_5790_n1540# 0.11fF
C5377 divbuf_0/a_28292_170# divbuf_0/a_28772_170# 0.07fF
C5378 divbuf_4/a_40320_n1600# divbuf_4/a_40350_n840# 0.04fF
C5379 divbuf_4/a_36532_170# divbuf_4/OUT4 0.19fF
C5380 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5381 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/OUT3 0.19fF
C5382 divbuf_2/a_28292_n240# divbuf_2/a_28772_n240# 0.05fF
C5383 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/a_2322_n240# 0.01fF
C5384 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/a_21012_170# 0.07fF
C5385 filter_0/a_4216_n5230# filter_0/v 0.19fF
C5386 divbuf_0/a_990_n840# divbuf_0/a_1470_n840# 0.07fF
C5387 divbuf_0/a_960_n1600# divbuf_0/a_990_n1540# 0.19fF
C5388 divbuf_0/a_16152_170# divbuf_0/OUT4 0.19fF
C5389 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/and_0/A 0.01fF
C5390 gnd pd_div_0/divider_0/tspc_2/a_630_n680# 0.61fF
C5391 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/out1 0.31fF
C5392 divbuf_2/a_39870_n840# divbuf_2/a_40350_n840# 0.07fF
C5393 divbuf_2/a_9630_n840# divbuf_2/a_9630_n1540# 0.01fF
C5394 divbuf_2/a_39840_n1600# divbuf_2/a_39870_n1540# 0.19fF
C5395 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_54240_n1600# 0.26fF
C5396 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C5397 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/a_40902_170# 0.07fF
C5398 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15390_n840# 0.04fF
C5399 divbuf_0/a_53790_n1540# divbuf_0/a_54270_n1540# 0.11fF
C5400 divbuf_1/a_8272_170# divbuf_1/OUT3 0.19fF
C5401 divbuf_1/a_13920_n1600# divbuf_1/a_13950_n840# 0.04fF
C5402 divbuf_3/a_29742_170# divbuf_3/a_30232_170# 0.07fF
C5403 divbuf_3/a_9732_170# divbuf_3/a_9732_n240# 0.01fF
C5404 divbuf_5/a_2880_n1600# divbuf_5/a_2910_n840# 0.04fF
C5405 pll_full_0/divbuf_0/a_46110_n1540# pll_full_0/divbuf_0/a_46590_n1540# 0.11fF
C5406 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/a_3390_n840# 0.05fF
C5407 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_13440_n1600# 0.26fF
C5408 divbuf_4/a_37992_170# divbuf_4/a_37992_n240# 0.01fF
C5409 divbuf_4/a_18092_n240# divbuf_4/a_18582_n240# 0.04fF
C5410 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/a_6750_n840# 0.03fF
C5411 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16800_n1600# 0.26fF
C5412 divbuf_3/a_2400_n1600# divbuf_3/a_2430_n1540# 0.19fF
C5413 divbuf_3/a_2430_n840# divbuf_3/a_2910_n840# 0.07fF
C5414 pd_div_0/divbuf_0/a_36030_n840# pd_div_0/divbuf_0/a_36030_n1540# 0.01fF
C5415 pd_div_0/divbuf_0/a_5310_n1540# pd_div_0/divbuf_0/a_5790_n1540# 0.11fF
C5416 divbuf_4/a_29760_n1600# divbuf_4/a_29790_n1540# 0.19fF
C5417 divbuf_4/a_29790_n840# divbuf_4/a_30270_n840# 0.07fF
C5418 divbuf_4/a_37502_n240# divbuf_4/OUT4 0.04fF
C5419 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5420 pll_full_0/divbuf_1/a_8670_n1540# pll_full_0/divbuf_1/a_9150_n1540# 0.11fF
C5421 pll_full_0/divbuf_1/a_39390_n840# pll_full_0/divbuf_1/a_39390_n1540# 0.01fF
C5422 divbuf_0/a_19562_n240# divbuf_0/OUT4 0.04fF
C5423 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n840# 0.04fF
C5424 divbuf_1/a_27322_170# divbuf_1/a_27802_170# 0.07fF
C5425 divbuf_5/a_19562_170# divbuf_5/a_20042_170# 0.07fF
C5426 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C5427 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_43710_n840# 0.04fF
C5428 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_4830_n1540# 0.19fF
C5429 ro_div_0/divbuf_0/a_4830_n840# ro_div_0/divbuf_0/a_5310_n840# 0.07fF
C5430 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Qbar 0.03fF
C5431 divbuf_1/a_3390_n840# divbuf_1/a_3870_n840# 0.07fF
C5432 divbuf_1/a_20042_170# divbuf_1/OUT4 0.19fF
C5433 divbuf_1/a_3360_n1600# divbuf_1/a_3390_n1540# 0.19fF
C5434 divbuf_5/a_52800_n1600# divbuf_5/a_53280_n1600# 0.26fF
C5435 divbuf_5/a_492_n240# divbuf_5/OUT2 0.42fF
C5436 divbuf_3/a_54720_n1600# divbuf_3/a_54750_n1540# 0.19fF
C5437 ro_div_0/divbuf_0/a_57630_n1540# ro_div_0/divbuf_0/a_58110_n1540# 0.11fF
C5438 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_2910_n840# 0.04fF
C5439 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/a_37022_n240# 0.01fF
C5440 divbuf_1/a_56190_n1540# divbuf_1/a_56670_n1540# 0.11fF
C5441 divbuf_3/a_52800_n1600# divbuf_3/a_52830_n840# 0.04fF
C5442 divbuf_5/a_45150_n1540# divbuf_5/a_45630_n1540# 0.11fF
C5443 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6270_n840# 0.04fF
C5444 divbuf_0/a_29262_n240# divbuf_0/a_29742_n240# 0.05fF
C5445 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/a_21982_n240# 0.05fF
C5446 divbuf_2/a_26400_n1600# divbuf_2/a_26880_n1600# 0.26fF
C5447 divbuf_2/a_17122_n240# divbuf_2/a_17310_n840# 0.02fF
C5448 divbuf_4/a_35520_n1600# divbuf_4/OUT4 0.00fF
C5449 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/a_41382_n240# 0.01fF
C5450 divbuf_0/a_10590_n840# divbuf_0/a_10590_n1540# 0.01fF
C5451 divbuf_0/a_40830_n840# divbuf_0/a_41310_n840# 0.07fF
C5452 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n1540# 0.19fF
C5453 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/a_2910_n1540# 0.01fF
C5454 pll_full_0/divbuf_0/a_33150_n840# pll_full_0/divbuf_0/a_33630_n840# 0.07fF
C5455 divbuf_1/a_29742_170# divbuf_1/a_29742_n240# 0.01fF
C5456 divbuf_2/a_49470_n840# divbuf_2/a_49470_n1540# 0.01fF
C5457 divbuf_2/a_18750_n1540# divbuf_2/a_19230_n1540# 0.11fF
C5458 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33150_n1540# 0.19fF
C5459 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55230_n840# 0.04fF
C5460 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5461 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/a_20042_170# 0.07fF
C5462 divbuf_1/a_53760_n1600# divbuf_1/a_53790_n840# 0.04fF
C5463 divbuf_1/a_24412_n240# divbuf_1/OUT4 0.04fF
C5464 divbuf_3/a_30712_n240# divbuf_3/a_31202_n240# 0.04fF
C5465 divbuf_5/a_42720_n1600# divbuf_5/a_42750_n840# 0.04fF
C5466 divbuf_5/a_41382_170# divbuf_5/OUT4 0.19fF
C5467 divbuf_5/a_1842_n240# divbuf_5/OUT2 0.04fF
C5468 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/a_23442_170# 0.07fF
C5469 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/a_2322_n240# 0.01fF
C5470 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C5471 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C5472 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_53280_n1600# 0.26fF
C5473 divbuf_3/a_42240_n1600# divbuf_3/a_42270_n1540# 0.19fF
C5474 divbuf_3/a_42270_n840# divbuf_3/a_42750_n840# 0.07fF
C5475 divbuf_3/a_12030_n840# divbuf_3/a_12030_n1540# 0.01fF
C5476 divbuf_4/a_16320_n1600# divbuf_4/a_16800_n1600# 0.26fF
C5477 divbuf_4/a_6822_n240# divbuf_4/a_6750_n840# 0.03fF
C5478 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56640_n1600# 0.26fF
C5479 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/OUT3 0.19fF
C5480 pd_div_0/divbuf_0/a_45150_n1540# pd_div_0/divbuf_0/a_45630_n1540# 0.11fF
C5481 divbuf_2/a_16320_n1600# divbuf_2/a_16350_n840# 0.04fF
C5482 divbuf_4/a_39390_n840# divbuf_4/a_39390_n1540# 0.01fF
C5483 divbuf_4/a_8670_n1540# divbuf_4/a_9150_n1540# 0.11fF
C5484 pll_full_0/divbuf_1/a_48510_n1540# pll_full_0/divbuf_1/a_48990_n1540# 0.11fF
C5485 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/a_33622_n240# 0.05fF
C5486 divbuf_1/a_31682_n240# divbuf_1/a_32172_n240# 0.04fF
C5487 divbuf_5/a_40412_170# divbuf_5/a_40412_n240# 0.01fF
C5488 divbuf_5/a_20532_n240# divbuf_5/a_21012_n240# 0.05fF
C5489 ro_div_0/divbuf_0/a_14430_n840# ro_div_0/divbuf_0/a_14430_n1540# 0.01fF
C5490 ro_div_0/divbuf_0/a_44670_n840# ro_div_0/divbuf_0/a_45150_n840# 0.07fF
C5491 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_44670_n1540# 0.19fF
C5492 divbuf_1/a_43200_n1600# divbuf_1/a_43230_n1540# 0.19fF
C5493 divbuf_1/a_43230_n840# divbuf_1/a_43710_n840# 0.07fF
C5494 divbuf_1/a_12990_n840# divbuf_1/a_12990_n1540# 0.01fF
C5495 divbuf_1/a_22560_n1600# divbuf_1/OUT4 0.01fF
C5496 divbuf_5/a_1440_n1600# divbuf_5/OUT2 0.01fF
C5497 divbuf_5/a_32160_n1600# divbuf_5/a_32190_n1540# 0.19fF
C5498 divbuf_5/a_32190_n840# divbuf_5/a_32670_n840# 0.07fF
C5499 divbuf_5/a_1950_n840# divbuf_5/a_1950_n1540# 0.01fF
C5500 divbuf_0/a_3912_170# divbuf_0/a_4392_170# 0.07fF
C5501 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_42750_n840# 0.04fF
C5502 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5503 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/OUT2 0.04fF
C5504 divbuf_2/a_33142_170# divbuf_2/a_33622_170# 0.07fF
C5505 divbuf_2/a_13742_170# divbuf_2/a_13742_n240# 0.01fF
C5506 divbuf_4/a_6240_n1600# divbuf_4/a_6270_n840# 0.04fF
C5507 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46110_n840# 0.04fF
C5508 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C5509 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/a_5790_n840# 0.04fF
C5510 divbuf_0/a_18092_n240# divbuf_0/a_18270_n840# 0.02fF
C5511 divbuf_0/a_27360_n1600# divbuf_0/a_27840_n1600# 0.26fF
C5512 divbuf_2/a_5790_n840# divbuf_2/a_6270_n840# 0.07fF
C5513 divbuf_2/a_5760_n1600# divbuf_2/a_5790_n1540# 0.19fF
C5514 divbuf_2/a_28292_170# divbuf_2/OUT4 0.19fF
C5515 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/a_10110_n840# 0.03fF
C5516 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_20160_n1600# 0.26fF
C5517 ro_div_0/ro_complete_0/cbank_0/switch_5/vin ro_div_0/ro_complete_0/a0 0.09fF
C5518 divbuf_0/a_19710_n1540# divbuf_0/a_20190_n1540# 0.11fF
C5519 divbuf_0/a_50430_n840# divbuf_0/a_50430_n1540# 0.01fF
C5520 divbuf_2/a_58590_n1540# divbuf_2/a_59070_n1540# 0.11fF
C5521 pll_full_0/divbuf_0/a_42750_n840# pll_full_0/divbuf_0/a_42750_n1540# 0.01fF
C5522 pll_full_0/divbuf_0/a_12030_n1540# pll_full_0/divbuf_0/a_12510_n1540# 0.11fF
C5523 divbuf_3/a_18092_170# divbuf_3/OUT4 0.19fF
C5524 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/a_40412_n240# 0.01fF
C5525 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/a_21012_n240# 0.05fF
C5526 divbuf_4/a_2322_170# divbuf_4/a_2322_n240# 0.01fF
C5527 divbuf_4/a_22952_170# divbuf_4/a_23442_170# 0.07fF
C5528 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/a_24412_n240# 0.04fF
C5529 divbuf_3/a_28800_n1600# divbuf_3/a_29280_n1600# 0.26fF
C5530 divbuf_3/a_19562_n240# divbuf_3/a_19710_n840# 0.03fF
C5531 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/OUT2 0.01fF
C5532 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32190_n1540# 0.19fF
C5533 pd_div_0/divbuf_0/a_32190_n840# pd_div_0/divbuf_0/a_32670_n840# 0.07fF
C5534 pd_div_0/divbuf_0/a_1950_n840# pd_div_0/divbuf_0/a_1950_n1540# 0.01fF
C5535 divbuf_4/a_7792_170# divbuf_4/OUT3 0.19fF
C5536 divbuf_4/a_56160_n1600# divbuf_4/a_56640_n1600# 0.26fF
C5537 pll_full_0/divbuf_1/a_5310_n840# pll_full_0/divbuf_1/a_5310_n1540# 0.01fF
C5538 pll_full_0/divbuf_1/a_35550_n840# pll_full_0/divbuf_1/a_36030_n840# 0.07fF
C5539 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_35550_n1540# 0.19fF
C5540 divbuf_3/a_21150_n1540# divbuf_3/a_21630_n1540# 0.11fF
C5541 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C5542 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n840# 0.04fF
C5543 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C5544 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z4 0.21fF
C5545 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/tspc_1/Z3 0.16fF
C5546 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/nor_1/A 0.01fF
C5547 divbuf_2/a_29262_n240# divbuf_2/OUT4 0.04fF
C5548 divbuf_2/a_56160_n1600# divbuf_2/a_56190_n840# 0.04fF
C5549 divbuf_4/a_48510_n1540# divbuf_4/a_48990_n1540# 0.11fF
C5550 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.00fF
C5551 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/A 0.35fF
C5552 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C5553 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C5554 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C5555 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_9630_n840# 0.04fF
C5556 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/a_22110_n840# 0.03fF
C5557 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31680_n1600# 0.26fF
C5558 divbuf_1/a_29760_n1600# divbuf_1/a_30240_n1600# 0.26fF
C5559 divbuf_1/a_20532_n240# divbuf_1/a_20670_n840# 0.03fF
C5560 divbuf_5/a_18720_n1600# divbuf_5/a_19200_n1600# 0.26fF
C5561 divbuf_5/a_9242_n240# divbuf_5/a_9150_n840# 0.03fF
C5562 pll_full_0/divbuf_0/a_60990_n840# pll_full_0/divbuf_0/OUT5 0.04fF
C5563 divbuf_3/a_19072_n240# divbuf_3/OUT4 0.04fF
C5564 ro_div_0/divbuf_0/a_23550_n1540# ro_div_0/divbuf_0/a_24030_n1540# 0.11fF
C5565 ro_div_0/divbuf_0/a_54270_n840# ro_div_0/divbuf_0/a_54270_n1540# 0.01fF
C5566 divbuf_1/a_52830_n840# divbuf_1/a_52830_n1540# 0.01fF
C5567 divbuf_1/a_22110_n1540# divbuf_1/a_22590_n1540# 0.11fF
C5568 divbuf_3/a_18720_n1600# divbuf_3/a_18750_n840# 0.04fF
C5569 divbuf_5/a_41790_n840# divbuf_5/a_41790_n1540# 0.01fF
C5570 divbuf_5/a_11070_n1540# divbuf_5/a_11550_n1540# 0.11fF
C5571 divbuf_0/a_34112_170# divbuf_0/a_34592_170# 0.07fF
C5572 divbuf_2/a_34112_n240# divbuf_2/a_34592_n240# 0.05fF
C5573 divbuf_4/a_8762_n240# divbuf_4/OUT3 0.04fF
C5574 divbuf_4/a_46080_n1600# divbuf_4/a_46110_n840# 0.04fF
C5575 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/a_13252_n240# 0.01fF
C5576 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/a_26832_170# 0.07fF
C5577 divbuf_0/a_6750_n840# divbuf_0/a_7230_n840# 0.07fF
C5578 divbuf_0/a_30232_170# divbuf_0/OUT4 0.19fF
C5579 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/a_8762_n240# 0.01fF
C5580 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n1540# 0.19fF
C5581 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/and_0/B 0.29fF
C5582 divbuf_1/a_17122_170# divbuf_1/a_17122_n240# 0.01fF
C5583 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_60000_n1600# 0.26fF
C5584 divbuf_2/a_45600_n1600# divbuf_2/a_45630_n1540# 0.19fF
C5585 divbuf_2/a_45630_n840# divbuf_2/a_46110_n840# 0.07fF
C5586 divbuf_2/a_15390_n840# divbuf_2/a_15390_n1540# 0.01fF
C5587 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5588 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/a_6822_n240# 0.04fF
C5589 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21150_n840# 0.04fF
C5590 divbuf_0/a_59550_n1540# divbuf_0/a_60030_n1540# 0.11fF
C5591 divbuf_1/a_5362_170# divbuf_1/OUT3 0.19fF
C5592 divbuf_1/a_19680_n1600# divbuf_1/a_19710_n840# 0.04fF
C5593 pll_full_0/divbuf_0/a_51870_n1540# pll_full_0/divbuf_0/a_52350_n1540# 0.11fF
C5594 divbuf_3/a_16152_170# divbuf_3/a_16152_n240# 0.01fF
C5595 divbuf_3/a_35562_170# divbuf_3/a_36052_170# 0.07fF
C5596 divbuf_5/a_8640_n1600# divbuf_5/a_8670_n840# 0.04fF
C5597 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_19200_n1600# 0.26fF
C5598 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/a_9150_n840# 0.03fF
C5599 divbuf_4/a_23922_n240# divbuf_4/a_24412_n240# 0.04fF
C5600 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_12990_n840# 0.02fF
C5601 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22560_n1600# 0.26fF
C5602 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_480_n1600# 0.00fF
C5603 divbuf_3/a_8160_n1600# divbuf_3/a_8190_n1540# 0.19fF
C5604 divbuf_3/a_8190_n840# divbuf_3/a_8670_n840# 0.07fF
C5605 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/a_41790_n1540# 0.01fF
C5606 pd_div_0/divbuf_0/a_11070_n1540# pd_div_0/divbuf_0/a_11550_n1540# 0.11fF
C5607 divbuf_4/a_35520_n1600# divbuf_4/a_35550_n1540# 0.19fF
C5608 divbuf_4/a_35550_n840# divbuf_4/a_36030_n840# 0.07fF
C5609 divbuf_4/a_5310_n840# divbuf_4/a_5310_n1540# 0.01fF
C5610 pll_full_0/divbuf_1/a_14430_n1540# pll_full_0/divbuf_1/a_14910_n1540# 0.11fF
C5611 pll_full_0/divbuf_1/a_45150_n840# pll_full_0/divbuf_1/a_45150_n1540# 0.01fF
C5612 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C5613 divbuf_2/a_2322_n240# divbuf_2/a_2430_n840# 0.03fF
C5614 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n840# 0.04fF
C5615 divbuf_0/a_31202_n240# divbuf_0/OUT4 0.04fF
C5616 divbuf_1/a_36532_170# divbuf_1/a_37022_170# 0.07fF
C5617 divbuf_5/a_5362_170# divbuf_5/a_5362_n240# 0.01fF
C5618 divbuf_5/a_25382_170# divbuf_5/a_25862_170# 0.07fF
C5619 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49470_n840# 0.04fF
C5620 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5621 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/a_11070_n840# 0.07fF
C5622 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_10590_n1540# 0.19fF
C5623 ro_div_0/divider_0/nor_1/A gnd 1.05fF
C5624 pd_div_0/pd_0/tspc_r_1/Qbar pd_div_0/pd_0/and_pd_0/Out1 0.05fF
C5625 divbuf_1/a_9120_n1600# divbuf_1/a_9150_n1540# 0.19fF
C5626 divbuf_1/a_35082_170# divbuf_1/OUT4 0.19fF
C5627 divbuf_1/a_9150_n840# divbuf_1/a_9630_n840# 0.07fF
C5628 divbuf_5/a_12772_170# divbuf_5/OUT4 0.19fF
C5629 divbuf_5/a_58560_n1600# divbuf_5/a_59040_n1600# 0.26fF
C5630 divbuf_3/a_60480_n1600# divbuf_3/a_60510_n1540# 0.19fF
C5631 ro_div_0/divbuf_0/OUT3 ro_div_0/divbuf_0/OUT4 0.36fF
C5632 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_8670_n840# 0.04fF
C5633 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12030_n840# 0.04fF
C5634 divbuf_3/a_58560_n1600# divbuf_3/a_58590_n840# 0.04fF
C5635 divbuf_5/a_50910_n1540# divbuf_5/a_51390_n1540# 0.11fF
C5636 divbuf_0/a_35082_n240# divbuf_0/a_35562_n240# 0.05fF
C5637 divbuf_2/a_32160_n1600# divbuf_2/a_32640_n1600# 0.26fF
C5638 divbuf_2/a_22952_n240# divbuf_2/a_23070_n840# 0.03fF
C5639 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/a_27802_n240# 0.05fF
C5640 gnd pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.61fF
C5641 divbuf_0/a_16350_n840# divbuf_0/a_16350_n1540# 0.01fF
C5642 divbuf_0/a_46590_n840# divbuf_0/a_47070_n840# 0.07fF
C5643 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n1540# 0.19fF
C5644 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_38910_n1540# 0.19fF
C5645 divbuf_2/a_55230_n840# divbuf_2/a_55230_n1540# 0.01fF
C5646 divbuf_2/a_24510_n1540# divbuf_2/a_24990_n1540# 0.11fF
C5647 pll_full_0/divbuf_0/a_38910_n840# pll_full_0/divbuf_0/a_39390_n840# 0.07fF
C5648 pll_full_0/divbuf_0/a_8670_n840# pll_full_0/divbuf_0/a_8670_n1540# 0.01fF
C5649 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5650 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/a_25862_170# 0.07fF
C5651 divbuf_3/a_51870_n1540# divbuf_3/a_52350_n1540# 0.11fF
C5652 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/a_8762_n240# 0.01fF
C5653 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/a_29262_170# 0.07fF
C5654 divbuf_1/a_36052_n240# divbuf_1/OUT4 0.04fF
C5655 divbuf_1/a_59520_n1600# divbuf_1/a_59550_n840# 0.04fF
C5656 divbuf_3/a_36532_n240# divbuf_3/a_37022_n240# 0.04fF
C5657 divbuf_5/a_13742_n240# divbuf_5/OUT4 0.04fF
C5658 divbuf_5/a_48480_n1600# divbuf_5/a_48510_n840# 0.04fF
C5659 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C5660 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z4 0.12fF
C5661 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C5662 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/OUT3 0.19fF
C5663 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_59040_n1600# 0.26fF
C5664 divbuf_4/a_22080_n1600# divbuf_4/a_22560_n1600# 0.26fF
C5665 divbuf_4/a_12772_n240# divbuf_4/a_12990_n840# 0.02fF
C5666 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C5667 divbuf_3/a_48000_n1600# divbuf_3/a_48030_n1540# 0.19fF
C5668 divbuf_3/a_48030_n840# divbuf_3/a_48510_n840# 0.07fF
C5669 divbuf_3/a_17790_n840# divbuf_3/a_17790_n1540# 0.01fF
C5670 pll_full_0/divbuf_1/a_1470_n840# pll_full_0/divbuf_1/a_1950_n840# 0.07fF
C5671 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5672 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1470_n1540# 0.19fF
C5673 pd_div_0/divbuf_0/a_50910_n1540# pd_div_0/divbuf_0/a_51390_n1540# 0.11fF
C5674 divbuf_2/a_22080_n1600# divbuf_2/a_22110_n840# 0.04fF
C5675 divbuf_4/a_45150_n840# divbuf_4/a_45150_n1540# 0.01fF
C5676 divbuf_4/a_14430_n1540# divbuf_4/a_14910_n1540# 0.11fF
C5677 pll_full_0/divbuf_1/a_54270_n1540# pll_full_0/divbuf_1/a_54750_n1540# 0.11fF
C5678 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/a_39442_n240# 0.05fF
C5679 divbuf_1/a_37502_n240# divbuf_1/a_37992_n240# 0.04fF
C5680 divbuf_5/a_26352_n240# divbuf_5/a_26832_n240# 0.05fF
C5681 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50430_n1540# 0.19fF
C5682 ro_div_0/divbuf_0/a_20190_n840# ro_div_0/divbuf_0/a_20190_n1540# 0.01fF
C5683 ro_div_0/divbuf_0/a_50430_n840# ro_div_0/divbuf_0/a_50910_n840# 0.07fF
C5684 divbuf_1/a_48990_n840# divbuf_1/a_49470_n840# 0.07fF
C5685 divbuf_1/a_18750_n840# divbuf_1/a_18750_n1540# 0.01fF
C5686 divbuf_1/a_34080_n1600# divbuf_1/OUT4 0.01fF
C5687 divbuf_1/a_48960_n1600# divbuf_1/a_48990_n1540# 0.19fF
C5688 divbuf_5/a_37950_n840# divbuf_5/a_38430_n840# 0.07fF
C5689 divbuf_5/a_7710_n840# divbuf_5/a_7710_n1540# 0.01fF
C5690 divbuf_5/a_12000_n1600# divbuf_5/OUT4 0.00fF
C5691 divbuf_5/a_37920_n1600# divbuf_5/a_37950_n1540# 0.19fF
C5692 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5693 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48510_n840# 0.04fF
C5694 divbuf_2/a_38962_170# divbuf_2/a_39442_170# 0.07fF
C5695 divbuf_2/a_19562_170# divbuf_2/a_19562_n240# 0.01fF
C5696 divbuf_4/a_12000_n1600# divbuf_4/a_12030_n840# 0.04fF
C5697 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_5362_170# 0.07fF
C5698 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5699 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_51870_n840# 0.04fF
C5700 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_12030_n840# 0.02fF
C5701 divbuf_0/a_23922_n240# divbuf_0/a_24030_n840# 0.03fF
C5702 divbuf_0/a_33120_n1600# divbuf_0/a_33600_n1600# 0.26fF
C5703 divbuf_0/a_8762_170# divbuf_0/OUT3 0.19fF
C5704 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25920_n1600# 0.26fF
C5705 divbuf_2/a_11520_n1600# divbuf_2/a_11550_n1540# 0.19fF
C5706 divbuf_2/a_39932_170# divbuf_2/OUT4 0.19fF
C5707 divbuf_2/a_11550_n840# divbuf_2/a_12030_n840# 0.07fF
C5708 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_16350_n840# 0.02fF
C5709 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C5710 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C5711 divbuf_0/a_25470_n1540# divbuf_0/a_25950_n1540# 0.11fF
C5712 divbuf_0/a_56190_n840# divbuf_0/a_56190_n1540# 0.01fF
C5713 pll_full_0/divbuf_0/a_17790_n1540# pll_full_0/divbuf_0/a_18270_n1540# 0.11fF
C5714 pll_full_0/divbuf_0/a_48510_n840# pll_full_0/divbuf_0/a_48510_n1540# 0.01fF
C5715 divbuf_3/a_29742_170# divbuf_3/OUT4 0.19fF
C5716 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/a_26832_n240# 0.05fF
C5717 divbuf_4/a_28772_170# divbuf_4/a_29262_170# 0.07fF
C5718 divbuf_4/a_8762_170# divbuf_4/a_8762_n240# 0.01fF
C5719 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/a_30232_n240# 0.04fF
C5720 divbuf_3/a_25382_n240# divbuf_3/a_25470_n840# 0.03fF
C5721 divbuf_3/a_34560_n1600# divbuf_3/a_35040_n1600# 0.26fF
C5722 pd_div_0/divbuf_0/a_37950_n840# pd_div_0/divbuf_0/a_38430_n840# 0.07fF
C5723 pd_div_0/divbuf_0/a_7710_n840# pd_div_0/divbuf_0/a_7710_n1540# 0.01fF
C5724 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5725 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_37950_n1540# 0.19fF
C5726 divbuf_4/a_1440_n1600# divbuf_4/a_1470_n1540# 0.19fF
C5727 divbuf_4/a_19562_170# divbuf_4/OUT4 0.19fF
C5728 divbuf_4/a_1470_n840# divbuf_4/a_1950_n840# 0.07fF
C5729 pll_full_0/divbuf_1/a_11070_n840# pll_full_0/divbuf_1/a_11070_n1540# 0.01fF
C5730 pll_full_0/divbuf_1/a_41310_n840# pll_full_0/divbuf_1/a_41790_n840# 0.07fF
C5731 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41310_n1540# 0.19fF
C5732 divbuf_3/a_26910_n1540# divbuf_3/a_27390_n1540# 0.11fF
C5733 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n840# 0.04fF
C5734 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 gnd 0.27fF
C5735 divbuf_1/a_8272_170# divbuf_1/a_8762_170# 0.07fF
C5736 divbuf_2/a_40902_n240# divbuf_2/OUT4 0.04fF
C5737 divbuf_4/a_54270_n1540# divbuf_4/a_54750_n1540# 0.11fF
C5738 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z3 0.45fF
C5739 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C5740 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/Out 0.08fF
C5741 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15390_n840# 0.04fF
C5742 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_37440_n1600# 0.26fF
C5743 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/a_27870_n840# 0.04fF
C5744 divbuf_1/a_26352_n240# divbuf_1/a_26430_n840# 0.04fF
C5745 divbuf_1/a_35520_n1600# divbuf_1/a_36000_n1600# 0.26fF
C5746 divbuf_5/a_15182_n240# divbuf_5/a_15390_n840# 0.02fF
C5747 divbuf_5/a_24480_n1600# divbuf_5/a_24960_n1600# 0.26fF
C5748 divbuf_3/a_30712_n240# divbuf_3/OUT4 0.04fF
C5749 ro_div_0/divbuf_0/a_29310_n1540# ro_div_0/divbuf_0/a_29790_n1540# 0.11fF
C5750 ro_div_0/divbuf_0/a_60030_n840# ro_div_0/divbuf_0/a_60030_n1540# 0.01fF
C5751 divbuf_1/a_58590_n840# divbuf_1/a_58590_n1540# 0.01fF
C5752 divbuf_1/a_27870_n1540# divbuf_1/a_28350_n1540# 0.11fF
C5753 divbuf_5/a_47550_n840# divbuf_5/a_47550_n1540# 0.01fF
C5754 divbuf_5/a_16830_n1540# divbuf_5/a_17310_n1540# 0.11fF
C5755 divbuf_3/a_24480_n1600# divbuf_3/a_24510_n840# 0.04fF
C5756 divbuf_0/a_20532_170# divbuf_0/a_20532_n240# 0.01fF
C5757 divbuf_0/a_39932_170# divbuf_0/a_40412_170# 0.07fF
C5758 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C5759 divbuf_2/a_39932_n240# divbuf_2/a_40412_n240# 0.05fF
C5760 divbuf_4/a_51840_n1600# divbuf_4/a_51870_n840# 0.04fF
C5761 divbuf_4/a_20532_n240# divbuf_4/OUT4 0.04fF
C5762 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5763 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/a_32652_170# 0.07fF
C5764 divbuf_0/a_12510_n840# divbuf_0/a_12990_n840# 0.07fF
C5765 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n1540# 0.19fF
C5766 divbuf_0/a_2322_n240# divbuf_0/OUT2 0.04fF
C5767 divbuf_0/a_41382_170# divbuf_0/OUT5 0.07fF
C5768 divbuf_2/a_51390_n840# divbuf_2/a_51870_n840# 0.07fF
C5769 divbuf_2/a_21150_n840# divbuf_2/a_21150_n1540# 0.01fF
C5770 divbuf_2/a_51360_n1600# divbuf_2/a_51390_n1540# 0.19fF
C5771 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5772 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_4830_n1540# 0.19fF
C5773 pll_full_0/divbuf_0/a_4830_n840# pll_full_0/divbuf_0/a_5310_n840# 0.07fF
C5774 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_13252_n240# 0.05fF
C5775 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_26910_n840# 0.04fF
C5776 divbuf_1/a_25440_n1600# divbuf_1/a_25470_n840# 0.04fF
C5777 divbuf_5/a_14400_n1600# divbuf_5/a_14430_n840# 0.04fF
C5778 divbuf_3/a_21982_170# divbuf_3/a_21982_n240# 0.01fF
C5779 pll_full_0/divbuf_0/a_57630_n1540# pll_full_0/divbuf_0/a_58110_n1540# 0.11fF
C5780 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_15390_n840# 0.02fF
C5781 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24960_n1600# 0.26fF
C5782 divbuf_4/a_29742_n240# divbuf_4/a_30232_n240# 0.04fF
C5783 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/a_18750_n840# 0.02fF
C5784 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_28320_n1600# 0.26fF
C5785 divbuf_3/a_13920_n1600# divbuf_3/a_13950_n1540# 0.19fF
C5786 divbuf_3/a_13950_n840# divbuf_3/a_14430_n840# 0.07fF
C5787 pd_div_0/divbuf_0/a_47550_n840# pd_div_0/divbuf_0/a_47550_n1540# 0.01fF
C5788 pd_div_0/divbuf_0/a_16830_n1540# pd_div_0/divbuf_0/a_17310_n1540# 0.11fF
C5789 divbuf_4/a_41280_n1600# divbuf_4/a_41310_n1540# 0.19fF
C5790 divbuf_4/a_41310_n840# divbuf_4/a_41790_n840# 0.07fF
C5791 divbuf_4/a_11070_n840# divbuf_4/a_11070_n1540# 0.01fF
C5792 pll_full_0/divbuf_1/a_20190_n1540# pll_full_0/divbuf_1/a_20670_n1540# 0.11fF
C5793 pll_full_0/divbuf_1/a_50910_n840# pll_full_0/divbuf_1/a_50910_n1540# 0.01fF
C5794 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5795 divbuf_0/a_0_n1600# divbuf_0/OUT 0.26fF
C5796 divbuf_0/a_1920_n1600# divbuf_0/OUT2 0.00fF
C5797 divbuf_1/a_1842_n240# divbuf_1/a_2322_n240# 0.05fF
C5798 divbuf_5/a_31202_170# divbuf_5/a_31682_170# 0.07fF
C5799 divbuf_5/a_11802_170# divbuf_5/a_11802_n240# 0.01fF
C5800 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5801 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55230_n840# 0.04fF
C5802 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16350_n1540# 0.19fF
C5803 ro_div_0/divbuf_0/a_16350_n840# ro_div_0/divbuf_0/a_16830_n840# 0.07fF
C5804 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/a_15182_170# 0.07fF
C5805 divbuf_1/a_14910_n840# divbuf_1/a_15390_n840# 0.07fF
C5806 divbuf_1/a_7302_n240# divbuf_1/OUT3 0.04fF
C5807 divbuf_1/a_14880_n1600# divbuf_1/a_14910_n1540# 0.19fF
C5808 divbuf_5/a_3870_n840# divbuf_5/a_4350_n840# 0.07fF
C5809 divbuf_5/a_3840_n1600# divbuf_5/a_3870_n1540# 0.19fF
C5810 divbuf_5/a_24412_170# divbuf_5/OUT4 0.19fF
C5811 divbuf_0/a_18092_170# divbuf_0/a_18582_170# 0.07fF
C5812 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14430_n840# 0.04fF
C5813 divbuf_2/a_3912_170# divbuf_2/a_4392_170# 0.07fF
C5814 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_17790_n840# 0.04fF
C5815 divbuf_5/a_56670_n1540# divbuf_5/a_57150_n1540# 0.11fF
C5816 divbuf_0/a_40902_n240# divbuf_0/a_41382_n240# 0.05fF
C5817 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/a_33622_n240# 0.05fF
C5818 divbuf_2/a_37920_n1600# divbuf_2/a_38400_n1600# 0.26fF
C5819 divbuf_2/a_28772_n240# divbuf_2/a_28830_n840# 0.04fF
C5820 divbuf_0/a_22110_n840# divbuf_0/a_22110_n1540# 0.01fF
C5821 divbuf_0/a_52350_n840# divbuf_0/a_52830_n840# 0.07fF
C5822 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n1540# 0.19fF
C5823 pll_full_0/divbuf_0/a_14430_n840# pll_full_0/divbuf_0/a_14430_n1540# 0.01fF
C5824 pll_full_0/divbuf_0/a_44670_n840# pll_full_0/divbuf_0/a_45150_n840# 0.07fF
C5825 divbuf_2/a_60990_n840# divbuf_2/a_60990_n1540# 0.01fF
C5826 divbuf_2/a_30270_n1540# divbuf_2/a_30750_n1540# 0.11fF
C5827 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_44670_n1540# 0.19fF
C5828 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C5829 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/a_31682_170# 0.07fF
C5830 divbuf_3/a_57630_n1540# divbuf_3/a_58110_n1540# 0.11fF
C5831 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/a_35082_170# 0.07fF
C5832 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/a_15182_n240# 0.01fF
C5833 divbuf_3/a_480_n1600# divbuf_3/a_960_n1600# 0.26fF
C5834 divbuf_5/a_54240_n1600# divbuf_5/a_54270_n840# 0.04fF
C5835 divbuf_5/a_25382_n240# divbuf_5/OUT4 0.04fF
C5836 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C5837 pd_div_0/divbuf_0/a_3870_n840# pd_div_0/divbuf_0/a_4350_n840# 0.07fF
C5838 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_3870_n1540# 0.19fF
C5839 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5840 divbuf_4/a_27840_n1600# divbuf_4/a_28320_n1600# 0.26fF
C5841 divbuf_4/a_18582_n240# divbuf_4/a_18750_n840# 0.02fF
C5842 pll_full_0/divbuf_1/a_7230_n840# pll_full_0/divbuf_1/a_7710_n840# 0.07fF
C5843 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5844 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7230_n1540# 0.19fF
C5845 divbuf_3/a_53790_n840# divbuf_3/a_54270_n840# 0.07fF
C5846 divbuf_3/a_23550_n840# divbuf_3/a_23550_n1540# 0.01fF
C5847 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C5848 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C5849 pd_div_0/divbuf_0/a_56670_n1540# pd_div_0/divbuf_0/a_57150_n1540# 0.11fF
C5850 divbuf_2/a_27840_n1600# divbuf_2/a_27870_n840# 0.04fF
C5851 divbuf_2/a_11312_170# divbuf_2/OUT4 0.23fF
C5852 divbuf_4/a_50910_n840# divbuf_4/a_50910_n1540# 0.01fF
C5853 divbuf_4/a_20190_n1540# divbuf_4/a_20670_n1540# 0.11fF
C5854 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/a_1470_n840# 0.03fF
C5855 pll_full_0/divbuf_1/a_60030_n1540# pll_full_0/divbuf_1/a_60510_n1540# 0.11fF
C5856 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/a3 0.13fF
C5857 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_3360_n1600# 0.26fF
C5858 divbuf_1/a_1440_n1600# divbuf_1/a_1920_n1600# 0.26fF
C5859 divbuf_5/a_32172_n240# divbuf_5/a_32652_n240# 0.05fF
C5860 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C5861 ro_div_0/divbuf_0/a_25950_n840# ro_div_0/divbuf_0/a_25950_n1540# 0.01fF
C5862 ro_div_0/divbuf_0/a_56190_n840# ro_div_0/divbuf_0/a_56670_n840# 0.07fF
C5863 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56190_n1540# 0.19fF
C5864 divbuf_1/a_54720_n1600# divbuf_1/a_54750_n1540# 0.19fF
C5865 divbuf_1/a_54750_n840# divbuf_1/a_55230_n840# 0.07fF
C5866 divbuf_1/a_24510_n840# divbuf_1/a_24510_n1540# 0.01fF
C5867 divbuf_3/a_11312_n240# divbuf_3/a_11070_n840# 0.02fF
C5868 divbuf_5/a_43680_n1600# divbuf_5/a_43710_n1540# 0.19fF
C5869 divbuf_5/a_43710_n840# divbuf_5/a_44190_n840# 0.07fF
C5870 divbuf_5/a_13470_n840# divbuf_5/a_13470_n1540# 0.01fF
C5871 divbuf_5/a_23520_n1600# divbuf_5/OUT4 0.00fF
C5872 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54270_n840# 0.04fF
C5873 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5874 divbuf_2/a_25382_170# divbuf_2/a_25382_n240# 0.01fF
C5875 divbuf_2/a_4882_n240# divbuf_2/a_5362_n240# 0.05fF
C5876 divbuf_4/a_17760_n1600# divbuf_4/a_17790_n840# 0.04fF
C5877 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C5878 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_57630_n840# 0.04fF
C5879 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5880 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_17790_n840# 0.02fF
C5881 divbuf_0/a_29742_n240# divbuf_0/a_29790_n840# 0.04fF
C5882 divbuf_0/a_38880_n1600# divbuf_0/a_39360_n1600# 0.26fF
C5883 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C5884 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/a_22110_n840# 0.03fF
C5885 divbuf_2/a_17310_n840# divbuf_2/a_17790_n840# 0.07fF
C5886 divbuf_2/a_12282_n240# divbuf_2/OUT4 0.04fF
C5887 divbuf_2/a_17280_n1600# divbuf_2/a_17310_n1540# 0.19fF
C5888 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31680_n1600# 0.26fF
C5889 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C5890 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/a_19562_170# 0.07fF
C5891 divbuf_0/a_31230_n1540# divbuf_0/a_31710_n1540# 0.11fF
C5892 divbuf_1/a_12282_n240# divbuf_1/a_12030_n840# 0.02fF
C5893 divbuf_3/a_6332_170# divbuf_3/a_6822_170# 0.07fF
C5894 pll_full_0/divbuf_0/a_54270_n840# pll_full_0/divbuf_0/a_54270_n1540# 0.01fF
C5895 pll_full_0/divbuf_0/a_23550_n1540# pll_full_0/divbuf_0/a_24030_n1540# 0.11fF
C5896 divbuf_3/a_41382_170# divbuf_3/OUT4 0.19fF
C5897 divbuf_3/a_1842_n240# divbuf_3/OUT2 0.04fF
C5898 ashish_0/a_150_0# ashish_0/vop 4.44fF
C5899 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/a_32652_n240# 0.05fF
C5900 divbuf_3/a_40320_n1600# divbuf_3/a_40800_n1600# 0.26fF
C5901 divbuf_3/a_31202_n240# divbuf_3/a_31230_n840# 0.05fF
C5902 divbuf_4/a_15182_170# divbuf_4/a_15182_n240# 0.01fF
C5903 divbuf_4/a_34592_170# divbuf_4/a_35082_170# 0.07fF
C5904 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/a_36052_n240# 0.04fF
C5905 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_43710_n1540# 0.19fF
C5906 pd_div_0/divbuf_0/a_43710_n840# pd_div_0/divbuf_0/a_44190_n840# 0.07fF
C5907 pd_div_0/divbuf_0/a_13470_n840# pd_div_0/divbuf_0/a_13470_n1540# 0.01fF
C5908 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5909 divbuf_4/a_7200_n1600# divbuf_4/a_7230_n1540# 0.19fF
C5910 divbuf_4/a_31202_170# divbuf_4/OUT4 0.19fF
C5911 divbuf_4/a_7230_n840# divbuf_4/a_7710_n840# 0.07fF
C5912 pll_full_0/divbuf_1/a_16830_n840# pll_full_0/divbuf_1/a_16830_n1540# 0.01fF
C5913 pll_full_0/divbuf_1/a_47070_n840# pll_full_0/divbuf_1/a_47550_n840# 0.07fF
C5914 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47070_n1540# 0.19fF
C5915 divbuf_3/a_32670_n1540# divbuf_3/a_33150_n1540# 0.11fF
C5916 divbuf_0/a_12772_170# divbuf_0/OUT4 0.19fF
C5917 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n840# 0.04fF
C5918 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/Out 0.04fF
C5919 pd_div_0/divider_0/prescaler_0/nand_0/z1 gnd 0.16fF
C5920 divbuf_1/a_33622_170# divbuf_1/a_34112_170# 0.07fF
C5921 divbuf_2/a_11040_n1600# divbuf_2/OUT3 0.00fF
C5922 divbuf_4/a_60030_n1540# divbuf_4/a_60510_n1540# 0.11fF
C5923 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/OUT2 0.19fF
C5924 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21150_n840# 0.04fF
C5925 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/a_19072_n240# 0.01fF
C5926 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/a_33630_n840# 0.06fF
C5927 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_43200_n1600# 0.26fF
C5928 divbuf_1/a_41280_n1600# divbuf_1/a_41760_n1600# 0.26fF
C5929 divbuf_1/a_18092_170# divbuf_1/OUT4 0.19fF
C5930 divbuf_1/a_32172_n240# divbuf_1/a_32190_n840# 0.06fF
C5931 divbuf_5/a_30240_n1600# divbuf_5/a_30720_n1600# 0.26fF
C5932 divbuf_5/a_21012_n240# divbuf_5/a_21150_n840# 0.03fF
C5933 divbuf_3/a_1440_n1600# divbuf_3/OUT2 0.01fF
C5934 ro_div_0/divbuf_0/a_35070_n1540# ro_div_0/divbuf_0/a_35550_n1540# 0.11fF
C5935 divbuf_1/a_33630_n1540# divbuf_1/a_34110_n1540# 0.11fF
C5936 divbuf_5/a_53310_n840# divbuf_5/a_53310_n1540# 0.01fF
C5937 divbuf_5/a_22590_n1540# divbuf_5/a_23070_n1540# 0.11fF
C5938 divbuf_3/a_30240_n1600# divbuf_3/a_30270_n840# 0.04fF
C5939 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C5940 io_analog[0] io_analog[1] 5.63fF
C5941 divbuf_0/a_5852_n240# divbuf_0/a_6332_n240# 0.05fF
C5942 divbuf_0/a_26352_170# divbuf_0/a_26352_n240# 0.01fF
C5943 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/a_38472_170# 0.07fF
C5944 divbuf_2/a_3840_n1600# divbuf_2/a_4320_n1600# 0.26fF
C5945 divbuf_4/a_32172_n240# divbuf_4/OUT4 0.04fF
C5946 divbuf_4/a_57600_n1600# divbuf_4/a_57630_n840# 0.04fF
C5947 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5948 divbuf_0/a_14222_n240# divbuf_0/OUT4 0.04fF
C5949 divbuf_0/a_18270_n840# divbuf_0/a_18750_n840# 0.07fF
C5950 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n1540# 0.19fF
C5951 divbuf_2/a_57120_n1600# divbuf_2/a_57150_n1540# 0.19fF
C5952 divbuf_2/a_57150_n840# divbuf_2/a_57630_n840# 0.07fF
C5953 divbuf_2/a_26910_n840# divbuf_2/a_26910_n1540# 0.01fF
C5954 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/a_11070_n840# 0.07fF
C5955 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_10590_n1540# 0.19fF
C5956 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5957 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/a_19072_n240# 0.04fF
C5958 ro_div_0/divider_0/tspc_0/Z4 gnd 0.44fF
C5959 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_32670_n840# 0.04fF
C5960 divbuf_1/a_31200_n1600# divbuf_1/a_31230_n840# 0.04fF
C5961 divbuf_5/a_20160_n1600# divbuf_5/a_20190_n840# 0.04fF
C5962 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C5963 divbuf_3/a_27802_170# divbuf_3/a_27802_n240# 0.01fF
C5964 divbuf_3/a_7302_n240# divbuf_3/a_7792_n240# 0.04fF
C5965 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 0.36fF
C5966 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30720_n1600# 0.26fF
C5967 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/a_21150_n840# 0.03fF
C5968 divbuf_4/a_35562_n240# divbuf_4/a_36052_n240# 0.04fF
C5969 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_34080_n1600# 0.26fF
C5970 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/a_24510_n840# 0.03fF
C5971 divbuf_3/a_19680_n1600# divbuf_3/a_19710_n1540# 0.19fF
C5972 divbuf_3/a_19710_n840# divbuf_3/a_20190_n840# 0.07fF
C5973 pd_div_0/divbuf_0/a_53310_n840# pd_div_0/divbuf_0/a_53310_n1540# 0.01fF
C5974 pd_div_0/divbuf_0/a_22590_n1540# pd_div_0/divbuf_0/a_23070_n1540# 0.11fF
C5975 divbuf_2/a_14702_n240# divbuf_2/a_14430_n840# 0.01fF
C5976 divbuf_4/a_47040_n1600# divbuf_4/a_47070_n1540# 0.19fF
C5977 divbuf_4/a_47070_n840# divbuf_4/a_47550_n840# 0.07fF
C5978 divbuf_4/a_16830_n840# divbuf_4/a_16830_n1540# 0.01fF
C5979 pll_full_0/divbuf_1/a_25950_n1540# pll_full_0/divbuf_1/a_26430_n1540# 0.11fF
C5980 pll_full_0/divbuf_1/a_56670_n840# pll_full_0/divbuf_1/a_56670_n1540# 0.01fF
C5981 divbuf_0/a_12480_n1600# divbuf_0/OUT4 0.00fF
C5982 divbuf_1/a_8272_n240# divbuf_1/a_8762_n240# 0.04fF
C5983 divbuf_5/a_17612_170# divbuf_5/a_17612_n240# 0.01fF
C5984 divbuf_5/a_37022_170# divbuf_5/a_37502_170# 0.07fF
C5985 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5986 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5987 ro_div_0/divbuf_0/a_22110_n840# ro_div_0/divbuf_0/a_22590_n840# 0.07fF
C5988 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22110_n1540# 0.19fF
C5989 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/a_2322_n240# 0.01fF
C5990 divbuf_1/a_20640_n1600# divbuf_1/a_20670_n1540# 0.19fF
C5991 divbuf_1/a_20670_n840# divbuf_1/a_21150_n840# 0.07fF
C5992 divbuf_1/a_19072_n240# divbuf_1/OUT4 0.04fF
C5993 divbuf_5/a_9600_n1600# divbuf_5/a_9630_n1540# 0.19fF
C5994 divbuf_5/a_36052_170# divbuf_5/OUT4 0.19fF
C5995 divbuf_5/a_9630_n840# divbuf_5/a_10110_n840# 0.07fF
C5996 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/OUT2 0.42fF
C5997 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20190_n840# 0.04fF
C5998 divbuf_2/a_9732_170# divbuf_2/a_10212_170# 0.07fF
C5999 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_23550_n840# 0.04fF
C6000 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/OUT2 0.19fF
C6001 divbuf_5/a_60990_n1540# divbuf_5/OUT5 0.19fF
C6002 divbuf_0/a_4800_n1600# divbuf_0/a_5280_n1600# 0.26fF
C6003 divbuf_2/a_43680_n1600# divbuf_2/a_44160_n1600# 0.26fF
C6004 divbuf_2/a_34592_n240# divbuf_2/a_34590_n840# 0.06fF
C6005 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/a_39442_n240# 0.05fF
C6006 divbuf_0/a_27870_n840# divbuf_0/a_27870_n1540# 0.01fF
C6007 divbuf_0/a_58110_n840# divbuf_0/a_58590_n840# 0.07fF
C6008 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n1540# 0.19fF
C6009 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50430_n1540# 0.19fF
C6010 divbuf_2/a_36030_n1540# divbuf_2/a_36510_n1540# 0.11fF
C6011 pll_full_0/divbuf_0/a_50430_n840# pll_full_0/divbuf_0/a_50910_n840# 0.07fF
C6012 pll_full_0/divbuf_0/a_20190_n840# pll_full_0/divbuf_0/a_20190_n1540# 0.01fF
C6013 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C6014 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/a_17612_n240# 0.01fF
C6015 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/a_37502_170# 0.07fF
C6016 divbuf_3/OUT3 divbuf_3/OUT4 0.36fF
C6017 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/a_21012_n240# 0.01fF
C6018 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/a_40902_170# 0.07fF
C6019 divbuf_3/a_6240_n1600# divbuf_3/a_6720_n1600# 0.26fF
C6020 divbuf_5/a_37022_n240# divbuf_5/OUT4 0.04fF
C6021 divbuf_5/a_60000_n1600# divbuf_5/a_60030_n840# 0.04fF
C6022 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C6023 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/clk 0.45fF
C6024 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_9630_n1540# 0.19fF
C6025 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6026 pd_div_0/divbuf_0/a_9630_n840# pd_div_0/divbuf_0/a_10110_n840# 0.07fF
C6027 divbuf_4/a_24412_n240# divbuf_4/a_24510_n840# 0.03fF
C6028 divbuf_4/a_33600_n1600# divbuf_4/a_34080_n1600# 0.26fF
C6029 pll_full_0/divbuf_1/a_12990_n840# pll_full_0/divbuf_1/a_13470_n840# 0.07fF
C6030 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_12990_n1540# 0.19fF
C6031 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/OUT3 0.07fF
C6032 divbuf_3/a_59550_n840# divbuf_3/a_60030_n840# 0.07fF
C6033 divbuf_3/a_29310_n840# divbuf_3/a_29310_n1540# 0.01fF
C6034 divbuf_0/a_15672_n240# divbuf_0/a_15390_n840# 0.01fF
C6035 pd_div_0/divbuf_0/a_60990_n1540# pd_div_0/divbuf_0/OUT5 0.19fF
C6036 divbuf_4/a_56670_n840# divbuf_4/a_56670_n1540# 0.01fF
C6037 divbuf_4/a_25950_n1540# divbuf_4/a_26430_n1540# 0.11fF
C6038 divbuf_2/a_33600_n1600# divbuf_2/a_33630_n840# 0.04fF
C6039 divbuf_2/a_22952_170# divbuf_2/OUT4 0.19fF
C6040 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_9120_n1600# 0.26fF
C6041 divbuf_1/a_7200_n1600# divbuf_1/a_7680_n1600# 0.26fF
C6042 divbuf_5/a_37992_n240# divbuf_5/a_38472_n240# 0.05fF
C6043 gnd pll_full_0/pd_0/DIV 0.01fF
C6044 divbuf_3/a_12772_170# divbuf_3/OUT4 0.19fF
C6045 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/OUT2 0.02fF
C6046 ro_div_0/divbuf_0/a_990_n1540# ro_div_0/divbuf_0/a_1470_n1540# 0.11fF
C6047 ro_div_0/divbuf_0/a_31710_n840# ro_div_0/divbuf_0/a_31710_n1540# 0.01fF
C6048 divbuf_1/a_60510_n840# divbuf_1/a_60990_n840# 0.07fF
C6049 divbuf_1/a_30270_n840# divbuf_1/a_30270_n1540# 0.01fF
C6050 divbuf_1/a_60480_n1600# divbuf_1/a_60510_n1540# 0.19fF
C6051 divbuf_3/a_17122_n240# divbuf_3/a_16830_n840# 0.00fF
C6052 divbuf_5/a_49470_n840# divbuf_5/a_49950_n840# 0.07fF
C6053 divbuf_5/a_19230_n840# divbuf_5/a_19230_n1540# 0.01fF
C6054 divbuf_5/a_35040_n1600# divbuf_5/OUT4 0.00fF
C6055 divbuf_5/a_49440_n1600# divbuf_5/a_49470_n1540# 0.19fF
C6056 divbuf_0/a_11312_170# divbuf_0/a_11802_170# 0.07fF
C6057 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6058 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60030_n840# 0.04fF
C6059 divbuf_4/a_2322_170# divbuf_4/OUT2 0.19fF
C6060 divbuf_4/a_23520_n1600# divbuf_4/a_23550_n840# 0.04fF
C6061 divbuf_2/a_31202_170# divbuf_2/a_31202_n240# 0.01fF
C6062 divbuf_2/a_11312_n240# divbuf_2/a_11802_n240# 0.04fF
C6063 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C6064 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C6065 divbuf_0/a_44640_n1600# divbuf_0/a_45120_n1600# 0.26fF
C6066 divbuf_0/a_35562_n240# divbuf_0/a_35550_n840# 0.05fF
C6067 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Q 0.51fF
C6068 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z3 0.06fF
C6069 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_37440_n1600# 0.26fF
C6070 divbuf_2/a_23040_n1600# divbuf_2/a_23070_n1540# 0.19fF
C6071 divbuf_2/a_23070_n840# divbuf_2/a_23550_n840# 0.07fF
C6072 divbuf_2/a_23922_n240# divbuf_2/OUT4 0.04fF
C6073 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/a_27870_n840# 0.04fF
C6074 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C6075 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/a_23922_170# 0.07fF
C6076 divbuf_0/a_36990_n1540# divbuf_0/a_37470_n1540# 0.11fF
C6077 divbuf_1/a_18092_n240# divbuf_1/a_17790_n840# 0.00fF
C6078 pll_full_0/divbuf_0/a_29310_n1540# pll_full_0/divbuf_0/a_29790_n1540# 0.11fF
C6079 pll_full_0/divbuf_0/a_60030_n840# pll_full_0/divbuf_0/a_60030_n1540# 0.01fF
C6080 divbuf_3/a_12772_170# divbuf_3/a_13252_170# 0.07fF
C6081 divbuf_3/a_13742_n240# divbuf_3/OUT4 0.04fF
C6082 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/a_38472_n240# 0.05fF
C6083 divbuf_4/a_40412_170# divbuf_4/a_40902_170# 0.07fF
C6084 divbuf_4/a_21012_170# divbuf_4/a_21012_n240# 0.01fF
C6085 divbuf_3/a_37022_n240# divbuf_3/a_36990_n840# 0.05fF
C6086 divbuf_3/a_46080_n1600# divbuf_3/a_46560_n1600# 0.26fF
C6087 pd_div_0/divbuf_0/a_49470_n840# pd_div_0/divbuf_0/a_49950_n840# 0.07fF
C6088 pd_div_0/divbuf_0/a_19230_n840# pd_div_0/divbuf_0/a_19230_n1540# 0.01fF
C6089 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6090 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49470_n1540# 0.19fF
C6091 divbuf_3/a_38430_n1540# divbuf_3/a_38910_n1540# 0.11fF
C6092 divbuf_4/a_3422_n240# divbuf_4/OUT3 0.07fF
C6093 divbuf_4/a_12960_n1600# divbuf_4/a_12990_n1540# 0.19fF
C6094 divbuf_4/a_12990_n840# divbuf_4/a_13470_n840# 0.07fF
C6095 pll_full_0/divbuf_1/a_22590_n840# pll_full_0/divbuf_1/a_22590_n1540# 0.01fF
C6096 pll_full_0/divbuf_1/a_52830_n840# pll_full_0/divbuf_1/a_53310_n840# 0.07fF
C6097 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_52830_n1540# 0.19fF
C6098 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6099 divbuf_0/a_24892_170# divbuf_0/OUT4 0.19fF
C6100 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n840# 0.04fF
C6101 gnd pd_div_0/divider_0/clk 0.07fF
C6102 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z4 0.22fF
C6103 pd_div_0/divider_0/tspc_2/Z2 pd_div_0/divider_0/tspc_2/Z3 0.16fF
C6104 divbuf_2/a_22080_n1600# divbuf_2/OUT4 0.01fF
C6105 divbuf_5/a_1352_170# divbuf_5/a_1842_170# 0.07fF
C6106 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_26910_n840# 0.04fF
C6107 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48960_n1600# 0.26fF
C6108 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/a_39390_n840# 0.04fF
C6109 divbuf_1/a_37992_n240# divbuf_1/a_37950_n840# 0.04fF
C6110 divbuf_1/a_6332_170# divbuf_1/OUT3 0.19fF
C6111 divbuf_1/a_47040_n1600# divbuf_1/a_47520_n1600# 0.26fF
C6112 divbuf_5/a_26832_n240# divbuf_5/a_26910_n840# 0.04fF
C6113 divbuf_5/a_36000_n1600# divbuf_5/a_36480_n1600# 0.26fF
C6114 divbuf_3/a_12000_n1600# divbuf_3/OUT4 0.00fF
C6115 ro_div_0/divbuf_0/a_40830_n1540# ro_div_0/divbuf_0/a_41310_n1540# 0.11fF
C6116 pd_0/REF li_17838_664356# 1.03fF
C6117 divbuf_1/a_39390_n1540# divbuf_1/a_39870_n1540# 0.11fF
C6118 divbuf_3/a_36000_n1600# divbuf_3/a_36030_n840# 0.04fF
C6119 divbuf_5/a_59070_n840# divbuf_5/a_59070_n1540# 0.01fF
C6120 divbuf_5/a_28350_n1540# divbuf_5/a_28830_n1540# 0.11fF
C6121 divbuf_0/a_32172_170# divbuf_0/a_32172_n240# 0.01fF
C6122 divbuf_0/a_12282_n240# divbuf_0/a_12772_n240# 0.04fF
C6123 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/a_24412_n240# 0.01fF
C6124 divbuf_2/a_9600_n1600# divbuf_2/a_10080_n1600# 0.26fF
C6125 divbuf_4/a_2880_n1600# divbuf_4/OUT2 0.00fF
C6126 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/a_4392_n240# 0.05fF
C6127 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/OUT2 0.07fF
C6128 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6129 ro_div_0/ro_complete_0/a4 ro_div_0/divider_0/clk 0.05fF
C6130 divbuf_0/a_24030_n840# divbuf_0/a_24510_n840# 0.07fF
C6131 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n1540# 0.19fF
C6132 divbuf_0/a_25862_n240# divbuf_0/OUT4 0.04fF
C6133 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16350_n1540# 0.19fF
C6134 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C6135 divbuf_1/a_13252_170# divbuf_1/a_13252_n240# 0.01fF
C6136 divbuf_2/a_510_n840# io_analog[10] 0.07fF
C6137 divbuf_2/a_32670_n840# divbuf_2/a_32670_n1540# 0.01fF
C6138 divbuf_2/a_1950_n1540# divbuf_2/a_2430_n1540# 0.11fF
C6139 pll_full_0/divbuf_0/a_16350_n840# pll_full_0/divbuf_0/a_16830_n840# 0.07fF
C6140 ro_div_0/divider_0/tspc_1/Z2 gnd 0.16fF
C6141 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38430_n840# 0.04fF
C6142 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/tspc_r_1/z5 0.20fF
C6143 pd_div_0/pd_0/R pd_div_0/pd_0/and_pd_0/Z1 0.02fF
C6144 divbuf_1/a_26352_170# divbuf_1/OUT4 0.19fF
C6145 divbuf_1/a_36960_n1600# divbuf_1/a_36990_n840# 0.04fF
C6146 divbuf_3/a_13742_n240# divbuf_3/a_14222_n240# 0.05fF
C6147 divbuf_3/a_33622_170# divbuf_3/a_33622_n240# 0.01fF
C6148 divbuf_5/a_7302_170# divbuf_5/OUT3 0.19fF
C6149 divbuf_5/a_25920_n1600# divbuf_5/a_25950_n840# 0.04fF
C6150 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/a_5852_170# 0.07fF
C6151 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C6152 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/a_26910_n840# 0.04fF
C6153 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36480_n1600# 0.26fF
C6154 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/a_30270_n840# 0.05fF
C6155 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39840_n1600# 0.26fF
C6156 divbuf_3/a_25440_n1600# divbuf_3/a_25470_n1540# 0.19fF
C6157 divbuf_3/a_25470_n840# divbuf_3/a_25950_n840# 0.07fF
C6158 pd_div_0/divbuf_0/a_59070_n840# pd_div_0/divbuf_0/a_59070_n1540# 0.01fF
C6159 pd_div_0/divbuf_0/a_28350_n1540# pd_div_0/divbuf_0/a_28830_n1540# 0.11fF
C6160 divbuf_4/a_52800_n1600# divbuf_4/a_52830_n1540# 0.19fF
C6161 divbuf_4/a_52830_n840# divbuf_4/a_53310_n840# 0.07fF
C6162 divbuf_4/a_22590_n840# divbuf_4/a_22590_n1540# 0.01fF
C6163 pll_full_0/divbuf_1/a_31710_n1540# pll_full_0/divbuf_1/a_32190_n1540# 0.11fF
C6164 gnd pll_full_0/divider_0/tspc_1/a_630_n680# 0.62fF
C6165 divbuf_0/a_24000_n1600# divbuf_0/OUT4 0.00fF
C6166 divbuf_1/a_14702_n240# divbuf_1/a_15182_n240# 0.05fF
C6167 divbuf_1/a_34592_170# divbuf_1/a_34592_n240# 0.01fF
C6168 divbuf_5/a_23442_170# divbuf_5/a_23442_n240# 0.01fF
C6169 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C6170 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_27870_n1540# 0.19fF
C6171 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6172 ro_div_0/divbuf_0/a_27870_n840# ro_div_0/divbuf_0/a_28350_n840# 0.07fF
C6173 divbuf_1/a_26430_n840# divbuf_1/a_26910_n840# 0.07fF
C6174 divbuf_1/a_30712_n240# divbuf_1/OUT4 0.04fF
C6175 divbuf_1/a_26400_n1600# divbuf_1/a_26430_n1540# 0.19fF
C6176 divbuf_5/a_15390_n840# divbuf_5/a_15870_n840# 0.07fF
C6177 divbuf_5/a_8272_n240# divbuf_5/OUT3 0.04fF
C6178 divbuf_5/a_15360_n1600# divbuf_5/a_15390_n1540# 0.19fF
C6179 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Q 0.04fF
C6180 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6181 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_25950_n840# 0.04fF
C6182 divbuf_2/a_16152_170# divbuf_2/a_16642_170# 0.07fF
C6183 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C6184 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C6185 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6186 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29310_n840# 0.04fF
C6187 divbuf_0/a_10560_n1600# divbuf_0/a_11040_n1600# 0.26fF
C6188 divbuf_2/a_49440_n1600# divbuf_2/a_49920_n1600# 0.26fF
C6189 divbuf_2/a_40412_n240# divbuf_2/a_40350_n840# 0.04fF
C6190 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_3360_n1600# 0.26fF
C6191 divbuf_0/a_2910_n1540# divbuf_0/a_3390_n1540# 0.11fF
C6192 divbuf_0/a_33630_n840# divbuf_0/a_33630_n1540# 0.01fF
C6193 pll_full_0/divbuf_0/a_25950_n840# pll_full_0/divbuf_0/a_25950_n1540# 0.01fF
C6194 pll_full_0/divbuf_0/a_56190_n840# pll_full_0/divbuf_0/a_56670_n840# 0.07fF
C6195 divbuf_2/a_41790_n1540# divbuf_2/a_42270_n1540# 0.11fF
C6196 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56190_n1540# 0.19fF
C6197 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C6198 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/a_23442_n240# 0.01fF
C6199 divbuf_4/a_5362_170# divbuf_4/a_5852_170# 0.07fF
C6200 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/a_6822_n240# 0.04fF
C6201 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/a_26832_n240# 0.01fF
C6202 divbuf_3/a_12000_n1600# divbuf_3/a_12480_n1600# 0.26fF
C6203 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C6204 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/nor_0/B 0.35fF
C6205 pd_div_0/divbuf_0/a_15390_n840# pd_div_0/divbuf_0/a_15870_n840# 0.07fF
C6206 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C6207 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15390_n1540# 0.19fF
C6208 divbuf_4/a_39360_n1600# divbuf_4/a_39840_n1600# 0.26fF
C6209 divbuf_4/a_30232_n240# divbuf_4/a_30270_n840# 0.05fF
C6210 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6211 pll_full_0/divbuf_1/a_18750_n840# pll_full_0/divbuf_1/a_19230_n840# 0.07fF
C6212 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_18750_n1540# 0.19fF
C6213 divbuf_3/a_35070_n840# divbuf_3/a_35070_n1540# 0.01fF
C6214 divbuf_3/a_4350_n1540# divbuf_3/a_4830_n1540# 0.11fF
C6215 divbuf_0/a_480_n1600# divbuf_0/a_510_n840# 0.04fF
C6216 divbuf_1/a_30712_170# divbuf_1/a_31202_170# 0.07fF
C6217 divbuf_4/a_31710_n1540# divbuf_4/a_32190_n1540# 0.11fF
C6218 divbuf_2/a_39360_n1600# divbuf_2/a_39390_n840# 0.04fF
C6219 divbuf_2/a_34592_170# divbuf_2/OUT4 0.19fF
C6220 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_13470_n840# 0.01fF
C6221 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C6222 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14880_n1600# 0.26fF
C6223 divbuf_1/a_3422_n240# divbuf_1/a_3390_n840# 0.05fF
C6224 divbuf_1/a_12960_n1600# divbuf_1/a_13440_n1600# 0.26fF
C6225 divbuf_5/a_1920_n1600# divbuf_5/a_2400_n1600# 0.26fF
C6226 divbuf_3/a_24412_170# divbuf_3/OUT4 0.19fF
C6227 ro_div_0/divbuf_0/a_6750_n1540# ro_div_0/divbuf_0/a_7230_n1540# 0.11fF
C6228 ro_div_0/divbuf_0/a_37470_n840# ro_div_0/divbuf_0/a_37470_n1540# 0.01fF
C6229 divbuf_1/a_36030_n840# divbuf_1/a_36030_n1540# 0.01fF
C6230 divbuf_1/a_5310_n1540# divbuf_1/a_5790_n1540# 0.11fF
C6231 divbuf_3/a_1920_n1600# divbuf_3/a_1950_n840# 0.04fF
C6232 divbuf_5/a_55200_n1600# divbuf_5/a_55230_n1540# 0.19fF
C6233 divbuf_5/a_55230_n840# divbuf_5/a_55710_n840# 0.07fF
C6234 divbuf_5/a_24990_n840# divbuf_5/a_24990_n1540# 0.01fF
C6235 divbuf_0/a_14702_170# divbuf_0/a_15182_170# 0.07fF
C6236 divbuf_0/a_3912_170# divbuf_0/a_3912_n240# 0.01fF
C6237 divbuf_4/a_29280_n1600# divbuf_4/a_29310_n840# 0.04fF
C6238 divbuf_4/a_14222_170# divbuf_4/OUT4 0.19fF
C6239 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6240 divbuf_2/a_37022_170# divbuf_2/a_37022_n240# 0.01fF
C6241 divbuf_2/a_17122_n240# divbuf_2/a_17612_n240# 0.04fF
C6242 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C6243 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C6244 divbuf_0/a_41382_n240# divbuf_0/a_41310_n840# 0.03fF
C6245 divbuf_0/a_50400_n1600# divbuf_0/a_50880_n1600# 0.26fF
C6246 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/and_0/B 0.78fF
C6247 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.44fF
C6248 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C6249 pd_div_0/divider_0/tspc_1/Z3 pd_div_0/divider_0/tspc_1/Z4 0.65fF
C6250 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/a_33630_n840# 0.06fF
C6251 divbuf_2/a_28830_n840# divbuf_2/a_29310_n840# 0.07fF
C6252 divbuf_2/a_35562_n240# divbuf_2/OUT4 0.04fF
C6253 divbuf_2/a_28800_n1600# divbuf_2/a_28830_n1540# 0.19fF
C6254 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/OUT3 0.19fF
C6255 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_43200_n1600# 0.26fF
C6256 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C6257 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/a_9242_n240# 0.01fF
C6258 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/a_29742_170# 0.07fF
C6259 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4350_n840# 0.04fF
C6260 divbuf_0/a_42750_n1540# divbuf_0/a_43230_n1540# 0.11fF
C6261 divbuf_1/a_2880_n1600# divbuf_1/a_2910_n840# 0.04fF
C6262 divbuf_3/a_18582_170# divbuf_3/a_19072_170# 0.07fF
C6263 divbuf_5/a_12772_n240# divbuf_5/a_12510_n840# 0.01fF
C6264 pll_full_0/divbuf_0/a_35070_n1540# pll_full_0/divbuf_0/a_35550_n1540# 0.11fF
C6265 divbuf_3/a_25382_n240# divbuf_3/OUT4 0.04fF
C6266 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_2400_n1600# 0.26fF
C6267 divbuf_4/a_26832_170# divbuf_4/a_26832_n240# 0.01fF
C6268 divbuf_4/a_6332_n240# divbuf_4/a_6822_n240# 0.04fF
C6269 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5760_n1600# 0.26fF
C6270 divbuf_3/a_51840_n1600# divbuf_3/a_52320_n1600# 0.26fF
C6271 divbuf_0/a_16642_170# divbuf_0/a_16642_n240# 0.01fF
C6272 divbuf_0/a_492_n240# divbuf_0/a_960_n1600# 0.00fF
C6273 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55230_n1540# 0.19fF
C6274 pd_div_0/divbuf_0/a_55230_n840# pd_div_0/divbuf_0/a_55710_n840# 0.07fF
C6275 pd_div_0/divbuf_0/a_24990_n840# pd_div_0/divbuf_0/a_24990_n1540# 0.01fF
C6276 divbuf_4/a_18720_n1600# divbuf_4/a_18750_n1540# 0.19fF
C6277 divbuf_4/a_18750_n840# divbuf_4/a_19230_n840# 0.07fF
C6278 divbuf_4/a_15182_n240# divbuf_4/OUT4 0.04fF
C6279 divbuf_3/a_44190_n1540# divbuf_3/a_44670_n1540# 0.11fF
C6280 pll_full_0/divbuf_1/a_28350_n840# pll_full_0/divbuf_1/a_28350_n1540# 0.01fF
C6281 pll_full_0/divbuf_1/a_58590_n840# pll_full_0/divbuf_1/a_59070_n840# 0.07fF
C6282 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_58590_n1540# 0.19fF
C6283 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/a_12282_n240# 0.01fF
C6284 divbuf_0/a_36532_170# divbuf_0/OUT4 0.19fF
C6285 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n840# 0.04fF
C6286 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6287 divbuf_2/a_33600_n1600# divbuf_2/OUT4 0.01fF
C6288 divbuf_5/a_7792_170# divbuf_5/a_8272_170# 0.07fF
C6289 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_32670_n840# 0.04fF
C6290 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54720_n1600# 0.26fF
C6291 divbuf_1/a_52800_n1600# divbuf_1/a_53280_n1600# 0.26fF
C6292 divbuf_5/a_41760_n1600# divbuf_5/a_42240_n1600# 0.26fF
C6293 divbuf_5/a_32652_n240# divbuf_5/a_32670_n840# 0.06fF
C6294 divbuf_3/a_23520_n1600# divbuf_3/OUT4 0.00fF
C6295 ro_div_0/divbuf_0/a_46590_n1540# ro_div_0/divbuf_0/a_47070_n1540# 0.11fF
C6296 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_12510_n840# 0.01fF
C6297 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/a_25862_n240# 0.01fF
C6298 divbuf_1/a_45150_n1540# divbuf_1/a_45630_n1540# 0.11fF
C6299 divbuf_3/a_41760_n1600# divbuf_3/a_41790_n840# 0.04fF
C6300 divbuf_5/a_34110_n1540# divbuf_5/a_34590_n1540# 0.11fF
C6301 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_15870_n840# 0.01fF
C6302 divbuf_0/a_18092_n240# divbuf_0/a_18582_n240# 0.04fF
C6303 divbuf_0/a_37992_170# divbuf_0/a_37992_n240# 0.01fF
C6304 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/a_10212_n240# 0.05fF
C6305 divbuf_2/a_15360_n1600# divbuf_2/a_15840_n1600# 0.26fF
C6306 divbuf_2/a_5852_n240# divbuf_2/a_5790_n840# 0.04fF
C6307 divbuf_4/a_13440_n1600# divbuf_4/OUT4 0.00fF
C6308 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/a_30232_n240# 0.01fF
C6309 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6310 divbuf_0/a_37502_n240# divbuf_0/OUT4 0.04fF
C6311 divbuf_0/a_29790_n840# divbuf_0/a_30270_n840# 0.07fF
C6312 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n1540# 0.19fF
C6313 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6314 pll_full_0/divbuf_0/a_22110_n840# pll_full_0/divbuf_0/a_22590_n840# 0.07fF
C6315 divbuf_2/a_38430_n840# divbuf_2/a_38430_n1540# 0.01fF
C6316 divbuf_2/a_7710_n1540# divbuf_2/a_8190_n1540# 0.11fF
C6317 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22110_n1540# 0.19fF
C6318 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44190_n840# 0.04fF
C6319 pd_div_0/pd_0/and_pd_0/Out1 pd_div_0/pd_0/and_pd_0/Z1 0.18fF
C6320 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/a_3912_170# 0.07fF
C6321 divbuf_1/a_42720_n1600# divbuf_1/a_42750_n840# 0.04fF
C6322 divbuf_1/a_41382_170# divbuf_1/OUT4 0.19fF
C6323 divbuf_1/a_1842_n240# divbuf_1/OUT2 0.04fF
C6324 divbuf_3/a_39442_170# divbuf_3/a_39442_n240# 0.01fF
C6325 divbuf_3/a_19562_n240# divbuf_3/a_20042_n240# 0.05fF
C6326 divbuf_5/a_31680_n1600# divbuf_5/a_31710_n840# 0.04fF
C6327 divbuf_5/a_19072_170# divbuf_5/OUT4 0.19fF
C6328 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/a_12282_170# 0.07fF
C6329 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_42240_n1600# 0.26fF
C6330 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/a_32670_n840# 0.06fF
C6331 divbuf_3/a_31200_n1600# divbuf_3/a_31230_n1540# 0.19fF
C6332 divbuf_3/a_31230_n840# divbuf_3/a_31710_n840# 0.07fF
C6333 divbuf_3/a_990_n840# divbuf_3/a_990_n1540# 0.01fF
C6334 divbuf_4/a_5280_n1600# divbuf_4/a_5760_n1600# 0.26fF
C6335 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45600_n1600# 0.26fF
C6336 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/a_36030_n840# 0.05fF
C6337 pd_div_0/divbuf_0/a_34110_n1540# pd_div_0/divbuf_0/a_34590_n1540# 0.11fF
C6338 divbuf_2/a_5280_n1600# divbuf_2/a_5310_n840# 0.04fF
C6339 divbuf_4/a_58560_n1600# divbuf_4/a_58590_n1540# 0.19fF
C6340 divbuf_4/a_58590_n840# divbuf_4/a_59070_n840# 0.07fF
C6341 divbuf_4/a_28350_n840# divbuf_4/a_28350_n1540# 0.01fF
C6342 pll_full_0/divbuf_1/a_37470_n1540# pll_full_0/divbuf_1/a_37950_n1540# 0.11fF
C6343 pd_0/DIV divbuf_5/a_0_n1600# 0.26fF
C6344 gnd pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.63fF
C6345 divbuf_0/a_35520_n1600# divbuf_0/OUT4 0.00fF
C6346 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/a_22472_n240# 0.04fF
C6347 divbuf_1/a_40412_170# divbuf_1/a_40412_n240# 0.01fF
C6348 divbuf_1/a_20532_n240# divbuf_1/a_21012_n240# 0.05fF
C6349 divbuf_5/a_29262_170# divbuf_5/a_29262_n240# 0.01fF
C6350 divbuf_5/a_8762_n240# divbuf_5/a_9242_n240# 0.05fF
C6351 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C6352 ro_div_0/divbuf_0/a_3390_n840# ro_div_0/divbuf_0/a_3390_n1540# 0.01fF
C6353 ro_div_0/divbuf_0/a_33630_n840# ro_div_0/divbuf_0/a_34110_n840# 0.07fF
C6354 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_33630_n1540# 0.19fF
C6355 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/a_7302_n240# 0.01fF
C6356 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_12772_n240# 0.01fF
C6357 divbuf_1/a_1440_n1600# divbuf_1/OUT2 0.01fF
C6358 divbuf_1/a_32160_n1600# divbuf_1/a_32190_n1540# 0.19fF
C6359 divbuf_1/a_32190_n840# divbuf_1/a_32670_n840# 0.07fF
C6360 divbuf_1/a_1950_n840# divbuf_1/a_1950_n1540# 0.01fF
C6361 divbuf_5/a_21120_n1600# divbuf_5/a_21150_n1540# 0.19fF
C6362 divbuf_5/a_21150_n840# divbuf_5/a_21630_n840# 0.07fF
C6363 divbuf_5/a_20042_n240# divbuf_5/OUT4 0.04fF
C6364 divbuf_3/a_53310_n840# divbuf_3/a_53310_n1540# 0.01fF
C6365 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C6366 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/and_0/OUT 0.14fF
C6367 divbuf_0/a_3422_170# divbuf_0/a_3912_170# 0.07fF
C6368 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_31710_n840# 0.04fF
C6369 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6370 divbuf_2/a_21982_170# divbuf_2/a_22472_170# 0.07fF
C6371 divbuf_2/a_1352_170# divbuf_2/a_1352_n240# 0.01fF
C6372 divbuf_4/a_16152_n240# divbuf_4/a_15870_n840# 0.01fF
C6373 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C6374 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6375 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35070_n840# 0.04fF
C6376 divbuf_0/a_6822_n240# divbuf_0/a_6750_n840# 0.03fF
C6377 divbuf_0/a_16320_n1600# divbuf_0/a_16800_n1600# 0.26fF
C6378 divbuf_2/a_5852_170# divbuf_2/OUT3 0.19fF
C6379 divbuf_2/a_55200_n1600# divbuf_2/a_55680_n1600# 0.26fF
C6380 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_9120_n1600# 0.26fF
C6381 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C6382 divbuf_0/a_8670_n1540# divbuf_0/a_9150_n1540# 0.11fF
C6383 divbuf_0/a_39390_n840# divbuf_0/a_39390_n1540# 0.01fF
C6384 divbuf_2/a_47550_n1540# divbuf_2/a_48030_n1540# 0.11fF
C6385 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/OUT2 0.02fF
C6386 pll_full_0/divbuf_0/a_31710_n840# pll_full_0/divbuf_0/a_31710_n1540# 0.01fF
C6387 pll_full_0/divbuf_0/a_990_n1540# pll_full_0/divbuf_0/a_1470_n1540# 0.11fF
C6388 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/a_29262_n240# 0.01fF
C6389 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/a_9242_n240# 0.05fF
C6390 divbuf_4/a_11802_170# divbuf_4/a_12282_170# 0.07fF
C6391 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/a_32652_n240# 0.01fF
C6392 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_13252_n240# 0.05fF
C6393 divbuf_3/a_17760_n1600# divbuf_3/a_18240_n1600# 0.26fF
C6394 divbuf_3/a_8272_n240# divbuf_3/a_8190_n840# 0.03fF
C6395 divbuf_0/a_4392_170# divbuf_0/a_4882_170# 0.07fF
C6396 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/tspc_0/Z2 0.11fF
C6397 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/a_3912_170# 0.07fF
C6398 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21150_n1540# 0.19fF
C6399 pd_div_0/divbuf_0/a_21150_n840# pd_div_0/divbuf_0/a_21630_n840# 0.07fF
C6400 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6401 divbuf_4/a_36052_n240# divbuf_4/a_36030_n840# 0.05fF
C6402 divbuf_4/a_45120_n1600# divbuf_4/a_45600_n1600# 0.26fF
C6403 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C6404 pll_full_0/divbuf_1/a_24510_n840# pll_full_0/divbuf_1/a_24990_n840# 0.07fF
C6405 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24510_n1540# 0.19fF
C6406 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6407 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_14910_n840# 0.01fF
C6408 divbuf_3/a_40830_n840# divbuf_3/a_40830_n1540# 0.01fF
C6409 divbuf_3/a_10110_n1540# divbuf_3/a_10590_n1540# 0.11fF
C6410 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n840# 0.04fF
C6411 divbuf_0/a_1352_170# divbuf_0/OUT2 0.23fF
C6412 divbuf_2/a_6822_n240# divbuf_2/OUT3 0.04fF
C6413 divbuf_2/a_45120_n1600# divbuf_2/a_45150_n840# 0.04fF
C6414 divbuf_4/a_37470_n1540# divbuf_4/a_37950_n1540# 0.11fF
C6415 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C6416 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C6417 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20640_n1600# 0.26fF
C6418 divbuf_1/a_18720_n1600# divbuf_1/a_19200_n1600# 0.26fF
C6419 divbuf_1/a_9242_n240# divbuf_1/a_9150_n840# 0.03fF
C6420 divbuf_5/a_7680_n1600# divbuf_5/a_8160_n1600# 0.26fF
C6421 divbuf_3/a_36052_170# divbuf_3/OUT4 0.19fF
C6422 ro_div_0/divbuf_0/a_12510_n1540# ro_div_0/divbuf_0/a_12990_n1540# 0.11fF
C6423 ro_div_0/divbuf_0/a_43230_n840# ro_div_0/divbuf_0/a_43230_n1540# 0.01fF
C6424 divbuf_1/a_41790_n840# divbuf_1/a_41790_n1540# 0.01fF
C6425 divbuf_1/a_11070_n1540# divbuf_1/a_11550_n1540# 0.11fF
C6426 divbuf_5/a_30750_n840# divbuf_5/a_30750_n1540# 0.01fF
C6427 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_510_n840# 0.00fF
C6428 divbuf_3/a_7680_n1600# divbuf_3/a_7710_n840# 0.04fF
C6429 divbuf_0/a_22952_170# divbuf_0/a_23442_170# 0.07fF
C6430 divbuf_2/a_22952_n240# divbuf_2/a_23442_n240# 0.04fF
C6431 divbuf_4/a_35040_n1600# divbuf_4/a_35070_n840# 0.04fF
C6432 divbuf_4/a_25862_170# divbuf_4/OUT4 0.19fF
C6433 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6434 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/a_8762_n240# 0.01fF
C6435 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C6436 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/a_17122_170# 0.07fF
C6437 divbuf_0/a_56160_n1600# divbuf_0/a_56640_n1600# 0.26fF
C6438 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 gnd 0.27fF
C6439 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C6440 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z2 0.14fF
C6441 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/and_0/B 0.31fF
C6442 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C6443 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C6444 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48960_n1600# 0.26fF
C6445 divbuf_2/a_34560_n1600# divbuf_2/a_34590_n1540# 0.19fF
C6446 divbuf_2/a_34590_n840# divbuf_2/a_35070_n840# 0.07fF
C6447 divbuf_2/a_4350_n840# divbuf_2/a_4350_n1540# 0.01fF
C6448 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/OUT3 0.19fF
C6449 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/a_39390_n840# 0.04fF
C6450 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/a_35562_170# 0.07fF
C6451 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10110_n840# 0.04fF
C6452 divbuf_0/a_48510_n1540# divbuf_0/a_48990_n1540# 0.11fF
C6453 divbuf_1/a_8640_n1600# divbuf_1/a_8670_n840# 0.04fF
C6454 pll_full_0/divbuf_0/a_40830_n1540# pll_full_0/divbuf_0/a_41310_n1540# 0.11fF
C6455 divbuf_3/a_4392_170# divbuf_3/a_4392_n240# 0.01fF
C6456 divbuf_3/a_24412_170# divbuf_3/a_24892_170# 0.07fF
C6457 divbuf_3/a_37022_n240# divbuf_3/OUT4 0.04fF
C6458 ro_div_0/divbuf_0/a_510_n1540# ro_div_0/divbuf_0/OUT 0.11fF
C6459 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_8160_n1600# 0.26fF
C6460 divbuf_4/a_12772_n240# divbuf_4/a_13252_n240# 0.05fF
C6461 divbuf_4/a_32652_170# divbuf_4/a_32652_n240# 0.01fF
C6462 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11520_n1600# 0.26fF
C6463 divbuf_3/a_57600_n1600# divbuf_3/a_58080_n1600# 0.26fF
C6464 pd_div_0/divbuf_0/a_30750_n840# pd_div_0/divbuf_0/a_30750_n1540# 0.01fF
C6465 divbuf_4/a_26832_n240# divbuf_4/OUT4 0.04fF
C6466 divbuf_4/a_24480_n1600# divbuf_4/a_24510_n1540# 0.19fF
C6467 divbuf_4/a_24510_n840# divbuf_4/a_24990_n840# 0.07fF
C6468 pll_full_0/divbuf_1/a_3390_n1540# pll_full_0/divbuf_1/a_3870_n1540# 0.11fF
C6469 pll_full_0/divbuf_1/a_34110_n840# pll_full_0/divbuf_1/a_34110_n1540# 0.01fF
C6470 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6471 divbuf_3/a_49950_n1540# divbuf_3/a_50430_n1540# 0.11fF
C6472 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/a_16642_n240# 0.01fF
C6473 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n840# 0.04fF
C6474 divbuf_0/a_8762_n240# divbuf_0/OUT3 0.04fF
C6475 divbuf_1/a_21982_170# divbuf_1/a_22472_170# 0.07fF
C6476 divbuf_1/a_31682_170# divbuf_1/a_31682_n240# 0.01fF
C6477 divbuf_5/a_14222_170# divbuf_5/a_14702_170# 0.07fF
C6478 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38430_n840# 0.04fF
C6479 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6480 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60480_n1600# 0.26fF
C6481 pd_div_0/div pd_div_0/pd_0/R 0.51fF
C6482 divbuf_1/a_58560_n1600# divbuf_1/a_59040_n1600# 0.26fF
C6483 divbuf_5/a_38472_n240# divbuf_5/a_38430_n840# 0.04fF
C6484 divbuf_5/a_47520_n1600# divbuf_5/a_48000_n1600# 0.26fF
C6485 divbuf_3/a_35040_n1600# divbuf_3/OUT4 0.00fF
C6486 ro_div_0/divbuf_0/a_52350_n1540# ro_div_0/divbuf_0/a_52830_n1540# 0.11fF
C6487 divbuf_4/a_492_n240# divbuf_4/a_510_n840# 0.00fF
C6488 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_990_n840# 0.04fF
C6489 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/a_31682_n240# 0.01fF
C6490 divbuf_1/a_50910_n1540# divbuf_1/a_51390_n1540# 0.11fF
C6491 divbuf_3/a_47520_n1600# divbuf_3/a_47550_n840# 0.04fF
C6492 divbuf_5/a_39870_n1540# divbuf_5/a_40350_n1540# 0.11fF
C6493 divbuf_0/a_23922_n240# divbuf_0/a_24412_n240# 0.04fF
C6494 divbuf_4/a_24960_n1600# divbuf_4/OUT4 0.00fF
C6495 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/a_36052_n240# 0.01fF
C6496 divbuf_2/a_21120_n1600# divbuf_2/a_21600_n1600# 0.26fF
C6497 divbuf_2/a_11802_n240# divbuf_2/a_12030_n840# 0.02fF
C6498 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_16642_n240# 0.04fF
C6499 divbuf_0/a_5310_n840# divbuf_0/a_5310_n1540# 0.01fF
C6500 divbuf_0/a_35550_n840# divbuf_0/a_36030_n840# 0.07fF
C6501 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n1540# 0.19fF
C6502 divbuf_1/a_24412_170# divbuf_1/a_24412_n240# 0.01fF
C6503 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_27870_n1540# 0.19fF
C6504 divbuf_2/a_44190_n840# divbuf_2/a_44190_n1540# 0.01fF
C6505 divbuf_2/a_13470_n1540# divbuf_2/a_13950_n1540# 0.11fF
C6506 pll_full_0/divbuf_0/a_27870_n840# pll_full_0/divbuf_0/a_28350_n840# 0.07fF
C6507 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6508 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C6509 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_49950_n840# 0.04fF
C6510 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/a_12282_170# 0.07fF
C6511 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/a_18092_170# 0.07fF
C6512 divbuf_1/a_13742_n240# divbuf_1/OUT4 0.04fF
C6513 divbuf_1/a_48480_n1600# divbuf_1/a_48510_n840# 0.04fF
C6514 divbuf_3/a_25382_n240# divbuf_3/a_25862_n240# 0.05fF
C6515 divbuf_5/a_30712_170# divbuf_5/OUT4 0.19fF
C6516 divbuf_5/a_37440_n1600# divbuf_5/a_37470_n840# 0.04fF
C6517 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/OUT2 0.19fF
C6518 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/a_38430_n840# 0.04fF
C6519 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_48000_n1600# 0.26fF
C6520 divbuf_4/a_11040_n1600# divbuf_4/a_11520_n1600# 0.26fF
C6521 divbuf_3/a_36990_n840# divbuf_3/a_37470_n840# 0.07fF
C6522 divbuf_3/a_6750_n840# divbuf_3/a_6750_n1540# 0.01fF
C6523 divbuf_3/a_36960_n1600# divbuf_3/a_36990_n1540# 0.19fF
C6524 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_51360_n1600# 0.26fF
C6525 pd_div_0/divbuf_0/a_39870_n1540# pd_div_0/divbuf_0/a_40350_n1540# 0.11fF
C6526 divbuf_2/a_11040_n1600# divbuf_2/a_11070_n840# 0.04fF
C6527 divbuf_4/a_34110_n840# divbuf_4/a_34110_n1540# 0.01fF
C6528 divbuf_4/a_3390_n1540# divbuf_4/a_3870_n1540# 0.11fF
C6529 pll_full_0/divbuf_1/a_43230_n1540# pll_full_0/divbuf_1/a_43710_n1540# 0.11fF
C6530 gnd pll_full_0/divider_0/prescaler_0/nand_1/z1 0.16fF
C6531 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/a_28292_n240# 0.04fF
C6532 divbuf_1/a_26352_n240# divbuf_1/a_26832_n240# 0.05fF
C6533 divbuf_5/a_15182_n240# divbuf_5/a_15672_n240# 0.04fF
C6534 divbuf_5/a_35082_170# divbuf_5/a_35082_n240# 0.01fF
C6535 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C6536 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39390_n1540# 0.19fF
C6537 ro_div_0/divbuf_0/a_9150_n840# ro_div_0/divbuf_0/a_9150_n1540# 0.01fF
C6538 ro_div_0/divbuf_0/a_39390_n840# ro_div_0/divbuf_0/a_39870_n840# 0.07fF
C6539 divbuf_1/a_37950_n840# divbuf_1/a_38430_n840# 0.07fF
C6540 divbuf_1/a_7710_n840# divbuf_1/a_7710_n1540# 0.01fF
C6541 divbuf_1/a_12000_n1600# divbuf_1/OUT4 0.00fF
C6542 divbuf_1/a_37920_n1600# divbuf_1/a_37950_n1540# 0.19fF
C6543 divbuf_5/a_26910_n840# divbuf_5/a_27390_n840# 0.07fF
C6544 divbuf_5/a_31682_n240# divbuf_5/OUT4 0.04fF
C6545 divbuf_5/a_26880_n1600# divbuf_5/a_26910_n1540# 0.19fF
C6546 divbuf_3/a_59070_n840# divbuf_3/a_59070_n1540# 0.01fF
C6547 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C6548 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/tspc_0/Z2 1.07fF
C6549 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 ro_div_0/divider_0/clk 0.12fF
C6550 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6551 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37470_n840# 0.04fF
C6552 divbuf_2/a_27802_170# divbuf_2/a_28292_170# 0.07fF
C6553 divbuf_2/a_7792_170# divbuf_2/a_7792_n240# 0.01fF
C6554 divbuf_4/a_960_n1600# divbuf_4/a_990_n840# 0.04fF
C6555 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6556 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_40830_n840# 0.04fF
C6557 divbuf_0/a_22080_n1600# divbuf_0/a_22560_n1600# 0.26fF
C6558 divbuf_0/a_12772_n240# divbuf_0/a_12990_n840# 0.02fF
C6559 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14880_n1600# 0.26fF
C6560 divbuf_2/a_480_n1600# divbuf_2/a_510_n1540# 0.19fF
C6561 divbuf_2/a_510_n840# divbuf_2/a_990_n840# 0.07fF
C6562 divbuf_2/a_17612_170# divbuf_2/OUT4 0.19fF
C6563 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/a_4830_n840# 0.04fF
C6564 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/a_13742_170# 0.07fF
C6565 divbuf_0/a_14430_n1540# divbuf_0/a_14910_n1540# 0.11fF
C6566 divbuf_0/a_45150_n840# divbuf_0/a_45150_n1540# 0.01fF
C6567 divbuf_2/a_53310_n1540# divbuf_2/a_53790_n1540# 0.11fF
C6568 pll_full_0/divbuf_0/a_6750_n1540# pll_full_0/divbuf_0/a_7230_n1540# 0.11fF
C6569 pll_full_0/divbuf_0/a_37470_n840# pll_full_0/divbuf_0/a_37470_n1540# 0.01fF
C6570 divbuf_3/a_7302_170# divbuf_3/OUT3 0.19fF
C6571 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_15672_n240# 0.04fF
C6572 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/a_35082_n240# 0.01fF
C6573 divbuf_3/a_14222_n240# divbuf_3/a_14430_n840# 0.02fF
C6574 divbuf_3/a_23520_n1600# divbuf_3/a_24000_n1600# 0.26fF
C6575 divbuf_4/a_17612_170# divbuf_4/a_18092_170# 0.07fF
C6576 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/a_19072_n240# 0.04fF
C6577 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/a_38472_n240# 0.01fF
C6578 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C6579 pd_div_0/divbuf_0/a_26910_n840# pd_div_0/divbuf_0/a_27390_n840# 0.07fF
C6580 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6581 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_26910_n1540# 0.19fF
C6582 divbuf_4/a_50880_n1600# divbuf_4/a_51360_n1600# 0.26fF
C6583 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6584 pll_full_0/divbuf_1/a_30270_n840# pll_full_0/divbuf_1/a_30750_n840# 0.07fF
C6585 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30270_n1540# 0.19fF
C6586 divbuf_3/a_46590_n840# divbuf_3/a_46590_n1540# 0.01fF
C6587 divbuf_3/a_15870_n1540# divbuf_3/a_16350_n1540# 0.11fF
C6588 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n840# 0.04fF
C6589 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_4882_170# 0.07fF
C6590 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_0/a_630_n680# 0.04fF
C6591 divbuf_2/a_50880_n1600# divbuf_2/a_50910_n840# 0.04fF
C6592 divbuf_2/a_18582_n240# divbuf_2/OUT4 0.04fF
C6593 divbuf_4/a_43230_n1540# divbuf_4/a_43710_n1540# 0.11fF
C6594 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C6595 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4350_n840# 0.04fF
C6596 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/a_3422_n240# 0.01fF
C6597 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_26400_n1600# 0.26fF
C6598 divbuf_1/a_15182_n240# divbuf_1/a_15390_n840# 0.02fF
C6599 divbuf_1/a_24480_n1600# divbuf_1/a_24960_n1600# 0.26fF
C6600 divbuf_5/a_3912_n240# divbuf_5/a_3870_n840# 0.04fF
C6601 divbuf_5/a_13440_n1600# divbuf_5/a_13920_n1600# 0.26fF
C6602 divbuf_3/a_8272_n240# divbuf_3/OUT3 0.04fF
C6603 ro_div_0/divbuf_0/a_18270_n1540# ro_div_0/divbuf_0/a_18750_n1540# 0.11fF
C6604 ro_div_0/divbuf_0/a_48990_n840# ro_div_0/divbuf_0/a_48990_n1540# 0.01fF
C6605 divbuf_1/a_47550_n840# divbuf_1/a_47550_n1540# 0.01fF
C6606 divbuf_1/a_16830_n1540# divbuf_1/a_17310_n1540# 0.11fF
C6607 divbuf_5/a_36510_n840# divbuf_5/a_36510_n1540# 0.01fF
C6608 divbuf_5/a_5790_n1540# divbuf_5/a_6270_n1540# 0.11fF
C6609 divbuf_3/a_13440_n1600# divbuf_3/a_13470_n840# 0.04fF
C6610 divbuf_0/a_28772_170# divbuf_0/a_29262_170# 0.07fF
C6611 divbuf_2/a_28772_n240# divbuf_2/a_29262_n240# 0.04fF
C6612 divbuf_4/a_40800_n1600# divbuf_4/a_40830_n840# 0.04fF
C6613 divbuf_4/a_37502_170# divbuf_4/OUT4 0.19fF
C6614 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6615 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/OUT3 0.19fF
C6616 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/a_21502_170# 0.07fF
C6617 divbuf_0/a_1470_n840# divbuf_0/a_1950_n840# 0.07fF
C6618 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n1540# 0.19fF
C6619 gnd pd_div_0/divider_0/nor_0/B 1.23fF
C6620 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/clk 0.04fF
C6621 divbuf_2/a_40350_n840# divbuf_2/a_40830_n840# 0.07fF
C6622 divbuf_2/a_10110_n840# divbuf_2/a_10110_n1540# 0.01fF
C6623 divbuf_2/a_40320_n1600# divbuf_2/a_40350_n1540# 0.19fF
C6624 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C6625 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54720_n1600# 0.26fF
C6626 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/a_41382_170# 0.07fF
C6627 divbuf_0/a_54270_n1540# divbuf_0/a_54750_n1540# 0.11fF
C6628 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_15870_n840# 0.04fF
C6629 divbuf_1/a_14400_n1600# divbuf_1/a_14430_n840# 0.04fF
C6630 divbuf_5/a_3360_n1600# divbuf_5/a_3390_n840# 0.04fF
C6631 divbuf_3/a_30232_170# divbuf_3/a_30712_170# 0.07fF
C6632 divbuf_3/a_10212_170# divbuf_3/a_10212_n240# 0.01fF
C6633 pll_full_0/divbuf_0/a_46590_n1540# pll_full_0/divbuf_0/a_47070_n1540# 0.11fF
C6634 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/a_3870_n840# 0.04fF
C6635 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13920_n1600# 0.26fF
C6636 divbuf_4/a_38472_170# divbuf_4/a_38472_n240# 0.01fF
C6637 divbuf_4/a_18582_n240# divbuf_4/a_19072_n240# 0.04fF
C6638 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/a_7230_n840# 0.03fF
C6639 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_17280_n1600# 0.26fF
C6640 divbuf_3/a_2880_n1600# divbuf_3/a_2910_n1540# 0.19fF
C6641 divbuf_3/a_2910_n840# divbuf_3/a_3390_n840# 0.07fF
C6642 pd_div_0/divbuf_0/a_36510_n840# pd_div_0/divbuf_0/a_36510_n1540# 0.01fF
C6643 pd_div_0/divbuf_0/a_5790_n1540# pd_div_0/divbuf_0/a_6270_n1540# 0.11fF
C6644 divbuf_4/a_30240_n1600# divbuf_4/a_30270_n1540# 0.19fF
C6645 divbuf_4/a_30270_n840# divbuf_4/a_30750_n840# 0.07fF
C6646 divbuf_4/a_38472_n240# divbuf_4/OUT4 0.04fF
C6647 pll_full_0/divbuf_1/a_9150_n1540# pll_full_0/divbuf_1/a_9630_n1540# 0.11fF
C6648 pll_full_0/divbuf_1/a_39870_n840# pll_full_0/divbuf_1/a_39870_n1540# 0.01fF
C6649 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6650 divbuf_0/a_20532_n240# divbuf_0/OUT4 0.04fF
C6651 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n840# 0.04fF
C6652 divbuf_1/a_27802_170# divbuf_1/a_28292_170# 0.07fF
C6653 divbuf_1/a_3422_170# divbuf_1/a_3422_n240# 0.01fF
C6654 divbuf_5/a_20042_170# divbuf_5/a_20532_170# 0.07fF
C6655 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44190_n840# 0.04fF
C6656 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C6657 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5310_n1540# 0.19fF
C6658 ro_div_0/divbuf_0/a_5310_n840# ro_div_0/divbuf_0/a_5790_n840# 0.07fF
C6659 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Qbar1 0.12fF
C6660 divbuf_1/a_3870_n840# divbuf_1/a_4350_n840# 0.07fF
C6661 divbuf_1/a_21012_170# divbuf_1/OUT4 0.19fF
C6662 divbuf_1/a_3840_n1600# divbuf_1/a_3870_n1540# 0.19fF
C6663 divbuf_5/a_1842_170# divbuf_5/OUT2 0.19fF
C6664 divbuf_5/a_53280_n1600# divbuf_5/a_53760_n1600# 0.26fF
C6665 divbuf_3/a_55200_n1600# divbuf_3/a_55230_n1540# 0.19fF
C6666 ro_div_0/divbuf_0/a_58110_n1540# ro_div_0/divbuf_0/a_58590_n1540# 0.11fF
C6667 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3390_n840# 0.04fF
C6668 divbuf_1/a_56670_n1540# divbuf_1/a_57150_n1540# 0.11fF
C6669 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_6750_n840# 0.04fF
C6670 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/a_37502_n240# 0.01fF
C6671 divbuf_3/a_53280_n1600# divbuf_3/a_53310_n840# 0.04fF
C6672 divbuf_5/a_45630_n1540# divbuf_5/a_46110_n1540# 0.11fF
C6673 divbuf_0/a_29742_n240# divbuf_0/a_30232_n240# 0.04fF
C6674 divbuf_4/a_36480_n1600# divbuf_4/OUT4 0.00fF
C6675 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/a_22472_n240# 0.04fF
C6676 divbuf_2/a_26880_n1600# divbuf_2/a_27360_n1600# 0.26fF
C6677 divbuf_2/a_17612_n240# divbuf_2/a_17790_n840# 0.02fF
C6678 divbuf_0/a_11070_n840# divbuf_0/a_11070_n1540# 0.01fF
C6679 divbuf_0/a_41310_n840# divbuf_0/a_41790_n840# 0.07fF
C6680 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n1540# 0.19fF
C6681 divbuf_1/a_30232_170# divbuf_1/a_30232_n240# 0.01fF
C6682 pll_full_0/divbuf_0/a_3390_n840# pll_full_0/divbuf_0/a_3390_n1540# 0.01fF
C6683 pll_full_0/divbuf_0/a_33630_n840# pll_full_0/divbuf_0/a_34110_n840# 0.07fF
C6684 divbuf_2/a_49950_n840# divbuf_2/a_49950_n1540# 0.01fF
C6685 divbuf_2/a_19230_n1540# divbuf_2/a_19710_n1540# 0.11fF
C6686 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_33630_n1540# 0.19fF
C6687 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_55710_n840# 0.04fF
C6688 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6689 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/a_20532_170# 0.07fF
C6690 divbuf_1/a_54240_n1600# divbuf_1/a_54270_n840# 0.04fF
C6691 divbuf_1/a_25382_n240# divbuf_1/OUT4 0.04fF
C6692 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/a_23922_170# 0.07fF
C6693 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/a_3422_n240# 0.01fF
C6694 divbuf_3/a_31202_n240# divbuf_3/a_31682_n240# 0.05fF
C6695 divbuf_5/a_2322_n240# divbuf_5/OUT3 0.04fF
C6696 divbuf_5/a_43200_n1600# divbuf_5/a_43230_n840# 0.04fF
C6697 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53760_n1600# 0.26fF
C6698 divbuf_4/a_16800_n1600# divbuf_4/a_17280_n1600# 0.26fF
C6699 divbuf_4/a_7302_n240# divbuf_4/a_7230_n840# 0.03fF
C6700 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_57120_n1600# 0.26fF
C6701 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/OUT3 0.19fF
C6702 divbuf_3/a_42720_n1600# divbuf_3/a_42750_n1540# 0.19fF
C6703 divbuf_3/a_42750_n840# divbuf_3/a_43230_n840# 0.07fF
C6704 divbuf_3/a_12510_n840# divbuf_3/a_12510_n1540# 0.01fF
C6705 pd_div_0/divbuf_0/a_45630_n1540# pd_div_0/divbuf_0/a_46110_n1540# 0.11fF
C6706 divbuf_4/a_39870_n840# divbuf_4/a_39870_n1540# 0.01fF
C6707 divbuf_4/a_9150_n1540# divbuf_4/a_9630_n1540# 0.11fF
C6708 divbuf_2/a_16800_n1600# divbuf_2/a_16830_n840# 0.04fF
C6709 pll_full_0/divbuf_1/a_48990_n1540# pll_full_0/divbuf_1/a_49470_n1540# 0.11fF
C6710 gnd pll_full_0/divider_0/and_0/Z1 0.32fF
C6711 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/a_34112_n240# 0.04fF
C6712 divbuf_1/a_32172_n240# divbuf_1/a_32652_n240# 0.05fF
C6713 divbuf_5/a_40902_170# divbuf_5/a_40902_n240# 0.01fF
C6714 divbuf_5/a_21012_n240# divbuf_5/a_21502_n240# 0.04fF
C6715 ro_div_0/divbuf_0/a_14910_n840# ro_div_0/divbuf_0/a_14910_n1540# 0.01fF
C6716 ro_div_0/divbuf_0/a_45150_n840# ro_div_0/divbuf_0/a_45630_n840# 0.07fF
C6717 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45150_n1540# 0.19fF
C6718 divbuf_1/a_43680_n1600# divbuf_1/a_43710_n1540# 0.19fF
C6719 divbuf_1/a_43710_n840# divbuf_1/a_44190_n840# 0.07fF
C6720 divbuf_1/a_13470_n840# divbuf_1/a_13470_n1540# 0.01fF
C6721 divbuf_1/a_23520_n1600# divbuf_1/OUT4 0.00fF
C6722 divbuf_5/a_2400_n1600# divbuf_5/OUT2 0.00fF
C6723 divbuf_5/a_32640_n1600# divbuf_5/a_32670_n1540# 0.19fF
C6724 divbuf_5/a_32670_n840# divbuf_5/a_33150_n840# 0.07fF
C6725 divbuf_5/a_2430_n840# divbuf_5/a_2430_n1540# 0.01fF
C6726 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/prescaler_0/Out 0.15fF
C6727 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/clk 0.64fF
C6728 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C6729 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43230_n840# 0.04fF
C6730 divbuf_4/a_6720_n1600# divbuf_4/a_6750_n840# 0.04fF
C6731 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/a_6270_n840# 0.04fF
C6732 divbuf_2/a_14222_170# divbuf_2/a_14222_n240# 0.01fF
C6733 divbuf_2/a_33622_170# divbuf_2/a_34112_170# 0.07fF
C6734 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_46590_n840# 0.04fF
C6735 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C6736 divbuf_0/a_18582_n240# divbuf_0/a_18750_n840# 0.02fF
C6737 divbuf_0/a_27840_n1600# divbuf_0/a_28320_n1600# 0.26fF
C6738 divbuf_2/a_6270_n840# divbuf_2/a_6750_n840# 0.07fF
C6739 divbuf_2/a_6240_n1600# divbuf_2/a_6270_n1540# 0.19fF
C6740 divbuf_2/a_29262_170# divbuf_2/OUT4 0.19fF
C6741 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20640_n1600# 0.26fF
C6742 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C6743 divbuf_0/a_20190_n1540# divbuf_0/a_20670_n1540# 0.11fF
C6744 divbuf_0/a_50910_n840# divbuf_0/a_50910_n1540# 0.01fF
C6745 divbuf_2/a_59070_n1540# divbuf_2/a_59550_n1540# 0.11fF
C6746 pll_full_0/divbuf_0/a_43230_n840# pll_full_0/divbuf_0/a_43230_n1540# 0.01fF
C6747 pll_full_0/divbuf_0/a_12510_n1540# pll_full_0/divbuf_0/a_12990_n1540# 0.11fF
C6748 divbuf_3/a_19072_170# divbuf_3/OUT4 0.19fF
C6749 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/a_40902_n240# 0.01fF
C6750 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/a_21502_n240# 0.04fF
C6751 divbuf_4/a_3422_170# divbuf_4/a_3422_n240# 0.01fF
C6752 divbuf_4/a_23442_170# divbuf_4/a_23922_170# 0.07fF
C6753 divbuf_3/a_29280_n1600# divbuf_3/a_29760_n1600# 0.26fF
C6754 divbuf_3/a_20042_n240# divbuf_3/a_20190_n840# 0.03fF
C6755 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/a_24892_n240# 0.05fF
C6756 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C6757 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_32670_n1540# 0.19fF
C6758 pd_div_0/divbuf_0/a_32670_n840# pd_div_0/divbuf_0/a_33150_n840# 0.07fF
C6759 pd_div_0/divbuf_0/a_2430_n840# pd_div_0/divbuf_0/a_2430_n1540# 0.01fF
C6760 divbuf_3/a_21630_n1540# divbuf_3/a_22110_n1540# 0.11fF
C6761 divbuf_4/a_8762_170# divbuf_4/OUT3 0.19fF
C6762 divbuf_4/a_56640_n1600# divbuf_4/a_57120_n1600# 0.26fF
C6763 pll_full_0/divbuf_1/a_5790_n840# pll_full_0/divbuf_1/a_5790_n1540# 0.01fF
C6764 pll_full_0/divbuf_1/a_36030_n840# pll_full_0/divbuf_1/a_36510_n840# 0.07fF
C6765 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36030_n1540# 0.19fF
C6766 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C6767 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/a_6332_170# 0.07fF
C6768 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n840# 0.04fF
C6769 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C6770 pd_div_0/divider_0/tspc_0/Q gnd 0.33fF
C6771 pd_div_0/divider_0/tspc_1/Z3 pd_div_0/divider_0/tspc_1/Q 0.05fF
C6772 divbuf_2/a_30232_n240# divbuf_2/OUT4 0.04fF
C6773 divbuf_2/a_56640_n1600# divbuf_2/a_56670_n840# 0.04fF
C6774 divbuf_4/a_48990_n1540# divbuf_4/a_49470_n1540# 0.11fF
C6775 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10110_n840# 0.04fF
C6776 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C6777 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C6778 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/a_22590_n840# 0.03fF
C6779 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_32160_n1600# 0.26fF
C6780 divbuf_1/a_30240_n1600# divbuf_1/a_30720_n1600# 0.26fF
C6781 divbuf_1/a_21012_n240# divbuf_1/a_21150_n840# 0.03fF
C6782 divbuf_5/a_19200_n1600# divbuf_5/a_19680_n1600# 0.26fF
C6783 divbuf_5/a_9732_n240# divbuf_5/a_9630_n840# 0.03fF
C6784 divbuf_3/a_20042_n240# divbuf_3/OUT4 0.04fF
C6785 ro_div_0/divbuf_0/a_24030_n1540# ro_div_0/divbuf_0/a_24510_n1540# 0.11fF
C6786 ro_div_0/divbuf_0/a_54750_n840# ro_div_0/divbuf_0/a_54750_n1540# 0.01fF
C6787 divbuf_1/a_53310_n840# divbuf_1/a_53310_n1540# 0.01fF
C6788 divbuf_1/a_22590_n1540# divbuf_1/a_23070_n1540# 0.11fF
C6789 divbuf_3/a_19200_n1600# divbuf_3/a_19230_n840# 0.04fF
C6790 divbuf_5/a_42270_n840# divbuf_5/a_42270_n1540# 0.01fF
C6791 divbuf_5/a_11550_n1540# divbuf_5/a_12030_n1540# 0.11fF
C6792 divbuf_0/a_34592_170# divbuf_0/a_35082_170# 0.07fF
C6793 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/a_13742_n240# 0.01fF
C6794 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/a_27322_170# 0.07fF
C6795 divbuf_2/a_34592_n240# divbuf_2/a_35082_n240# 0.04fF
C6796 divbuf_4/a_9732_n240# divbuf_4/OUT3 0.04fF
C6797 divbuf_4/a_46560_n1600# divbuf_4/a_46590_n840# 0.04fF
C6798 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/a_6332_n240# 0.01fF
C6799 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/a_11802_170# 0.07fF
C6800 divbuf_0/a_7230_n840# divbuf_0/a_7710_n840# 0.07fF
C6801 divbuf_0/a_31202_170# divbuf_0/OUT4 0.19fF
C6802 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n1540# 0.19fF
C6803 divbuf_1/a_17612_170# divbuf_1/a_17612_n240# 0.01fF
C6804 divbuf_2/a_46080_n1600# divbuf_2/a_46110_n1540# 0.19fF
C6805 divbuf_2/a_46110_n840# divbuf_2/a_46590_n840# 0.07fF
C6806 divbuf_2/a_15870_n840# divbuf_2/a_15870_n1540# 0.01fF
C6807 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60480_n1600# 0.26fF
C6808 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6809 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/a_7302_n240# 0.05fF
C6810 divbuf_0/a_60030_n1540# divbuf_0/a_60510_n1540# 0.11fF
C6811 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_21630_n840# 0.04fF
C6812 divbuf_1/a_20160_n1600# divbuf_1/a_20190_n840# 0.04fF
C6813 divbuf_3/a_16642_170# divbuf_3/a_16642_n240# 0.01fF
C6814 divbuf_3/a_36052_170# divbuf_3/a_36532_170# 0.07fF
C6815 divbuf_5/a_9120_n1600# divbuf_5/a_9150_n840# 0.04fF
C6816 pll_full_0/divbuf_0/a_52350_n1540# pll_full_0/divbuf_0/a_52830_n1540# 0.11fF
C6817 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19680_n1600# 0.26fF
C6818 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/a_9630_n840# 0.03fF
C6819 divbuf_4/a_24412_n240# divbuf_4/a_24892_n240# 0.05fF
C6820 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_23040_n1600# 0.26fF
C6821 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_13470_n840# 0.02fF
C6822 divbuf_3/a_8640_n1600# divbuf_3/a_8670_n1540# 0.19fF
C6823 divbuf_3/a_8670_n840# divbuf_3/a_9150_n840# 0.07fF
C6824 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6825 pd_div_0/divbuf_0/a_42270_n840# pd_div_0/divbuf_0/a_42270_n1540# 0.01fF
C6826 pd_div_0/divbuf_0/a_11550_n1540# pd_div_0/divbuf_0/a_12030_n1540# 0.11fF
C6827 divbuf_4/a_8640_n1600# divbuf_4/OUT3 0.00fF
C6828 divbuf_4/a_36000_n1600# divbuf_4/a_36030_n1540# 0.19fF
C6829 divbuf_4/a_36030_n840# divbuf_4/a_36510_n840# 0.07fF
C6830 divbuf_4/a_5790_n840# divbuf_4/a_5790_n1540# 0.01fF
C6831 pll_full_0/divbuf_1/a_14910_n1540# pll_full_0/divbuf_1/a_15390_n1540# 0.11fF
C6832 pll_full_0/divbuf_1/a_45630_n840# pll_full_0/divbuf_1/a_45630_n1540# 0.01fF
C6833 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C6834 ro_div_0/ro_complete_0/a1 ro_div_0/divider_0/clk 0.05fF
C6835 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n840# 0.04fF
C6836 divbuf_0/a_32172_n240# divbuf_0/OUT4 0.04fF
C6837 divbuf_1/a_37022_170# divbuf_1/a_37502_170# 0.07fF
C6838 divbuf_5/a_5852_170# divbuf_5/a_5852_n240# 0.01fF
C6839 divbuf_5/a_25862_170# divbuf_5/a_26352_170# 0.07fF
C6840 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_480_n1600# 0.00fF
C6841 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6842 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_49950_n840# 0.04fF
C6843 ro_div_0/divbuf_0/a_11070_n840# ro_div_0/divbuf_0/a_11550_n840# 0.07fF
C6844 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11070_n1540# 0.19fF
C6845 ro_div_0/divider_0/tspc_1/Z4 gnd 0.44fF
C6846 divbuf_1/a_9600_n1600# divbuf_1/a_9630_n1540# 0.19fF
C6847 divbuf_1/a_36052_170# divbuf_1/OUT4 0.19fF
C6848 divbuf_1/a_9630_n840# divbuf_1/a_10110_n840# 0.07fF
C6849 divbuf_5/a_13742_170# divbuf_5/OUT4 0.19fF
C6850 divbuf_5/a_59040_n1600# divbuf_5/a_59520_n1600# 0.26fF
C6851 ro_div_0/divbuf_0/OUT4 ro_div_0/divbuf_0/OUT5 0.26fF
C6852 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9150_n840# 0.04fF
C6853 divbuf_1/a_60990_n1540# divbuf_1/OUT5 0.19fF
C6854 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12510_n840# 0.04fF
C6855 divbuf_3/a_59040_n1600# divbuf_3/a_59070_n840# 0.04fF
C6856 divbuf_5/a_51390_n1540# divbuf_5/a_51870_n1540# 0.11fF
C6857 divbuf_0/a_35562_n240# divbuf_0/a_36052_n240# 0.04fF
C6858 divbuf_2/a_32640_n1600# divbuf_2/a_33120_n1600# 0.26fF
C6859 divbuf_2/a_23442_n240# divbuf_2/a_23550_n840# 0.03fF
C6860 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/a_28292_n240# 0.04fF
C6861 divbuf_0/a_16830_n840# divbuf_0/a_16830_n1540# 0.01fF
C6862 divbuf_0/a_47070_n840# divbuf_0/a_47550_n840# 0.07fF
C6863 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n1540# 0.19fF
C6864 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39390_n1540# 0.19fF
C6865 divbuf_2/a_55710_n840# divbuf_2/a_55710_n1540# 0.01fF
C6866 divbuf_2/a_24990_n1540# divbuf_2/a_25470_n1540# 0.11fF
C6867 pll_full_0/divbuf_0/a_39390_n840# pll_full_0/divbuf_0/a_39870_n840# 0.07fF
C6868 pll_full_0/divbuf_0/a_9150_n840# pll_full_0/divbuf_0/a_9150_n1540# 0.01fF
C6869 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6870 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/a_26352_170# 0.07fF
C6871 divbuf_1/a_37022_n240# divbuf_1/OUT4 0.04fF
C6872 divbuf_1/a_60000_n1600# divbuf_1/a_60030_n840# 0.04fF
C6873 divbuf_3/a_52350_n1540# divbuf_3/a_52830_n1540# 0.11fF
C6874 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/a_9242_n240# 0.01fF
C6875 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/a_29742_170# 0.07fF
C6876 divbuf_3/a_37022_n240# divbuf_3/a_37502_n240# 0.05fF
C6877 divbuf_5/a_48960_n1600# divbuf_5/a_48990_n840# 0.04fF
C6878 divbuf_5/a_14702_n240# divbuf_5/OUT4 0.04fF
C6879 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C6880 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/nor_1/A 0.03fF
C6881 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C6882 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/OUT4 0.23fF
C6883 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59520_n1600# 0.26fF
C6884 divbuf_4/a_13252_n240# divbuf_4/a_13470_n840# 0.02fF
C6885 divbuf_4/a_22560_n1600# divbuf_4/a_23040_n1600# 0.26fF
C6886 pll_full_0/divbuf_1/a_1950_n840# pll_full_0/divbuf_1/a_2430_n840# 0.07fF
C6887 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6888 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_1950_n1540# 0.19fF
C6889 divbuf_3/a_48510_n840# divbuf_3/a_48990_n840# 0.07fF
C6890 divbuf_3/a_18270_n840# divbuf_3/a_18270_n1540# 0.01fF
C6891 divbuf_3/a_48480_n1600# divbuf_3/a_48510_n1540# 0.19fF
C6892 pd_div_0/divbuf_0/a_51390_n1540# pd_div_0/divbuf_0/a_51870_n1540# 0.11fF
C6893 divbuf_4/a_45630_n840# divbuf_4/a_45630_n1540# 0.01fF
C6894 divbuf_4/a_14910_n1540# divbuf_4/a_15390_n1540# 0.11fF
C6895 pll_full_0/divbuf_1/a_54750_n1540# pll_full_0/divbuf_1/a_55230_n1540# 0.11fF
C6896 divbuf_2/a_22560_n1600# divbuf_2/a_22590_n840# 0.04fF
C6897 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/a_39932_n240# 0.04fF
C6898 divbuf_1/a_37992_n240# divbuf_1/a_38472_n240# 0.05fF
C6899 divbuf_5/a_26832_n240# divbuf_5/a_27322_n240# 0.04fF
C6900 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_50910_n1540# 0.19fF
C6901 ro_div_0/divbuf_0/a_20670_n840# ro_div_0/divbuf_0/a_20670_n1540# 0.01fF
C6902 ro_div_0/divbuf_0/a_50910_n840# ro_div_0/divbuf_0/a_51390_n840# 0.07fF
C6903 divbuf_1/a_49470_n840# divbuf_1/a_49950_n840# 0.07fF
C6904 divbuf_1/a_19230_n840# divbuf_1/a_19230_n1540# 0.01fF
C6905 divbuf_1/a_35040_n1600# divbuf_1/OUT4 0.00fF
C6906 divbuf_1/a_49440_n1600# divbuf_1/a_49470_n1540# 0.19fF
C6907 divbuf_5/a_38430_n840# divbuf_5/a_38910_n840# 0.07fF
C6908 divbuf_5/a_8190_n840# divbuf_5/a_8190_n1540# 0.01fF
C6909 divbuf_5/a_12960_n1600# divbuf_5/OUT4 0.00fF
C6910 divbuf_5/a_38400_n1600# divbuf_5/a_38430_n1540# 0.19fF
C6911 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_48990_n840# 0.04fF
C6912 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6913 divbuf_4/a_12480_n1600# divbuf_4/a_12510_n840# 0.04fF
C6914 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6915 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52350_n840# 0.04fF
C6916 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12510_n840# 0.02fF
C6917 divbuf_2/a_39442_170# divbuf_2/a_39932_170# 0.07fF
C6918 divbuf_2/a_20042_170# divbuf_2/a_20042_n240# 0.01fF
C6919 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/a_5852_170# 0.07fF
C6920 divbuf_0/a_33600_n1600# divbuf_0/a_34080_n1600# 0.26fF
C6921 divbuf_0/a_24412_n240# divbuf_0/a_24510_n840# 0.03fF
C6922 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_26400_n1600# 0.26fF
C6923 divbuf_2/a_12000_n1600# divbuf_2/a_12030_n1540# 0.19fF
C6924 divbuf_2/a_40902_170# divbuf_2/OUT4 0.19fF
C6925 divbuf_2/a_12030_n840# divbuf_2/a_12510_n840# 0.07fF
C6926 divbuf_2/a_1352_n240# divbuf_2/OUT2 0.07fF
C6927 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_16830_n840# 0.02fF
C6928 divbuf_0/a_25950_n1540# divbuf_0/a_26430_n1540# 0.11fF
C6929 divbuf_0/a_56670_n840# divbuf_0/a_56670_n1540# 0.01fF
C6930 pll_full_0/divbuf_0/a_18270_n1540# pll_full_0/divbuf_0/a_18750_n1540# 0.11fF
C6931 pll_full_0/divbuf_0/a_48990_n840# pll_full_0/divbuf_0/a_48990_n1540# 0.01fF
C6932 divbuf_3/a_30712_170# divbuf_3/OUT4 0.19fF
C6933 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/a_27322_n240# 0.04fF
C6934 divbuf_4/a_29262_170# divbuf_4/a_29742_170# 0.07fF
C6935 divbuf_4/a_9242_170# divbuf_4/a_9242_n240# 0.01fF
C6936 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/a_30712_n240# 0.05fF
C6937 divbuf_3/a_25862_n240# divbuf_3/a_25950_n840# 0.03fF
C6938 divbuf_3/a_35040_n1600# divbuf_3/a_35520_n1600# 0.26fF
C6939 pd_div_0/divbuf_0/a_38430_n840# pd_div_0/divbuf_0/a_38910_n840# 0.07fF
C6940 pd_div_0/divbuf_0/a_8190_n840# pd_div_0/divbuf_0/a_8190_n1540# 0.01fF
C6941 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6942 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38430_n1540# 0.19fF
C6943 divbuf_4/a_1920_n1600# divbuf_4/a_1950_n1540# 0.19fF
C6944 divbuf_4/a_20532_170# divbuf_4/OUT4 0.19fF
C6945 divbuf_4/a_1950_n840# divbuf_4/a_2430_n840# 0.07fF
C6946 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/a_1842_170# 0.07fF
C6947 divbuf_3/a_27390_n1540# divbuf_3/a_27870_n1540# 0.11fF
C6948 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C6949 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6950 pll_full_0/divbuf_1/a_11550_n840# pll_full_0/divbuf_1/a_11550_n1540# 0.01fF
C6951 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/a_42270_n840# 0.07fF
C6952 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_41790_n1540# 0.19fF
C6953 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n840# 0.04fF
C6954 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.44fF
C6955 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_2/Z4 0.02fF
C6956 divbuf_2/a_960_n1600# divbuf_2/OUT2 0.00fF
C6957 divbuf_2/a_41382_n240# divbuf_2/OUT5 0.04fF
C6958 divbuf_4/a_54750_n1540# divbuf_4/a_55230_n1540# 0.11fF
C6959 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_15870_n840# 0.04fF
C6960 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z4 0.15fF
C6961 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/Out 0.11fF
C6962 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C6963 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37920_n1600# 0.26fF
C6964 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/a_28350_n840# 0.04fF
C6965 divbuf_1/a_26832_n240# divbuf_1/a_26910_n840# 0.04fF
C6966 divbuf_1/a_36000_n1600# divbuf_1/a_36480_n1600# 0.26fF
C6967 divbuf_5/a_15672_n240# divbuf_5/a_15870_n840# 0.02fF
C6968 divbuf_5/a_24960_n1600# divbuf_5/a_25440_n1600# 0.26fF
C6969 divbuf_3/a_31682_n240# divbuf_3/OUT4 0.04fF
C6970 ro_div_0/divbuf_0/a_29790_n1540# ro_div_0/divbuf_0/a_30270_n1540# 0.11fF
C6971 ro_div_0/divbuf_0/a_60510_n840# ro_div_0/divbuf_0/a_60510_n1540# 0.01fF
C6972 divbuf_1/a_59070_n840# divbuf_1/a_59070_n1540# 0.01fF
C6973 divbuf_1/a_28350_n1540# divbuf_1/a_28830_n1540# 0.11fF
C6974 divbuf_3/a_24960_n1600# divbuf_3/a_24990_n840# 0.04fF
C6975 divbuf_5/a_48030_n840# divbuf_5/a_48030_n1540# 0.01fF
C6976 divbuf_5/a_17310_n1540# divbuf_5/a_17790_n1540# 0.11fF
C6977 divbuf_0/a_21012_170# divbuf_0/a_21012_n240# 0.01fF
C6978 divbuf_0/a_40412_170# divbuf_0/a_40902_170# 0.07fF
C6979 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C6980 divbuf_2/a_40412_n240# divbuf_2/a_40902_n240# 0.04fF
C6981 divbuf_4/a_52320_n1600# divbuf_4/a_52350_n840# 0.04fF
C6982 divbuf_4/a_21502_n240# divbuf_4/OUT4 0.04fF
C6983 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/a_33142_170# 0.07fF
C6984 divbuf_0/a_12990_n840# divbuf_0/a_13470_n840# 0.07fF
C6985 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n1540# 0.19fF
C6986 divbuf_0/a_3422_n240# divbuf_0/OUT3 0.07fF
C6987 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6988 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5310_n1540# 0.19fF
C6989 divbuf_2/a_51870_n840# divbuf_2/a_52350_n840# 0.07fF
C6990 divbuf_2/a_21630_n840# divbuf_2/a_21630_n1540# 0.01fF
C6991 divbuf_2/a_51840_n1600# divbuf_2/a_51870_n1540# 0.19fF
C6992 pll_full_0/divbuf_0/a_5310_n840# pll_full_0/divbuf_0/a_5790_n840# 0.07fF
C6993 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_13742_n240# 0.04fF
C6994 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27390_n840# 0.04fF
C6995 divbuf_1/a_6822_170# divbuf_1/OUT3 0.19fF
C6996 divbuf_1/a_25920_n1600# divbuf_1/a_25950_n840# 0.04fF
C6997 divbuf_3/a_492_n240# divbuf_3/a_960_n1600# 0.00fF
C6998 divbuf_3/a_1352_n240# divbuf_3/a_1842_n240# 0.04fF
C6999 divbuf_3/a_22472_170# divbuf_3/a_22472_n240# 0.01fF
C7000 divbuf_5/a_14880_n1600# divbuf_5/a_14910_n840# 0.04fF
C7001 pll_full_0/divbuf_0/a_58110_n1540# pll_full_0/divbuf_0/a_58590_n1540# 0.11fF
C7002 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_15870_n840# 0.02fF
C7003 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_25440_n1600# 0.26fF
C7004 divbuf_4/a_30232_n240# divbuf_4/a_30712_n240# 0.05fF
C7005 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/a_19230_n840# 0.02fF
C7006 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28800_n1600# 0.26fF
C7007 divbuf_3/a_14430_n840# divbuf_3/a_14910_n840# 0.07fF
C7008 divbuf_3/a_14400_n1600# divbuf_3/a_14430_n1540# 0.19fF
C7009 pd_div_0/divbuf_0/a_48030_n840# pd_div_0/divbuf_0/a_48030_n1540# 0.01fF
C7010 pd_div_0/divbuf_0/a_17310_n1540# pd_div_0/divbuf_0/a_17790_n1540# 0.11fF
C7011 divbuf_4/a_41760_n1600# divbuf_4/a_41790_n1540# 0.19fF
C7012 divbuf_4/a_41790_n840# divbuf_4/a_42270_n840# 0.07fF
C7013 divbuf_4/a_11550_n840# divbuf_4/a_11550_n1540# 0.01fF
C7014 divbuf_4/a_19680_n1600# divbuf_4/OUT4 0.00fF
C7015 pll_full_0/divbuf_1/a_20670_n1540# pll_full_0/divbuf_1/a_21150_n1540# 0.11fF
C7016 pll_full_0/divbuf_1/a_51390_n840# pll_full_0/divbuf_1/a_51390_n1540# 0.01fF
C7017 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7018 divbuf_0/a_2880_n1600# divbuf_0/OUT2 0.00fF
C7019 divbuf_5/a_31682_170# divbuf_5/a_32172_170# 0.07fF
C7020 divbuf_5/a_12282_170# divbuf_5/a_12282_n240# 0.01fF
C7021 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_55710_n840# 0.04fF
C7022 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7023 ro_div_0/divider_0/tspc_2/Z3 gnd 0.27fF
C7024 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_16830_n1540# 0.19fF
C7025 ro_div_0/divbuf_0/a_16830_n840# ro_div_0/divbuf_0/a_17310_n840# 0.07fF
C7026 divbuf_1/a_15390_n840# divbuf_1/a_15870_n840# 0.07fF
C7027 divbuf_1/a_8272_n240# divbuf_1/OUT3 0.04fF
C7028 divbuf_1/a_15360_n1600# divbuf_1/a_15390_n1540# 0.19fF
C7029 divbuf_5/a_4350_n840# divbuf_5/a_4830_n840# 0.07fF
C7030 divbuf_5/a_4320_n1600# divbuf_5/a_4350_n1540# 0.19fF
C7031 divbuf_5/a_25382_170# divbuf_5/OUT4 0.19fF
C7032 divbuf_0/a_18582_170# divbuf_0/a_19072_170# 0.07fF
C7033 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_14910_n840# 0.04fF
C7034 divbuf_2/a_4392_170# divbuf_2/a_4882_170# 0.07fF
C7035 divbuf_5/a_57150_n1540# divbuf_5/a_57630_n1540# 0.11fF
C7036 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18270_n840# 0.04fF
C7037 divbuf_2/a_38400_n1600# divbuf_2/a_38880_n1600# 0.26fF
C7038 divbuf_2/a_29262_n240# divbuf_2/a_29310_n840# 0.04fF
C7039 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/a_34112_n240# 0.04fF
C7040 divbuf_0/a_22590_n840# divbuf_0/a_22590_n1540# 0.01fF
C7041 divbuf_0/a_52830_n840# divbuf_0/a_53310_n840# 0.07fF
C7042 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n1540# 0.19fF
C7043 divbuf_2/a_30750_n1540# divbuf_2/a_31230_n1540# 0.11fF
C7044 pll_full_0/divbuf_0/a_14910_n840# pll_full_0/divbuf_0/a_14910_n1540# 0.01fF
C7045 pll_full_0/divbuf_0/a_45150_n840# pll_full_0/divbuf_0/a_45630_n840# 0.07fF
C7046 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45150_n1540# 0.19fF
C7047 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C7048 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/a_32172_170# 0.07fF
C7049 divbuf_3/a_58110_n1540# divbuf_3/a_58590_n1540# 0.11fF
C7050 divbuf_5/a_26352_n240# divbuf_5/OUT4 0.04fF
C7051 divbuf_5/a_54720_n1600# divbuf_5/a_54750_n840# 0.04fF
C7052 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/a_35562_170# 0.07fF
C7053 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/a_15672_n240# 0.01fF
C7054 divbuf_3/a_960_n1600# divbuf_3/a_1440_n1600# 0.26fF
C7055 divbuf_0/a_9242_170# divbuf_0/a_9732_170# 0.07fF
C7056 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/prescaler_0/Out 0.12fF
C7057 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C7058 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C7059 pd_div_0/divbuf_0/a_4350_n840# pd_div_0/divbuf_0/a_4830_n840# 0.07fF
C7060 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4350_n1540# 0.19fF
C7061 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7062 divbuf_4/a_28320_n1600# divbuf_4/a_28800_n1600# 0.26fF
C7063 divbuf_4/a_19072_n240# divbuf_4/a_19230_n840# 0.02fF
C7064 pll_full_0/divbuf_1/a_7710_n840# pll_full_0/divbuf_1/a_8190_n840# 0.07fF
C7065 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7066 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_7710_n1540# 0.19fF
C7067 divbuf_3/a_54270_n840# divbuf_3/a_54750_n840# 0.07fF
C7068 divbuf_3/a_24030_n840# divbuf_3/a_24030_n1540# 0.01fF
C7069 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C7070 pd_div_0/divbuf_0/a_57150_n1540# pd_div_0/divbuf_0/a_57630_n1540# 0.11fF
C7071 divbuf_2/a_28320_n1600# divbuf_2/a_28350_n840# 0.04fF
C7072 divbuf_2/a_12282_170# divbuf_2/OUT4 0.19fF
C7073 divbuf_4/a_51390_n840# divbuf_4/a_51390_n1540# 0.01fF
C7074 divbuf_4/a_20670_n1540# divbuf_4/a_21150_n1540# 0.11fF
C7075 pll_full_0/divbuf_1/a_60510_n1540# pll_full_0/divbuf_1/a_60990_n1540# 0.11fF
C7076 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/a_1950_n840# 0.03fF
C7077 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3840_n1600# 0.26fF
C7078 divbuf_1/a_1920_n1600# divbuf_1/a_2400_n1600# 0.26fF
C7079 divbuf_5/a_32652_n240# divbuf_5/a_33142_n240# 0.04fF
C7080 divbuf_3/a_1842_170# divbuf_3/OUT2 0.19fF
C7081 ro_div_0/divbuf_0/a_26430_n840# ro_div_0/divbuf_0/a_26430_n1540# 0.01fF
C7082 ro_div_0/divbuf_0/a_56670_n840# ro_div_0/divbuf_0/a_57150_n840# 0.07fF
C7083 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_56670_n1540# 0.19fF
C7084 divbuf_1/a_55200_n1600# divbuf_1/a_55230_n1540# 0.19fF
C7085 divbuf_1/a_55230_n840# divbuf_1/a_55710_n840# 0.07fF
C7086 divbuf_1/a_24990_n840# divbuf_1/a_24990_n1540# 0.01fF
C7087 divbuf_3/a_11802_n240# divbuf_3/a_11550_n840# 0.02fF
C7088 divbuf_5/a_44160_n1600# divbuf_5/a_44190_n1540# 0.19fF
C7089 divbuf_5/a_44190_n840# divbuf_5/a_44670_n840# 0.07fF
C7090 divbuf_5/a_13950_n840# divbuf_5/a_13950_n1540# 0.01fF
C7091 divbuf_5/a_24480_n1600# divbuf_5/OUT4 0.00fF
C7092 ro_div_0/divider_0/and_0/B ro_div_0/divider_0/and_0/Z1 0.07fF
C7093 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7094 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_54750_n840# 0.04fF
C7095 divbuf_2/a_25862_170# divbuf_2/a_25862_n240# 0.01fF
C7096 divbuf_2/a_5362_n240# divbuf_2/a_5852_n240# 0.04fF
C7097 divbuf_4/a_18240_n1600# divbuf_4/a_18270_n840# 0.04fF
C7098 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58110_n840# 0.04fF
C7099 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7100 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_18270_n840# 0.02fF
C7101 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C7102 divbuf_0/a_30232_n240# divbuf_0/a_30270_n840# 0.05fF
C7103 divbuf_0/a_39360_n1600# divbuf_0/a_39840_n1600# 0.26fF
C7104 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C7105 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C7106 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C7107 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/a_22590_n840# 0.03fF
C7108 divbuf_2/a_17790_n840# divbuf_2/a_18270_n840# 0.07fF
C7109 divbuf_2/a_13252_n240# divbuf_2/OUT4 0.04fF
C7110 divbuf_2/a_17760_n1600# divbuf_2/a_17790_n1540# 0.19fF
C7111 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_32160_n1600# 0.26fF
C7112 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C7113 divbuf_0/a_31710_n1540# divbuf_0/a_32190_n1540# 0.11fF
C7114 divbuf_1/a_12772_n240# divbuf_1/a_12510_n840# 0.01fF
C7115 divbuf_3/a_6822_170# divbuf_3/a_7302_170# 0.07fF
C7116 pll_full_0/divbuf_0/a_54750_n840# pll_full_0/divbuf_0/a_54750_n1540# 0.01fF
C7117 pll_full_0/divbuf_0/a_24030_n1540# pll_full_0/divbuf_0/a_24510_n1540# 0.11fF
C7118 divbuf_3/a_2322_n240# divbuf_3/OUT3 0.04fF
C7119 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/a_33142_n240# 0.04fF
C7120 divbuf_4/a_15672_170# divbuf_4/a_15672_n240# 0.01fF
C7121 divbuf_4/a_35082_170# divbuf_4/a_35562_170# 0.07fF
C7122 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/a_36532_n240# 0.05fF
C7123 divbuf_3/a_40800_n1600# divbuf_3/a_41280_n1600# 0.26fF
C7124 divbuf_3/a_31682_n240# divbuf_3/a_31710_n840# 0.05fF
C7125 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44190_n1540# 0.19fF
C7126 pd_div_0/divbuf_0/a_44190_n840# pd_div_0/divbuf_0/a_44670_n840# 0.07fF
C7127 pd_div_0/divbuf_0/a_13950_n840# pd_div_0/divbuf_0/a_13950_n1540# 0.01fF
C7128 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7129 divbuf_4/a_7680_n1600# divbuf_4/a_7710_n1540# 0.19fF
C7130 divbuf_4/a_32172_170# divbuf_4/OUT4 0.19fF
C7131 divbuf_4/a_7710_n840# divbuf_4/a_8190_n840# 0.07fF
C7132 pll_full_0/divbuf_1/a_17310_n840# pll_full_0/divbuf_1/a_17310_n1540# 0.01fF
C7133 pll_full_0/divbuf_1/a_47550_n840# pll_full_0/divbuf_1/a_48030_n840# 0.07fF
C7134 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_47550_n1540# 0.19fF
C7135 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C7136 divbuf_3/a_33150_n1540# divbuf_3/a_33630_n1540# 0.11fF
C7137 divbuf_0/a_13742_170# divbuf_0/OUT4 0.19fF
C7138 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n840# 0.04fF
C7139 pd_div_0/divider_0/prescaler_0/tspc_1/Q gnd 0.83fF
C7140 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/tspc_0/Z3 0.05fF
C7141 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_21630_n840# 0.04fF
C7142 divbuf_2/a_11520_n1600# divbuf_2/OUT4 0.01fF
C7143 divbuf_4/a_60510_n1540# divbuf_4/a_60990_n1540# 0.11fF
C7144 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/a_19562_n240# 0.01fF
C7145 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/a_34110_n840# 0.06fF
C7146 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43680_n1600# 0.26fF
C7147 divbuf_1/a_41760_n1600# divbuf_1/a_42240_n1600# 0.26fF
C7148 divbuf_1/a_32652_n240# divbuf_1/a_32670_n840# 0.06fF
C7149 divbuf_5/a_30720_n1600# divbuf_5/a_31200_n1600# 0.26fF
C7150 divbuf_5/a_21502_n240# divbuf_5/a_21630_n840# 0.03fF
C7151 divbuf_3/a_2400_n1600# divbuf_3/OUT2 0.00fF
C7152 ro_div_0/divbuf_0/a_35550_n1540# ro_div_0/divbuf_0/a_36030_n1540# 0.11fF
C7153 divbuf_1/a_34110_n1540# divbuf_1/a_34590_n1540# 0.11fF
C7154 divbuf_3/a_30720_n1600# divbuf_3/a_30750_n840# 0.04fF
C7155 divbuf_5/a_53790_n840# divbuf_5/a_53790_n1540# 0.01fF
C7156 divbuf_5/a_23070_n1540# divbuf_5/a_23550_n1540# 0.11fF
C7157 divbuf_0/a_6332_n240# divbuf_0/a_6822_n240# 0.04fF
C7158 divbuf_0/a_26832_170# divbuf_0/a_26832_n240# 0.01fF
C7159 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/a_38962_170# 0.07fF
C7160 divbuf_2/a_4320_n1600# divbuf_2/a_4800_n1600# 0.26fF
C7161 divbuf_4/a_33142_n240# divbuf_4/OUT4 0.04fF
C7162 divbuf_4/a_58080_n1600# divbuf_4/a_58110_n840# 0.04fF
C7163 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/OUT4 0.03fF
C7164 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7165 divbuf_0/a_15182_n240# divbuf_0/OUT4 0.04fF
C7166 divbuf_0/a_18750_n840# divbuf_0/a_19230_n840# 0.07fF
C7167 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n1540# 0.19fF
C7168 pll_full_0/divbuf_0/a_11070_n840# pll_full_0/divbuf_0/a_11550_n840# 0.07fF
C7169 divbuf_2/a_57600_n1600# divbuf_2/a_57630_n1540# 0.19fF
C7170 divbuf_2/a_57630_n840# divbuf_2/a_58110_n840# 0.07fF
C7171 divbuf_2/a_27390_n840# divbuf_2/a_27390_n1540# 0.01fF
C7172 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11070_n1540# 0.19fF
C7173 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7174 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/a_19562_n240# 0.04fF
C7175 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33150_n840# 0.04fF
C7176 pd_div_0/pd_0/tspc_r_0/Z4 pd_div_0/pd_0/tspc_r_0/z5 0.04fF
C7177 pd_div_0/pd_0/DOWN pd_div_0/pd_0/UP 0.49fF
C7178 divbuf_1/a_3422_170# divbuf_1/OUT3 0.23fF
C7179 divbuf_1/a_31680_n1600# divbuf_1/a_31710_n840# 0.04fF
C7180 divbuf_3/a_28292_170# divbuf_3/a_28292_n240# 0.01fF
C7181 divbuf_3/a_7792_n240# divbuf_3/a_8272_n240# 0.05fF
C7182 divbuf_5/a_20640_n1600# divbuf_5/a_20670_n840# 0.04fF
C7183 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 0.26fF
C7184 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_31200_n1600# 0.26fF
C7185 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/a_21630_n840# 0.03fF
C7186 divbuf_3/a_20160_n1600# divbuf_3/a_20190_n1540# 0.19fF
C7187 divbuf_3/a_20190_n840# divbuf_3/a_20670_n840# 0.07fF
C7188 divbuf_4/a_36052_n240# divbuf_4/a_36532_n240# 0.05fF
C7189 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34560_n1600# 0.26fF
C7190 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/a_24990_n840# 0.03fF
C7191 pd_div_0/divbuf_0/a_53790_n840# pd_div_0/divbuf_0/a_53790_n1540# 0.01fF
C7192 pd_div_0/divbuf_0/a_23070_n1540# pd_div_0/divbuf_0/a_23550_n1540# 0.11fF
C7193 divbuf_2/a_15182_n240# divbuf_2/a_14910_n840# 0.01fF
C7194 divbuf_4/a_31200_n1600# divbuf_4/OUT4 0.00fF
C7195 divbuf_4/a_47520_n1600# divbuf_4/a_47550_n1540# 0.19fF
C7196 divbuf_4/a_47550_n840# divbuf_4/a_48030_n840# 0.07fF
C7197 divbuf_4/a_17310_n840# divbuf_4/a_17310_n1540# 0.01fF
C7198 pll_full_0/divbuf_1/a_26430_n1540# pll_full_0/divbuf_1/a_26910_n1540# 0.11fF
C7199 pll_full_0/divbuf_1/a_57150_n840# pll_full_0/divbuf_1/a_57150_n1540# 0.01fF
C7200 divbuf_0/a_13440_n1600# divbuf_0/OUT4 0.00fF
C7201 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7202 divbuf_1/a_8762_n240# divbuf_1/a_9242_n240# 0.05fF
C7203 divbuf_5/a_18092_170# divbuf_5/a_18092_n240# 0.01fF
C7204 divbuf_5/a_37502_170# divbuf_5/a_37992_170# 0.07fF
C7205 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7206 ro_div_0/divbuf_0/a_22590_n840# ro_div_0/divbuf_0/a_23070_n840# 0.07fF
C7207 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_22590_n1540# 0.19fF
C7208 divbuf_1/a_21120_n1600# divbuf_1/a_21150_n1540# 0.19fF
C7209 divbuf_1/a_21150_n840# divbuf_1/a_21630_n840# 0.07fF
C7210 divbuf_1/a_20042_n240# divbuf_1/OUT4 0.04fF
C7211 divbuf_5/a_10080_n1600# divbuf_5/a_10110_n1540# 0.19fF
C7212 divbuf_5/a_37022_170# divbuf_5/OUT4 0.19fF
C7213 divbuf_5/a_10110_n840# divbuf_5/a_10590_n840# 0.07fF
C7214 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C7215 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z1 0.00fF
C7216 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C7217 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_20670_n840# 0.04fF
C7218 divbuf_5/OUT2 divbuf_5/OUT3 0.36fF
C7219 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24030_n840# 0.04fF
C7220 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/OUT3 0.23fF
C7221 divbuf_0/a_5280_n1600# divbuf_0/a_5760_n1600# 0.26fF
C7222 divbuf_2/a_44160_n1600# divbuf_2/a_44640_n1600# 0.26fF
C7223 divbuf_2/a_35082_n240# divbuf_2/a_35070_n840# 0.05fF
C7224 divbuf_4/a_10590_n840# divbuf_4/OUT4 0.03fF
C7225 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/a_39932_n240# 0.04fF
C7226 divbuf_0/a_28350_n840# divbuf_0/a_28350_n1540# 0.01fF
C7227 divbuf_0/a_58590_n840# divbuf_0/a_59070_n840# 0.07fF
C7228 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n1540# 0.19fF
C7229 divbuf_2/a_36510_n1540# divbuf_2/a_36990_n1540# 0.11fF
C7230 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_50910_n1540# 0.19fF
C7231 pll_full_0/divbuf_0/a_50910_n840# pll_full_0/divbuf_0/a_51390_n840# 0.07fF
C7232 pll_full_0/divbuf_0/a_20670_n840# pll_full_0/divbuf_0/a_20670_n1540# 0.01fF
C7233 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C7234 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/a_18092_n240# 0.01fF
C7235 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/a_37992_170# 0.07fF
C7236 divbuf_3/OUT4 divbuf_3/OUT5 0.26fF
C7237 divbuf_5/a_60480_n1600# divbuf_5/a_60510_n840# 0.04fF
C7238 divbuf_5/a_37992_n240# divbuf_5/OUT4 0.04fF
C7239 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/a_21502_n240# 0.01fF
C7240 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/a_41382_170# 0.07fF
C7241 divbuf_3/a_6720_n1600# divbuf_3/a_7200_n1600# 0.26fF
C7242 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/clk 0.12fF
C7243 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10110_n1540# 0.19fF
C7244 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7245 pd_div_0/divbuf_0/a_10110_n840# pd_div_0/divbuf_0/a_10590_n840# 0.07fF
C7246 divbuf_4/a_24892_n240# divbuf_4/a_24990_n840# 0.03fF
C7247 divbuf_4/a_34080_n1600# divbuf_4/a_34560_n1600# 0.26fF
C7248 pll_full_0/divbuf_1/a_13470_n840# pll_full_0/divbuf_1/a_13950_n840# 0.07fF
C7249 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13470_n1540# 0.19fF
C7250 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C7251 divbuf_3/a_60030_n840# divbuf_3/a_60510_n840# 0.07fF
C7252 divbuf_3/a_29790_n840# divbuf_3/a_29790_n1540# 0.01fF
C7253 divbuf_0/a_16152_n240# divbuf_0/a_15870_n840# 0.01fF
C7254 pd_div_0/divbuf_0/OUT2 pd_div_0/divbuf_0/OUT3 0.36fF
C7255 divbuf_2/a_34080_n1600# divbuf_2/a_34110_n840# 0.04fF
C7256 divbuf_2/a_23922_170# divbuf_2/OUT4 0.19fF
C7257 divbuf_4/a_57150_n840# divbuf_4/a_57150_n1540# 0.01fF
C7258 divbuf_4/a_26430_n1540# divbuf_4/a_26910_n1540# 0.11fF
C7259 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9600_n1600# 0.26fF
C7260 divbuf_1/a_7680_n1600# divbuf_1/a_8160_n1600# 0.26fF
C7261 divbuf_5/a_38472_n240# divbuf_5/a_38962_n240# 0.04fF
C7262 divbuf_3/a_13742_170# divbuf_3/OUT4 0.19fF
C7263 ro_div_0/divbuf_0/a_1470_n1540# ro_div_0/divbuf_0/a_1950_n1540# 0.11fF
C7264 ro_div_0/divbuf_0/a_32190_n840# ro_div_0/divbuf_0/a_32190_n1540# 0.01fF
C7265 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/OUT5 0.26fF
C7266 divbuf_1/a_30750_n840# divbuf_1/a_30750_n1540# 0.01fF
C7267 divbuf_5/a_49950_n840# divbuf_5/a_50430_n840# 0.07fF
C7268 divbuf_5/a_19710_n840# divbuf_5/a_19710_n1540# 0.01fF
C7269 divbuf_5/a_36000_n1600# divbuf_5/OUT4 0.00fF
C7270 divbuf_5/a_49920_n1600# divbuf_5/a_49950_n1540# 0.19fF
C7271 divbuf_3/a_17612_n240# divbuf_3/a_17310_n840# 0.00fF
C7272 divbuf_3/a_51390_n1540# divbuf_3/a_51870_n1540# 0.11fF
C7273 divbuf_0/a_11802_170# divbuf_0/a_12282_170# 0.07fF
C7274 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C7275 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/a_60510_n840# 0.04fF
C7276 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7277 divbuf_2/a_11802_n240# divbuf_2/a_12282_n240# 0.05fF
C7278 divbuf_2/a_31682_170# divbuf_2/a_31682_n240# 0.01fF
C7279 divbuf_4/a_3422_170# divbuf_4/OUT3 0.23fF
C7280 divbuf_4/a_24000_n1600# divbuf_4/a_24030_n840# 0.04fF
C7281 divbuf_0/a_45120_n1600# divbuf_0/a_45600_n1600# 0.26fF
C7282 divbuf_0/a_36052_n240# divbuf_0/a_36030_n840# 0.05fF
C7283 pd_div_0/divider_0/nor_0/Z1 gnd 0.01fF
C7284 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C7285 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_0/a_630_n680# 0.01fF
C7286 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37920_n1600# 0.26fF
C7287 divbuf_2/a_23520_n1600# divbuf_2/a_23550_n1540# 0.19fF
C7288 divbuf_2/a_23550_n840# divbuf_2/a_24030_n840# 0.07fF
C7289 divbuf_2/a_24892_n240# divbuf_2/OUT4 0.04fF
C7290 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/a_28350_n840# 0.04fF
C7291 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/a_24412_170# 0.07fF
C7292 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/a_1352_n240# 0.01fF
C7293 divbuf_0/a_37470_n1540# divbuf_0/a_37950_n1540# 0.11fF
C7294 pll_full_0/divbuf_0/a_29790_n1540# pll_full_0/divbuf_0/a_30270_n1540# 0.11fF
C7295 pll_full_0/divbuf_0/a_60510_n840# pll_full_0/divbuf_0/a_60510_n1540# 0.01fF
C7296 divbuf_3/a_13252_170# divbuf_3/a_13742_170# 0.07fF
C7297 divbuf_3/a_14702_n240# divbuf_3/OUT4 0.04fF
C7298 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/a_38962_n240# 0.04fF
C7299 divbuf_4/a_40902_170# divbuf_4/a_41382_170# 0.07fF
C7300 divbuf_4/a_21502_170# divbuf_4/a_21502_n240# 0.01fF
C7301 pll_full_0/divbuf_1/a_0_n1600# pll_full_0/divbuf_1/a_480_n1600# 0.26fF
C7302 divbuf_3/a_37502_n240# divbuf_3/a_37470_n840# 0.05fF
C7303 divbuf_3/a_46560_n1600# divbuf_3/a_47040_n1600# 0.26fF
C7304 pd_div_0/divbuf_0/a_49950_n840# pd_div_0/divbuf_0/a_50430_n840# 0.07fF
C7305 pd_div_0/divbuf_0/a_19710_n840# pd_div_0/divbuf_0/a_19710_n1540# 0.01fF
C7306 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7307 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_49950_n1540# 0.19fF
C7308 divbuf_4/a_4392_n240# divbuf_4/OUT3 0.04fF
C7309 divbuf_4/a_13440_n1600# divbuf_4/a_13470_n1540# 0.19fF
C7310 divbuf_4/a_13470_n840# divbuf_4/a_13950_n840# 0.07fF
C7311 pll_full_0/divbuf_1/a_23070_n840# pll_full_0/divbuf_1/a_23070_n1540# 0.01fF
C7312 pll_full_0/divbuf_1/a_53310_n840# pll_full_0/divbuf_1/a_53790_n840# 0.07fF
C7313 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53310_n1540# 0.19fF
C7314 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7315 divbuf_3/a_38910_n1540# divbuf_3/a_39390_n1540# 0.11fF
C7316 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_0_n1600# 0.26fF
C7317 divbuf_0/a_25862_170# divbuf_0/OUT4 0.19fF
C7318 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n840# 0.04fF
C7319 gnd pd_div_0/divider_0/tspc_0/Z3 0.27fF
C7320 pd_div_0/divider_0/tspc_2/Z3 pd_div_0/bufin 0.05fF
C7321 pd_div_0/divider_0/tspc_2/Z2 pd_div_0/divider_0/tspc_2/Z4 0.36fF
C7322 divbuf_5/a_1842_170# divbuf_5/a_2322_170# 0.07fF
C7323 divbuf_2/a_23040_n1600# divbuf_2/OUT4 0.01fF
C7324 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27390_n840# 0.04fF
C7325 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7326 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C7327 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_49440_n1600# 0.26fF
C7328 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/a_39870_n840# 0.04fF
C7329 divbuf_1/a_38472_n240# divbuf_1/a_38430_n840# 0.04fF
C7330 divbuf_1/a_47520_n1600# divbuf_1/a_48000_n1600# 0.26fF
C7331 divbuf_5/a_27322_n240# divbuf_5/a_27390_n840# 0.04fF
C7332 divbuf_5/a_36480_n1600# divbuf_5/a_36960_n1600# 0.26fF
C7333 divbuf_3/a_12960_n1600# divbuf_3/OUT4 0.00fF
C7334 ro_div_0/divbuf_0/a_41310_n1540# ro_div_0/divbuf_0/a_41790_n1540# 0.11fF
C7335 divbuf_1/a_39870_n1540# divbuf_1/a_40350_n1540# 0.11fF
C7336 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/a_20532_n240# 0.01fF
C7337 divbuf_3/a_36480_n1600# divbuf_3/a_36510_n840# 0.04fF
C7338 divbuf_5/a_59550_n840# divbuf_5/a_59550_n1540# 0.01fF
C7339 divbuf_5/a_28830_n1540# divbuf_5/a_29310_n1540# 0.11fF
C7340 io_clamp_low[2] io_clamp_high[2] 0.53fF
C7341 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/OUT3 0.07fF
C7342 divbuf_0/a_32652_170# divbuf_0/a_32652_n240# 0.01fF
C7343 divbuf_0/a_12772_n240# divbuf_0/a_13252_n240# 0.05fF
C7344 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/a_24892_n240# 0.01fF
C7345 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/OUT2 0.04fF
C7346 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/OUT5 0.07fF
C7347 divbuf_2/a_10080_n1600# divbuf_2/a_10560_n1600# 0.26fF
C7348 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/a_4882_n240# 0.04fF
C7349 divbuf_0/a_24510_n840# divbuf_0/a_24990_n840# 0.07fF
C7350 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n1540# 0.19fF
C7351 divbuf_0/a_26832_n240# divbuf_0/OUT4 0.04fF
C7352 divbuf_1/a_13742_170# divbuf_1/a_13742_n240# 0.01fF
C7353 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_16830_n1540# 0.19fF
C7354 divbuf_2/a_2910_n840# divbuf_2/OUT3 0.03fF
C7355 divbuf_2/a_33150_n840# divbuf_2/a_33150_n1540# 0.01fF
C7356 divbuf_2/a_2430_n1540# divbuf_2/a_2910_n1540# 0.11fF
C7357 pll_full_0/divbuf_0/a_16830_n840# pll_full_0/divbuf_0/a_17310_n840# 0.07fF
C7358 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/OUT4 0.07fF
C7359 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_38910_n840# 0.04fF
C7360 ro_div_0/divider_0/tspc_1/Q gnd 0.33fF
C7361 divbuf_1/a_27322_170# divbuf_1/OUT4 0.19fF
C7362 divbuf_1/a_37440_n1600# divbuf_1/a_37470_n840# 0.04fF
C7363 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/a_6332_170# 0.07fF
C7364 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C7365 divbuf_3/a_14222_n240# divbuf_3/a_14702_n240# 0.05fF
C7366 divbuf_3/a_34112_170# divbuf_3/a_34112_n240# 0.01fF
C7367 divbuf_5/a_26400_n1600# divbuf_5/a_26430_n840# 0.04fF
C7368 divbuf_5/a_8272_170# divbuf_5/OUT3 0.19fF
C7369 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/a_27390_n840# 0.04fF
C7370 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36960_n1600# 0.26fF
C7371 divbuf_4/a_0_n1600# divbuf_4/a_480_n1600# 0.26fF
C7372 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/a_30750_n840# 0.05fF
C7373 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_40320_n1600# 0.26fF
C7374 divbuf_3/a_25950_n840# divbuf_3/a_26430_n840# 0.07fF
C7375 divbuf_3/a_25920_n1600# divbuf_3/a_25950_n1540# 0.19fF
C7376 pd_div_0/divbuf_0/a_59550_n840# pd_div_0/divbuf_0/a_59550_n1540# 0.01fF
C7377 pd_div_0/divbuf_0/a_28830_n1540# pd_div_0/divbuf_0/a_29310_n1540# 0.11fF
C7378 divbuf_4/a_53280_n1600# divbuf_4/a_53310_n1540# 0.19fF
C7379 divbuf_4/a_53310_n840# divbuf_4/a_53790_n840# 0.07fF
C7380 divbuf_4/a_23070_n840# divbuf_4/a_23070_n1540# 0.01fF
C7381 pll_full_0/divbuf_1/a_32190_n1540# pll_full_0/divbuf_1/a_32670_n1540# 0.11fF
C7382 divbuf_0/a_24960_n1600# divbuf_0/OUT4 0.00fF
C7383 divbuf_1/a_15182_n240# divbuf_1/a_15672_n240# 0.04fF
C7384 divbuf_1/a_35082_170# divbuf_1/a_35082_n240# 0.01fF
C7385 divbuf_2/a_41790_n840# divbuf_2/OUT5 0.03fF
C7386 divbuf_5/a_3422_n240# divbuf_5/a_3912_n240# 0.04fF
C7387 divbuf_5/a_23922_170# divbuf_5/a_23922_n240# 0.01fF
C7388 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C7389 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28350_n1540# 0.19fF
C7390 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7391 ro_div_0/divbuf_0/a_28350_n840# ro_div_0/divbuf_0/a_28830_n840# 0.07fF
C7392 divbuf_1/a_26910_n840# divbuf_1/a_27390_n840# 0.07fF
C7393 divbuf_1/a_31682_n240# divbuf_1/OUT4 0.04fF
C7394 divbuf_1/a_26880_n1600# divbuf_1/a_26910_n1540# 0.19fF
C7395 divbuf_5/a_15870_n840# divbuf_5/a_16350_n840# 0.07fF
C7396 divbuf_5/a_9242_n240# divbuf_5/OUT3 0.04fF
C7397 divbuf_5/a_15840_n1600# divbuf_5/a_15870_n1540# 0.19fF
C7398 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26430_n840# 0.04fF
C7399 pd_div_0/divbuf_0/a_3912_170# pd_div_0/divbuf_0/OUT3 0.19fF
C7400 divbuf_2/a_16642_170# divbuf_2/a_17122_170# 0.07fF
C7401 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C7402 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C7403 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7404 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_29790_n840# 0.04fF
C7405 divbuf_0/a_11040_n1600# divbuf_0/a_11520_n1600# 0.26fF
C7406 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3840_n1600# 0.26fF
C7407 divbuf_2/a_49920_n1600# divbuf_2/a_50400_n1600# 0.26fF
C7408 divbuf_2/a_40902_n240# divbuf_2/a_40830_n840# 0.03fF
C7409 divbuf_0/a_3390_n1540# divbuf_0/a_3870_n1540# 0.11fF
C7410 divbuf_0/a_34110_n840# divbuf_0/a_34110_n1540# 0.01fF
C7411 pll_full_0/divbuf_0/a_26430_n840# pll_full_0/divbuf_0/a_26430_n1540# 0.01fF
C7412 pll_full_0/divbuf_0/a_56670_n840# pll_full_0/divbuf_0/a_57150_n840# 0.07fF
C7413 divbuf_2/a_42270_n1540# divbuf_2/a_42750_n1540# 0.11fF
C7414 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_56670_n1540# 0.19fF
C7415 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C7416 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/a_3912_n240# 0.04fF
C7417 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/a_23922_n240# 0.01fF
C7418 divbuf_3/a_12480_n1600# divbuf_3/a_12960_n1600# 0.26fF
C7419 divbuf_4/a_5852_170# divbuf_4/a_6332_170# 0.07fF
C7420 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/a_7302_n240# 0.05fF
C7421 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/a_27322_n240# 0.01fF
C7422 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z2 0.01fF
C7423 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/clk 0.60fF
C7424 pd_div_0/divbuf_0/a_15870_n840# pd_div_0/divbuf_0/a_16350_n840# 0.07fF
C7425 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C7426 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_15870_n1540# 0.19fF
C7427 divbuf_4/a_39840_n1600# divbuf_4/a_40320_n1600# 0.26fF
C7428 divbuf_4/a_30712_n240# divbuf_4/a_30750_n840# 0.05fF
C7429 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7430 pll_full_0/divbuf_1/a_19230_n840# pll_full_0/divbuf_1/a_19710_n840# 0.07fF
C7431 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19230_n1540# 0.19fF
C7432 divbuf_3/a_35550_n840# divbuf_3/a_35550_n1540# 0.01fF
C7433 divbuf_3/a_4830_n1540# divbuf_3/a_5310_n1540# 0.11fF
C7434 divbuf_0/a_960_n1600# divbuf_0/a_990_n840# 0.04fF
C7435 divbuf_0/a_6332_170# divbuf_0/OUT3 0.19fF
C7436 divbuf_1/a_31202_170# divbuf_1/a_31682_170# 0.07fF
C7437 divbuf_2/a_39840_n1600# divbuf_2/a_39870_n840# 0.04fF
C7438 divbuf_2/a_35562_170# divbuf_2/OUT4 0.19fF
C7439 divbuf_4/a_32190_n1540# divbuf_4/a_32670_n1540# 0.11fF
C7440 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_13950_n840# 0.01fF
C7441 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_15360_n1600# 0.26fF
C7442 divbuf_1/a_3912_n240# divbuf_1/a_3870_n840# 0.04fF
C7443 divbuf_1/a_13440_n1600# divbuf_1/a_13920_n1600# 0.26fF
C7444 divbuf_5/a_2400_n1600# divbuf_5/a_2880_n1600# 0.26fF
C7445 divbuf_3/a_25382_170# divbuf_3/OUT4 0.19fF
C7446 ro_div_0/divbuf_0/a_7230_n1540# ro_div_0/divbuf_0/a_7710_n1540# 0.11fF
C7447 ro_div_0/divbuf_0/a_37950_n840# ro_div_0/divbuf_0/a_37950_n1540# 0.01fF
C7448 divbuf_1/a_36510_n840# divbuf_1/a_36510_n1540# 0.01fF
C7449 divbuf_1/a_5790_n1540# divbuf_1/a_6270_n1540# 0.11fF
C7450 divbuf_5/a_55680_n1600# divbuf_5/a_55710_n1540# 0.19fF
C7451 divbuf_5/a_55710_n840# divbuf_5/a_56190_n840# 0.07fF
C7452 divbuf_5/a_25470_n840# divbuf_5/a_25470_n1540# 0.01fF
C7453 divbuf_3/a_2400_n1600# divbuf_3/a_2430_n840# 0.04fF
C7454 divbuf_0/a_15182_170# divbuf_0/a_15672_170# 0.07fF
C7455 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C7456 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/a_11802_170# 0.07fF
C7457 divbuf_2/a_37502_170# divbuf_2/a_37502_n240# 0.01fF
C7458 divbuf_2/a_17612_n240# divbuf_2/a_18092_n240# 0.05fF
C7459 divbuf_4/a_29760_n1600# divbuf_4/a_29790_n840# 0.04fF
C7460 divbuf_4/a_15182_170# divbuf_4/OUT4 0.19fF
C7461 divbuf_0/a_50880_n1600# divbuf_0/a_51360_n1600# 0.26fF
C7462 pd_div_0/divider_0/nor_1/B gnd 1.17fF
C7463 divbuf_2/a_29310_n840# divbuf_2/a_29790_n840# 0.07fF
C7464 divbuf_2/a_36532_n240# divbuf_2/OUT4 0.04fF
C7465 divbuf_2/a_29280_n1600# divbuf_2/a_29310_n1540# 0.19fF
C7466 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/a_34110_n840# 0.06fF
C7467 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/OUT3 0.19fF
C7468 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43680_n1600# 0.26fF
C7469 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/a_9732_n240# 0.01fF
C7470 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/a_30232_170# 0.07fF
C7471 divbuf_0/a_43230_n1540# divbuf_0/a_43710_n1540# 0.11fF
C7472 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_4830_n840# 0.04fF
C7473 divbuf_1/a_3360_n1600# divbuf_1/a_3390_n840# 0.04fF
C7474 divbuf_5/a_13252_n240# divbuf_5/a_12990_n840# 0.01fF
C7475 divbuf_3/a_19072_170# divbuf_3/a_19562_170# 0.07fF
C7476 pll_full_0/divbuf_0/a_35550_n1540# pll_full_0/divbuf_0/a_36030_n1540# 0.11fF
C7477 divbuf_3/a_26352_n240# divbuf_3/OUT4 0.04fF
C7478 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2880_n1600# 0.26fF
C7479 divbuf_4/a_27322_170# divbuf_4/a_27322_n240# 0.01fF
C7480 divbuf_4/a_6822_n240# divbuf_4/a_7302_n240# 0.05fF
C7481 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_6240_n1600# 0.26fF
C7482 divbuf_3/a_52320_n1600# divbuf_3/a_52800_n1600# 0.26fF
C7483 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_55710_n1540# 0.19fF
C7484 pd_div_0/divbuf_0/a_55710_n840# pd_div_0/divbuf_0/a_56190_n840# 0.07fF
C7485 pd_div_0/divbuf_0/a_25470_n840# pd_div_0/divbuf_0/a_25470_n1540# 0.01fF
C7486 divbuf_4/a_19200_n1600# divbuf_4/a_19230_n1540# 0.19fF
C7487 divbuf_4/a_19230_n840# divbuf_4/a_19710_n840# 0.07fF
C7488 divbuf_4/a_16152_n240# divbuf_4/OUT4 0.04fF
C7489 pll_full_0/divbuf_1/a_28830_n840# pll_full_0/divbuf_1/a_28830_n1540# 0.01fF
C7490 pll_full_0/divbuf_1/a_59070_n840# pll_full_0/divbuf_1/a_59550_n840# 0.07fF
C7491 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59070_n1540# 0.19fF
C7492 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/a_11312_n240# 0.01fF
C7493 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7494 divbuf_3/a_44670_n1540# divbuf_3/a_45150_n1540# 0.11fF
C7495 divbuf_0/a_37502_170# divbuf_0/OUT4 0.19fF
C7496 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n840# 0.04fF
C7497 pd_div_0/divider_0/and_0/A pd_div_0/divider_0/and_0/B 0.18fF
C7498 divbuf_1/a_5362_170# divbuf_1/a_5362_n240# 0.01fF
C7499 divbuf_5/a_8272_170# divbuf_5/a_8762_170# 0.07fF
C7500 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7501 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33150_n840# 0.04fF
C7502 divbuf_2/a_34560_n1600# divbuf_2/OUT4 0.01fF
C7503 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_55200_n1600# 0.26fF
C7504 divbuf_1/a_53280_n1600# divbuf_1/a_53760_n1600# 0.26fF
C7505 divbuf_5/a_42240_n1600# divbuf_5/a_42720_n1600# 0.26fF
C7506 divbuf_5/a_33142_n240# divbuf_5/a_33150_n840# 0.06fF
C7507 divbuf_3/a_24480_n1600# divbuf_3/OUT4 0.00fF
C7508 ro_div_0/divbuf_0/a_47070_n1540# ro_div_0/divbuf_0/a_47550_n1540# 0.11fF
C7509 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_12990_n840# 0.01fF
C7510 divbuf_1/a_45630_n1540# divbuf_1/a_46110_n1540# 0.11fF
C7511 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_16350_n840# 0.00fF
C7512 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/a_26352_n240# 0.01fF
C7513 divbuf_3/a_42240_n1600# divbuf_3/a_42270_n840# 0.04fF
C7514 divbuf_5/a_34590_n1540# divbuf_5/a_35070_n1540# 0.11fF
C7515 divbuf_0/a_18582_n240# divbuf_0/a_19072_n240# 0.04fF
C7516 divbuf_0/a_38472_170# divbuf_0/a_38472_n240# 0.01fF
C7517 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7518 divbuf_2/a_15840_n1600# divbuf_2/a_16320_n1600# 0.26fF
C7519 divbuf_2/a_6332_n240# divbuf_2/a_6270_n840# 0.04fF
C7520 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/a_30712_n240# 0.01fF
C7521 divbuf_0/a_38472_n240# divbuf_0/OUT4 0.04fF
C7522 divbuf_0/a_30270_n840# divbuf_0/a_30750_n840# 0.07fF
C7523 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n1540# 0.19fF
C7524 divbuf_1/a_19072_170# divbuf_1/a_19072_n240# 0.01fF
C7525 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7526 pll_full_0/divbuf_0/a_22590_n840# pll_full_0/divbuf_0/a_23070_n840# 0.07fF
C7527 divbuf_2/a_38910_n840# divbuf_2/a_38910_n1540# 0.01fF
C7528 divbuf_2/a_8190_n1540# divbuf_2/a_8670_n1540# 0.11fF
C7529 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_22590_n1540# 0.19fF
C7530 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_44670_n840# 0.04fF
C7531 divbuf_1/a_2322_n240# divbuf_1/OUT3 0.04fF
C7532 divbuf_1/a_43200_n1600# divbuf_1/a_43230_n840# 0.04fF
C7533 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/a_12772_170# 0.07fF
C7534 divbuf_3/a_39932_170# divbuf_3/a_39932_n240# 0.01fF
C7535 divbuf_3/a_20042_n240# divbuf_3/a_20532_n240# 0.04fF
C7536 divbuf_5/a_32160_n1600# divbuf_5/a_32190_n840# 0.04fF
C7537 divbuf_5/a_20042_170# divbuf_5/OUT4 0.19fF
C7538 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42720_n1600# 0.26fF
C7539 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/a_33150_n840# 0.06fF
C7540 divbuf_4/a_5760_n1600# divbuf_4/a_6240_n1600# 0.26fF
C7541 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_46080_n1600# 0.26fF
C7542 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/a_36510_n840# 0.05fF
C7543 divbuf_3/a_31680_n1600# divbuf_3/a_31710_n1540# 0.19fF
C7544 divbuf_3/a_31710_n840# divbuf_3/a_32190_n840# 0.07fF
C7545 divbuf_3/a_1470_n840# divbuf_3/a_1470_n1540# 0.01fF
C7546 pd_div_0/divbuf_0/a_34590_n1540# pd_div_0/divbuf_0/a_35070_n1540# 0.11fF
C7547 divbuf_4/a_59040_n1600# divbuf_4/a_59070_n1540# 0.19fF
C7548 divbuf_4/a_59070_n840# divbuf_4/a_59550_n840# 0.07fF
C7549 divbuf_4/a_28830_n840# divbuf_4/a_28830_n1540# 0.01fF
C7550 divbuf_2/a_5760_n1600# divbuf_2/a_5790_n840# 0.04fF
C7551 pll_full_0/divbuf_1/a_37950_n1540# pll_full_0/divbuf_1/a_38430_n1540# 0.11fF
C7552 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/a_22952_n240# 0.05fF
C7553 divbuf_0/a_36480_n1600# divbuf_0/OUT4 0.00fF
C7554 divbuf_1/a_40902_170# divbuf_1/a_40902_n240# 0.01fF
C7555 divbuf_1/a_21012_n240# divbuf_1/a_21502_n240# 0.04fF
C7556 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7557 divbuf_5/a_29742_170# divbuf_5/a_29742_n240# 0.01fF
C7558 divbuf_5/a_9242_n240# divbuf_5/a_9732_n240# 0.04fF
C7559 ro_div_0/divbuf_0/a_3870_n840# ro_div_0/divbuf_0/a_3870_n1540# 0.01fF
C7560 ro_div_0/divbuf_0/a_34110_n840# ro_div_0/divbuf_0/a_34590_n840# 0.07fF
C7561 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34110_n1540# 0.19fF
C7562 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/a_7792_n240# 0.01fF
C7563 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/a_13252_n240# 0.01fF
C7564 divbuf_1/a_2400_n1600# divbuf_1/OUT2 0.00fF
C7565 divbuf_1/a_32640_n1600# divbuf_1/a_32670_n1540# 0.19fF
C7566 divbuf_1/a_32670_n840# divbuf_1/a_33150_n840# 0.07fF
C7567 divbuf_1/a_2430_n840# divbuf_1/a_2430_n1540# 0.01fF
C7568 divbuf_5/a_21600_n1600# divbuf_5/a_21630_n1540# 0.19fF
C7569 divbuf_5/a_21630_n840# divbuf_5/a_22110_n840# 0.07fF
C7570 divbuf_5/a_21012_n240# divbuf_5/OUT4 0.04fF
C7571 divbuf_3/a_53790_n840# divbuf_3/a_53790_n1540# 0.01fF
C7572 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/a4 0.09fF
C7573 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C7574 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C7575 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32190_n840# 0.04fF
C7576 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7577 divbuf_4/a_16642_n240# divbuf_4/a_16350_n840# 0.00fF
C7578 divbuf_2/a_22472_170# divbuf_2/a_22952_170# 0.07fF
C7579 divbuf_2/a_1842_170# divbuf_2/a_1842_n240# 0.01fF
C7580 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C7581 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7582 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_35550_n840# 0.04fF
C7583 divbuf_0/a_7302_n240# divbuf_0/a_7230_n840# 0.03fF
C7584 divbuf_0/a_16800_n1600# divbuf_0/a_17280_n1600# 0.26fF
C7585 divbuf_2/a_6822_170# divbuf_2/OUT3 0.19fF
C7586 divbuf_2/a_55680_n1600# divbuf_2/a_56160_n1600# 0.26fF
C7587 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9600_n1600# 0.26fF
C7588 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C7589 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/a4 0.09fF
C7590 divbuf_0/a_9150_n1540# divbuf_0/a_9630_n1540# 0.11fF
C7591 divbuf_0/a_39870_n840# divbuf_0/a_39870_n1540# 0.01fF
C7592 divbuf_2/a_48030_n1540# divbuf_2/a_48510_n1540# 0.11fF
C7593 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/OUT5 0.26fF
C7594 pll_full_0/divbuf_0/a_32190_n840# pll_full_0/divbuf_0/a_32190_n1540# 0.01fF
C7595 pll_full_0/divbuf_0/a_1470_n1540# pll_full_0/divbuf_0/a_1950_n1540# 0.11fF
C7596 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/a_29742_n240# 0.01fF
C7597 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/a_9732_n240# 0.04fF
C7598 divbuf_4/a_12282_170# divbuf_4/a_12772_170# 0.07fF
C7599 divbuf_3/a_18240_n1600# divbuf_3/a_18720_n1600# 0.26fF
C7600 divbuf_3/a_8762_n240# divbuf_3/a_8670_n840# 0.03fF
C7601 divbuf_5/a_19200_n1600# divbuf_5/OUT4 0.00fF
C7602 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/a_33142_n240# 0.01fF
C7603 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_13742_n240# 0.04fF
C7604 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/A 0.01fF
C7605 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_21630_n1540# 0.19fF
C7606 pd_div_0/divbuf_0/a_21630_n840# pd_div_0/divbuf_0/a_22110_n840# 0.07fF
C7607 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7608 divbuf_3/a_41310_n840# divbuf_3/a_41310_n1540# 0.01fF
C7609 divbuf_3/a_10590_n1540# divbuf_3/a_11070_n1540# 0.11fF
C7610 divbuf_4/a_36532_n240# divbuf_4/a_36510_n840# 0.05fF
C7611 divbuf_4/a_45600_n1600# divbuf_4/a_46080_n1600# 0.26fF
C7612 pll_full_0/divbuf_1/a_24990_n840# pll_full_0/divbuf_1/a_25470_n840# 0.07fF
C7613 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_24990_n1540# 0.19fF
C7614 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7615 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_15390_n840# 0.01fF
C7616 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n840# 0.04fF
C7617 divbuf_2/a_7792_n240# divbuf_2/OUT3 0.04fF
C7618 divbuf_2/a_45600_n1600# divbuf_2/a_45630_n840# 0.04fF
C7619 divbuf_4/a_37950_n1540# divbuf_4/a_38430_n1540# 0.11fF
C7620 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_21120_n1600# 0.26fF
C7621 divbuf_1/a_19200_n1600# divbuf_1/a_19680_n1600# 0.26fF
C7622 divbuf_1/a_9732_n240# divbuf_1/a_9630_n840# 0.03fF
C7623 divbuf_5/a_8160_n1600# divbuf_5/a_8640_n1600# 0.26fF
C7624 divbuf_3/a_37022_170# divbuf_3/OUT4 0.19fF
C7625 ro_div_0/divbuf_0/a_12990_n1540# ro_div_0/divbuf_0/a_13470_n1540# 0.11fF
C7626 ro_div_0/divbuf_0/a_43710_n840# ro_div_0/divbuf_0/a_43710_n1540# 0.01fF
C7627 divbuf_1/a_42270_n840# divbuf_1/a_42270_n1540# 0.01fF
C7628 divbuf_1/a_11550_n1540# divbuf_1/a_12030_n1540# 0.11fF
C7629 divbuf_3/a_8160_n1600# divbuf_3/a_8190_n840# 0.04fF
C7630 divbuf_5/a_31230_n840# divbuf_5/a_31230_n1540# 0.01fF
C7631 divbuf_5/a_510_n1540# divbuf_5/a_990_n1540# 0.11fF
C7632 divbuf_0/a_23442_170# divbuf_0/a_23922_170# 0.07fF
C7633 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7634 divbuf_2/a_23442_n240# divbuf_2/a_23922_n240# 0.05fF
C7635 divbuf_4/a_35520_n1600# divbuf_4/a_35550_n840# 0.04fF
C7636 divbuf_4/a_26832_170# divbuf_4/OUT4 0.19fF
C7637 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.44fF
C7638 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/a_17612_170# 0.07fF
C7639 divbuf_0/a_56640_n1600# divbuf_0/a_57120_n1600# 0.26fF
C7640 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_49440_n1600# 0.26fF
C7641 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/Out 0.19fF
C7642 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.44fF
C7643 pd_div_0/divider_0/prescaler_0/tspc_0/D pd_div_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C7644 divbuf_2/a_35040_n1600# divbuf_2/a_35070_n1540# 0.19fF
C7645 divbuf_2/a_35070_n840# divbuf_2/a_35550_n840# 0.07fF
C7646 divbuf_2/a_4830_n840# divbuf_2/a_4830_n1540# 0.01fF
C7647 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/a_39870_n840# 0.04fF
C7648 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C7649 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C7650 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C7651 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/a_36052_170# 0.07fF
C7652 divbuf_0/a_48990_n1540# divbuf_0/a_49470_n1540# 0.11fF
C7653 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_10590_n840# 0.04fF
C7654 divbuf_1/a_9120_n1600# divbuf_1/a_9150_n840# 0.04fF
C7655 divbuf_3/a_4882_170# divbuf_3/a_4882_n240# 0.01fF
C7656 divbuf_3/a_24892_170# divbuf_3/a_25382_170# 0.07fF
C7657 pll_full_0/divbuf_0/a_41310_n1540# pll_full_0/divbuf_0/a_41790_n1540# 0.11fF
C7658 divbuf_3/a_37992_n240# divbuf_3/OUT4 0.04fF
C7659 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8640_n1600# 0.26fF
C7660 divbuf_4/a_13252_n240# divbuf_4/a_13742_n240# 0.04fF
C7661 divbuf_4/a_33142_170# divbuf_4/a_33142_n240# 0.01fF
C7662 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_12000_n1600# 0.26fF
C7663 divbuf_3/a_58080_n1600# divbuf_3/a_58560_n1600# 0.26fF
C7664 pd_div_0/divbuf_0/a_31230_n840# pd_div_0/divbuf_0/a_31230_n1540# 0.01fF
C7665 pd_div_0/divbuf_0/a_510_n1540# pd_div_0/divbuf_0/a_990_n1540# 0.11fF
C7666 divbuf_4/a_27802_n240# divbuf_4/OUT4 0.04fF
C7667 divbuf_4/a_24960_n1600# divbuf_4/a_24990_n1540# 0.19fF
C7668 divbuf_4/a_24990_n840# divbuf_4/a_25470_n840# 0.07fF
C7669 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/a_17122_n240# 0.01fF
C7670 pll_full_0/divbuf_1/a_3870_n1540# pll_full_0/divbuf_1/a_4350_n1540# 0.11fF
C7671 pll_full_0/divbuf_1/a_34590_n840# pll_full_0/divbuf_1/a_34590_n1540# 0.01fF
C7672 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7673 divbuf_3/a_50430_n1540# divbuf_3/a_50910_n1540# 0.11fF
C7674 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n840# 0.04fF
C7675 divbuf_0/a_9732_n240# divbuf_0/OUT3 0.04fF
C7676 divbuf_1/a_22472_170# divbuf_1/a_22952_170# 0.07fF
C7677 divbuf_1/a_32172_170# divbuf_1/a_32172_n240# 0.01fF
C7678 divbuf_5/a_14702_170# divbuf_5/a_15182_170# 0.07fF
C7679 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_38910_n840# 0.04fF
C7680 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7681 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_0/Qbar 0.21fF
C7682 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z4 0.02fF
C7683 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/R 0.01fF
C7684 divbuf_1/a_59040_n1600# divbuf_1/a_59520_n1600# 0.26fF
C7685 divbuf_5/a_38962_n240# divbuf_5/a_38910_n840# 0.04fF
C7686 divbuf_5/a_48000_n1600# divbuf_5/a_48480_n1600# 0.26fF
C7687 divbuf_3/a_36000_n1600# divbuf_3/OUT4 0.00fF
C7688 ro_div_0/divbuf_0/a_52830_n1540# ro_div_0/divbuf_0/a_53310_n1540# 0.11fF
C7689 divbuf_1/a_51390_n1540# divbuf_1/a_51870_n1540# 0.11fF
C7690 divbuf_5/a_40350_n1540# divbuf_5/a_40830_n1540# 0.11fF
C7691 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1470_n840# 0.04fF
C7692 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/a_32172_n240# 0.01fF
C7693 divbuf_3/a_48000_n1600# divbuf_3/a_48030_n840# 0.04fF
C7694 divbuf_0/a_24412_n240# divbuf_0/a_24892_n240# 0.05fF
C7695 divbuf_2/a_21600_n1600# divbuf_2/a_22080_n1600# 0.26fF
C7696 divbuf_2/a_12282_n240# divbuf_2/a_12510_n840# 0.02fF
C7697 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/a_36532_n240# 0.01fF
C7698 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_17122_n240# 0.05fF
C7699 divbuf_0/a_5790_n840# divbuf_0/a_5790_n1540# 0.01fF
C7700 divbuf_0/a_36030_n840# divbuf_0/a_36510_n840# 0.07fF
C7701 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n1540# 0.19fF
C7702 divbuf_0/a_8640_n1600# divbuf_0/OUT3 0.00fF
C7703 divbuf_1/a_24892_170# divbuf_1/a_24892_n240# 0.01fF
C7704 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28350_n1540# 0.19fF
C7705 divbuf_2/a_44670_n840# divbuf_2/a_44670_n1540# 0.01fF
C7706 divbuf_2/a_13950_n1540# divbuf_2/a_14430_n1540# 0.11fF
C7707 pll_full_0/divbuf_0/a_28350_n840# pll_full_0/divbuf_0/a_28830_n840# 0.07fF
C7708 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7709 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50430_n840# 0.04fF
C7710 ro_div_0/divider_0/and_0/B gnd 0.66fF
C7711 divbuf_1/a_48960_n1600# divbuf_1/a_48990_n840# 0.04fF
C7712 divbuf_1/a_14702_n240# divbuf_1/OUT4 0.04fF
C7713 divbuf_5/a_37920_n1600# divbuf_5/a_37950_n840# 0.04fF
C7714 divbuf_5/a_31682_170# divbuf_5/OUT4 0.19fF
C7715 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/a_18582_170# 0.07fF
C7716 divbuf_3/a_25862_n240# divbuf_3/a_26352_n240# 0.04fF
C7717 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/a_38910_n840# 0.04fF
C7718 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48480_n1600# 0.26fF
C7719 divbuf_4/a_11520_n1600# divbuf_4/a_12000_n1600# 0.26fF
C7720 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51840_n1600# 0.26fF
C7721 divbuf_3/a_37470_n840# divbuf_3/a_37950_n840# 0.07fF
C7722 divbuf_3/a_7230_n840# divbuf_3/a_7230_n1540# 0.01fF
C7723 divbuf_3/a_37440_n1600# divbuf_3/a_37470_n1540# 0.19fF
C7724 pd_div_0/divbuf_0/a_40350_n1540# pd_div_0/divbuf_0/a_40830_n1540# 0.11fF
C7725 divbuf_4/a_34590_n840# divbuf_4/a_34590_n1540# 0.01fF
C7726 divbuf_4/a_3870_n1540# divbuf_4/a_4350_n1540# 0.11fF
C7727 pll_full_0/divbuf_1/a_43710_n1540# pll_full_0/divbuf_1/a_44190_n1540# 0.11fF
C7728 divbuf_2/a_11520_n1600# divbuf_2/a_11550_n840# 0.04fF
C7729 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/a_28772_n240# 0.05fF
C7730 divbuf_1/a_26832_n240# divbuf_1/a_27322_n240# 0.04fF
C7731 divbuf_5/a_15672_n240# divbuf_5/a_16152_n240# 0.05fF
C7732 divbuf_5/a_35562_170# divbuf_5/a_35562_n240# 0.01fF
C7733 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7734 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_39870_n1540# 0.19fF
C7735 ro_div_0/divbuf_0/a_9630_n840# ro_div_0/divbuf_0/a_9630_n1540# 0.01fF
C7736 ro_div_0/divbuf_0/a_39870_n840# ro_div_0/divbuf_0/a_40350_n840# 0.07fF
C7737 divbuf_1/a_38430_n840# divbuf_1/a_38910_n840# 0.07fF
C7738 divbuf_1/a_8190_n840# divbuf_1/a_8190_n1540# 0.01fF
C7739 divbuf_1/a_12960_n1600# divbuf_1/OUT4 0.00fF
C7740 divbuf_1/a_38400_n1600# divbuf_1/a_38430_n1540# 0.19fF
C7741 divbuf_5/a_27390_n840# divbuf_5/a_27870_n840# 0.07fF
C7742 divbuf_5/a_32652_n240# divbuf_5/OUT4 0.04fF
C7743 divbuf_5/a_27360_n1600# divbuf_5/a_27390_n1540# 0.19fF
C7744 divbuf_3/a_59550_n840# divbuf_3/a_59550_n1540# 0.01fF
C7745 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C7746 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C7747 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_37950_n840# 0.04fF
C7748 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7749 divbuf_4/a_1440_n1600# divbuf_4/a_1470_n840# 0.04fF
C7750 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7751 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41310_n840# 0.04fF
C7752 divbuf_2/a_28292_170# divbuf_2/a_28772_170# 0.07fF
C7753 divbuf_2/a_8272_170# divbuf_2/a_8272_n240# 0.01fF
C7754 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C7755 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_8272_170# 0.07fF
C7756 divbuf_0/a_22560_n1600# divbuf_0/a_23040_n1600# 0.26fF
C7757 divbuf_0/a_13252_n240# divbuf_0/a_13470_n840# 0.02fF
C7758 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_15360_n1600# 0.26fF
C7759 divbuf_2/a_960_n1600# divbuf_2/a_990_n1540# 0.19fF
C7760 divbuf_2/a_18582_170# divbuf_2/OUT4 0.19fF
C7761 divbuf_2/a_990_n840# divbuf_2/a_1470_n840# 0.07fF
C7762 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/a_5310_n840# 0.04fF
C7763 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/a_14222_170# 0.07fF
C7764 divbuf_0/a_14910_n1540# divbuf_0/a_15390_n1540# 0.11fF
C7765 divbuf_0/a_45630_n840# divbuf_0/a_45630_n1540# 0.01fF
C7766 pll_full_0/divbuf_0/a_7230_n1540# pll_full_0/divbuf_0/a_7710_n1540# 0.11fF
C7767 pll_full_0/divbuf_0/a_37950_n840# pll_full_0/divbuf_0/a_37950_n1540# 0.01fF
C7768 divbuf_2/a_53790_n1540# divbuf_2/a_54270_n1540# 0.11fF
C7769 divbuf_3/a_8272_170# divbuf_3/OUT3 0.19fF
C7770 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_16152_n240# 0.05fF
C7771 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/a_35562_n240# 0.01fF
C7772 divbuf_4/a_18092_170# divbuf_4/a_18582_170# 0.07fF
C7773 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/a_19562_n240# 0.04fF
C7774 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/a_38962_n240# 0.01fF
C7775 divbuf_3/a_14702_n240# divbuf_3/a_14910_n840# 0.02fF
C7776 divbuf_3/a_24000_n1600# divbuf_3/a_24480_n1600# 0.26fF
C7777 pd_div_0/divbuf_0/a_27390_n840# pd_div_0/divbuf_0/a_27870_n840# 0.07fF
C7778 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7779 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27390_n1540# 0.19fF
C7780 divbuf_4/a_51360_n1600# divbuf_4/a_51840_n1600# 0.26fF
C7781 divbuf_3/a_47070_n840# divbuf_3/a_47070_n1540# 0.01fF
C7782 divbuf_3/a_16350_n1540# divbuf_3/a_16830_n1540# 0.11fF
C7783 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C7784 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C7785 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7786 pll_full_0/divbuf_1/a_30750_n840# pll_full_0/divbuf_1/a_31230_n840# 0.07fF
C7787 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/a_510_n1540# 0.01fF
C7788 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_30750_n1540# 0.19fF
C7789 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n840# 0.04fF
C7790 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z2 0.01fF
C7791 divbuf_2/a_51360_n1600# divbuf_2/a_51390_n840# 0.04fF
C7792 divbuf_2/a_19562_n240# divbuf_2/OUT4 0.04fF
C7793 divbuf_4/a_43710_n1540# divbuf_4/a_44190_n1540# 0.11fF
C7794 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_4830_n840# 0.04fF
C7795 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C7796 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26880_n1600# 0.26fF
C7797 divbuf_1/a_15672_n240# divbuf_1/a_15870_n840# 0.02fF
C7798 divbuf_1/a_24960_n1600# divbuf_1/a_25440_n1600# 0.26fF
C7799 divbuf_5/a_4392_n240# divbuf_5/a_4350_n840# 0.04fF
C7800 divbuf_5/a_13920_n1600# divbuf_5/a_14400_n1600# 0.26fF
C7801 divbuf_3/a_9242_n240# divbuf_3/OUT3 0.04fF
C7802 ro_div_0/divbuf_0/a_18750_n1540# ro_div_0/divbuf_0/a_19230_n1540# 0.11fF
C7803 ro_div_0/divbuf_0/a_49470_n840# ro_div_0/divbuf_0/a_49470_n1540# 0.01fF
C7804 divbuf_1/a_48030_n840# divbuf_1/a_48030_n1540# 0.01fF
C7805 divbuf_1/a_17310_n1540# divbuf_1/a_17790_n1540# 0.11fF
C7806 divbuf_3/a_13920_n1600# divbuf_3/a_13950_n840# 0.04fF
C7807 divbuf_5/a_36990_n840# divbuf_5/a_36990_n1540# 0.01fF
C7808 divbuf_5/a_6270_n1540# divbuf_5/a_6750_n1540# 0.11fF
C7809 divbuf_0/a_29262_170# divbuf_0/a_29742_170# 0.07fF
C7810 divbuf_2/a_29262_n240# divbuf_2/a_29742_n240# 0.05fF
C7811 divbuf_4/a_41280_n1600# divbuf_4/a_41310_n840# 0.04fF
C7812 divbuf_4/a_38472_170# divbuf_4/OUT4 0.19fF
C7813 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/a_21982_170# 0.07fF
C7814 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/OUT3 0.19fF
C7815 divbuf_0/a_1950_n840# divbuf_0/a_2430_n840# 0.07fF
C7816 divbuf_0/a_20532_170# divbuf_0/OUT4 0.19fF
C7817 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n1540# 0.19fF
C7818 pd_div_0/divider_0/prescaler_0/tspc_0/D pd_div_0/divider_0/clk 0.26fF
C7819 gnd pd_div_0/divider_0/tspc_2/Z2 0.16fF
C7820 divbuf_2/a_40830_n840# divbuf_2/a_41310_n840# 0.07fF
C7821 divbuf_2/a_10590_n840# divbuf_2/a_10590_n1540# 0.01fF
C7822 divbuf_2/a_40800_n1600# divbuf_2/a_40830_n1540# 0.19fF
C7823 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_55200_n1600# 0.26fF
C7824 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16350_n840# 0.04fF
C7825 divbuf_0/a_54750_n1540# divbuf_0/a_55230_n1540# 0.11fF
C7826 divbuf_1/a_5852_170# divbuf_1/OUT3 0.19fF
C7827 divbuf_1/a_14880_n1600# divbuf_1/a_14910_n840# 0.04fF
C7828 divbuf_3/a_30712_170# divbuf_3/a_31202_170# 0.07fF
C7829 divbuf_3/a_11312_170# divbuf_3/a_11312_n240# 0.01fF
C7830 divbuf_5/a_3840_n1600# divbuf_5/a_3870_n840# 0.04fF
C7831 pll_full_0/divbuf_0/a_47070_n1540# pll_full_0/divbuf_0/a_47550_n1540# 0.11fF
C7832 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/a_4350_n840# 0.04fF
C7833 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_14400_n1600# 0.26fF
C7834 divbuf_3/a_3390_n840# divbuf_3/a_3870_n840# 0.07fF
C7835 divbuf_3/a_3360_n1600# divbuf_3/a_3390_n1540# 0.19fF
C7836 divbuf_4/a_38962_170# divbuf_4/a_38962_n240# 0.01fF
C7837 divbuf_4/a_19072_n240# divbuf_4/a_19562_n240# 0.04fF
C7838 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/a_7710_n840# 0.03fF
C7839 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17760_n1600# 0.26fF
C7840 pd_div_0/divbuf_0/a_36990_n840# pd_div_0/divbuf_0/a_36990_n1540# 0.01fF
C7841 pd_div_0/divbuf_0/a_6270_n1540# pd_div_0/divbuf_0/a_6750_n1540# 0.11fF
C7842 divbuf_4/a_30720_n1600# divbuf_4/a_30750_n1540# 0.19fF
C7843 divbuf_4/a_510_n840# divbuf_4/a_510_n1540# 0.01fF
C7844 divbuf_4/a_30750_n840# divbuf_4/a_31230_n840# 0.07fF
C7845 divbuf_4/a_39442_n240# divbuf_4/OUT4 0.04fF
C7846 pll_full_0/divbuf_1/a_9630_n1540# pll_full_0/divbuf_1/a_10110_n1540# 0.11fF
C7847 pll_full_0/divbuf_1/a_40350_n840# pll_full_0/divbuf_1/a_40350_n1540# 0.01fF
C7848 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7849 divbuf_0/a_21502_n240# divbuf_0/OUT4 0.04fF
C7850 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n840# 0.04fF
C7851 divbuf_1/a_28292_170# divbuf_1/a_28772_170# 0.07fF
C7852 divbuf_5/a_20532_170# divbuf_5/a_21012_170# 0.07fF
C7853 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_44670_n840# 0.04fF
C7854 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C7855 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_5790_n1540# 0.19fF
C7856 ro_div_0/divbuf_0/a_5790_n840# ro_div_0/divbuf_0/a_6270_n840# 0.07fF
C7857 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/UP 0.03fF
C7858 divbuf_1/a_4350_n840# divbuf_1/a_4830_n840# 0.07fF
C7859 divbuf_1/a_21982_170# divbuf_1/OUT4 0.19fF
C7860 divbuf_1/a_4320_n1600# divbuf_1/a_4350_n1540# 0.19fF
C7861 divbuf_5/a_2322_170# divbuf_5/OUT3 0.07fF
C7862 divbuf_5/a_53760_n1600# divbuf_5/a_54240_n1600# 0.26fF
C7863 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C7864 divbuf_3/a_55680_n1600# divbuf_3/a_55710_n1540# 0.19fF
C7865 ro_div_0/divbuf_0/a_58590_n1540# ro_div_0/divbuf_0/a_59070_n1540# 0.11fF
C7866 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_3870_n840# 0.04fF
C7867 divbuf_1/a_57150_n1540# divbuf_1/a_57630_n1540# 0.11fF
C7868 divbuf_5/a_46110_n1540# divbuf_5/a_46590_n1540# 0.11fF
C7869 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7230_n840# 0.04fF
C7870 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/a_37992_n240# 0.01fF
C7871 divbuf_3/a_53760_n1600# divbuf_3/a_53790_n840# 0.04fF
C7872 divbuf_0/a_30232_n240# divbuf_0/a_30712_n240# 0.05fF
C7873 divbuf_2/a_27360_n1600# divbuf_2/a_27840_n1600# 0.26fF
C7874 divbuf_2/a_18092_n240# divbuf_2/a_18270_n840# 0.02fF
C7875 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/a_22952_n240# 0.05fF
C7876 gnd pll_full_0/divider_0/nor_1/Z1 0.01fF
C7877 divbuf_0/a_19680_n1600# divbuf_0/OUT4 0.00fF
C7878 divbuf_0/a_11550_n840# divbuf_0/a_11550_n1540# 0.01fF
C7879 divbuf_0/a_41790_n840# divbuf_0/a_42270_n840# 0.07fF
C7880 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n1540# 0.19fF
C7881 divbuf_2/a_50430_n840# divbuf_2/a_50430_n1540# 0.01fF
C7882 divbuf_2/a_19710_n1540# divbuf_2/a_20190_n1540# 0.11fF
C7883 pll_full_0/divbuf_0/a_3870_n840# pll_full_0/divbuf_0/a_3870_n1540# 0.01fF
C7884 pll_full_0/divbuf_0/a_34110_n840# pll_full_0/divbuf_0/a_34590_n840# 0.07fF
C7885 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34110_n1540# 0.19fF
C7886 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56190_n840# 0.04fF
C7887 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7888 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/a_21012_170# 0.07fF
C7889 divbuf_1/a_26352_n240# divbuf_1/OUT4 0.04fF
C7890 divbuf_1/a_54720_n1600# divbuf_1/a_54750_n840# 0.04fF
C7891 divbuf_5/a_3912_n240# divbuf_5/OUT3 0.04fF
C7892 divbuf_5/a_43680_n1600# divbuf_5/a_43710_n840# 0.04fF
C7893 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/a_24412_170# 0.07fF
C7894 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/a_3912_n240# 0.01fF
C7895 divbuf_3/a_31682_n240# divbuf_3/a_32172_n240# 0.04fF
C7896 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C7897 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/OUT3 0.19fF
C7898 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_54240_n1600# 0.26fF
C7899 divbuf_4/a_17280_n1600# divbuf_4/a_17760_n1600# 0.26fF
C7900 divbuf_4/a_7792_n240# divbuf_4/a_7710_n840# 0.03fF
C7901 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57600_n1600# 0.26fF
C7902 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/OUT3 0.19fF
C7903 divbuf_3/a_43200_n1600# divbuf_3/a_43230_n1540# 0.19fF
C7904 divbuf_3/a_43230_n840# divbuf_3/a_43710_n840# 0.07fF
C7905 divbuf_3/a_12990_n840# divbuf_3/a_12990_n1540# 0.01fF
C7906 pd_div_0/divbuf_0/a_46110_n1540# pd_div_0/divbuf_0/a_46590_n1540# 0.11fF
C7907 divbuf_2/a_17280_n1600# divbuf_2/a_17310_n840# 0.04fF
C7908 divbuf_4/a_40350_n840# divbuf_4/a_40350_n1540# 0.01fF
C7909 divbuf_4/a_9630_n1540# divbuf_4/a_10110_n1540# 0.11fF
C7910 pll_full_0/divbuf_1/a_49470_n1540# pll_full_0/divbuf_1/a_49950_n1540# 0.11fF
C7911 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/a_34592_n240# 0.05fF
C7912 divbuf_1/a_32652_n240# divbuf_1/a_33142_n240# 0.04fF
C7913 divbuf_5/a_41382_170# divbuf_5/a_41382_n240# 0.01fF
C7914 divbuf_5/a_21502_n240# divbuf_5/a_21982_n240# 0.05fF
C7915 ro_div_0/divbuf_0/a_15390_n840# ro_div_0/divbuf_0/a_15390_n1540# 0.01fF
C7916 ro_div_0/divbuf_0/a_45630_n840# ro_div_0/divbuf_0/a_46110_n840# 0.07fF
C7917 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_45630_n1540# 0.19fF
C7918 divbuf_1/a_44160_n1600# divbuf_1/a_44190_n1540# 0.19fF
C7919 divbuf_1/a_44190_n840# divbuf_1/a_44670_n840# 0.07fF
C7920 divbuf_1/a_13950_n840# divbuf_1/a_13950_n1540# 0.01fF
C7921 divbuf_1/a_24480_n1600# divbuf_1/OUT4 0.00fF
C7922 divbuf_5/a_33120_n1600# divbuf_5/a_33150_n1540# 0.19fF
C7923 divbuf_5/a_33150_n840# divbuf_5/a_33630_n840# 0.07fF
C7924 divbuf_5/a_2910_n840# divbuf_5/a_2910_n1540# 0.01fF
C7925 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_0/Z2 0.23fF
C7926 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/clk 0.12fF
C7927 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C7928 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_43710_n840# 0.04fF
C7929 divbuf_2/a_14702_170# divbuf_2/a_14702_n240# 0.01fF
C7930 divbuf_2/a_34112_170# divbuf_2/a_34592_170# 0.07fF
C7931 divbuf_4/a_7200_n1600# divbuf_4/a_7230_n840# 0.04fF
C7932 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47070_n840# 0.04fF
C7933 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7934 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/a_6750_n840# 0.03fF
C7935 divbuf_0/a_19072_n240# divbuf_0/a_19230_n840# 0.02fF
C7936 divbuf_0/a_28320_n1600# divbuf_0/a_28800_n1600# 0.26fF
C7937 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11550_n840# 0.02fF
C7938 divbuf_2/a_30232_170# divbuf_2/OUT4 0.19fF
C7939 divbuf_2/a_6750_n840# divbuf_2/a_7230_n840# 0.07fF
C7940 divbuf_2/a_6720_n1600# divbuf_2/a_6750_n1540# 0.19fF
C7941 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_21120_n1600# 0.26fF
C7942 divbuf_0/a_20670_n1540# divbuf_0/a_21150_n1540# 0.11fF
C7943 divbuf_0/a_51390_n840# divbuf_0/a_51390_n1540# 0.01fF
C7944 divbuf_2/a_59550_n1540# divbuf_2/a_60030_n1540# 0.11fF
C7945 pll_full_0/divbuf_0/a_43710_n840# pll_full_0/divbuf_0/a_43710_n1540# 0.01fF
C7946 pll_full_0/divbuf_0/a_12990_n1540# pll_full_0/divbuf_0/a_13470_n1540# 0.11fF
C7947 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C7948 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C7949 divbuf_3/a_20042_170# divbuf_3/OUT4 0.19fF
C7950 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/a_41382_n240# 0.01fF
C7951 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/a_21982_n240# 0.05fF
C7952 divbuf_4/a_3912_170# divbuf_4/a_3912_n240# 0.01fF
C7953 divbuf_4/a_23922_170# divbuf_4/a_24412_170# 0.07fF
C7954 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/a_25382_n240# 0.04fF
C7955 divbuf_3/a_29760_n1600# divbuf_3/a_30240_n1600# 0.26fF
C7956 divbuf_3/a_20532_n240# divbuf_3/a_20670_n840# 0.03fF
C7957 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C7958 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33150_n1540# 0.19fF
C7959 pd_div_0/divbuf_0/a_33150_n840# pd_div_0/divbuf_0/a_33630_n840# 0.07fF
C7960 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/a_2910_n1540# 0.01fF
C7961 divbuf_4/a_9732_170# divbuf_4/OUT3 0.19fF
C7962 divbuf_4/a_57120_n1600# divbuf_4/a_57600_n1600# 0.26fF
C7963 pll_full_0/divbuf_1/a_6270_n840# pll_full_0/divbuf_1/a_6270_n1540# 0.01fF
C7964 pll_full_0/divbuf_1/a_36510_n840# pll_full_0/divbuf_1/a_36990_n840# 0.07fF
C7965 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36510_n1540# 0.19fF
C7966 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C7967 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/a_14702_170# 0.07fF
C7968 divbuf_3/a_22110_n1540# divbuf_3/a_22590_n1540# 0.11fF
C7969 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C7970 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n840# 0.04fF
C7971 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 0.22fF
C7972 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C7973 divbuf_4/a_49470_n1540# divbuf_4/a_49950_n1540# 0.11fF
C7974 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C7975 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_10590_n840# 0.04fF
C7976 divbuf_2/a_31202_n240# divbuf_2/OUT4 0.04fF
C7977 divbuf_2/a_57120_n1600# divbuf_2/a_57150_n840# 0.04fF
C7978 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C7979 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C7980 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/a_23070_n840# 0.03fF
C7981 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32640_n1600# 0.26fF
C7982 divbuf_1/a_30720_n1600# divbuf_1/a_31200_n1600# 0.26fF
C7983 divbuf_1/a_21502_n240# divbuf_1/a_21630_n840# 0.03fF
C7984 divbuf_5/a_19680_n1600# divbuf_5/a_20160_n1600# 0.26fF
C7985 divbuf_5/a_10212_n240# divbuf_5/a_10110_n840# 0.03fF
C7986 divbuf_3/a_21012_n240# divbuf_3/OUT4 0.04fF
C7987 ro_div_0/divbuf_0/a_24510_n1540# ro_div_0/divbuf_0/a_24990_n1540# 0.11fF
C7988 ro_div_0/divbuf_0/a_55230_n840# ro_div_0/divbuf_0/a_55230_n1540# 0.01fF
C7989 divbuf_1/a_53790_n840# divbuf_1/a_53790_n1540# 0.01fF
C7990 divbuf_1/a_23070_n1540# divbuf_1/a_23550_n1540# 0.11fF
C7991 divbuf_3/a_19680_n1600# divbuf_3/a_19710_n840# 0.04fF
C7992 divbuf_5/a_42750_n840# divbuf_5/a_42750_n1540# 0.01fF
C7993 divbuf_5/a_12030_n1540# divbuf_5/a_12510_n1540# 0.11fF
C7994 divbuf_0/a_35082_170# divbuf_0/a_35562_170# 0.07fF
C7995 divbuf_4/a_10212_n240# divbuf_4/OUT4 0.04fF
C7996 divbuf_4/a_47040_n1600# divbuf_4/a_47070_n840# 0.04fF
C7997 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/OUT3 0.19fF
C7998 divbuf_2/a_35082_n240# divbuf_2/a_35562_n240# 0.05fF
C7999 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/a_27802_170# 0.07fF
C8000 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/a_14222_n240# 0.01fF
C8001 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/a_6822_n240# 0.01fF
C8002 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/a_12282_170# 0.07fF
C8003 divbuf_0/a_7710_n840# divbuf_0/a_8190_n840# 0.07fF
C8004 divbuf_0/a_32172_170# divbuf_0/OUT4 0.19fF
C8005 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n1540# 0.19fF
C8006 divbuf_1/a_18092_170# divbuf_1/a_18092_n240# 0.01fF
C8007 divbuf_2/a_46560_n1600# divbuf_2/a_46590_n1540# 0.19fF
C8008 divbuf_2/a_46590_n840# divbuf_2/a_47070_n840# 0.07fF
C8009 divbuf_2/a_16350_n840# divbuf_2/a_16350_n1540# 0.01fF
C8010 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8011 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/a_7792_n240# 0.04fF
C8012 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22110_n840# 0.04fF
C8013 divbuf_0/a_60510_n1540# divbuf_0/a_60990_n1540# 0.11fF
C8014 pll_full_0/divbuf_0/a_52830_n1540# pll_full_0/divbuf_0/a_53310_n1540# 0.11fF
C8015 divbuf_1/a_20640_n1600# divbuf_1/a_20670_n840# 0.04fF
C8016 divbuf_3/a_17122_170# divbuf_3/a_17122_n240# 0.01fF
C8017 divbuf_3/a_36532_170# divbuf_3/a_37022_170# 0.07fF
C8018 divbuf_5/a_9600_n1600# divbuf_5/a_9630_n840# 0.04fF
C8019 divbuf_3/a_19200_n1600# divbuf_3/OUT4 0.00fF
C8020 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_20160_n1600# 0.26fF
C8021 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/a_10110_n840# 0.03fF
C8022 divbuf_4/a_24892_n240# divbuf_4/a_25382_n240# 0.04fF
C8023 divbuf_3/a_9120_n1600# divbuf_3/a_9150_n1540# 0.19fF
C8024 divbuf_3/a_9150_n840# divbuf_3/a_9630_n840# 0.07fF
C8025 divbuf_5/a_60990_n840# divbuf_5/OUT5 0.04fF
C8026 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23520_n1600# 0.26fF
C8027 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_13950_n840# 0.02fF
C8028 pd_div_0/divbuf_0/a_42750_n840# pd_div_0/divbuf_0/a_42750_n1540# 0.01fF
C8029 pd_div_0/divbuf_0/a_12030_n1540# pd_div_0/divbuf_0/a_12510_n1540# 0.11fF
C8030 divbuf_4/a_9600_n1600# divbuf_4/OUT3 0.00fF
C8031 divbuf_4/a_36480_n1600# divbuf_4/a_36510_n1540# 0.19fF
C8032 divbuf_4/a_36510_n840# divbuf_4/a_36990_n840# 0.07fF
C8033 divbuf_4/a_6270_n840# divbuf_4/a_6270_n1540# 0.01fF
C8034 pll_full_0/divbuf_1/a_15390_n1540# pll_full_0/divbuf_1/a_15870_n1540# 0.11fF
C8035 pll_full_0/divbuf_1/a_46110_n840# pll_full_0/divbuf_1/a_46110_n1540# 0.01fF
C8036 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C8037 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n840# 0.04fF
C8038 divbuf_0/a_33142_n240# divbuf_0/OUT4 0.04fF
C8039 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8040 divbuf_1/a_37502_170# divbuf_1/a_37992_170# 0.07fF
C8041 divbuf_5/a_6332_170# divbuf_5/a_6332_n240# 0.01fF
C8042 divbuf_5/a_26352_170# divbuf_5/a_26832_170# 0.07fF
C8043 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50430_n840# 0.04fF
C8044 ro_div_0/divbuf_0/a_11550_n840# ro_div_0/divbuf_0/a_12030_n840# 0.07fF
C8045 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_11550_n1540# 0.19fF
C8046 divbuf_1/a_10080_n1600# divbuf_1/a_10110_n1540# 0.19fF
C8047 divbuf_1/a_37022_170# divbuf_1/OUT4 0.19fF
C8048 divbuf_1/a_10110_n840# divbuf_1/a_10590_n840# 0.07fF
C8049 divbuf_5/a_14702_170# divbuf_5/OUT4 0.19fF
C8050 divbuf_5/a_59520_n1600# divbuf_5/a_60000_n1600# 0.26fF
C8051 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_9630_n840# 0.04fF
C8052 divbuf_1/OUT2 divbuf_1/OUT3 0.36fF
C8053 divbuf_3/a_59520_n1600# divbuf_3/a_59550_n840# 0.04fF
C8054 divbuf_5/a_51870_n1540# divbuf_5/a_52350_n1540# 0.11fF
C8055 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_12990_n840# 0.04fF
C8056 divbuf_0/a_36052_n240# divbuf_0/a_36532_n240# 0.05fF
C8057 pd_div_0/divbuf_0/a_60990_n840# pd_div_0/divbuf_0/OUT5 0.04fF
C8058 divbuf_2/a_33120_n1600# divbuf_2/a_33600_n1600# 0.26fF
C8059 divbuf_2/a_23922_n240# divbuf_2/a_24030_n840# 0.03fF
C8060 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/a_28772_n240# 0.05fF
C8061 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.17fF
C8062 divbuf_0/a_17310_n840# divbuf_0/a_17310_n1540# 0.01fF
C8063 divbuf_0/a_47550_n840# divbuf_0/a_48030_n840# 0.07fF
C8064 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n1540# 0.19fF
C8065 divbuf_0/a_31200_n1600# divbuf_0/OUT4 0.00fF
C8066 divbuf_2/a_56190_n840# divbuf_2/a_56190_n1540# 0.01fF
C8067 divbuf_2/a_25470_n1540# divbuf_2/a_25950_n1540# 0.11fF
C8068 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_39870_n1540# 0.19fF
C8069 pll_full_0/divbuf_0/a_39870_n840# pll_full_0/divbuf_0/a_40350_n840# 0.07fF
C8070 pll_full_0/divbuf_0/a_9630_n840# pll_full_0/divbuf_0/a_9630_n1540# 0.01fF
C8071 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8072 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/a_26832_170# 0.07fF
C8073 divbuf_1/a_60480_n1600# divbuf_1/a_60510_n840# 0.04fF
C8074 divbuf_1/a_37992_n240# divbuf_1/OUT4 0.04fF
C8075 divbuf_3/a_37502_n240# divbuf_3/a_37992_n240# 0.04fF
C8076 divbuf_3/a_52830_n1540# divbuf_3/a_53310_n1540# 0.11fF
C8077 divbuf_5/a_49440_n1600# divbuf_5/a_49470_n840# 0.04fF
C8078 divbuf_5/a_15672_n240# divbuf_5/OUT4 0.04fF
C8079 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/a_9732_n240# 0.01fF
C8080 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/a_30232_170# 0.07fF
C8081 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/nor_0/B 0.06fF
C8082 pd_div_0/divbuf_0/a_12282_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8083 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_60000_n1600# 0.26fF
C8084 divbuf_4/a_13742_n240# divbuf_4/a_13950_n840# 0.02fF
C8085 divbuf_4/a_23040_n1600# divbuf_4/a_23520_n1600# 0.26fF
C8086 pll_full_0/divbuf_1/a_2430_n840# pll_full_0/divbuf_1/a_2910_n840# 0.07fF
C8087 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8088 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2430_n1540# 0.19fF
C8089 divbuf_3/a_48990_n840# divbuf_3/a_49470_n840# 0.07fF
C8090 divbuf_3/a_18750_n840# divbuf_3/a_18750_n1540# 0.01fF
C8091 divbuf_3/a_48960_n1600# divbuf_3/a_48990_n1540# 0.19fF
C8092 pd_div_0/divbuf_0/a_51870_n1540# pd_div_0/divbuf_0/a_52350_n1540# 0.11fF
C8093 divbuf_2/a_1352_170# divbuf_2/OUT2 0.23fF
C8094 divbuf_2/a_23040_n1600# divbuf_2/a_23070_n840# 0.04fF
C8095 divbuf_4/a_46110_n840# divbuf_4/a_46110_n1540# 0.01fF
C8096 divbuf_4/a_15390_n1540# divbuf_4/a_15870_n1540# 0.11fF
C8097 pll_full_0/divbuf_1/a_55230_n1540# pll_full_0/divbuf_1/a_55710_n1540# 0.11fF
C8098 divbuf_0/a_10590_n840# divbuf_0/OUT4 0.03fF
C8099 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/a_40412_n240# 0.05fF
C8100 divbuf_1/a_38472_n240# divbuf_1/a_38962_n240# 0.04fF
C8101 divbuf_5/a_27322_n240# divbuf_5/a_27802_n240# 0.05fF
C8102 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51390_n1540# 0.19fF
C8103 ro_div_0/divbuf_0/a_21150_n840# ro_div_0/divbuf_0/a_21150_n1540# 0.01fF
C8104 ro_div_0/divbuf_0/a_51390_n840# ro_div_0/divbuf_0/a_51870_n840# 0.07fF
C8105 divbuf_1/a_49950_n840# divbuf_1/a_50430_n840# 0.07fF
C8106 divbuf_1/a_19710_n840# divbuf_1/a_19710_n1540# 0.01fF
C8107 divbuf_1/a_36000_n1600# divbuf_1/OUT4 0.00fF
C8108 divbuf_1/a_49920_n1600# divbuf_1/a_49950_n1540# 0.19fF
C8109 divbuf_5/a_38910_n840# divbuf_5/a_39390_n840# 0.07fF
C8110 divbuf_5/a_8670_n840# divbuf_5/a_8670_n1540# 0.01fF
C8111 divbuf_5/a_38880_n1600# divbuf_5/a_38910_n1540# 0.19fF
C8112 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49470_n840# 0.04fF
C8113 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8114 divbuf_2/a_39932_170# divbuf_2/a_40412_170# 0.07fF
C8115 divbuf_2/a_20532_170# divbuf_2/a_20532_n240# 0.01fF
C8116 divbuf_4/a_12960_n1600# divbuf_4/a_12990_n840# 0.04fF
C8117 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8118 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_52830_n840# 0.04fF
C8119 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_12990_n840# 0.02fF
C8120 divbuf_0/a_34080_n1600# divbuf_0/a_34560_n1600# 0.26fF
C8121 divbuf_0/a_24892_n240# divbuf_0/a_24990_n840# 0.03fF
C8122 divbuf_2/a_41382_170# divbuf_2/OUT5 0.07fF
C8123 divbuf_2/a_2322_n240# divbuf_2/OUT2 0.04fF
C8124 divbuf_2/a_12480_n1600# divbuf_2/a_12510_n1540# 0.19fF
C8125 divbuf_2/a_12510_n840# divbuf_2/a_12990_n840# 0.07fF
C8126 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C8127 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26880_n1600# 0.26fF
C8128 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_17310_n840# 0.02fF
C8129 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C8130 divbuf_0/a_26430_n1540# divbuf_0/a_26910_n1540# 0.11fF
C8131 divbuf_0/a_57150_n840# divbuf_0/a_57150_n1540# 0.01fF
C8132 pll_full_0/divbuf_0/a_18750_n1540# pll_full_0/divbuf_0/a_19230_n1540# 0.11fF
C8133 pll_full_0/divbuf_0/a_49470_n840# pll_full_0/divbuf_0/a_49470_n1540# 0.01fF
C8134 divbuf_3/a_31682_170# divbuf_3/OUT4 0.19fF
C8135 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/a_27802_n240# 0.05fF
C8136 divbuf_4/a_29742_170# divbuf_4/a_30232_170# 0.07fF
C8137 divbuf_4/a_9732_170# divbuf_4/a_9732_n240# 0.01fF
C8138 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/a_31202_n240# 0.04fF
C8139 divbuf_3/a_26352_n240# divbuf_3/a_26430_n840# 0.04fF
C8140 divbuf_3/a_35520_n1600# divbuf_3/a_36000_n1600# 0.26fF
C8141 pd_div_0/divbuf_0/a_38910_n840# pd_div_0/divbuf_0/a_39390_n840# 0.07fF
C8142 pd_div_0/divbuf_0/a_8670_n840# pd_div_0/divbuf_0/a_8670_n1540# 0.01fF
C8143 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_38910_n1540# 0.19fF
C8144 divbuf_4/a_2400_n1600# divbuf_4/a_2430_n1540# 0.19fF
C8145 divbuf_4/a_21502_170# divbuf_4/OUT4 0.19fF
C8146 divbuf_4/a_2430_n840# divbuf_4/a_2910_n840# 0.07fF
C8147 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C8148 pll_full_0/divbuf_1/a_12030_n840# pll_full_0/divbuf_1/a_12030_n1540# 0.01fF
C8149 pll_full_0/divbuf_1/a_42270_n840# pll_full_0/divbuf_1/a_42750_n840# 0.07fF
C8150 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42270_n1540# 0.19fF
C8151 divbuf_3/a_27870_n1540# divbuf_3/a_28350_n1540# 0.11fF
C8152 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n840# 0.04fF
C8153 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/clk 0.45fF
C8154 pd_div_0/divider_0/tspc_1/Z3 gnd 0.27fF
C8155 divbuf_1/a_14702_170# divbuf_1/a_15182_170# 0.07fF
C8156 divbuf_4/a_55230_n1540# divbuf_4/a_55710_n1540# 0.11fF
C8157 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/Out 0.28fF
C8158 divbuf_2/a_1920_n1600# divbuf_2/OUT2 0.00fF
C8159 divbuf_2/a_0_n1600# io_analog[10] 0.26fF
C8160 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16350_n840# 0.04fF
C8161 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/a_28830_n840# 0.04fF
C8162 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_38400_n1600# 0.26fF
C8163 divbuf_1/a_27322_n240# divbuf_1/a_27390_n840# 0.04fF
C8164 divbuf_1/a_36480_n1600# divbuf_1/a_36960_n1600# 0.26fF
C8165 divbuf_5/a_16152_n240# divbuf_5/a_16350_n840# 0.02fF
C8166 divbuf_5/a_25440_n1600# divbuf_5/a_25920_n1600# 0.26fF
C8167 divbuf_3/a_32652_n240# divbuf_3/OUT4 0.04fF
C8168 ro_div_0/divbuf_0/a_30270_n1540# ro_div_0/divbuf_0/a_30750_n1540# 0.11fF
C8169 ro_div_0/divbuf_0/a_60990_n840# ro_div_0/divbuf_0/a_60990_n1540# 0.01fF
C8170 divbuf_1/a_59550_n840# divbuf_1/a_59550_n1540# 0.01fF
C8171 divbuf_1/a_28830_n1540# divbuf_1/a_29310_n1540# 0.11fF
C8172 divbuf_3/a_25440_n1600# divbuf_3/a_25470_n840# 0.04fF
C8173 divbuf_5/a_48510_n840# divbuf_5/a_48510_n1540# 0.01fF
C8174 divbuf_5/a_17790_n1540# divbuf_5/a_18270_n1540# 0.11fF
C8175 divbuf_0/a_21502_170# divbuf_0/a_21502_n240# 0.01fF
C8176 divbuf_0/a_40902_170# divbuf_0/a_41382_170# 0.07fF
C8177 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C8178 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C8179 divbuf_4/a_52800_n1600# divbuf_4/a_52830_n840# 0.04fF
C8180 divbuf_4/a_22472_n240# divbuf_4/OUT4 0.04fF
C8181 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/OUT2 0.02fF
C8182 divbuf_2/a_40902_n240# divbuf_2/a_41382_n240# 0.05fF
C8183 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/a_33622_170# 0.07fF
C8184 divbuf_0/a_13470_n840# divbuf_0/a_13950_n840# 0.07fF
C8185 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n1540# 0.19fF
C8186 divbuf_0/a_4392_n240# divbuf_0/OUT3 0.04fF
C8187 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8188 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_5790_n1540# 0.19fF
C8189 divbuf_2/a_52320_n1600# divbuf_2/a_52350_n1540# 0.19fF
C8190 divbuf_2/a_52350_n840# divbuf_2/a_52830_n840# 0.07fF
C8191 divbuf_2/a_22110_n840# divbuf_2/a_22110_n1540# 0.01fF
C8192 pll_full_0/divbuf_0/a_5790_n840# pll_full_0/divbuf_0/a_6270_n840# 0.07fF
C8193 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_14222_n240# 0.05fF
C8194 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_27870_n840# 0.04fF
C8195 divbuf_1/a_26400_n1600# divbuf_1/a_26430_n840# 0.04fF
C8196 divbuf_3/a_22952_170# divbuf_3/a_22952_n240# 0.01fF
C8197 divbuf_3/a_1842_n240# divbuf_3/a_2322_n240# 0.05fF
C8198 divbuf_5/a_15360_n1600# divbuf_5/a_15390_n840# 0.04fF
C8199 pll_full_0/divbuf_0/a_58590_n1540# pll_full_0/divbuf_0/a_59070_n1540# 0.11fF
C8200 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_16350_n840# 0.02fF
C8201 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25920_n1600# 0.26fF
C8202 divbuf_4/a_30712_n240# divbuf_4/a_31202_n240# 0.04fF
C8203 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/a_19710_n840# 0.03fF
C8204 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_29280_n1600# 0.26fF
C8205 divbuf_3/a_14910_n840# divbuf_3/a_15390_n840# 0.07fF
C8206 divbuf_3/a_14880_n1600# divbuf_3/a_14910_n1540# 0.19fF
C8207 pd_div_0/divbuf_0/a_48510_n840# pd_div_0/divbuf_0/a_48510_n1540# 0.01fF
C8208 pd_div_0/divbuf_0/a_17790_n1540# pd_div_0/divbuf_0/a_18270_n1540# 0.11fF
C8209 divbuf_4/a_42240_n1600# divbuf_4/a_42270_n1540# 0.19fF
C8210 divbuf_4/a_42270_n840# divbuf_4/a_42750_n840# 0.07fF
C8211 divbuf_4/a_12030_n840# divbuf_4/a_12030_n1540# 0.01fF
C8212 divbuf_4/a_20640_n1600# divbuf_4/OUT4 0.00fF
C8213 pll_full_0/divbuf_1/a_21150_n1540# pll_full_0/divbuf_1/a_21630_n1540# 0.11fF
C8214 pll_full_0/divbuf_1/a_51870_n840# pll_full_0/divbuf_1/a_51870_n1540# 0.01fF
C8215 ashish_0/a_150_n710# ashish_0/von 4.33fF
C8216 divbuf_1/a_3422_n240# divbuf_1/a_3912_n240# 0.04fF
C8217 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56190_n840# 0.04fF
C8218 divbuf_5/a_32172_170# divbuf_5/a_32652_170# 0.07fF
C8219 divbuf_5/a_12772_170# divbuf_5/a_12772_n240# 0.01fF
C8220 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8221 pd_0/DOWN pd_0/UP 2.19fF
C8222 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17310_n1540# 0.19fF
C8223 ro_div_0/divbuf_0/a_17310_n840# ro_div_0/divbuf_0/a_17790_n840# 0.07fF
C8224 ro_div_0/divider_0/tspc_2/Z4 gnd 0.44fF
C8225 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C8226 divbuf_1/a_15870_n840# divbuf_1/a_16350_n840# 0.07fF
C8227 divbuf_1/a_9242_n240# divbuf_1/OUT3 0.04fF
C8228 divbuf_1/a_15840_n1600# divbuf_1/a_15870_n1540# 0.19fF
C8229 divbuf_5/a_4830_n840# divbuf_5/a_5310_n840# 0.07fF
C8230 divbuf_5/a_4800_n1600# divbuf_5/a_4830_n1540# 0.19fF
C8231 divbuf_5/a_26352_170# divbuf_5/OUT4 0.19fF
C8232 divbuf_0/a_19072_170# divbuf_0/a_19562_170# 0.07fF
C8233 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15390_n840# 0.04fF
C8234 divbuf_2/a_4882_170# divbuf_2/a_5362_170# 0.07fF
C8235 divbuf_5/a_57630_n1540# divbuf_5/a_58110_n1540# 0.11fF
C8236 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_18750_n840# 0.04fF
C8237 divbuf_0/a_0_n1600# divbuf_0/a_480_n1600# 0.26fF
C8238 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/a_34592_n240# 0.05fF
C8239 divbuf_2/a_38880_n1600# divbuf_2/a_39360_n1600# 0.26fF
C8240 divbuf_2/a_29742_n240# divbuf_2/a_29790_n840# 0.04fF
C8241 divbuf_4/a_990_n840# divbuf_4/OUT2 0.02fF
C8242 divbuf_0/a_23070_n840# divbuf_0/a_23070_n1540# 0.01fF
C8243 divbuf_0/a_53310_n840# divbuf_0/a_53790_n840# 0.07fF
C8244 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n1540# 0.19fF
C8245 pll_full_0/divbuf_0/a_15390_n840# pll_full_0/divbuf_0/a_15390_n1540# 0.01fF
C8246 pll_full_0/divbuf_0/a_45630_n840# pll_full_0/divbuf_0/a_46110_n840# 0.07fF
C8247 divbuf_2/a_31230_n1540# divbuf_2/a_31710_n1540# 0.11fF
C8248 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_45630_n1540# 0.19fF
C8249 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C8250 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/a_32652_170# 0.07fF
C8251 divbuf_3/a_58590_n1540# divbuf_3/a_59070_n1540# 0.11fF
C8252 divbuf_3/a_1440_n1600# divbuf_3/a_1920_n1600# 0.26fF
C8253 divbuf_5/a_27322_n240# divbuf_5/OUT4 0.04fF
C8254 divbuf_5/a_55200_n1600# divbuf_5/a_55230_n840# 0.04fF
C8255 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/a_36052_170# 0.07fF
C8256 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/a_16152_n240# 0.01fF
C8257 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/and_0/B 0.18fF
C8258 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/nor_0/B 0.47fF
C8259 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z2 0.36fF
C8260 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_0/Z3 0.05fF
C8261 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C8262 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/clk 0.01fF
C8263 pd_div_0/divbuf_0/a_4830_n840# pd_div_0/divbuf_0/a_5310_n840# 0.07fF
C8264 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_4830_n1540# 0.19fF
C8265 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8266 divbuf_4/a_28800_n1600# divbuf_4/a_29280_n1600# 0.26fF
C8267 divbuf_4/a_19562_n240# divbuf_4/a_19710_n840# 0.03fF
C8268 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C8269 pll_full_0/divbuf_1/a_8190_n840# pll_full_0/divbuf_1/a_8670_n840# 0.07fF
C8270 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8271 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8190_n1540# 0.19fF
C8272 divbuf_3/a_54750_n840# divbuf_3/a_55230_n840# 0.07fF
C8273 divbuf_3/a_24510_n840# divbuf_3/a_24510_n1540# 0.01fF
C8274 pd_div_0/divbuf_0/a_57630_n1540# pd_div_0/divbuf_0/a_58110_n1540# 0.11fF
C8275 divbuf_2/a_28800_n1600# divbuf_2/a_28830_n840# 0.04fF
C8276 divbuf_2/a_13252_170# divbuf_2/OUT4 0.19fF
C8277 divbuf_4/a_51870_n840# divbuf_4/a_51870_n1540# 0.01fF
C8278 divbuf_4/a_21150_n1540# divbuf_4/a_21630_n1540# 0.11fF
C8279 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/a_2430_n840# 0.03fF
C8280 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_4320_n1600# 0.26fF
C8281 divbuf_1/a_2400_n1600# divbuf_1/a_2880_n1600# 0.26fF
C8282 divbuf_5/a_33142_n240# divbuf_5/a_33622_n240# 0.05fF
C8283 divbuf_3/a_2322_170# divbuf_3/OUT3 0.07fF
C8284 ro_div_0/divbuf_0/a_26910_n840# ro_div_0/divbuf_0/a_26910_n1540# 0.01fF
C8285 ro_div_0/divbuf_0/a_57150_n840# ro_div_0/divbuf_0/a_57630_n840# 0.07fF
C8286 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57150_n1540# 0.19fF
C8287 divbuf_1/a_55680_n1600# divbuf_1/a_55710_n1540# 0.19fF
C8288 divbuf_1/a_55710_n840# divbuf_1/a_56190_n840# 0.07fF
C8289 divbuf_1/a_25470_n840# divbuf_1/a_25470_n1540# 0.01fF
C8290 divbuf_3/a_12282_n240# divbuf_3/a_12030_n840# 0.02fF
C8291 divbuf_5/a_44640_n1600# divbuf_5/a_44670_n1540# 0.19fF
C8292 divbuf_5/a_44670_n840# divbuf_5/a_45150_n840# 0.07fF
C8293 divbuf_5/a_14430_n840# divbuf_5/a_14430_n1540# 0.01fF
C8294 divbuf_0/a_5362_170# divbuf_0/a_4882_170# 0.07fF
C8295 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8296 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55230_n840# 0.04fF
C8297 divbuf_2/a_26352_170# divbuf_2/a_26352_n240# 0.01fF
C8298 divbuf_2/a_5852_n240# divbuf_2/a_6332_n240# 0.05fF
C8299 divbuf_4/a_18720_n1600# divbuf_4/a_18750_n840# 0.04fF
C8300 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_58590_n840# 0.04fF
C8301 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8302 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/a_18750_n840# 0.02fF
C8303 divbuf_0/a_30712_n240# divbuf_0/a_30750_n840# 0.05fF
C8304 divbuf_0/a_39840_n1600# divbuf_0/a_40320_n1600# 0.26fF
C8305 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C8306 divbuf_2/a_18270_n840# divbuf_2/a_18750_n840# 0.07fF
C8307 divbuf_2/a_14222_n240# divbuf_2/OUT4 0.04fF
C8308 divbuf_2/a_18240_n1600# divbuf_2/a_18270_n1540# 0.19fF
C8309 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/a_23070_n840# 0.03fF
C8310 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32640_n1600# 0.26fF
C8311 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C8312 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C8313 divbuf_0/a_32190_n1540# divbuf_0/a_32670_n1540# 0.11fF
C8314 divbuf_1/a_13252_n240# divbuf_1/a_12990_n840# 0.01fF
C8315 divbuf_3/a_7302_170# divbuf_3/a_7792_170# 0.07fF
C8316 divbuf_5/a_1352_n240# divbuf_5/a_1470_n840# 0.03fF
C8317 pll_full_0/divbuf_0/a_55230_n840# pll_full_0/divbuf_0/a_55230_n1540# 0.01fF
C8318 pll_full_0/divbuf_0/a_24510_n1540# pll_full_0/divbuf_0/a_24990_n1540# 0.11fF
C8319 divbuf_3/a_3912_n240# divbuf_3/OUT3 0.04fF
C8320 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/a_33622_n240# 0.05fF
C8321 divbuf_4/a_16152_170# divbuf_4/a_16152_n240# 0.01fF
C8322 divbuf_4/a_35562_170# divbuf_4/a_36052_170# 0.07fF
C8323 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/a_37022_n240# 0.04fF
C8324 divbuf_3/a_41280_n1600# divbuf_3/a_41760_n1600# 0.26fF
C8325 divbuf_3/a_32172_n240# divbuf_3/a_32190_n840# 0.06fF
C8326 divbuf_0/a_4882_170# divbuf_0/a_4882_n240# 0.01fF
C8327 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_44670_n1540# 0.19fF
C8328 pd_div_0/divbuf_0/a_44670_n840# pd_div_0/divbuf_0/a_45150_n840# 0.07fF
C8329 pd_div_0/divbuf_0/a_14430_n840# pd_div_0/divbuf_0/a_14430_n1540# 0.01fF
C8330 divbuf_4/a_8160_n1600# divbuf_4/a_8190_n1540# 0.19fF
C8331 divbuf_4/a_33142_170# divbuf_4/OUT4 0.19fF
C8332 divbuf_4/a_8190_n840# divbuf_4/a_8670_n840# 0.07fF
C8333 pll_full_0/divbuf_1/a_17790_n840# pll_full_0/divbuf_1/a_17790_n1540# 0.01fF
C8334 pll_full_0/divbuf_1/a_48030_n840# pll_full_0/divbuf_1/a_48510_n840# 0.07fF
C8335 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48030_n1540# 0.19fF
C8336 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C8337 divbuf_3/a_33630_n1540# divbuf_3/a_34110_n1540# 0.11fF
C8338 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C8339 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/a_3422_n240# 0.01fF
C8340 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/a_20042_170# 0.07fF
C8341 divbuf_0/a_7302_170# divbuf_0/OUT3 0.19fF
C8342 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n840# 0.04fF
C8343 pd_div_0/divider_0/prescaler_0/tspc_0/Q gnd 0.35fF
C8344 divbuf_2/a_12480_n1600# divbuf_2/OUT4 0.00fF
C8345 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C8346 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/Out 0.91fF
C8347 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22110_n840# 0.04fF
C8348 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/a_34590_n840# 0.06fF
C8349 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_44160_n1600# 0.26fF
C8350 divbuf_1/a_31202_170# divbuf_1/OUT4 0.19fF
C8351 divbuf_1/a_42240_n1600# divbuf_1/a_42720_n1600# 0.26fF
C8352 divbuf_1/a_33142_n240# divbuf_1/a_33150_n840# 0.06fF
C8353 divbuf_5/a_31200_n1600# divbuf_5/a_31680_n1600# 0.26fF
C8354 divbuf_5/a_21982_n240# divbuf_5/a_22110_n840# 0.03fF
C8355 ro_div_0/divbuf_0/a_36030_n1540# ro_div_0/divbuf_0/a_36510_n1540# 0.11fF
C8356 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/a_1470_n840# 0.03fF
C8357 divbuf_1/a_34590_n1540# divbuf_1/a_35070_n1540# 0.11fF
C8358 divbuf_3/a_31200_n1600# divbuf_3/a_31230_n840# 0.04fF
C8359 divbuf_5/a_54270_n840# divbuf_5/a_54270_n1540# 0.01fF
C8360 divbuf_5/a_23550_n1540# divbuf_5/a_24030_n1540# 0.11fF
C8361 divbuf_0/a_6822_n240# divbuf_0/a_7302_n240# 0.05fF
C8362 divbuf_0/a_27322_170# divbuf_0/a_27322_n240# 0.01fF
C8363 divbuf_2/a_4800_n1600# divbuf_2/a_5280_n1600# 0.26fF
C8364 divbuf_4/a_34112_n240# divbuf_4/OUT4 0.04fF
C8365 divbuf_4/a_58560_n1600# divbuf_4/a_58590_n840# 0.04fF
C8366 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8367 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/a_39442_170# 0.07fF
C8368 divbuf_0/a_16152_n240# divbuf_0/OUT4 0.04fF
C8369 divbuf_0/a_19230_n840# divbuf_0/a_19710_n840# 0.07fF
C8370 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n1540# 0.19fF
C8371 pll_full_0/divbuf_0/a_11550_n840# pll_full_0/divbuf_0/a_12030_n840# 0.07fF
C8372 divbuf_2/a_58080_n1600# divbuf_2/a_58110_n1540# 0.19fF
C8373 divbuf_2/a_58110_n840# divbuf_2/a_58590_n840# 0.07fF
C8374 divbuf_2/a_27870_n840# divbuf_2/a_27870_n1540# 0.01fF
C8375 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_11550_n1540# 0.19fF
C8376 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8377 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/a_20042_n240# 0.05fF
C8378 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_33630_n840# 0.04fF
C8379 pd_div_0/pd_0/R pd_div_0/pd_0/REF 0.61fF
C8380 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/a_1352_170# 0.07fF
C8381 divbuf_1/a_32160_n1600# divbuf_1/a_32190_n840# 0.04fF
C8382 divbuf_3/a_28772_170# divbuf_3/a_28772_n240# 0.01fF
C8383 divbuf_3/a_8272_n240# divbuf_3/a_8762_n240# 0.04fF
C8384 divbuf_5/a_21120_n1600# divbuf_5/a_21150_n840# 0.04fF
C8385 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31680_n1600# 0.26fF
C8386 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/a_22110_n840# 0.03fF
C8387 divbuf_4/a_36532_n240# divbuf_4/a_37022_n240# 0.04fF
C8388 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_35040_n1600# 0.26fF
C8389 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/a_25470_n840# 0.03fF
C8390 divbuf_3/a_20640_n1600# divbuf_3/a_20670_n1540# 0.19fF
C8391 divbuf_3/a_20670_n840# divbuf_3/a_21150_n840# 0.07fF
C8392 pd_div_0/divbuf_0/a_54270_n840# pd_div_0/divbuf_0/a_54270_n1540# 0.01fF
C8393 pd_div_0/divbuf_0/a_23550_n1540# pd_div_0/divbuf_0/a_24030_n1540# 0.11fF
C8394 divbuf_4/a_32160_n1600# divbuf_4/OUT4 0.00fF
C8395 divbuf_4/a_48000_n1600# divbuf_4/a_48030_n1540# 0.19fF
C8396 divbuf_4/a_48030_n840# divbuf_4/a_48510_n840# 0.07fF
C8397 divbuf_4/a_17790_n840# divbuf_4/a_17790_n1540# 0.01fF
C8398 pll_full_0/divbuf_1/a_26910_n1540# pll_full_0/divbuf_1/a_27390_n1540# 0.11fF
C8399 pll_full_0/divbuf_1/a_57630_n840# pll_full_0/divbuf_1/a_57630_n1540# 0.01fF
C8400 divbuf_2/a_15672_n240# divbuf_2/a_15390_n840# 0.01fF
C8401 divbuf_1/a_9242_n240# divbuf_1/a_9732_n240# 0.04fF
C8402 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8403 divbuf_5/a_18582_170# divbuf_5/a_18582_n240# 0.01fF
C8404 divbuf_5/a_37992_170# divbuf_5/a_38472_170# 0.07fF
C8405 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8406 ro_div_0/divbuf_0/a_23070_n840# ro_div_0/divbuf_0/a_23550_n840# 0.07fF
C8407 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23070_n1540# 0.19fF
C8408 divbuf_1/a_21600_n1600# divbuf_1/a_21630_n1540# 0.19fF
C8409 divbuf_1/a_21630_n840# divbuf_1/a_22110_n840# 0.07fF
C8410 divbuf_1/a_21012_n240# divbuf_1/OUT4 0.04fF
C8411 divbuf_5/a_10560_n1600# divbuf_5/a_10590_n1540# 0.19fF
C8412 divbuf_5/a_37992_170# divbuf_5/OUT4 0.19fF
C8413 divbuf_5/a_10590_n840# divbuf_5/a_11070_n840# 0.07fF
C8414 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/nor_1/B 0.22fF
C8415 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C8416 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C8417 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/OUT3 0.19fF
C8418 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21150_n840# 0.04fF
C8419 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24510_n840# 0.04fF
C8420 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/OUT3 0.19fF
C8421 divbuf_2/a_11312_170# divbuf_2/a_11802_170# 0.07fF
C8422 divbuf_5/OUT3 divbuf_5/OUT4 0.36fF
C8423 divbuf_0/a_5760_n1600# divbuf_0/a_6240_n1600# 0.26fF
C8424 divbuf_2/a_44640_n1600# divbuf_2/a_45120_n1600# 0.26fF
C8425 divbuf_2/a_35562_n240# divbuf_2/a_35550_n840# 0.05fF
C8426 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/a_40412_n240# 0.05fF
C8427 gnd pll_full_0/divider_0/prescaler_0/Out 0.46fF
C8428 divbuf_0/a_28830_n840# divbuf_0/a_28830_n1540# 0.01fF
C8429 divbuf_0/a_59070_n840# divbuf_0/a_59550_n840# 0.07fF
C8430 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n1540# 0.19fF
C8431 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51390_n1540# 0.19fF
C8432 divbuf_2/a_36990_n1540# divbuf_2/a_37470_n1540# 0.11fF
C8433 pll_full_0/divbuf_0/a_51390_n840# pll_full_0/divbuf_0/a_51870_n840# 0.07fF
C8434 pll_full_0/divbuf_0/a_21150_n840# pll_full_0/divbuf_0/a_21150_n1540# 0.01fF
C8435 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C8436 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/a_18582_n240# 0.01fF
C8437 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/a_38472_170# 0.07fF
C8438 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/a_21982_n240# 0.01fF
C8439 divbuf_1/a_19200_n1600# divbuf_1/OUT4 0.00fF
C8440 divbuf_3/a_7200_n1600# divbuf_3/a_7680_n1600# 0.26fF
C8441 divbuf_5/a_38962_n240# divbuf_5/OUT4 0.04fF
C8442 divbuf_3/a_60990_n840# divbuf_3/OUT5 0.04fF
C8443 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C8444 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C8445 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_10590_n1540# 0.19fF
C8446 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8447 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/a_11070_n840# 0.07fF
C8448 divbuf_3/a_60510_n840# divbuf_3/a_60990_n840# 0.07fF
C8449 divbuf_3/a_30270_n840# divbuf_3/a_30270_n1540# 0.01fF
C8450 divbuf_4/a_25382_n240# divbuf_4/a_25470_n840# 0.03fF
C8451 divbuf_4/a_34560_n1600# divbuf_4/a_35040_n1600# 0.26fF
C8452 pll_full_0/divbuf_1/a_13950_n840# pll_full_0/divbuf_1/a_14430_n840# 0.07fF
C8453 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_13950_n1540# 0.19fF
C8454 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C8455 divbuf_0/a_16642_n240# divbuf_0/a_16350_n840# 0.00fF
C8456 pd_div_0/divbuf_0/OUT3 pd_div_0/divbuf_0/OUT4 0.36fF
C8457 divbuf_2/a_34560_n1600# divbuf_2/a_34590_n840# 0.04fF
C8458 divbuf_2/a_24892_170# divbuf_2/OUT4 0.19fF
C8459 divbuf_4/a_57630_n840# divbuf_4/a_57630_n1540# 0.01fF
C8460 divbuf_4/a_26910_n1540# divbuf_4/a_27390_n1540# 0.11fF
C8461 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_10080_n1600# 0.26fF
C8462 divbuf_1/a_8160_n1600# divbuf_1/a_8640_n1600# 0.26fF
C8463 divbuf_5/a_38962_n240# divbuf_5/a_39442_n240# 0.05fF
C8464 divbuf_3/a_14702_170# divbuf_3/OUT4 0.19fF
C8465 ro_div_0/divbuf_0/a_1950_n1540# ro_div_0/divbuf_0/a_2430_n1540# 0.11fF
C8466 ro_div_0/divbuf_0/a_32670_n840# ro_div_0/divbuf_0/a_32670_n1540# 0.01fF
C8467 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/OUT 0.07fF
C8468 divbuf_1/a_31230_n840# divbuf_1/a_31230_n1540# 0.01fF
C8469 divbuf_1/a_510_n1540# divbuf_1/a_990_n1540# 0.11fF
C8470 divbuf_3/a_18092_n240# divbuf_3/a_17790_n840# 0.00fF
C8471 divbuf_5/a_50430_n840# divbuf_5/a_50910_n840# 0.07fF
C8472 divbuf_5/a_20190_n840# divbuf_5/a_20190_n1540# 0.01fF
C8473 divbuf_5/a_50400_n1600# divbuf_5/a_50430_n1540# 0.19fF
C8474 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8475 divbuf_2/a_12282_n240# divbuf_2/a_12772_n240# 0.04fF
C8476 divbuf_2/a_32172_170# divbuf_2/a_32172_n240# 0.01fF
C8477 divbuf_4/a_4392_170# divbuf_4/OUT3 0.19fF
C8478 divbuf_4/a_24480_n1600# divbuf_4/a_24510_n840# 0.04fF
C8479 divbuf_0/a_45600_n1600# divbuf_0/a_46080_n1600# 0.26fF
C8480 divbuf_0/a_36532_n240# divbuf_0/a_36510_n840# 0.05fF
C8481 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C8482 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z4 0.12fF
C8483 divbuf_2/a_25862_n240# divbuf_2/OUT4 0.04fF
C8484 divbuf_2/a_24000_n1600# divbuf_2/a_24030_n1540# 0.19fF
C8485 divbuf_2/a_24030_n840# divbuf_2/a_24510_n840# 0.07fF
C8486 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_38400_n1600# 0.26fF
C8487 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/a_28830_n840# 0.04fF
C8488 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C8489 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/a_24892_170# 0.07fF
C8490 divbuf_0/a_37950_n1540# divbuf_0/a_38430_n1540# 0.11fF
C8491 divbuf_3/a_13742_170# divbuf_3/a_14222_170# 0.07fF
C8492 pll_full_0/divbuf_0/a_30270_n1540# pll_full_0/divbuf_0/a_30750_n1540# 0.11fF
C8493 pll_full_0/divbuf_0/a_60990_n840# pll_full_0/divbuf_0/a_60990_n1540# 0.01fF
C8494 divbuf_3/a_15672_n240# divbuf_3/OUT4 0.04fF
C8495 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/a_39442_n240# 0.05fF
C8496 divbuf_4/a_21982_170# divbuf_4/a_21982_n240# 0.01fF
C8497 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_960_n1600# 0.26fF
C8498 divbuf_3/a_37992_n240# divbuf_3/a_37950_n840# 0.04fF
C8499 divbuf_3/a_47040_n1600# divbuf_3/a_47520_n1600# 0.26fF
C8500 divbuf_0/a_12772_170# divbuf_0/a_12772_n240# 0.01fF
C8501 pd_div_0/divbuf_0/a_50430_n840# pd_div_0/divbuf_0/a_50910_n840# 0.07fF
C8502 pd_div_0/divbuf_0/a_20190_n840# pd_div_0/divbuf_0/a_20190_n1540# 0.01fF
C8503 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50430_n1540# 0.19fF
C8504 divbuf_4/a_5362_n240# divbuf_4/OUT3 0.04fF
C8505 divbuf_4/a_13920_n1600# divbuf_4/a_13950_n1540# 0.19fF
C8506 divbuf_4/a_13950_n840# divbuf_4/a_14430_n840# 0.07fF
C8507 pll_full_0/divbuf_1/a_23550_n840# pll_full_0/divbuf_1/a_23550_n1540# 0.01fF
C8508 pll_full_0/divbuf_1/a_53790_n840# pll_full_0/divbuf_1/a_54270_n840# 0.07fF
C8509 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_53790_n1540# 0.19fF
C8510 divbuf_3/a_39390_n1540# divbuf_3/a_39870_n1540# 0.11fF
C8511 divbuf_0/a_26832_170# divbuf_0/OUT4 0.19fF
C8512 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n840# 0.04fF
C8513 gnd pd_div_0/divider_0/and_0/A 0.69fF
C8514 divbuf_2/a_24000_n1600# divbuf_2/OUT4 0.00fF
C8515 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z3 0.45fF
C8516 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_27870_n840# 0.04fF
C8517 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/a_40350_n840# 0.04fF
C8518 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49920_n1600# 0.26fF
C8519 divbuf_1/a_2322_170# divbuf_1/OUT3 0.07fF
C8520 divbuf_1/a_38962_n240# divbuf_1/a_38910_n840# 0.04fF
C8521 divbuf_1/a_48000_n1600# divbuf_1/a_48480_n1600# 0.26fF
C8522 divbuf_5/a_27802_n240# divbuf_5/a_27870_n840# 0.04fF
C8523 divbuf_5/a_36960_n1600# divbuf_5/a_37440_n1600# 0.26fF
C8524 ro_div_0/divbuf_0/a_41790_n1540# ro_div_0/divbuf_0/a_42270_n1540# 0.11fF
C8525 divbuf_1/a_40350_n1540# divbuf_1/a_40830_n1540# 0.11fF
C8526 divbuf_5/a_60030_n840# divbuf_5/a_60030_n1540# 0.01fF
C8527 divbuf_5/a_29310_n1540# divbuf_5/a_29790_n1540# 0.11fF
C8528 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11070_n840# 0.02fF
C8529 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/a_21012_n240# 0.01fF
C8530 divbuf_3/a_36960_n1600# divbuf_3/a_36990_n840# 0.04fF
C8531 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/OUT3 0.19fF
C8532 divbuf_0/a_33142_170# divbuf_0/a_33142_n240# 0.01fF
C8533 divbuf_0/a_13252_n240# divbuf_0/a_13742_n240# 0.04fF
C8534 divbuf_2/a_10560_n1600# divbuf_2/a_11040_n1600# 0.26fF
C8535 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/OUT3 0.07fF
C8536 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/IN 0.13fF
C8537 ro_div_0/ro_complete_0/a5 ro_div_0/divider_0/clk 0.10fF
C8538 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/a_25382_n240# 0.01fF
C8539 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/a_5362_n240# 0.05fF
C8540 divbuf_0/a_24990_n840# divbuf_0/a_25470_n840# 0.07fF
C8541 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n1540# 0.19fF
C8542 divbuf_0/a_27802_n240# divbuf_0/OUT4 0.04fF
C8543 divbuf_1/a_14222_170# divbuf_1/a_14222_n240# 0.01fF
C8544 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17310_n1540# 0.19fF
C8545 divbuf_2/a_33630_n840# divbuf_2/a_33630_n1540# 0.01fF
C8546 divbuf_2/a_2910_n1540# divbuf_2/a_3390_n1540# 0.11fF
C8547 pll_full_0/divbuf_0/a_17310_n840# pll_full_0/divbuf_0/a_17790_n840# 0.07fF
C8548 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8549 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39390_n840# 0.04fF
C8550 ro_div_0/divider_0/tspc_0/a_630_n680# gnd 0.62fF
C8551 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_4882_170# 0.07fF
C8552 divbuf_1/a_37920_n1600# divbuf_1/a_37950_n840# 0.04fF
C8553 divbuf_1/a_28292_170# divbuf_1/OUT4 0.19fF
C8554 divbuf_5/a_26880_n1600# divbuf_5/a_26910_n840# 0.04fF
C8555 divbuf_5/a_9242_170# divbuf_5/OUT3 0.19fF
C8556 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/a_6822_170# 0.07fF
C8557 divbuf_3/a_14702_n240# divbuf_3/a_15182_n240# 0.05fF
C8558 divbuf_3/a_34592_170# divbuf_3/a_34592_n240# 0.01fF
C8559 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/a_27870_n840# 0.04fF
C8560 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_37440_n1600# 0.26fF
C8561 divbuf_4/a_480_n1600# divbuf_4/a_960_n1600# 0.26fF
C8562 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/a_31230_n840# 0.05fF
C8563 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40800_n1600# 0.26fF
C8564 divbuf_3/a_26430_n840# divbuf_3/a_26910_n840# 0.07fF
C8565 divbuf_3/a_26400_n1600# divbuf_3/a_26430_n1540# 0.19fF
C8566 pd_div_0/divbuf_0/a_60030_n840# pd_div_0/divbuf_0/a_60030_n1540# 0.01fF
C8567 pd_div_0/divbuf_0/a_29310_n1540# pd_div_0/divbuf_0/a_29790_n1540# 0.11fF
C8568 divbuf_2/a_480_n1600# divbuf_2/a_510_n840# 0.04fF
C8569 divbuf_4/a_53760_n1600# divbuf_4/a_53790_n1540# 0.19fF
C8570 divbuf_4/a_53790_n840# divbuf_4/a_54270_n840# 0.07fF
C8571 divbuf_4/a_23550_n840# divbuf_4/a_23550_n1540# 0.01fF
C8572 pll_full_0/divbuf_1/a_32670_n1540# pll_full_0/divbuf_1/a_33150_n1540# 0.11fF
C8573 divbuf_1/a_15672_n240# divbuf_1/a_16152_n240# 0.05fF
C8574 divbuf_1/a_35562_170# divbuf_1/a_35562_n240# 0.01fF
C8575 divbuf_5/a_3912_n240# divbuf_5/a_4392_n240# 0.05fF
C8576 divbuf_5/a_24412_170# divbuf_5/a_24412_n240# 0.01fF
C8577 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C8578 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_28830_n1540# 0.19fF
C8579 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8580 ro_div_0/divbuf_0/a_28830_n840# ro_div_0/divbuf_0/a_29310_n840# 0.07fF
C8581 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_4392_n240# 0.01fF
C8582 divbuf_1/a_27390_n840# divbuf_1/a_27870_n840# 0.07fF
C8583 divbuf_1/a_32652_n240# divbuf_1/OUT4 0.04fF
C8584 divbuf_1/a_27360_n1600# divbuf_1/a_27390_n1540# 0.19fF
C8585 divbuf_5/a_16350_n840# divbuf_5/a_16830_n840# 0.07fF
C8586 divbuf_5/a_10212_n240# divbuf_5/OUT3 0.04fF
C8587 divbuf_5/a_16320_n1600# divbuf_5/a_16350_n1540# 0.19fF
C8588 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C8589 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/nor_1/A 0.21fF
C8590 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C8591 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_26910_n840# 0.04fF
C8592 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/OUT3 0.19fF
C8593 divbuf_2/a_17122_170# divbuf_2/a_17612_170# 0.07fF
C8594 divbuf_4/a_11312_n240# divbuf_4/a_11070_n840# 0.02fF
C8595 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8596 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30270_n840# 0.04fF
C8597 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C8598 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C8599 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C8600 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C8601 divbuf_0/a_11520_n1600# divbuf_0/a_12000_n1600# 0.26fF
C8602 divbuf_2/a_50400_n1600# divbuf_2/a_50880_n1600# 0.26fF
C8603 divbuf_2/a_41382_n240# divbuf_2/a_41310_n840# 0.03fF
C8604 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_4320_n1600# 0.26fF
C8605 divbuf_0/a_3870_n1540# divbuf_0/a_4350_n1540# 0.11fF
C8606 divbuf_0/a_34590_n840# divbuf_0/a_34590_n1540# 0.01fF
C8607 pll_full_0/divbuf_0/a_26910_n840# pll_full_0/divbuf_0/a_26910_n1540# 0.01fF
C8608 pll_full_0/divbuf_0/a_57150_n840# pll_full_0/divbuf_0/a_57630_n840# 0.07fF
C8609 divbuf_2/a_42750_n1540# divbuf_2/a_43230_n1540# 0.11fF
C8610 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57150_n1540# 0.19fF
C8611 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C8612 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/a_4392_n240# 0.05fF
C8613 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/a_24412_n240# 0.01fF
C8614 divbuf_4/a_6332_170# divbuf_4/a_6822_170# 0.07fF
C8615 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/a_7792_n240# 0.04fF
C8616 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/a_27802_n240# 0.01fF
C8617 divbuf_3/a_3422_n240# divbuf_3/a_3390_n840# 0.05fF
C8618 divbuf_3/a_12960_n1600# divbuf_3/a_13440_n1600# 0.26fF
C8619 divbuf_5/a_9120_n1600# divbuf_5/OUT3 0.00fF
C8620 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C8621 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/Z1 0.04fF
C8622 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z2 0.40fF
C8623 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divbuf_0/IN 0.04fF
C8624 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/clk 0.05fF
C8625 pd_div_0/divbuf_0/a_16350_n840# pd_div_0/divbuf_0/a_16830_n840# 0.07fF
C8626 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C8627 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16350_n1540# 0.19fF
C8628 divbuf_4/a_40320_n1600# divbuf_4/a_40800_n1600# 0.26fF
C8629 divbuf_4/a_31202_n240# divbuf_4/a_31230_n840# 0.05fF
C8630 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8631 pll_full_0/divbuf_1/a_19710_n840# pll_full_0/divbuf_1/a_20190_n840# 0.07fF
C8632 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_19710_n1540# 0.19fF
C8633 divbuf_3/a_36030_n840# divbuf_3/a_36030_n1540# 0.01fF
C8634 divbuf_3/a_5310_n1540# divbuf_3/a_5790_n1540# 0.11fF
C8635 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n840# 0.04fF
C8636 divbuf_1/a_31682_170# divbuf_1/a_32172_170# 0.07fF
C8637 divbuf_2/a_40320_n1600# divbuf_2/a_40350_n840# 0.04fF
C8638 divbuf_2/a_36532_170# divbuf_2/OUT4 0.19fF
C8639 divbuf_4/a_32670_n1540# divbuf_4/a_33150_n1540# 0.11fF
C8640 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_14430_n840# 0.01fF
C8641 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15840_n1600# 0.26fF
C8642 divbuf_1/a_4392_n240# divbuf_1/a_4350_n840# 0.04fF
C8643 divbuf_1/a_13920_n1600# divbuf_1/a_14400_n1600# 0.26fF
C8644 divbuf_5/a_2880_n1600# divbuf_5/a_3360_n1600# 0.26fF
C8645 divbuf_3/a_26352_170# divbuf_3/OUT4 0.19fF
C8646 ro_div_0/divbuf_0/a_7710_n1540# ro_div_0/divbuf_0/a_8190_n1540# 0.11fF
C8647 ro_div_0/divbuf_0/a_38430_n840# ro_div_0/divbuf_0/a_38430_n1540# 0.01fF
C8648 divbuf_1/a_36990_n840# divbuf_1/a_36990_n1540# 0.01fF
C8649 divbuf_1/a_6270_n1540# divbuf_1/a_6750_n1540# 0.11fF
C8650 divbuf_3/a_2880_n1600# divbuf_3/a_2910_n840# 0.04fF
C8651 divbuf_5/a_56160_n1600# divbuf_5/a_56190_n1540# 0.19fF
C8652 divbuf_5/a_56190_n840# divbuf_5/a_56670_n840# 0.07fF
C8653 divbuf_5/a_25950_n840# divbuf_5/a_25950_n1540# 0.01fF
C8654 divbuf_0/a_15672_170# divbuf_0/a_16152_170# 0.07fF
C8655 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C8656 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/a_12282_170# 0.07fF
C8657 divbuf_2/a_37992_170# divbuf_2/a_37992_n240# 0.01fF
C8658 divbuf_2/a_18092_n240# divbuf_2/a_18582_n240# 0.04fF
C8659 divbuf_4/a_30240_n1600# divbuf_4/a_30270_n840# 0.04fF
C8660 divbuf_4/a_16152_170# divbuf_4/OUT4 0.19fF
C8661 divbuf_0/a_51360_n1600# divbuf_0/a_51840_n1600# 0.26fF
C8662 pd_div_0/divider_0/prescaler_0/m1_2700_2190# gnd 0.22fF
C8663 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C8664 divbuf_1/a_5362_170# divbuf_1/a_4882_170# 0.07fF
C8665 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/a_34590_n840# 0.06fF
C8666 divbuf_2/a_29760_n1600# divbuf_2/a_29790_n1540# 0.19fF
C8667 divbuf_2/a_29790_n840# divbuf_2/a_30270_n840# 0.07fF
C8668 divbuf_2/a_37502_n240# divbuf_2/OUT4 0.04fF
C8669 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_44160_n1600# 0.26fF
C8670 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C8671 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C8672 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/a_10212_n240# 0.01fF
C8673 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/a_30712_170# 0.07fF
C8674 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5310_n840# 0.04fF
C8675 divbuf_0/a_43710_n1540# divbuf_0/a_44190_n1540# 0.11fF
C8676 divbuf_1/a_3840_n1600# divbuf_1/a_3870_n840# 0.04fF
C8677 divbuf_3/a_19562_170# divbuf_3/a_20042_170# 0.07fF
C8678 divbuf_5/a_13742_n240# divbuf_5/a_13470_n840# 0.01fF
C8679 pll_full_0/divbuf_0/a_36030_n1540# pll_full_0/divbuf_0/a_36510_n1540# 0.11fF
C8680 divbuf_3/a_27322_n240# divbuf_3/OUT4 0.04fF
C8681 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_3360_n1600# 0.26fF
C8682 divbuf_3/a_52800_n1600# divbuf_3/a_53280_n1600# 0.26fF
C8683 divbuf_4/a_27802_170# divbuf_4/a_27802_n240# 0.01fF
C8684 divbuf_4/a_7302_n240# divbuf_4/a_7792_n240# 0.04fF
C8685 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6720_n1600# 0.26fF
C8686 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56190_n1540# 0.19fF
C8687 pd_div_0/divbuf_0/a_56190_n840# pd_div_0/divbuf_0/a_56670_n840# 0.07fF
C8688 pd_div_0/divbuf_0/a_25950_n840# pd_div_0/divbuf_0/a_25950_n1540# 0.01fF
C8689 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/a_11802_n240# 0.01fF
C8690 pll_full_0/divbuf_0/a_1842_170# pll_full_0/divbuf_0/a_1842_n240# 0.01fF
C8691 divbuf_4/a_19680_n1600# divbuf_4/a_19710_n1540# 0.19fF
C8692 divbuf_4/a_19710_n840# divbuf_4/a_20190_n840# 0.07fF
C8693 divbuf_4/a_17122_n240# divbuf_4/OUT4 0.04fF
C8694 pll_full_0/divbuf_1/a_29310_n840# pll_full_0/divbuf_1/a_29310_n1540# 0.01fF
C8695 pll_full_0/divbuf_1/a_59550_n840# pll_full_0/divbuf_1/a_60030_n840# 0.07fF
C8696 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_59550_n1540# 0.19fF
C8697 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8698 divbuf_3/a_45150_n1540# divbuf_3/a_45630_n1540# 0.11fF
C8699 divbuf_0/a_38472_170# divbuf_0/OUT4 0.19fF
C8700 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n840# 0.04fF
C8701 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8702 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_33630_n840# 0.04fF
C8703 divbuf_2/a_35520_n1600# divbuf_2/OUT4 0.00fF
C8704 divbuf_5/a_8762_170# divbuf_5/a_9242_170# 0.07fF
C8705 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55680_n1600# 0.26fF
C8706 divbuf_1/a_14702_170# divbuf_1/OUT4 0.19fF
C8707 divbuf_1/a_53760_n1600# divbuf_1/a_54240_n1600# 0.26fF
C8708 divbuf_5/a_42720_n1600# divbuf_5/a_43200_n1600# 0.26fF
C8709 divbuf_5/a_33622_n240# divbuf_5/a_33630_n840# 0.06fF
C8710 ro_div_0/divbuf_0/a_47550_n1540# ro_div_0/divbuf_0/a_48030_n1540# 0.11fF
C8711 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_13470_n840# 0.01fF
C8712 divbuf_1/a_46110_n1540# divbuf_1/a_46590_n1540# 0.11fF
C8713 divbuf_5/a_35070_n1540# divbuf_5/a_35550_n1540# 0.11fF
C8714 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_16830_n840# 0.00fF
C8715 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/a_26832_n240# 0.01fF
C8716 divbuf_3/a_42720_n1600# divbuf_3/a_42750_n840# 0.04fF
C8717 divbuf_0/a_19072_n240# divbuf_0/a_19562_n240# 0.04fF
C8718 divbuf_0/a_38962_170# divbuf_0/a_38962_n240# 0.01fF
C8719 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11802_n240# 0.04fF
C8720 divbuf_2/a_16320_n1600# divbuf_2/a_16800_n1600# 0.26fF
C8721 divbuf_2/a_6822_n240# divbuf_2/a_6750_n840# 0.03fF
C8722 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/a_31202_n240# 0.01fF
C8723 divbuf_0/a_1842_170# divbuf_0/a_2322_170# 0.07fF
C8724 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8725 divbuf_0/a_39442_n240# divbuf_0/OUT4 0.04fF
C8726 divbuf_0/a_30750_n840# divbuf_0/a_31230_n840# 0.07fF
C8727 divbuf_0/a_510_n840# divbuf_0/a_510_n1540# 0.01fF
C8728 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n1540# 0.19fF
C8729 divbuf_1/a_19562_170# divbuf_1/a_19562_n240# 0.01fF
C8730 divbuf_2/a_39390_n840# divbuf_2/a_39390_n1540# 0.01fF
C8731 divbuf_2/a_8670_n1540# divbuf_2/a_9150_n1540# 0.11fF
C8732 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8733 pll_full_0/divbuf_0/a_23070_n840# pll_full_0/divbuf_0/a_23550_n840# 0.07fF
C8734 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23070_n1540# 0.19fF
C8735 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45150_n840# 0.04fF
C8736 divbuf_1/a_3912_n240# divbuf_1/OUT3 0.04fF
C8737 divbuf_1/a_43680_n1600# divbuf_1/a_43710_n840# 0.04fF
C8738 divbuf_5/a_32640_n1600# divbuf_5/a_32670_n840# 0.04fF
C8739 divbuf_5/a_21012_170# divbuf_5/OUT4 0.19fF
C8740 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/a_13252_170# 0.07fF
C8741 divbuf_3/a_40412_170# divbuf_3/a_40412_n240# 0.01fF
C8742 divbuf_3/a_20532_n240# divbuf_3/a_21012_n240# 0.05fF
C8743 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_43200_n1600# 0.26fF
C8744 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/a_33630_n840# 0.06fF
C8745 divbuf_4/a_6240_n1600# divbuf_4/a_6720_n1600# 0.26fF
C8746 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46560_n1600# 0.26fF
C8747 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/a_36990_n840# 0.05fF
C8748 divbuf_3/a_32160_n1600# divbuf_3/a_32190_n1540# 0.19fF
C8749 divbuf_3/a_32190_n840# divbuf_3/a_32670_n840# 0.07fF
C8750 divbuf_3/a_1950_n840# divbuf_3/a_1950_n1540# 0.01fF
C8751 ashish_0/a_150_0# ashish_0/a_150_n710# 6.31fF
C8752 pd_div_0/divbuf_0/a_35070_n1540# pd_div_0/divbuf_0/a_35550_n1540# 0.11fF
C8753 divbuf_2/a_6240_n1600# divbuf_2/a_6270_n840# 0.04fF
C8754 divbuf_4/a_59520_n1600# divbuf_4/a_59550_n1540# 0.19fF
C8755 divbuf_4/a_59550_n840# divbuf_4/a_60030_n840# 0.07fF
C8756 divbuf_4/a_29310_n840# divbuf_4/a_29310_n1540# 0.01fF
C8757 pll_full_0/divbuf_1/a_38430_n1540# pll_full_0/divbuf_1/a_38910_n1540# 0.11fF
C8758 gnd pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.16fF
C8759 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/a_23442_n240# 0.04fF
C8760 divbuf_1/a_41382_170# divbuf_1/a_41382_n240# 0.01fF
C8761 divbuf_1/a_21502_n240# divbuf_1/a_21982_n240# 0.05fF
C8762 divbuf_5/a_30232_170# divbuf_5/a_30232_n240# 0.01fF
C8763 divbuf_5/a_9732_n240# divbuf_5/a_10212_n240# 0.05fF
C8764 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C8765 ro_div_0/divbuf_0/a_4350_n840# ro_div_0/divbuf_0/a_4350_n1540# 0.01fF
C8766 ro_div_0/divbuf_0/a_34590_n840# ro_div_0/divbuf_0/a_35070_n840# 0.07fF
C8767 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_34590_n1540# 0.19fF
C8768 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/a_8272_n240# 0.01fF
C8769 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/a_13742_n240# 0.01fF
C8770 divbuf_1/a_33120_n1600# divbuf_1/a_33150_n1540# 0.19fF
C8771 divbuf_1/a_33150_n840# divbuf_1/a_33630_n840# 0.07fF
C8772 divbuf_1/a_2910_n840# divbuf_1/a_2910_n1540# 0.01fF
C8773 divbuf_5/a_22080_n1600# divbuf_5/a_22110_n1540# 0.19fF
C8774 divbuf_5/a_22110_n840# divbuf_5/a_22590_n840# 0.07fF
C8775 divbuf_5/a_21982_n240# divbuf_5/OUT4 0.04fF
C8776 ashish_0/von ashish_0/Gnd 0.33fF
C8777 divbuf_3/a_54270_n840# divbuf_3/a_54270_n1540# 0.01fF
C8778 divbuf_0/a_8762_170# divbuf_0/a_8272_170# 0.07fF
C8779 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/nor_1/A 0.15fF
C8780 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C8781 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_32670_n840# 0.04fF
C8782 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8783 divbuf_2/a_2322_170# divbuf_2/a_2322_n240# 0.01fF
C8784 divbuf_2/a_22952_170# divbuf_2/a_23442_170# 0.07fF
C8785 divbuf_4/a_17122_n240# divbuf_4/a_16830_n840# 0.00fF
C8786 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8787 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36030_n840# 0.04fF
C8788 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C8789 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C8790 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C8791 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C8792 divbuf_0/a_7792_n240# divbuf_0/a_7710_n840# 0.03fF
C8793 divbuf_0/a_17280_n1600# divbuf_0/a_17760_n1600# 0.26fF
C8794 divbuf_2/a_7792_170# divbuf_2/OUT3 0.19fF
C8795 divbuf_2/a_56160_n1600# divbuf_2/a_56640_n1600# 0.26fF
C8796 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_10080_n1600# 0.26fF
C8797 divbuf_0/a_40350_n840# divbuf_0/a_40350_n1540# 0.01fF
C8798 divbuf_0/a_9630_n1540# divbuf_0/a_10110_n1540# 0.11fF
C8799 divbuf_2/a_48510_n1540# divbuf_2/a_48990_n1540# 0.11fF
C8800 pll_full_0/divbuf_0/a_32670_n840# pll_full_0/divbuf_0/a_32670_n1540# 0.01fF
C8801 pll_full_0/divbuf_0/a_1950_n1540# pll_full_0/divbuf_0/a_2430_n1540# 0.11fF
C8802 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/a_30232_n240# 0.01fF
C8803 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/a_10212_n240# 0.05fF
C8804 divbuf_4/a_12772_170# divbuf_4/a_13252_170# 0.07fF
C8805 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/a_33622_n240# 0.01fF
C8806 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_14222_n240# 0.05fF
C8807 divbuf_3/a_18720_n1600# divbuf_3/a_19200_n1600# 0.26fF
C8808 divbuf_3/a_9242_n240# divbuf_3/a_9150_n840# 0.03fF
C8809 divbuf_5/a_20160_n1600# divbuf_5/OUT4 0.00fF
C8810 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22110_n1540# 0.19fF
C8811 pd_div_0/divbuf_0/a_22110_n840# pd_div_0/divbuf_0/a_22590_n840# 0.07fF
C8812 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8813 divbuf_4/a_37022_n240# divbuf_4/a_36990_n840# 0.05fF
C8814 divbuf_4/a_46080_n1600# divbuf_4/a_46560_n1600# 0.26fF
C8815 pll_full_0/divbuf_1/a_25470_n840# pll_full_0/divbuf_1/a_25950_n840# 0.07fF
C8816 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25470_n1540# 0.19fF
C8817 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8818 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_15870_n840# 0.01fF
C8819 divbuf_3/a_41790_n840# divbuf_3/a_41790_n1540# 0.01fF
C8820 divbuf_3/a_11070_n1540# divbuf_3/a_11550_n1540# 0.11fF
C8821 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C8822 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/a_4392_170# 0.07fF
C8823 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n840# 0.04fF
C8824 divbuf_4/a_38430_n1540# divbuf_4/a_38910_n1540# 0.11fF
C8825 divbuf_2/a_8762_n240# divbuf_2/OUT3 0.04fF
C8826 divbuf_2/a_46080_n1600# divbuf_2/a_46110_n840# 0.04fF
C8827 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21600_n1600# 0.26fF
C8828 divbuf_1/a_19680_n1600# divbuf_1/a_20160_n1600# 0.26fF
C8829 divbuf_1/a_10212_n240# divbuf_1/a_10110_n840# 0.03fF
C8830 divbuf_5/a_8640_n1600# divbuf_5/a_9120_n1600# 0.26fF
C8831 divbuf_3/a_37992_170# divbuf_3/OUT4 0.19fF
C8832 ro_div_0/divbuf_0/a_13470_n1540# ro_div_0/divbuf_0/a_13950_n1540# 0.11fF
C8833 ro_div_0/divbuf_0/a_44190_n840# ro_div_0/divbuf_0/a_44190_n1540# 0.01fF
C8834 divbuf_1/a_42750_n840# divbuf_1/a_42750_n1540# 0.01fF
C8835 divbuf_1/a_12030_n1540# divbuf_1/a_12510_n1540# 0.11fF
C8836 divbuf_3/a_8640_n1600# divbuf_3/a_8670_n840# 0.04fF
C8837 divbuf_5/a_31710_n840# divbuf_5/a_31710_n1540# 0.01fF
C8838 divbuf_5/a_990_n1540# divbuf_5/a_1470_n1540# 0.11fF
C8839 divbuf_5/a_510_n840# divbuf_5/OUT2 0.02fF
C8840 divbuf_0/a_23922_170# divbuf_0/a_24412_170# 0.07fF
C8841 divbuf_0/a_7792_170# divbuf_0/a_7792_n240# 0.01fF
C8842 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C8843 divbuf_4/a_36000_n1600# divbuf_4/a_36030_n840# 0.04fF
C8844 divbuf_4/a_27802_170# divbuf_4/OUT4 0.19fF
C8845 divbuf_2/a_23922_n240# divbuf_2/a_24412_n240# 0.04fF
C8846 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/a_18092_170# 0.07fF
C8847 divbuf_0/a_57120_n1600# divbuf_0/a_57600_n1600# 0.26fF
C8848 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/clk 0.45fF
C8849 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C8850 divbuf_1/a_30712_170# divbuf_1/a_30232_170# 0.07fF
C8851 divbuf_2/a_35520_n1600# divbuf_2/a_35550_n1540# 0.19fF
C8852 divbuf_2/a_35550_n840# divbuf_2/a_36030_n840# 0.07fF
C8853 divbuf_2/a_5310_n840# divbuf_2/a_5310_n1540# 0.01fF
C8854 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49920_n1600# 0.26fF
C8855 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/OUT3 0.23fF
C8856 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/a_40350_n840# 0.04fF
C8857 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C8858 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/a_36532_170# 0.07fF
C8859 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11070_n840# 0.04fF
C8860 divbuf_0/a_49470_n1540# divbuf_0/a_49950_n1540# 0.11fF
C8861 divbuf_1/a_9600_n1600# divbuf_1/a_9630_n840# 0.04fF
C8862 pll_full_0/divbuf_0/a_41790_n1540# pll_full_0/divbuf_0/a_42270_n1540# 0.11fF
C8863 divbuf_3/a_5362_170# divbuf_3/a_5362_n240# 0.01fF
C8864 divbuf_3/a_25382_170# divbuf_3/a_25862_170# 0.07fF
C8865 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C8866 divbuf_3/a_38962_n240# divbuf_3/OUT4 0.04fF
C8867 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_9120_n1600# 0.26fF
C8868 divbuf_4/a_13742_n240# divbuf_4/a_14222_n240# 0.05fF
C8869 divbuf_4/a_33622_170# divbuf_4/a_33622_n240# 0.01fF
C8870 divbuf_1/a_60990_n840# divbuf_1/OUT5 0.04fF
C8871 divbuf_3/a_58560_n1600# divbuf_3/a_59040_n1600# 0.26fF
C8872 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12480_n1600# 0.26fF
C8873 pd_div_0/divbuf_0/a_31710_n840# pd_div_0/divbuf_0/a_31710_n1540# 0.01fF
C8874 pd_div_0/divbuf_0/a_990_n1540# pd_div_0/divbuf_0/a_1470_n1540# 0.11fF
C8875 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/OUT2 0.02fF
C8876 divbuf_3/a_50910_n1540# divbuf_3/a_51390_n1540# 0.11fF
C8877 divbuf_4/a_28772_n240# divbuf_4/OUT4 0.04fF
C8878 divbuf_4/a_25440_n1600# divbuf_4/a_25470_n1540# 0.19fF
C8879 divbuf_4/a_25470_n840# divbuf_4/a_25950_n840# 0.07fF
C8880 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/a_17612_n240# 0.01fF
C8881 pll_full_0/divbuf_1/a_4350_n1540# pll_full_0/divbuf_1/a_4830_n1540# 0.11fF
C8882 pll_full_0/divbuf_1/a_35070_n840# pll_full_0/divbuf_1/a_35070_n1540# 0.01fF
C8883 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8884 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n840# 0.04fF
C8885 divbuf_0/a_10212_n240# divbuf_0/OUT4 0.04fF
C8886 divbuf_1/a_22952_170# divbuf_1/a_23442_170# 0.07fF
C8887 divbuf_1/a_32652_170# divbuf_1/a_32652_n240# 0.01fF
C8888 divbuf_5/a_15182_170# divbuf_5/a_15672_170# 0.07fF
C8889 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39390_n840# 0.04fF
C8890 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8891 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/a_990_n840# 0.07fF
C8892 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_510_n1540# 0.19fF
C8893 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/z5 0.11fF
C8894 divbuf_1/a_59520_n1600# divbuf_1/a_60000_n1600# 0.26fF
C8895 divbuf_5/a_39442_n240# divbuf_5/a_39390_n840# 0.04fF
C8896 divbuf_5/a_48480_n1600# divbuf_5/a_48960_n1600# 0.26fF
C8897 ro_div_0/divbuf_0/a_53310_n1540# ro_div_0/divbuf_0/a_53790_n1540# 0.11fF
C8898 divbuf_1/a_51870_n1540# divbuf_1/a_52350_n1540# 0.11fF
C8899 divbuf_3/a_48480_n1600# divbuf_3/a_48510_n840# 0.04fF
C8900 divbuf_5/a_40830_n1540# divbuf_5/a_41310_n1540# 0.11fF
C8901 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_1950_n840# 0.04fF
C8902 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/a_32652_n240# 0.01fF
C8903 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C8904 divbuf_0/a_24892_n240# divbuf_0/a_25382_n240# 0.04fF
C8905 divbuf_2/a_22080_n1600# divbuf_2/a_22560_n1600# 0.26fF
C8906 divbuf_2/a_12772_n240# divbuf_2/a_12990_n840# 0.02fF
C8907 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/a_37022_n240# 0.01fF
C8908 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_17612_n240# 0.04fF
C8909 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n1540# 0.19fF
C8910 divbuf_0/a_9600_n1600# divbuf_0/OUT3 0.00fF
C8911 divbuf_0/a_36510_n840# divbuf_0/a_36990_n840# 0.07fF
C8912 divbuf_0/a_6270_n840# divbuf_0/a_6270_n1540# 0.01fF
C8913 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_28830_n1540# 0.19fF
C8914 divbuf_1/a_25382_170# divbuf_1/a_25382_n240# 0.01fF
C8915 divbuf_2/a_45150_n840# divbuf_2/a_45150_n1540# 0.01fF
C8916 divbuf_2/a_14430_n1540# divbuf_2/a_14910_n1540# 0.11fF
C8917 pll_full_0/divbuf_0/a_28830_n840# pll_full_0/divbuf_0/a_29310_n840# 0.07fF
C8918 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8919 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_50910_n840# 0.04fF
C8920 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/a_15672_170# 0.07fF
C8921 divbuf_1/a_49440_n1600# divbuf_1/a_49470_n840# 0.04fF
C8922 divbuf_1/a_15672_n240# divbuf_1/OUT4 0.04fF
C8923 divbuf_3/a_26352_n240# divbuf_3/a_26832_n240# 0.05fF
C8924 divbuf_5/a_38400_n1600# divbuf_5/a_38430_n840# 0.04fF
C8925 divbuf_5/a_32652_170# divbuf_5/OUT4 0.19fF
C8926 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/a_19072_170# 0.07fF
C8927 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C8928 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/nor_1/B 0.18fF
C8929 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/a_39390_n840# 0.04fF
C8930 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48960_n1600# 0.26fF
C8931 divbuf_4/a_12000_n1600# divbuf_4/a_12480_n1600# 0.26fF
C8932 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_52320_n1600# 0.26fF
C8933 divbuf_3/a_37950_n840# divbuf_3/a_38430_n840# 0.07fF
C8934 divbuf_3/a_7710_n840# divbuf_3/a_7710_n1540# 0.01fF
C8935 divbuf_3/a_37920_n1600# divbuf_3/a_37950_n1540# 0.19fF
C8936 pd_div_0/divbuf_0/a_40830_n1540# pd_div_0/divbuf_0/a_41310_n1540# 0.11fF
C8937 divbuf_2/a_12000_n1600# divbuf_2/a_12030_n840# 0.04fF
C8938 divbuf_4/a_35070_n840# divbuf_4/a_35070_n1540# 0.01fF
C8939 divbuf_4/a_4350_n1540# divbuf_4/a_4830_n1540# 0.11fF
C8940 pll_full_0/divbuf_1/a_44190_n1540# pll_full_0/divbuf_1/a_44670_n1540# 0.11fF
C8941 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/a_29262_n240# 0.04fF
C8942 divbuf_1/a_27322_n240# divbuf_1/a_27802_n240# 0.05fF
C8943 divbuf_5/a_16152_n240# divbuf_5/a_16642_n240# 0.04fF
C8944 divbuf_5/a_36052_170# divbuf_5/a_36052_n240# 0.01fF
C8945 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C8946 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40350_n1540# 0.19fF
C8947 ro_div_0/divbuf_0/a_10110_n840# ro_div_0/divbuf_0/a_10110_n1540# 0.01fF
C8948 ro_div_0/divbuf_0/a_40350_n840# ro_div_0/divbuf_0/a_40830_n840# 0.07fF
C8949 divbuf_1/a_38910_n840# divbuf_1/a_39390_n840# 0.07fF
C8950 divbuf_1/a_8670_n840# divbuf_1/a_8670_n1540# 0.01fF
C8951 divbuf_1/a_38880_n1600# divbuf_1/a_38910_n1540# 0.19fF
C8952 divbuf_5/a_27870_n840# divbuf_5/a_28350_n840# 0.07fF
C8953 divbuf_5/a_33622_n240# divbuf_5/OUT4 0.04fF
C8954 divbuf_5/a_27840_n1600# divbuf_5/a_27870_n1540# 0.19fF
C8955 divbuf_3/a_60030_n840# divbuf_3/a_60030_n1540# 0.01fF
C8956 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C8957 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C8958 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C8959 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C8960 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/clk 0.01fF
C8961 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38430_n840# 0.04fF
C8962 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8963 divbuf_2/a_28772_170# divbuf_2/a_29262_170# 0.07fF
C8964 divbuf_2/a_8762_170# divbuf_2/a_8762_n240# 0.01fF
C8965 divbuf_4/a_1920_n1600# divbuf_4/a_1950_n840# 0.04fF
C8966 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/a_8762_170# 0.07fF
C8967 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8968 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_41790_n840# 0.04fF
C8969 divbuf_0/a_23040_n1600# divbuf_0/a_23520_n1600# 0.26fF
C8970 divbuf_0/a_13742_n240# divbuf_0/a_13950_n840# 0.02fF
C8971 divbuf_2/a_1440_n1600# divbuf_2/a_1470_n1540# 0.19fF
C8972 divbuf_2/a_19562_170# divbuf_2/OUT4 0.19fF
C8973 divbuf_2/a_1470_n840# divbuf_2/a_1950_n840# 0.07fF
C8974 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15840_n1600# 0.26fF
C8975 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/a_5790_n840# 0.04fF
C8976 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C8977 divbuf_0/a_15390_n1540# divbuf_0/a_15870_n1540# 0.11fF
C8978 divbuf_0/a_46110_n840# divbuf_0/a_46110_n1540# 0.01fF
C8979 pll_full_0/divbuf_0/a_7710_n1540# pll_full_0/divbuf_0/a_8190_n1540# 0.11fF
C8980 pll_full_0/divbuf_0/a_38430_n840# pll_full_0/divbuf_0/a_38430_n1540# 0.01fF
C8981 divbuf_2/a_54270_n1540# divbuf_2/a_54750_n1540# 0.11fF
C8982 divbuf_3/a_9242_170# divbuf_3/OUT3 0.19fF
C8983 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_16642_n240# 0.04fF
C8984 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/a_36052_n240# 0.01fF
C8985 divbuf_4/a_18582_170# divbuf_4/a_19072_170# 0.07fF
C8986 divbuf_5/a_31680_n1600# divbuf_5/OUT4 0.00fF
C8987 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/a_20042_n240# 0.05fF
C8988 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/a_39442_n240# 0.01fF
C8989 divbuf_3/a_15182_n240# divbuf_3/a_15390_n840# 0.02fF
C8990 divbuf_3/a_24480_n1600# divbuf_3/a_24960_n1600# 0.26fF
C8991 pd_div_0/divbuf_0/a_27870_n840# pd_div_0/divbuf_0/a_28350_n840# 0.07fF
C8992 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8993 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_27870_n1540# 0.19fF
C8994 divbuf_4/a_51840_n1600# divbuf_4/a_52320_n1600# 0.26fF
C8995 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8996 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/a_990_n1540# 0.01fF
C8997 pll_full_0/divbuf_1/a_31230_n840# pll_full_0/divbuf_1/a_31710_n840# 0.07fF
C8998 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31230_n1540# 0.19fF
C8999 divbuf_3/a_47550_n840# divbuf_3/a_47550_n1540# 0.01fF
C9000 divbuf_3/a_16830_n1540# divbuf_3/a_17310_n1540# 0.11fF
C9001 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C9002 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n840# 0.04fF
C9003 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/a4 0.12fF
C9004 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Q 0.04fF
C9005 divbuf_4/a_44190_n1540# divbuf_4/a_44670_n1540# 0.11fF
C9006 divbuf_2/a_51840_n1600# divbuf_2/a_51870_n840# 0.04fF
C9007 divbuf_2/a_20532_n240# divbuf_2/OUT4 0.04fF
C9008 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5310_n840# 0.04fF
C9009 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_27360_n1600# 0.26fF
C9010 divbuf_1/a_16152_n240# divbuf_1/a_16350_n840# 0.02fF
C9011 divbuf_1/a_25440_n1600# divbuf_1/a_25920_n1600# 0.26fF
C9012 divbuf_5/a_4882_n240# divbuf_5/a_4830_n840# 0.04fF
C9013 divbuf_5/a_14400_n1600# divbuf_5/a_14880_n1600# 0.26fF
C9014 divbuf_3/a_10212_n240# divbuf_3/OUT3 0.04fF
C9015 ro_div_0/divbuf_0/a_19230_n1540# ro_div_0/divbuf_0/a_19710_n1540# 0.11fF
C9016 ro_div_0/divbuf_0/a_49950_n840# ro_div_0/divbuf_0/a_49950_n1540# 0.01fF
C9017 divbuf_1/a_48510_n840# divbuf_1/a_48510_n1540# 0.01fF
C9018 divbuf_1/a_17790_n1540# divbuf_1/a_18270_n1540# 0.11fF
C9019 divbuf_3/a_14400_n1600# divbuf_3/a_14430_n840# 0.04fF
C9020 divbuf_5/a_37470_n840# divbuf_5/a_37470_n1540# 0.01fF
C9021 divbuf_5/a_6750_n1540# divbuf_5/a_7230_n1540# 0.11fF
C9022 divbuf_0/a_29742_170# divbuf_0/a_30232_170# 0.07fF
C9023 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C9024 divbuf_4/a_41760_n1600# divbuf_4/a_41790_n840# 0.04fF
C9025 divbuf_4/a_39442_170# divbuf_4/OUT4 0.19fF
C9026 divbuf_2/a_29742_n240# divbuf_2/a_30232_n240# 0.04fF
C9027 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/a_22472_170# 0.07fF
C9028 divbuf_0/a_2430_n840# divbuf_0/a_2910_n840# 0.07fF
C9029 divbuf_0/a_21502_170# divbuf_0/OUT4 0.19fF
C9030 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n1540# 0.19fF
C9031 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/nor_0/B 0.35fF
C9032 gnd pd_div_0/bufin 0.29fF
C9033 divbuf_1/a_3912_170# divbuf_1/a_3422_170# 0.07fF
C9034 divbuf_2/a_41280_n1600# divbuf_2/a_41310_n1540# 0.19fF
C9035 divbuf_2/a_41310_n840# divbuf_2/a_41790_n840# 0.07fF
C9036 divbuf_2/a_11070_n840# divbuf_2/a_11070_n1540# 0.01fF
C9037 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55680_n1600# 0.26fF
C9038 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/a_1842_n240# 0.04fF
C9039 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_16830_n840# 0.04fF
C9040 divbuf_0/a_55230_n1540# divbuf_0/a_55710_n1540# 0.11fF
C9041 divbuf_1/a_15360_n1600# divbuf_1/a_15390_n840# 0.04fF
C9042 divbuf_1/a_7302_170# divbuf_1/OUT3 0.19fF
C9043 divbuf_3/a_31202_170# divbuf_3/a_31682_170# 0.07fF
C9044 divbuf_3/a_11802_170# divbuf_3/a_11802_n240# 0.01fF
C9045 divbuf_5/a_4320_n1600# divbuf_5/a_4350_n840# 0.04fF
C9046 pll_full_0/divbuf_0/a_47550_n1540# pll_full_0/divbuf_0/a_48030_n1540# 0.11fF
C9047 divbuf_3/a_9120_n1600# divbuf_3/OUT3 0.00fF
C9048 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/a_4830_n840# 0.04fF
C9049 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14880_n1600# 0.26fF
C9050 divbuf_4/a_39442_170# divbuf_4/a_39442_n240# 0.01fF
C9051 divbuf_4/a_19562_n240# divbuf_4/a_20042_n240# 0.05fF
C9052 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/a_8190_n840# 0.03fF
C9053 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_18240_n1600# 0.26fF
C9054 divbuf_3/a_3870_n840# divbuf_3/a_4350_n840# 0.07fF
C9055 divbuf_3/a_3840_n1600# divbuf_3/a_3870_n1540# 0.19fF
C9056 pd_div_0/divbuf_0/a_37470_n840# pd_div_0/divbuf_0/a_37470_n1540# 0.01fF
C9057 pd_div_0/divbuf_0/a_6750_n1540# pd_div_0/divbuf_0/a_7230_n1540# 0.11fF
C9058 divbuf_4/a_31200_n1600# divbuf_4/a_31230_n1540# 0.19fF
C9059 divbuf_4/a_31230_n840# divbuf_4/a_31710_n840# 0.07fF
C9060 divbuf_4/a_990_n840# divbuf_4/a_990_n1540# 0.01fF
C9061 divbuf_4/a_40412_n240# divbuf_4/OUT4 0.04fF
C9062 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9063 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/divider_0/clk 1.30fF
C9064 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_480_n1600# 0.00fF
C9065 pll_full_0/divbuf_1/a_10110_n1540# pll_full_0/divbuf_1/a_10590_n1540# 0.11fF
C9066 pll_full_0/divbuf_1/a_40830_n840# pll_full_0/divbuf_1/a_40830_n1540# 0.01fF
C9067 divbuf_0/a_22472_n240# divbuf_0/OUT4 0.04fF
C9068 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n840# 0.04fF
C9069 divbuf_1/a_28772_170# divbuf_1/a_29262_170# 0.07fF
C9070 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45150_n840# 0.04fF
C9071 divbuf_5/a_21012_170# divbuf_5/a_21502_170# 0.07fF
C9072 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C9073 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6270_n1540# 0.19fF
C9074 ro_div_0/divbuf_0/a_6270_n840# ro_div_0/divbuf_0/a_6750_n840# 0.07fF
C9075 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z2 0.19fF
C9076 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z1 0.09fF
C9077 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_4882_170# 0.07fF
C9078 divbuf_1/a_4830_n840# divbuf_1/a_5310_n840# 0.07fF
C9079 divbuf_1/a_22952_170# divbuf_1/OUT4 0.19fF
C9080 divbuf_1/a_4800_n1600# divbuf_1/a_4830_n1540# 0.19fF
C9081 divbuf_5/a_3912_170# divbuf_5/OUT3 0.19fF
C9082 divbuf_5/a_54240_n1600# divbuf_5/a_54720_n1600# 0.26fF
C9083 divbuf_3/a_56160_n1600# divbuf_3/a_56190_n1540# 0.19fF
C9084 ro_div_0/divbuf_0/a_59070_n1540# ro_div_0/divbuf_0/a_59550_n1540# 0.11fF
C9085 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4350_n840# 0.04fF
C9086 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/a_38472_n240# 0.01fF
C9087 divbuf_1/a_57630_n1540# divbuf_1/a_58110_n1540# 0.11fF
C9088 divbuf_3/a_54240_n1600# divbuf_3/a_54270_n840# 0.04fF
C9089 divbuf_5/a_46590_n1540# divbuf_5/a_47070_n1540# 0.11fF
C9090 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_7710_n840# 0.04fF
C9091 divbuf_0/a_30712_n240# divbuf_0/a_31202_n240# 0.04fF
C9092 divbuf_2/a_27840_n1600# divbuf_2/a_28320_n1600# 0.26fF
C9093 divbuf_2/a_18582_n240# divbuf_2/a_18750_n840# 0.02fF
C9094 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/a_23442_n240# 0.04fF
C9095 divbuf_0/a_20640_n1600# divbuf_0/OUT4 0.00fF
C9096 divbuf_0/a_12030_n840# divbuf_0/a_12030_n1540# 0.01fF
C9097 divbuf_0/a_42270_n840# divbuf_0/a_42750_n840# 0.07fF
C9098 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n1540# 0.19fF
C9099 pll_full_0/divbuf_0/a_4350_n840# pll_full_0/divbuf_0/a_4350_n1540# 0.01fF
C9100 pll_full_0/divbuf_0/a_34590_n840# pll_full_0/divbuf_0/a_35070_n840# 0.07fF
C9101 divbuf_2/a_50910_n840# divbuf_2/a_50910_n1540# 0.01fF
C9102 divbuf_2/a_20190_n1540# divbuf_2/a_20670_n1540# 0.11fF
C9103 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_34590_n1540# 0.19fF
C9104 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_56670_n840# 0.04fF
C9105 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9106 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/a_21502_170# 0.07fF
C9107 divbuf_1/a_27322_n240# divbuf_1/OUT4 0.04fF
C9108 divbuf_1/a_55200_n1600# divbuf_1/a_55230_n840# 0.04fF
C9109 divbuf_3/a_32172_n240# divbuf_3/a_32652_n240# 0.05fF
C9110 divbuf_5/a_4882_n240# divbuf_5/OUT3 0.04fF
C9111 divbuf_5/a_44160_n1600# divbuf_5/a_44190_n840# 0.04fF
C9112 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/a_24892_170# 0.07fF
C9113 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/a_4392_n240# 0.01fF
C9114 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.61fF
C9115 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z3 0.45fF
C9116 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54720_n1600# 0.26fF
C9117 divbuf_3/a_43680_n1600# divbuf_3/a_43710_n1540# 0.19fF
C9118 divbuf_3/a_43710_n840# divbuf_3/a_44190_n840# 0.07fF
C9119 divbuf_3/a_13470_n840# divbuf_3/a_13470_n1540# 0.01fF
C9120 divbuf_4/a_17760_n1600# divbuf_4/a_18240_n1600# 0.26fF
C9121 divbuf_4/a_8272_n240# divbuf_4/a_8190_n840# 0.03fF
C9122 io_clamp_low[2] io_analog[6] 0.53fF
C9123 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_58080_n1600# 0.26fF
C9124 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/OUT4 0.07fF
C9125 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C9126 pd_div_0/divbuf_0/a_46590_n1540# pd_div_0/divbuf_0/a_47070_n1540# 0.11fF
C9127 divbuf_2/a_17760_n1600# divbuf_2/a_17790_n840# 0.04fF
C9128 divbuf_4/a_40830_n840# divbuf_4/a_40830_n1540# 0.01fF
C9129 divbuf_4/a_10110_n1540# divbuf_4/a_10590_n1540# 0.11fF
C9130 pll_full_0/divbuf_1/a_49950_n1540# pll_full_0/divbuf_1/a_50430_n1540# 0.11fF
C9131 divbuf_0/a_990_n840# divbuf_0/OUT2 0.02fF
C9132 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/a_35082_n240# 0.04fF
C9133 divbuf_1/a_33142_n240# divbuf_1/a_33622_n240# 0.05fF
C9134 divbuf_5/a_21982_n240# divbuf_5/a_22472_n240# 0.04fF
C9135 ro_div_0/divbuf_0/a_15870_n840# ro_div_0/divbuf_0/a_15870_n1540# 0.01fF
C9136 ro_div_0/divbuf_0/a_46110_n840# ro_div_0/divbuf_0/a_46590_n840# 0.07fF
C9137 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46110_n1540# 0.19fF
C9138 divbuf_1/a_44640_n1600# divbuf_1/a_44670_n1540# 0.19fF
C9139 divbuf_1/a_44670_n840# divbuf_1/a_45150_n840# 0.07fF
C9140 divbuf_1/a_14430_n840# divbuf_1/a_14430_n1540# 0.01fF
C9141 divbuf_5/a_33600_n1600# divbuf_5/a_33630_n1540# 0.19fF
C9142 divbuf_5/a_33630_n840# divbuf_5/a_34110_n840# 0.07fF
C9143 divbuf_5/a_3390_n840# divbuf_5/a_3390_n1540# 0.01fF
C9144 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C9145 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/switch_3/vin 0.20fF
C9146 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C9147 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44190_n840# 0.04fF
C9148 divbuf_2/a_15182_170# divbuf_2/a_15182_n240# 0.01fF
C9149 divbuf_2/a_34592_170# divbuf_2/a_35082_170# 0.07fF
C9150 divbuf_4/a_7680_n1600# divbuf_4/a_7710_n840# 0.04fF
C9151 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_47550_n840# 0.04fF
C9152 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9153 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/a_7230_n840# 0.03fF
C9154 divbuf_0/a_19562_n240# divbuf_0/a_19710_n840# 0.03fF
C9155 divbuf_0/a_28800_n1600# divbuf_0/a_29280_n1600# 0.26fF
C9156 divbuf_2/a_7200_n1600# divbuf_2/a_7230_n1540# 0.19fF
C9157 divbuf_2/a_31202_170# divbuf_2/OUT4 0.19fF
C9158 divbuf_2/a_7230_n840# divbuf_2/a_7710_n840# 0.07fF
C9159 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_12030_n840# 0.02fF
C9160 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21600_n1600# 0.26fF
C9161 divbuf_0/a_51870_n840# divbuf_0/a_51870_n1540# 0.01fF
C9162 divbuf_0/a_21150_n1540# divbuf_0/a_21630_n1540# 0.11fF
C9163 divbuf_1/a_1352_n240# divbuf_1/a_1470_n840# 0.03fF
C9164 divbuf_2/a_60030_n1540# divbuf_2/a_60510_n1540# 0.11fF
C9165 pll_full_0/divbuf_0/a_44190_n840# pll_full_0/divbuf_0/a_44190_n1540# 0.01fF
C9166 pll_full_0/divbuf_0/a_13470_n1540# pll_full_0/divbuf_0/a_13950_n1540# 0.11fF
C9167 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C9168 divbuf_3/a_21012_170# divbuf_3/OUT4 0.19fF
C9169 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/a_22472_n240# 0.04fF
C9170 divbuf_4/a_4392_170# divbuf_4/a_4392_n240# 0.01fF
C9171 divbuf_4/a_24412_170# divbuf_4/a_24892_170# 0.07fF
C9172 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/a_25862_n240# 0.05fF
C9173 divbuf_3/a_30240_n1600# divbuf_3/a_30720_n1600# 0.26fF
C9174 divbuf_3/a_21012_n240# divbuf_3/a_21150_n840# 0.03fF
C9175 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C9176 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_33630_n1540# 0.19fF
C9177 pd_div_0/divbuf_0/a_33630_n840# pd_div_0/divbuf_0/a_34110_n840# 0.07fF
C9178 pd_div_0/divbuf_0/a_3390_n840# pd_div_0/divbuf_0/a_3390_n1540# 0.01fF
C9179 divbuf_4/a_10212_170# divbuf_4/OUT4 0.07fF
C9180 divbuf_4/a_57600_n1600# divbuf_4/a_58080_n1600# 0.26fF
C9181 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_36990_n1540# 0.19fF
C9182 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/OUT3 0.01fF
C9183 pll_full_0/divbuf_1/a_6750_n840# pll_full_0/divbuf_1/a_6750_n1540# 0.01fF
C9184 pll_full_0/divbuf_1/a_36990_n840# pll_full_0/divbuf_1/a_37470_n840# 0.07fF
C9185 divbuf_3/a_22590_n1540# divbuf_3/a_23070_n1540# 0.11fF
C9186 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C9187 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C9188 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n840# 0.04fF
C9189 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 0.94fF
C9190 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/and_0/OUT 0.14fF
C9191 divbuf_2/a_32172_n240# divbuf_2/OUT4 0.04fF
C9192 divbuf_2/a_57600_n1600# divbuf_2/a_57630_n840# 0.04fF
C9193 divbuf_4/a_49950_n1540# divbuf_4/a_50430_n1540# 0.11fF
C9194 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C9195 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C9196 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11070_n840# 0.04fF
C9197 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/a_23550_n840# 0.03fF
C9198 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_33120_n1600# 0.26fF
C9199 divbuf_1/a_31200_n1600# divbuf_1/a_31680_n1600# 0.26fF
C9200 divbuf_1/a_21982_n240# divbuf_1/a_22110_n840# 0.03fF
C9201 divbuf_5/a_20160_n1600# divbuf_5/a_20640_n1600# 0.26fF
C9202 divbuf_3/a_21982_n240# divbuf_3/OUT4 0.04fF
C9203 ro_div_0/divbuf_0/a_24990_n1540# ro_div_0/divbuf_0/a_25470_n1540# 0.11fF
C9204 ro_div_0/divbuf_0/a_55710_n840# ro_div_0/divbuf_0/a_55710_n1540# 0.01fF
C9205 divbuf_1/a_54270_n840# divbuf_1/a_54270_n1540# 0.01fF
C9206 divbuf_1/a_23550_n1540# divbuf_1/a_24030_n1540# 0.11fF
C9207 divbuf_5/a_43230_n840# divbuf_5/a_43230_n1540# 0.01fF
C9208 divbuf_5/a_12510_n1540# divbuf_5/a_12990_n1540# 0.11fF
C9209 divbuf_3/a_20160_n1600# divbuf_3/a_20190_n840# 0.04fF
C9210 divbuf_0/a_35562_170# divbuf_0/a_36052_170# 0.07fF
C9211 divbuf_2/a_35562_n240# divbuf_2/a_36052_n240# 0.04fF
C9212 divbuf_4/a_11802_n240# divbuf_4/OUT4 0.04fF
C9213 divbuf_4/a_47520_n1600# divbuf_4/a_47550_n840# 0.04fF
C9214 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/a_28292_170# 0.07fF
C9215 pll_full_0/divbuf_0/a_7302_170# pll_full_0/divbuf_0/a_7302_n240# 0.01fF
C9216 divbuf_0/a_8190_n840# divbuf_0/a_8670_n840# 0.07fF
C9217 divbuf_0/a_33142_170# divbuf_0/OUT4 0.19fF
C9218 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n1540# 0.19fF
C9219 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/tspc_0/Z2 0.11fF
C9220 divbuf_1/a_6332_170# divbuf_1/a_6332_n240# 0.01fF
C9221 divbuf_1/a_18582_170# divbuf_1/a_18582_n240# 0.01fF
C9222 divbuf_2/a_47040_n1600# divbuf_2/a_47070_n1540# 0.19fF
C9223 divbuf_2/a_47070_n840# divbuf_2/a_47550_n840# 0.07fF
C9224 divbuf_2/a_16830_n840# divbuf_2/a_16830_n1540# 0.01fF
C9225 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_510_n1540# 0.19fF
C9226 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/a_990_n840# 0.07fF
C9227 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9228 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/a_8272_n240# 0.05fF
C9229 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_22590_n840# 0.04fF
C9230 divbuf_1/a_21120_n1600# divbuf_1/a_21150_n840# 0.04fF
C9231 divbuf_5/a_10080_n1600# divbuf_5/a_10110_n840# 0.04fF
C9232 pll_full_0/divbuf_0/a_53310_n1540# pll_full_0/divbuf_0/a_53790_n1540# 0.11fF
C9233 divbuf_3/a_17612_170# divbuf_3/a_17612_n240# 0.01fF
C9234 divbuf_3/a_37022_170# divbuf_3/a_37502_170# 0.07fF
C9235 divbuf_3/a_20160_n1600# divbuf_3/OUT4 0.00fF
C9236 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20640_n1600# 0.26fF
C9237 divbuf_4/a_25382_n240# divbuf_4/a_25862_n240# 0.05fF
C9238 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_24000_n1600# 0.26fF
C9239 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_14430_n840# 0.02fF
C9240 divbuf_3/a_9600_n1600# divbuf_3/a_9630_n1540# 0.19fF
C9241 divbuf_3/a_9630_n840# divbuf_3/a_10110_n840# 0.07fF
C9242 pd_div_0/divbuf_0/a_43230_n840# pd_div_0/divbuf_0/a_43230_n1540# 0.01fF
C9243 pd_div_0/divbuf_0/a_12510_n1540# pd_div_0/divbuf_0/a_12990_n1540# 0.11fF
C9244 divbuf_4/a_36990_n840# divbuf_4/a_37470_n840# 0.07fF
C9245 divbuf_4/a_6750_n840# divbuf_4/a_6750_n1540# 0.01fF
C9246 divbuf_4/a_10560_n1600# divbuf_4/OUT3 0.01fF
C9247 divbuf_4/a_36960_n1600# divbuf_4/a_36990_n1540# 0.19fF
C9248 pll_full_0/divbuf_1/a_15870_n1540# pll_full_0/divbuf_1/a_16350_n1540# 0.11fF
C9249 pll_full_0/divbuf_1/a_46590_n840# pll_full_0/divbuf_1/a_46590_n1540# 0.01fF
C9250 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C9251 ro_div_0/ro_complete_0/cbank_0/v ro_div_0/divider_0/clk 1.27fF
C9252 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n840# 0.04fF
C9253 divbuf_0/a_34112_n240# divbuf_0/OUT4 0.04fF
C9254 divbuf_1/a_37992_170# divbuf_1/a_38472_170# 0.07fF
C9255 divbuf_5/a_6822_170# divbuf_5/a_6822_n240# 0.01fF
C9256 divbuf_5/a_26832_170# divbuf_5/a_27322_170# 0.07fF
C9257 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9258 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_50910_n840# 0.04fF
C9259 ro_div_0/divbuf_0/a_12030_n840# ro_div_0/divbuf_0/a_12510_n840# 0.07fF
C9260 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12030_n1540# 0.19fF
C9261 ro_div_0/divider_0/and_0/OUT gnd 0.32fF
C9262 divbuf_1/a_10560_n1600# divbuf_1/a_10590_n1540# 0.19fF
C9263 divbuf_1/a_37992_170# divbuf_1/OUT4 0.19fF
C9264 divbuf_1/a_10590_n840# divbuf_1/a_11070_n840# 0.07fF
C9265 divbuf_5/a_15672_170# divbuf_5/OUT4 0.19fF
C9266 divbuf_5/a_60000_n1600# divbuf_5/a_60480_n1600# 0.26fF
C9267 divbuf_3/a_510_n840# divbuf_3/OUT2 0.02fF
C9268 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10110_n840# 0.04fF
C9269 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13470_n840# 0.04fF
C9270 divbuf_1/OUT3 divbuf_1/OUT4 0.36fF
C9271 divbuf_3/a_60000_n1600# divbuf_3/a_60030_n840# 0.04fF
C9272 divbuf_5/a_52350_n1540# divbuf_5/a_52830_n1540# 0.11fF
C9273 divbuf_0/a_36532_n240# divbuf_0/a_37022_n240# 0.04fF
C9274 divbuf_2/a_24412_n240# divbuf_2/a_24510_n840# 0.03fF
C9275 divbuf_2/a_33600_n1600# divbuf_2/a_34080_n1600# 0.26fF
C9276 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/a_29262_n240# 0.04fF
C9277 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n1540# 0.19fF
C9278 divbuf_0/a_32160_n1600# divbuf_0/OUT4 0.00fF
C9279 divbuf_0/a_48030_n840# divbuf_0/a_48510_n840# 0.07fF
C9280 divbuf_0/a_17790_n840# divbuf_0/a_17790_n1540# 0.01fF
C9281 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40350_n1540# 0.19fF
C9282 divbuf_2/a_56670_n840# divbuf_2/a_56670_n1540# 0.01fF
C9283 divbuf_2/a_25950_n1540# divbuf_2/a_26430_n1540# 0.11fF
C9284 pll_full_0/divbuf_0/a_40350_n840# pll_full_0/divbuf_0/a_40830_n840# 0.07fF
C9285 pll_full_0/divbuf_0/a_10110_n840# pll_full_0/divbuf_0/a_10110_n1540# 0.01fF
C9286 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/OUT5 0.04fF
C9287 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C9288 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/a_27322_170# 0.07fF
C9289 divbuf_3/a_53310_n1540# divbuf_3/a_53790_n1540# 0.11fF
C9290 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/a_10212_n240# 0.01fF
C9291 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/a_30712_170# 0.07fF
C9292 divbuf_1/a_38962_n240# divbuf_1/OUT4 0.04fF
C9293 divbuf_3/a_37992_n240# divbuf_3/a_38472_n240# 0.05fF
C9294 divbuf_5/a_49920_n1600# divbuf_5/a_49950_n840# 0.04fF
C9295 divbuf_5/a_16642_n240# divbuf_5/OUT4 0.04fF
C9296 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/and_0/OUT 0.05fF
C9297 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9298 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60480_n1600# 0.26fF
C9299 divbuf_4/a_14222_n240# divbuf_4/a_14430_n840# 0.02fF
C9300 divbuf_4/a_23520_n1600# divbuf_4/a_24000_n1600# 0.26fF
C9301 divbuf_3/a_49470_n840# divbuf_3/a_49950_n840# 0.07fF
C9302 divbuf_3/a_19230_n840# divbuf_3/a_19230_n1540# 0.01fF
C9303 divbuf_3/a_49440_n1600# divbuf_3/a_49470_n1540# 0.19fF
C9304 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C9305 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/a_3390_n840# 0.07fF
C9306 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9307 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_2910_n1540# 0.19fF
C9308 pd_div_0/divbuf_0/a_52350_n1540# pd_div_0/divbuf_0/a_52830_n1540# 0.11fF
C9309 divbuf_2/a_2322_170# divbuf_2/OUT2 0.19fF
C9310 divbuf_2/a_23520_n1600# divbuf_2/a_23550_n840# 0.04fF
C9311 divbuf_4/a_46590_n840# divbuf_4/a_46590_n1540# 0.01fF
C9312 divbuf_4/a_15870_n1540# divbuf_4/a_16350_n1540# 0.11fF
C9313 pll_full_0/divbuf_1/a_55710_n1540# pll_full_0/divbuf_1/a_56190_n1540# 0.11fF
C9314 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/a_40902_n240# 0.04fF
C9315 divbuf_1/a_38962_n240# divbuf_1/a_39442_n240# 0.05fF
C9316 divbuf_5/a_27802_n240# divbuf_5/a_28292_n240# 0.04fF
C9317 ashish_0/a_150_0# ashish_0/Gnd 1.74fF
C9318 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_51870_n1540# 0.19fF
C9319 ro_div_0/divbuf_0/a_21630_n840# ro_div_0/divbuf_0/a_21630_n1540# 0.01fF
C9320 ro_div_0/divbuf_0/a_51870_n840# ro_div_0/divbuf_0/a_52350_n840# 0.07fF
C9321 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/IN 0.00fF
C9322 divbuf_1/a_50430_n840# divbuf_1/a_50910_n840# 0.07fF
C9323 divbuf_1/a_20190_n840# divbuf_1/a_20190_n1540# 0.01fF
C9324 divbuf_1/a_50400_n1600# divbuf_1/a_50430_n1540# 0.19fF
C9325 divbuf_5/a_39390_n840# divbuf_5/a_39870_n840# 0.07fF
C9326 divbuf_5/a_9150_n840# divbuf_5/a_9150_n1540# 0.01fF
C9327 divbuf_5/a_39360_n1600# divbuf_5/a_39390_n1540# 0.19fF
C9328 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_49950_n840# 0.04fF
C9329 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9330 divbuf_2/a_40412_170# divbuf_2/a_40902_170# 0.07fF
C9331 divbuf_2/a_21012_170# divbuf_2/a_21012_n240# 0.01fF
C9332 divbuf_4/a_13440_n1600# divbuf_4/a_13470_n840# 0.04fF
C9333 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9334 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53310_n840# 0.04fF
C9335 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_13470_n840# 0.02fF
C9336 divbuf_0/a_34560_n1600# divbuf_0/a_35040_n1600# 0.26fF
C9337 divbuf_0/a_17122_170# divbuf_0/OUT4 0.19fF
C9338 divbuf_0/a_25382_n240# divbuf_0/a_25470_n840# 0.03fF
C9339 divbuf_2/a_3422_n240# divbuf_2/OUT3 0.07fF
C9340 divbuf_2/a_12960_n1600# divbuf_2/a_12990_n1540# 0.19fF
C9341 divbuf_2/a_12990_n840# divbuf_2/a_13470_n840# 0.07fF
C9342 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_27360_n1600# 0.26fF
C9343 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_17790_n840# 0.02fF
C9344 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C9345 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/a_15182_170# 0.07fF
C9346 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C9347 divbuf_0/a_26910_n1540# divbuf_0/a_27390_n1540# 0.11fF
C9348 divbuf_0/a_57630_n840# divbuf_0/a_57630_n1540# 0.01fF
C9349 divbuf_3/a_1352_170# divbuf_3/a_1842_170# 0.07fF
C9350 pll_full_0/divbuf_0/a_19230_n1540# pll_full_0/divbuf_0/a_19710_n1540# 0.11fF
C9351 pll_full_0/divbuf_0/a_49950_n840# pll_full_0/divbuf_0/a_49950_n1540# 0.01fF
C9352 divbuf_3/a_32652_170# divbuf_3/OUT4 0.19fF
C9353 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/a_28292_n240# 0.04fF
C9354 divbuf_3/a_26832_n240# divbuf_3/a_26910_n840# 0.04fF
C9355 divbuf_3/a_36000_n1600# divbuf_3/a_36480_n1600# 0.26fF
C9356 divbuf_4/a_30232_170# divbuf_4/a_30712_170# 0.07fF
C9357 divbuf_4/a_10212_170# divbuf_4/a_10212_n240# 0.01fF
C9358 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/a_31682_n240# 0.05fF
C9359 divbuf_0/a_6822_170# divbuf_0/a_6822_n240# 0.01fF
C9360 pd_div_0/divbuf_0/a_39390_n840# pd_div_0/divbuf_0/a_39870_n840# 0.07fF
C9361 pd_div_0/divbuf_0/a_9150_n840# pd_div_0/divbuf_0/a_9150_n1540# 0.01fF
C9362 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39390_n1540# 0.19fF
C9363 divbuf_4/a_2880_n1600# divbuf_4/a_2910_n1540# 0.19fF
C9364 divbuf_4/a_22472_170# divbuf_4/OUT4 0.19fF
C9365 divbuf_4/a_2910_n840# divbuf_4/a_3390_n840# 0.07fF
C9366 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C9367 pll_full_0/divbuf_1/a_12510_n840# pll_full_0/divbuf_1/a_12510_n1540# 0.01fF
C9368 pll_full_0/divbuf_1/a_42750_n840# pll_full_0/divbuf_1/a_43230_n840# 0.07fF
C9369 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_42750_n1540# 0.19fF
C9370 divbuf_3/a_28350_n1540# divbuf_3/a_28830_n1540# 0.11fF
C9371 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n840# 0.04fF
C9372 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 pd_div_0/divider_0/clk 0.12fF
C9373 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 0.22fF
C9374 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/tspc_0/Z2 1.07fF
C9375 divbuf_1/a_15182_170# divbuf_1/a_15672_170# 0.07fF
C9376 divbuf_2/a_2880_n1600# divbuf_2/OUT2 0.00fF
C9377 divbuf_4/a_55710_n1540# divbuf_4/a_56190_n1540# 0.11fF
C9378 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_16830_n840# 0.04fF
C9379 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/a_14702_n240# 0.01fF
C9380 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/a_29310_n840# 0.04fF
C9381 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38880_n1600# 0.26fF
C9382 divbuf_1/a_27802_n240# divbuf_1/a_27870_n840# 0.04fF
C9383 divbuf_1/a_36960_n1600# divbuf_1/a_37440_n1600# 0.26fF
C9384 divbuf_5/a_16642_n240# divbuf_5/a_16830_n840# 0.02fF
C9385 divbuf_5/a_25920_n1600# divbuf_5/a_26400_n1600# 0.26fF
C9386 divbuf_3/a_33622_n240# divbuf_3/OUT4 0.04fF
C9387 ro_div_0/divbuf_0/a_30750_n1540# ro_div_0/divbuf_0/a_31230_n1540# 0.11fF
C9388 divbuf_1/a_60030_n840# divbuf_1/a_60030_n1540# 0.01fF
C9389 divbuf_1/a_29310_n1540# divbuf_1/a_29790_n1540# 0.11fF
C9390 divbuf_5/a_48990_n840# divbuf_5/a_48990_n1540# 0.01fF
C9391 divbuf_5/a_18270_n1540# divbuf_5/a_18750_n1540# 0.11fF
C9392 divbuf_3/a_25920_n1600# divbuf_3/a_25950_n840# 0.04fF
C9393 divbuf_0/a_21982_170# divbuf_0/a_21982_n240# 0.01fF
C9394 divbuf_4/a_53280_n1600# divbuf_4/a_53310_n840# 0.04fF
C9395 divbuf_4/a_23442_n240# divbuf_4/OUT4 0.04fF
C9396 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9397 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/a_34112_170# 0.07fF
C9398 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n1540# 0.19fF
C9399 divbuf_0/a_5362_n240# divbuf_0/OUT3 0.04fF
C9400 divbuf_0/a_13950_n840# divbuf_0/a_14430_n840# 0.07fF
C9401 divbuf_2/a_52800_n1600# divbuf_2/a_52830_n1540# 0.19fF
C9402 divbuf_2/a_52830_n840# divbuf_2/a_53310_n840# 0.07fF
C9403 divbuf_2/a_22590_n840# divbuf_2/a_22590_n1540# 0.01fF
C9404 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9405 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6270_n1540# 0.19fF
C9406 pll_full_0/divbuf_0/a_6270_n840# pll_full_0/divbuf_0/a_6750_n840# 0.07fF
C9407 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_14702_n240# 0.05fF
C9408 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28350_n840# 0.04fF
C9409 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z3 0.65fF
C9410 divbuf_1/a_26880_n1600# divbuf_1/a_26910_n840# 0.04fF
C9411 divbuf_5/a_15840_n1600# divbuf_5/a_15870_n840# 0.04fF
C9412 divbuf_3/a_23442_170# divbuf_3/a_23442_n240# 0.01fF
C9413 pll_full_0/divbuf_0/a_59070_n1540# pll_full_0/divbuf_0/a_59550_n1540# 0.11fF
C9414 divbuf_3/a_31680_n1600# divbuf_3/OUT4 0.00fF
C9415 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_16830_n840# 0.02fF
C9416 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_26400_n1600# 0.26fF
C9417 divbuf_4/a_31202_n240# divbuf_4/a_31682_n240# 0.05fF
C9418 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/a_20190_n840# 0.03fF
C9419 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29760_n1600# 0.26fF
C9420 divbuf_3/a_15390_n840# divbuf_3/a_15870_n840# 0.07fF
C9421 divbuf_3/a_15360_n1600# divbuf_3/a_15390_n1540# 0.19fF
C9422 pd_div_0/divbuf_0/a_48990_n840# pd_div_0/divbuf_0/a_48990_n1540# 0.01fF
C9423 pd_div_0/divbuf_0/a_18270_n1540# pd_div_0/divbuf_0/a_18750_n1540# 0.11fF
C9424 divbuf_4/a_42720_n1600# divbuf_4/a_42750_n1540# 0.19fF
C9425 divbuf_4/a_42750_n840# divbuf_4/a_43230_n840# 0.07fF
C9426 divbuf_4/a_12510_n840# divbuf_4/a_12510_n1540# 0.01fF
C9427 divbuf_4/a_21600_n1600# divbuf_4/OUT4 0.01fF
C9428 pll_full_0/divbuf_1/a_21630_n1540# pll_full_0/divbuf_1/a_22110_n1540# 0.11fF
C9429 pll_full_0/divbuf_1/a_52350_n840# pll_full_0/divbuf_1/a_52350_n1540# 0.01fF
C9430 divbuf_1/a_3912_n240# divbuf_1/a_4392_n240# 0.05fF
C9431 divbuf_5/a_32652_170# divbuf_5/a_33142_170# 0.07fF
C9432 divbuf_5/a_13252_170# divbuf_5/a_13252_n240# 0.01fF
C9433 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_56670_n840# 0.04fF
C9434 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9435 pd_0/R pd_0/REF 0.61fF
C9436 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_17790_n1540# 0.19fF
C9437 ro_div_0/divbuf_0/a_17790_n840# ro_div_0/divbuf_0/a_18270_n840# 0.07fF
C9438 divbuf_1/a_16350_n840# divbuf_1/a_16830_n840# 0.07fF
C9439 divbuf_1/a_10212_n240# divbuf_1/OUT3 0.04fF
C9440 divbuf_1/a_16320_n1600# divbuf_1/a_16350_n1540# 0.19fF
C9441 divbuf_5/a_5310_n840# divbuf_5/a_5790_n840# 0.07fF
C9442 divbuf_5/a_5280_n1600# divbuf_5/a_5310_n1540# 0.19fF
C9443 divbuf_5/a_27322_170# divbuf_5/OUT4 0.19fF
C9444 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_15870_n840# 0.04fF
C9445 divbuf_2/a_5362_170# divbuf_2/a_5852_170# 0.07fF
C9446 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19230_n840# 0.04fF
C9447 divbuf_5/a_58110_n1540# divbuf_5/a_58590_n1540# 0.11fF
C9448 divbuf_0/a_480_n1600# divbuf_0/a_960_n1600# 0.26fF
C9449 divbuf_2/a_39360_n1600# divbuf_2/a_39840_n1600# 0.26fF
C9450 divbuf_2/a_30232_n240# divbuf_2/a_30270_n840# 0.05fF
C9451 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/a_35082_n240# 0.04fF
C9452 divbuf_0/a_23550_n840# divbuf_0/a_23550_n1540# 0.01fF
C9453 divbuf_0/a_53790_n840# divbuf_0/a_54270_n840# 0.07fF
C9454 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n1540# 0.19fF
C9455 pll_full_0/divbuf_0/a_15870_n840# pll_full_0/divbuf_0/a_15870_n1540# 0.01fF
C9456 pll_full_0/divbuf_0/a_46110_n840# pll_full_0/divbuf_0/a_46590_n840# 0.07fF
C9457 divbuf_2/a_31710_n1540# divbuf_2/a_32190_n1540# 0.11fF
C9458 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46110_n1540# 0.19fF
C9459 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C9460 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/a_33142_170# 0.07fF
C9461 divbuf_1/a_9120_n1600# divbuf_1/OUT3 0.00fF
C9462 divbuf_3/a_59070_n1540# divbuf_3/a_59550_n1540# 0.11fF
C9463 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/a_36532_170# 0.07fF
C9464 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/a_16642_n240# 0.01fF
C9465 divbuf_3/a_1920_n1600# divbuf_3/a_2400_n1600# 0.26fF
C9466 divbuf_5/a_28292_n240# divbuf_5/OUT4 0.04fF
C9467 divbuf_5/a_55680_n1600# divbuf_5/a_55710_n840# 0.04fF
C9468 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_1/Z4 0.02fF
C9469 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_2/Z2 0.20fF
C9470 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C9471 pd_div_0/divbuf_0/a_5310_n840# pd_div_0/divbuf_0/a_5790_n840# 0.07fF
C9472 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5310_n1540# 0.19fF
C9473 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9474 divbuf_4/a_29280_n1600# divbuf_4/a_29760_n1600# 0.26fF
C9475 divbuf_4/a_20042_n240# divbuf_4/a_20190_n840# 0.03fF
C9476 pll_full_0/divbuf_1/a_8670_n840# pll_full_0/divbuf_1/a_9150_n840# 0.07fF
C9477 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9478 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_8670_n1540# 0.19fF
C9479 divbuf_3/a_55230_n840# divbuf_3/a_55710_n840# 0.07fF
C9480 divbuf_3/a_24990_n840# divbuf_3/a_24990_n1540# 0.01fF
C9481 divbuf_0/a_11312_n240# divbuf_0/a_11070_n840# 0.02fF
C9482 pd_div_0/divbuf_0/a_58110_n1540# pd_div_0/divbuf_0/a_58590_n1540# 0.11fF
C9483 divbuf_4/a_52350_n840# divbuf_4/a_52350_n1540# 0.01fF
C9484 divbuf_4/a_21630_n1540# divbuf_4/a_22110_n1540# 0.11fF
C9485 divbuf_2/a_29280_n1600# divbuf_2/a_29310_n840# 0.04fF
C9486 divbuf_2/a_14222_170# divbuf_2/OUT4 0.19fF
C9487 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4800_n1600# 0.26fF
C9488 divbuf_1/a_2880_n1600# divbuf_1/a_3360_n1600# 0.26fF
C9489 divbuf_5/a_33622_n240# divbuf_5/a_34112_n240# 0.04fF
C9490 divbuf_3/a_3912_170# divbuf_3/OUT3 0.19fF
C9491 ro_div_0/divbuf_0/a_27390_n840# ro_div_0/divbuf_0/a_27390_n1540# 0.01fF
C9492 ro_div_0/divbuf_0/a_57630_n840# ro_div_0/divbuf_0/a_58110_n840# 0.07fF
C9493 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_57630_n1540# 0.19fF
C9494 divbuf_1/a_56160_n1600# divbuf_1/a_56190_n1540# 0.19fF
C9495 divbuf_1/a_56190_n840# divbuf_1/a_56670_n840# 0.07fF
C9496 divbuf_1/a_25950_n840# divbuf_1/a_25950_n1540# 0.01fF
C9497 divbuf_3/a_12772_n240# divbuf_3/a_12510_n840# 0.01fF
C9498 divbuf_5/a_45120_n1600# divbuf_5/a_45150_n1540# 0.19fF
C9499 divbuf_5/a_45150_n840# divbuf_5/a_45630_n840# 0.07fF
C9500 divbuf_5/a_14910_n840# divbuf_5/a_14910_n1540# 0.01fF
C9501 divbuf_0/a_5362_170# divbuf_0/a_5852_170# 0.07fF
C9502 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9503 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_55710_n840# 0.04fF
C9504 divbuf_4/a_19200_n1600# divbuf_4/a_19230_n840# 0.04fF
C9505 divbuf_2/a_26832_170# divbuf_2/a_26832_n240# 0.01fF
C9506 divbuf_2/a_6332_n240# divbuf_2/a_6822_n240# 0.04fF
C9507 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C9508 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59070_n840# 0.04fF
C9509 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9510 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/a_19230_n840# 0.02fF
C9511 divbuf_0/a_31202_n240# divbuf_0/a_31230_n840# 0.05fF
C9512 divbuf_0/a_40320_n1600# divbuf_0/a_40800_n1600# 0.26fF
C9513 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/a_23550_n840# 0.03fF
C9514 divbuf_2/a_18720_n1600# divbuf_2/a_18750_n1540# 0.19fF
C9515 divbuf_2/a_18750_n840# divbuf_2/a_19230_n840# 0.07fF
C9516 divbuf_2/a_15182_n240# divbuf_2/OUT4 0.04fF
C9517 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_33120_n1600# 0.26fF
C9518 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/A 0.55fF
C9519 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_3912_n240# 0.01fF
C9520 pd_0/DIV pd_0/R 0.51fF
C9521 divbuf_0/a_32670_n1540# divbuf_0/a_33150_n1540# 0.11fF
C9522 divbuf_1/a_13742_n240# divbuf_1/a_13470_n840# 0.01fF
C9523 divbuf_3/a_7792_170# divbuf_3/a_8272_170# 0.07fF
C9524 divbuf_5/a_1842_n240# divbuf_5/a_1950_n840# 0.03fF
C9525 pll_full_0/divbuf_0/a_55710_n840# pll_full_0/divbuf_0/a_55710_n1540# 0.01fF
C9526 pll_full_0/divbuf_0/a_24990_n1540# pll_full_0/divbuf_0/a_25470_n1540# 0.11fF
C9527 divbuf_3/a_4882_n240# divbuf_3/OUT3 0.04fF
C9528 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/a_34112_n240# 0.04fF
C9529 divbuf_4/a_16642_170# divbuf_4/a_16642_n240# 0.01fF
C9530 divbuf_4/a_36052_170# divbuf_4/a_36532_170# 0.07fF
C9531 divbuf_3/a_41760_n1600# divbuf_3/a_42240_n1600# 0.26fF
C9532 divbuf_3/a_32652_n240# divbuf_3/a_32670_n840# 0.06fF
C9533 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/a_37502_n240# 0.05fF
C9534 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45150_n1540# 0.19fF
C9535 pd_div_0/divbuf_0/a_45150_n840# pd_div_0/divbuf_0/a_45630_n840# 0.07fF
C9536 pd_div_0/divbuf_0/a_14910_n840# pd_div_0/divbuf_0/a_14910_n1540# 0.01fF
C9537 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/a_9242_n240# 0.01fF
C9538 divbuf_4/a_8640_n1600# divbuf_4/a_8670_n1540# 0.19fF
C9539 divbuf_4/a_34112_170# divbuf_4/OUT4 0.19fF
C9540 divbuf_4/a_8670_n840# divbuf_4/a_9150_n840# 0.07fF
C9541 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48510_n1540# 0.19fF
C9542 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C9543 pll_full_0/divbuf_1/a_18270_n840# pll_full_0/divbuf_1/a_18270_n1540# 0.01fF
C9544 pll_full_0/divbuf_1/a_48510_n840# pll_full_0/divbuf_1/a_48990_n840# 0.07fF
C9545 divbuf_3/a_34110_n1540# divbuf_3/a_34590_n1540# 0.11fF
C9546 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n840# 0.04fF
C9547 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_22590_n840# 0.04fF
C9548 pd_div_0/divider_0/prescaler_0/tspc_2/D gnd 0.05fF
C9549 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/clk 0.64fF
C9550 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/prescaler_0/Out 0.15fF
C9551 divbuf_2/a_13440_n1600# divbuf_2/OUT4 0.00fF
C9552 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9553 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z1 0.03fF
C9554 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C9555 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/a_35070_n840# 0.05fF
C9556 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44640_n1600# 0.26fF
C9557 divbuf_1/a_32172_170# divbuf_1/OUT4 0.19fF
C9558 divbuf_1/a_42720_n1600# divbuf_1/a_43200_n1600# 0.26fF
C9559 divbuf_1/a_33622_n240# divbuf_1/a_33630_n840# 0.06fF
C9560 divbuf_5/a_31680_n1600# divbuf_5/a_32160_n1600# 0.26fF
C9561 divbuf_5/a_22472_n240# divbuf_5/a_22590_n840# 0.03fF
C9562 ro_div_0/divbuf_0/a_36510_n1540# ro_div_0/divbuf_0/a_36990_n1540# 0.11fF
C9563 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/a_1950_n840# 0.03fF
C9564 divbuf_1/a_35070_n1540# divbuf_1/a_35550_n1540# 0.11fF
C9565 divbuf_3/a_31680_n1600# divbuf_3/a_31710_n840# 0.04fF
C9566 divbuf_5/a_54750_n840# divbuf_5/a_54750_n1540# 0.01fF
C9567 divbuf_5/a_24030_n1540# divbuf_5/a_24510_n1540# 0.11fF
C9568 divbuf_0/a_7302_n240# divbuf_0/a_7792_n240# 0.04fF
C9569 divbuf_0/a_27802_170# divbuf_0/a_27802_n240# 0.01fF
C9570 divbuf_2/a_5280_n1600# divbuf_2/a_5760_n1600# 0.26fF
C9571 divbuf_4/a_35082_n240# divbuf_4/OUT4 0.04fF
C9572 divbuf_4/a_59040_n1600# divbuf_4/a_59070_n840# 0.04fF
C9573 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/a_39932_170# 0.07fF
C9574 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/a_20042_n240# 0.01fF
C9575 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9576 divbuf_0/a_17122_n240# divbuf_0/OUT4 0.04fF
C9577 divbuf_0/a_19710_n840# divbuf_0/a_20190_n840# 0.07fF
C9578 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n1540# 0.19fF
C9579 divbuf_2/a_58560_n1600# divbuf_2/a_58590_n1540# 0.19fF
C9580 divbuf_2/a_58590_n840# divbuf_2/a_59070_n840# 0.07fF
C9581 divbuf_2/a_28350_n840# divbuf_2/a_28350_n1540# 0.01fF
C9582 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/OUT2 0.07fF
C9583 pll_full_0/divbuf_0/a_12030_n840# pll_full_0/divbuf_0/a_12510_n840# 0.07fF
C9584 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12030_n1540# 0.19fF
C9585 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9586 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34110_n840# 0.04fF
C9587 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Qbar1 0.30fF
C9588 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_1/Qbar 0.02fF
C9589 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_5852_170# 0.07fF
C9590 divbuf_1/a_9242_170# divbuf_1/OUT3 0.19fF
C9591 divbuf_1/a_32640_n1600# divbuf_1/a_32670_n840# 0.04fF
C9592 divbuf_3/a_29262_170# divbuf_3/a_29262_n240# 0.01fF
C9593 divbuf_3/a_8762_n240# divbuf_3/a_9242_n240# 0.05fF
C9594 divbuf_5/a_21600_n1600# divbuf_5/a_21630_n840# 0.04fF
C9595 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_32160_n1600# 0.26fF
C9596 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/a_22590_n840# 0.03fF
C9597 divbuf_4/a_37022_n240# divbuf_4/a_37502_n240# 0.05fF
C9598 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35520_n1600# 0.26fF
C9599 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/a_25950_n840# 0.03fF
C9600 divbuf_3/a_21120_n1600# divbuf_3/a_21150_n1540# 0.19fF
C9601 divbuf_3/a_21150_n840# divbuf_3/a_21630_n840# 0.07fF
C9602 pd_div_0/divbuf_0/a_54750_n840# pd_div_0/divbuf_0/a_54750_n1540# 0.01fF
C9603 pd_div_0/divbuf_0/a_24030_n1540# pd_div_0/divbuf_0/a_24510_n1540# 0.11fF
C9604 divbuf_2/a_16152_n240# divbuf_2/a_15870_n840# 0.01fF
C9605 divbuf_4/a_48510_n840# divbuf_4/a_48990_n840# 0.07fF
C9606 divbuf_4/a_18270_n840# divbuf_4/a_18270_n1540# 0.01fF
C9607 divbuf_4/a_33120_n1600# divbuf_4/OUT4 0.01fF
C9608 divbuf_4/a_48480_n1600# divbuf_4/a_48510_n1540# 0.19fF
C9609 pll_full_0/divbuf_1/a_27390_n1540# pll_full_0/divbuf_1/a_27870_n1540# 0.11fF
C9610 pll_full_0/divbuf_1/a_58110_n840# pll_full_0/divbuf_1/a_58110_n1540# 0.01fF
C9611 divbuf_1/a_9732_n240# divbuf_1/a_10212_n240# 0.05fF
C9612 divbuf_5/a_19072_170# divbuf_5/a_19072_n240# 0.01fF
C9613 divbuf_5/a_38472_170# divbuf_5/a_38962_170# 0.07fF
C9614 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C9615 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/OUT5 0.04fF
C9616 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9617 ro_div_0/divbuf_0/a_23550_n840# ro_div_0/divbuf_0/a_24030_n840# 0.07fF
C9618 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_23550_n1540# 0.19fF
C9619 divbuf_1/a_22080_n1600# divbuf_1/a_22110_n1540# 0.19fF
C9620 divbuf_1/a_22110_n840# divbuf_1/a_22590_n840# 0.07fF
C9621 divbuf_1/a_21982_n240# divbuf_1/OUT4 0.04fF
C9622 divbuf_5/a_11040_n1600# divbuf_5/a_11070_n1540# 0.19fF
C9623 divbuf_5/a_38962_170# divbuf_5/OUT4 0.19fF
C9624 divbuf_5/a_11070_n840# divbuf_5/a_11550_n840# 0.07fF
C9625 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C9626 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C9627 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/OUT3 0.19fF
C9628 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_21630_n840# 0.04fF
C9629 divbuf_2/a_11802_170# divbuf_2/a_12282_170# 0.07fF
C9630 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_24990_n840# 0.04fF
C9631 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/OUT3 0.19fF
C9632 divbuf_5/OUT4 divbuf_5/OUT5 0.26fF
C9633 divbuf_0/a_6240_n1600# divbuf_0/a_6720_n1600# 0.26fF
C9634 divbuf_2/a_36052_n240# divbuf_2/a_36030_n840# 0.05fF
C9635 divbuf_2/a_45120_n1600# divbuf_2/a_45600_n1600# 0.26fF
C9636 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/a_40902_n240# 0.04fF
C9637 gnd pll_full_0/divider_0/tspc_0/Z2 0.16fF
C9638 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n1540# 0.19fF
C9639 divbuf_0/a_59550_n840# divbuf_0/a_60030_n840# 0.07fF
C9640 divbuf_0/a_29310_n840# divbuf_0/a_29310_n1540# 0.01fF
C9641 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_51870_n1540# 0.19fF
C9642 divbuf_2/a_37470_n1540# divbuf_2/a_37950_n1540# 0.11fF
C9643 pll_full_0/divbuf_0/a_51870_n840# pll_full_0/divbuf_0/a_52350_n840# 0.07fF
C9644 pll_full_0/divbuf_0/a_21630_n840# pll_full_0/divbuf_0/a_21630_n1540# 0.01fF
C9645 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C9646 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/a_19072_n240# 0.01fF
C9647 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/a_38962_170# 0.07fF
C9648 divbuf_1/a_20160_n1600# divbuf_1/OUT4 0.00fF
C9649 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/a_22472_n240# 0.01fF
C9650 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/a_1842_n240# 0.04fF
C9651 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_960_n1600# 0.00fF
C9652 divbuf_3/a_7680_n1600# divbuf_3/a_8160_n1600# 0.26fF
C9653 divbuf_5/a_39932_n240# divbuf_5/OUT4 0.04fF
C9654 divbuf_3/a_510_n1540# io_analog[9] 0.11fF
C9655 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/a3 0.13fF
C9656 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/Out 0.01fF
C9657 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C9658 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/clk 0.14fF
C9659 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11070_n1540# 0.19fF
C9660 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9661 pd_div_0/divbuf_0/a_11070_n840# pd_div_0/divbuf_0/a_11550_n840# 0.07fF
C9662 divbuf_4/a_25862_n240# divbuf_4/a_25950_n840# 0.03fF
C9663 divbuf_4/a_35040_n1600# divbuf_4/a_35520_n1600# 0.26fF
C9664 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14430_n1540# 0.19fF
C9665 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C9666 pll_full_0/divbuf_1/a_14430_n840# pll_full_0/divbuf_1/a_14910_n840# 0.07fF
C9667 divbuf_3/a_30750_n840# divbuf_3/a_30750_n1540# 0.01fF
C9668 divbuf_0/a_17122_n240# divbuf_0/a_16830_n840# 0.00fF
C9669 pd_div_0/divbuf_0/OUT4 pd_div_0/divbuf_0/OUT5 0.26fF
C9670 divbuf_4/a_58110_n840# divbuf_4/a_58110_n1540# 0.01fF
C9671 divbuf_4/a_27390_n1540# divbuf_4/a_27870_n1540# 0.11fF
C9672 divbuf_2/a_35040_n1600# divbuf_2/a_35070_n840# 0.04fF
C9673 divbuf_2/a_25862_170# divbuf_2/OUT4 0.19fF
C9674 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C9675 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10560_n1600# 0.26fF
C9676 divbuf_1/a_8640_n1600# divbuf_1/a_9120_n1600# 0.26fF
C9677 divbuf_5/a_39442_n240# divbuf_5/a_39932_n240# 0.04fF
C9678 divbuf_3/a_15672_170# divbuf_3/OUT4 0.19fF
C9679 ro_div_0/divbuf_0/a_2430_n1540# ro_div_0/divbuf_0/a_2910_n1540# 0.11fF
C9680 ro_div_0/divbuf_0/a_33150_n840# ro_div_0/divbuf_0/a_33150_n1540# 0.01fF
C9681 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/OUT3 0.03fF
C9682 divbuf_1/a_31710_n840# divbuf_1/a_31710_n1540# 0.01fF
C9683 divbuf_1/a_990_n1540# divbuf_1/a_1470_n1540# 0.11fF
C9684 divbuf_1/a_510_n840# divbuf_1/OUT2 0.02fF
C9685 divbuf_5/a_50910_n840# divbuf_5/a_51390_n840# 0.07fF
C9686 divbuf_5/a_20670_n840# divbuf_5/a_20670_n1540# 0.01fF
C9687 divbuf_5/a_50880_n1600# divbuf_5/a_50910_n1540# 0.19fF
C9688 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C9689 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9690 divbuf_4/a_5362_170# divbuf_4/OUT3 0.19fF
C9691 divbuf_4/a_24960_n1600# divbuf_4/a_24990_n840# 0.04fF
C9692 divbuf_2/a_12772_n240# divbuf_2/a_13252_n240# 0.05fF
C9693 divbuf_2/a_32652_170# divbuf_2/a_32652_n240# 0.01fF
C9694 divbuf_0/a_46080_n1600# divbuf_0/a_46560_n1600# 0.26fF
C9695 divbuf_0/a_9732_170# divbuf_0/OUT3 0.19fF
C9696 divbuf_0/a_37022_n240# divbuf_0/a_36990_n840# 0.05fF
C9697 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C9698 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/nor_1/A 0.03fF
C9699 divbuf_2/a_26832_n240# divbuf_2/OUT4 0.04fF
C9700 divbuf_2/a_24480_n1600# divbuf_2/a_24510_n1540# 0.19fF
C9701 divbuf_2/a_24510_n840# divbuf_2/a_24990_n840# 0.07fF
C9702 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38880_n1600# 0.26fF
C9703 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/a_29310_n840# 0.04fF
C9704 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/a_25382_170# 0.07fF
C9705 divbuf_0/a_38430_n1540# divbuf_0/a_38910_n1540# 0.11fF
C9706 pll_full_0/divbuf_0/a_30750_n1540# pll_full_0/divbuf_0/a_31230_n1540# 0.11fF
C9707 divbuf_3/a_14222_170# divbuf_3/a_14702_170# 0.07fF
C9708 divbuf_3/a_16642_n240# divbuf_3/OUT4 0.04fF
C9709 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/OUT5 0.03fF
C9710 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/a_39932_n240# 0.04fF
C9711 divbuf_4/a_492_n240# divbuf_4/a_960_n1600# 0.00fF
C9712 divbuf_4/a_1352_n240# divbuf_4/a_1842_n240# 0.04fF
C9713 divbuf_4/a_22472_170# divbuf_4/a_22472_n240# 0.01fF
C9714 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_1440_n1600# 0.26fF
C9715 divbuf_3/a_38472_n240# divbuf_3/a_38430_n840# 0.04fF
C9716 divbuf_3/a_47520_n1600# divbuf_3/a_48000_n1600# 0.26fF
C9717 divbuf_0/a_13252_170# divbuf_0/a_13252_n240# 0.01fF
C9718 pd_div_0/divbuf_0/a_50910_n840# pd_div_0/divbuf_0/a_51390_n840# 0.07fF
C9719 pd_div_0/divbuf_0/a_20670_n840# pd_div_0/divbuf_0/a_20670_n1540# 0.01fF
C9720 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_50910_n1540# 0.19fF
C9721 divbuf_2/a_492_n240# divbuf_2/a_510_n840# 0.00fF
C9722 divbuf_3/a_39870_n1540# divbuf_3/a_40350_n1540# 0.11fF
C9723 divbuf_4/a_14430_n840# divbuf_4/a_14910_n840# 0.07fF
C9724 divbuf_4/a_6332_n240# divbuf_4/OUT3 0.04fF
C9725 divbuf_4/a_14400_n1600# divbuf_4/a_14430_n1540# 0.19fF
C9726 pll_full_0/divbuf_1/a_24030_n840# pll_full_0/divbuf_1/a_24030_n1540# 0.01fF
C9727 pll_full_0/divbuf_1/a_54270_n840# pll_full_0/divbuf_1/a_54750_n840# 0.07fF
C9728 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54270_n1540# 0.19fF
C9729 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_5362_n240# 0.01fF
C9730 divbuf_0/a_27802_170# divbuf_0/OUT4 0.19fF
C9731 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n840# 0.04fF
C9732 divbuf_1/a_7792_170# divbuf_1/a_7792_n240# 0.01fF
C9733 divbuf_2/a_24960_n1600# divbuf_2/OUT4 0.00fF
C9734 divbuf_5/a_3422_170# divbuf_5/a_3912_170# 0.07fF
C9735 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28350_n840# 0.04fF
C9736 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C9737 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C9738 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/a_40830_n840# 0.03fF
C9739 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_50400_n1600# 0.26fF
C9740 divbuf_1/a_39442_n240# divbuf_1/a_39390_n840# 0.04fF
C9741 divbuf_1/a_9732_170# divbuf_1/OUT3 0.19fF
C9742 divbuf_1/a_48480_n1600# divbuf_1/a_48960_n1600# 0.26fF
C9743 divbuf_5/a_28292_n240# divbuf_5/a_28350_n840# 0.04fF
C9744 divbuf_5/a_37440_n1600# divbuf_5/a_37920_n1600# 0.26fF
C9745 ro_div_0/divbuf_0/a_42270_n1540# ro_div_0/divbuf_0/a_42750_n1540# 0.11fF
C9746 divbuf_1/a_40830_n1540# divbuf_1/a_41310_n1540# 0.11fF
C9747 divbuf_3/a_37440_n1600# divbuf_3/a_37470_n840# 0.04fF
C9748 divbuf_5/a_60510_n840# divbuf_5/a_60510_n1540# 0.01fF
C9749 divbuf_5/a_29790_n1540# divbuf_5/a_30270_n1540# 0.11fF
C9750 io_clamp_low[1] io_clamp_high[1] 0.53fF
C9751 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_11550_n840# 0.02fF
C9752 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/a_21502_n240# 0.01fF
C9753 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/OUT3 0.19fF
C9754 divbuf_0/a_33622_170# divbuf_0/a_33622_n240# 0.01fF
C9755 divbuf_0/a_13742_n240# divbuf_0/a_14222_n240# 0.05fF
C9756 divbuf_2/a_11040_n1600# divbuf_2/a_11520_n1600# 0.26fF
C9757 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/a_25862_n240# 0.01fF
C9758 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/a_5852_n240# 0.04fF
C9759 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C9760 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n1540# 0.19fF
C9761 divbuf_0/a_28772_n240# divbuf_0/OUT4 0.04fF
C9762 divbuf_0/a_25470_n840# divbuf_0/a_25950_n840# 0.07fF
C9763 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_17790_n1540# 0.19fF
C9764 divbuf_2/a_34110_n840# divbuf_2/a_34110_n1540# 0.01fF
C9765 divbuf_2/a_3390_n1540# divbuf_2/a_3870_n1540# 0.11fF
C9766 pll_full_0/divbuf_0/a_17790_n840# pll_full_0/divbuf_0/a_18270_n840# 0.07fF
C9767 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9768 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_39870_n840# 0.04fF
C9769 divbuf_1/a_38400_n1600# divbuf_1/a_38430_n840# 0.04fF
C9770 divbuf_1/a_29262_170# divbuf_1/OUT4 0.19fF
C9771 divbuf_3/a_15182_n240# divbuf_3/a_15672_n240# 0.04fF
C9772 divbuf_3/a_35082_170# divbuf_3/a_35082_n240# 0.01fF
C9773 divbuf_5/a_27360_n1600# divbuf_5/a_27390_n840# 0.04fF
C9774 divbuf_5/a_10212_170# divbuf_5/OUT3 0.19fF
C9775 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/a_7302_170# 0.07fF
C9776 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/a_28350_n840# 0.04fF
C9777 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37920_n1600# 0.26fF
C9778 divbuf_4/a_960_n1600# divbuf_4/a_1440_n1600# 0.26fF
C9779 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/a_31710_n840# 0.05fF
C9780 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_41280_n1600# 0.26fF
C9781 divbuf_3/a_26910_n840# divbuf_3/a_27390_n840# 0.07fF
C9782 divbuf_3/a_26880_n1600# divbuf_3/a_26910_n1540# 0.19fF
C9783 pd_div_0/divbuf_0/a_60510_n840# pd_div_0/divbuf_0/a_60510_n1540# 0.01fF
C9784 pd_div_0/divbuf_0/a_29790_n1540# pd_div_0/divbuf_0/a_30270_n1540# 0.11fF
C9785 divbuf_2/a_960_n1600# divbuf_2/a_990_n840# 0.04fF
C9786 divbuf_4/a_54240_n1600# divbuf_4/a_54270_n1540# 0.19fF
C9787 divbuf_4/a_54270_n840# divbuf_4/a_54750_n840# 0.07fF
C9788 divbuf_4/a_24030_n840# divbuf_4/a_24030_n1540# 0.01fF
C9789 pll_full_0/divbuf_1/a_33150_n1540# pll_full_0/divbuf_1/a_33630_n1540# 0.11fF
C9790 divbuf_1/a_16152_n240# divbuf_1/a_16642_n240# 0.04fF
C9791 divbuf_1/a_36052_170# divbuf_1/a_36052_n240# 0.01fF
C9792 divbuf_5/a_4392_n240# divbuf_5/a_4882_n240# 0.04fF
C9793 divbuf_5/a_24892_170# divbuf_5/a_24892_n240# 0.01fF
C9794 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C9795 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29310_n1540# 0.19fF
C9796 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9797 ro_div_0/divbuf_0/a_29310_n840# ro_div_0/divbuf_0/a_29790_n840# 0.07fF
C9798 pd_div_0/divbuf_0/a_4882_170# pd_div_0/divbuf_0/a_4882_n240# 0.01fF
C9799 divbuf_1/a_27870_n840# divbuf_1/a_28350_n840# 0.07fF
C9800 divbuf_1/a_33622_n240# divbuf_1/OUT4 0.04fF
C9801 divbuf_1/a_27840_n1600# divbuf_1/a_27870_n1540# 0.19fF
C9802 divbuf_5/a_16830_n840# divbuf_5/a_17310_n840# 0.07fF
C9803 divbuf_5/a_11312_n240# divbuf_5/OUT4 0.07fF
C9804 divbuf_5/a_16800_n1600# divbuf_5/a_16830_n1540# 0.19fF
C9805 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C9806 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/switch_1/vin 0.20fF
C9807 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z2 1.07fF
C9808 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z3 0.38fF
C9809 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C9810 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C9811 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27390_n840# 0.04fF
C9812 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/OUT3 0.19fF
C9813 divbuf_2/a_17612_170# divbuf_2/a_18092_170# 0.07fF
C9814 divbuf_4/a_11802_n240# divbuf_4/a_11550_n840# 0.02fF
C9815 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C9816 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9817 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_30750_n840# 0.04fF
C9818 divbuf_0/a_12000_n1600# divbuf_0/a_12480_n1600# 0.26fF
C9819 divbuf_2/a_50880_n1600# divbuf_2/a_51360_n1600# 0.26fF
C9820 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4800_n1600# 0.26fF
C9821 divbuf_0/a_4350_n1540# divbuf_0/a_4830_n1540# 0.11fF
C9822 divbuf_0/a_35070_n840# divbuf_0/a_35070_n1540# 0.01fF
C9823 pll_full_0/divbuf_0/a_27390_n840# pll_full_0/divbuf_0/a_27390_n1540# 0.01fF
C9824 pll_full_0/divbuf_0/a_57630_n840# pll_full_0/divbuf_0/a_58110_n840# 0.07fF
C9825 divbuf_2/a_43230_n1540# divbuf_2/a_43710_n1540# 0.11fF
C9826 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_57630_n1540# 0.19fF
C9827 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C9828 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/a_4882_n240# 0.04fF
C9829 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/a_24892_n240# 0.01fF
C9830 divbuf_1/a_31680_n1600# divbuf_1/OUT4 0.00fF
C9831 divbuf_4/a_6822_170# divbuf_4/a_7302_170# 0.07fF
C9832 divbuf_5/a_10080_n1600# divbuf_5/OUT3 0.00fF
C9833 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/a_8272_n240# 0.05fF
C9834 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/a_28292_n240# 0.01fF
C9835 divbuf_3/a_3912_n240# divbuf_3/a_3870_n840# 0.04fF
C9836 divbuf_3/a_13440_n1600# divbuf_3/a_13920_n1600# 0.26fF
C9837 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C9838 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z3 0.06fF
C9839 ro_div_0/divider_0/nor_0/B ro_div_0/divbuf_0/IN 0.30fF
C9840 ro_div_0/divider_0/prescaler_0/tspc_2/D ro_div_0/divider_0/clk 0.29fF
C9841 pd_div_0/divbuf_0/a_16830_n840# pd_div_0/divbuf_0/a_17310_n840# 0.07fF
C9842 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/OUT4 0.07fF
C9843 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_16830_n1540# 0.19fF
C9844 divbuf_4/a_40800_n1600# divbuf_4/a_41280_n1600# 0.26fF
C9845 divbuf_4/a_31682_n240# divbuf_4/a_31710_n840# 0.05fF
C9846 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9847 pll_full_0/divbuf_1/a_20190_n840# pll_full_0/divbuf_1/a_20670_n840# 0.07fF
C9848 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20190_n1540# 0.19fF
C9849 divbuf_3/a_36510_n840# divbuf_3/a_36510_n1540# 0.01fF
C9850 divbuf_3/a_5790_n1540# divbuf_3/a_6270_n1540# 0.11fF
C9851 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n840# 0.04fF
C9852 divbuf_1/a_32172_170# divbuf_1/a_32652_170# 0.07fF
C9853 divbuf_2/a_40800_n1600# divbuf_2/a_40830_n840# 0.04fF
C9854 divbuf_2/a_37502_170# divbuf_2/OUT4 0.19fF
C9855 divbuf_4/a_33150_n1540# divbuf_4/a_33630_n1540# 0.11fF
C9856 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_14910_n840# 0.01fF
C9857 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C9858 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_16320_n1600# 0.26fF
C9859 divbuf_1/a_4882_n240# divbuf_1/a_4830_n840# 0.04fF
C9860 divbuf_1/a_14400_n1600# divbuf_1/a_14880_n1600# 0.26fF
C9861 divbuf_5/a_3360_n1600# divbuf_5/a_3840_n1600# 0.26fF
C9862 divbuf_3/a_27322_170# divbuf_3/OUT4 0.19fF
C9863 ro_div_0/divbuf_0/a_8190_n1540# ro_div_0/divbuf_0/a_8670_n1540# 0.11fF
C9864 ro_div_0/divbuf_0/a_38910_n840# ro_div_0/divbuf_0/a_38910_n1540# 0.01fF
C9865 divbuf_1/a_37470_n840# divbuf_1/a_37470_n1540# 0.01fF
C9866 divbuf_1/a_6750_n1540# divbuf_1/a_7230_n1540# 0.11fF
C9867 divbuf_3/a_3360_n1600# divbuf_3/a_3390_n840# 0.04fF
C9868 divbuf_5/a_56640_n1600# divbuf_5/a_56670_n1540# 0.19fF
C9869 divbuf_5/a_56670_n840# divbuf_5/a_57150_n840# 0.07fF
C9870 divbuf_5/a_26430_n840# divbuf_5/a_26430_n1540# 0.01fF
C9871 divbuf_0/a_9732_170# divbuf_0/a_9732_n240# 0.01fF
C9872 divbuf_0/a_16152_170# divbuf_0/a_16642_170# 0.07fF
C9873 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C9874 divbuf_2/a_38472_170# divbuf_2/a_38472_n240# 0.01fF
C9875 divbuf_2/a_18582_n240# divbuf_2/a_19072_n240# 0.04fF
C9876 divbuf_4/a_30720_n1600# divbuf_4/a_30750_n840# 0.04fF
C9877 divbuf_4/a_17122_170# divbuf_4/OUT4 0.19fF
C9878 divbuf_0/a_51840_n1600# divbuf_0/a_52320_n1600# 0.26fF
C9879 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C9880 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 0.61fF
C9881 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C9882 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/prescaler_0/Out 0.12fF
C9883 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/a_35070_n840# 0.05fF
C9884 divbuf_2/a_30240_n1600# divbuf_2/a_30270_n1540# 0.19fF
C9885 divbuf_2/a_30270_n840# divbuf_2/a_30750_n840# 0.07fF
C9886 divbuf_2/a_38472_n240# divbuf_2/OUT4 0.04fF
C9887 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44640_n1600# 0.26fF
C9888 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C9889 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C9890 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/Out 0.11fF
C9891 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/a_31202_170# 0.07fF
C9892 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_5790_n840# 0.04fF
C9893 divbuf_0/a_44190_n1540# divbuf_0/a_44670_n1540# 0.11fF
C9894 divbuf_1/a_4320_n1600# divbuf_1/a_4350_n840# 0.04fF
C9895 divbuf_3/a_20042_170# divbuf_3/a_20532_170# 0.07fF
C9896 divbuf_5/a_14222_n240# divbuf_5/a_13950_n840# 0.01fF
C9897 pll_full_0/divbuf_0/a_36510_n1540# pll_full_0/divbuf_0/a_36990_n1540# 0.11fF
C9898 divbuf_3/a_28292_n240# divbuf_3/OUT4 0.04fF
C9899 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3840_n1600# 0.26fF
C9900 divbuf_4/a_28292_170# divbuf_4/a_28292_n240# 0.01fF
C9901 divbuf_4/a_7792_n240# divbuf_4/a_8272_n240# 0.05fF
C9902 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_7200_n1600# 0.26fF
C9903 divbuf_3/a_53280_n1600# divbuf_3/a_53760_n1600# 0.26fF
C9904 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_56670_n1540# 0.19fF
C9905 pd_div_0/divbuf_0/a_56670_n840# pd_div_0/divbuf_0/a_57150_n840# 0.07fF
C9906 pd_div_0/divbuf_0/a_26430_n840# pd_div_0/divbuf_0/a_26430_n1540# 0.01fF
C9907 divbuf_4/a_20160_n1600# divbuf_4/a_20190_n1540# 0.19fF
C9908 divbuf_4/a_20190_n840# divbuf_4/a_20670_n840# 0.07fF
C9909 divbuf_4/a_18092_n240# divbuf_4/OUT4 0.04fF
C9910 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60030_n1540# 0.19fF
C9911 pll_full_0/divbuf_1/a_29790_n840# pll_full_0/divbuf_1/a_29790_n1540# 0.01fF
C9912 pll_full_0/divbuf_1/a_60030_n840# pll_full_0/divbuf_1/a_60510_n840# 0.07fF
C9913 pll_full_0/divbuf_0/a_12282_170# pll_full_0/divbuf_0/a_12282_n240# 0.01fF
C9914 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9915 divbuf_3/a_45630_n1540# divbuf_3/a_46110_n1540# 0.11fF
C9916 divbuf_0/a_39442_170# divbuf_0/OUT4 0.19fF
C9917 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n840# 0.04fF
C9918 pd_div_0/divider_0/and_0/B pd_div_0/divider_0/and_0/Z1 0.07fF
C9919 divbuf_1/a_8762_170# divbuf_1/a_9242_170# 0.07fF
C9920 divbuf_1/a_9732_170# divbuf_1/a_9732_n240# 0.01fF
C9921 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9922 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34110_n840# 0.04fF
C9923 divbuf_2/a_36480_n1600# divbuf_2/OUT4 0.00fF
C9924 divbuf_5/a_9242_170# divbuf_5/a_9732_170# 0.07fF
C9925 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_56160_n1600# 0.26fF
C9926 divbuf_1/a_15672_170# divbuf_1/OUT4 0.19fF
C9927 divbuf_1/a_54240_n1600# divbuf_1/a_54720_n1600# 0.26fF
C9928 divbuf_5/a_43200_n1600# divbuf_5/a_43680_n1600# 0.26fF
C9929 divbuf_5/a_34112_n240# divbuf_5/a_34110_n840# 0.06fF
C9930 ro_div_0/divbuf_0/a_48030_n1540# ro_div_0/divbuf_0/a_48510_n1540# 0.11fF
C9931 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_13950_n840# 0.01fF
C9932 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_17310_n840# 0.00fF
C9933 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/a_27322_n240# 0.01fF
C9934 divbuf_1/a_46590_n1540# divbuf_1/a_47070_n1540# 0.11fF
C9935 divbuf_3/a_43200_n1600# divbuf_3/a_43230_n840# 0.04fF
C9936 divbuf_5/a_35550_n1540# divbuf_5/a_36030_n1540# 0.11fF
C9937 divbuf_0/a_19562_n240# divbuf_0/a_20042_n240# 0.05fF
C9938 divbuf_0/a_39442_170# divbuf_0/a_39442_n240# 0.01fF
C9939 divbuf_2/a_16800_n1600# divbuf_2/a_17280_n1600# 0.26fF
C9940 divbuf_2/a_7302_n240# divbuf_2/a_7230_n840# 0.03fF
C9941 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_12282_n240# 0.05fF
C9942 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/a_31682_n240# 0.01fF
C9943 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9944 divbuf_0/a_40412_n240# divbuf_0/OUT4 0.04fF
C9945 divbuf_0/a_990_n840# divbuf_0/a_990_n1540# 0.01fF
C9946 divbuf_0/a_31230_n840# divbuf_0/a_31710_n840# 0.07fF
C9947 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n1540# 0.19fF
C9948 divbuf_1/a_20042_170# divbuf_1/a_20042_n240# 0.01fF
C9949 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9950 pll_full_0/divbuf_0/a_23550_n840# pll_full_0/divbuf_0/a_24030_n840# 0.07fF
C9951 divbuf_2/a_39870_n840# divbuf_2/a_39870_n1540# 0.01fF
C9952 divbuf_2/a_9150_n1540# divbuf_2/a_9630_n1540# 0.11fF
C9953 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_23550_n1540# 0.19fF
C9954 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_45630_n840# 0.04fF
C9955 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/a_7302_170# 0.07fF
C9956 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_12282_170# 0.07fF
C9957 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/a_13742_170# 0.07fF
C9958 divbuf_1/a_4882_n240# divbuf_1/OUT3 0.04fF
C9959 divbuf_1/a_44160_n1600# divbuf_1/a_44190_n840# 0.04fF
C9960 divbuf_3/a_40902_170# divbuf_3/a_40902_n240# 0.01fF
C9961 divbuf_3/a_21012_n240# divbuf_3/a_21502_n240# 0.04fF
C9962 divbuf_5/a_33120_n1600# divbuf_5/a_33150_n840# 0.04fF
C9963 divbuf_5/a_21982_170# divbuf_5/OUT4 0.19fF
C9964 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43680_n1600# 0.26fF
C9965 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/a_34110_n840# 0.06fF
C9966 divbuf_3/a_32640_n1600# divbuf_3/a_32670_n1540# 0.19fF
C9967 divbuf_3/a_32670_n840# divbuf_3/a_33150_n840# 0.07fF
C9968 divbuf_3/a_2430_n840# divbuf_3/a_2430_n1540# 0.01fF
C9969 divbuf_4/a_6720_n1600# divbuf_4/a_7200_n1600# 0.26fF
C9970 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_47040_n1600# 0.26fF
C9971 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/a_37470_n840# 0.05fF
C9972 pd_div_0/divbuf_0/a_35550_n1540# pd_div_0/divbuf_0/a_36030_n1540# 0.11fF
C9973 divbuf_2/a_6720_n1600# divbuf_2/a_6750_n840# 0.04fF
C9974 divbuf_4/a_60030_n840# divbuf_4/a_60510_n840# 0.07fF
C9975 divbuf_4/a_29790_n840# divbuf_4/a_29790_n1540# 0.01fF
C9976 divbuf_4/a_60000_n1600# divbuf_4/a_60030_n1540# 0.19fF
C9977 pll_full_0/divbuf_1/a_38910_n1540# pll_full_0/divbuf_1/a_39390_n1540# 0.11fF
C9978 gnd pll_full_0/divider_0/nor_1/A 1.05fF
C9979 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/a_23922_n240# 0.05fF
C9980 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C9981 divbuf_1/a_21982_n240# divbuf_1/a_22472_n240# 0.04fF
C9982 divbuf_5/a_30712_170# divbuf_5/a_30712_n240# 0.01fF
C9983 ro_div_0/divbuf_0/a_4830_n840# ro_div_0/divbuf_0/a_4830_n1540# 0.01fF
C9984 ro_div_0/divbuf_0/a_35070_n840# ro_div_0/divbuf_0/a_35550_n840# 0.07fF
C9985 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35070_n1540# 0.19fF
C9986 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/a_14222_n240# 0.01fF
C9987 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/a_8762_n240# 0.01fF
C9988 divbuf_1/a_33600_n1600# divbuf_1/a_33630_n1540# 0.19fF
C9989 divbuf_1/a_33630_n840# divbuf_1/a_34110_n840# 0.07fF
C9990 divbuf_1/a_3390_n840# divbuf_1/a_3390_n1540# 0.01fF
C9991 divbuf_5/a_22560_n1600# divbuf_5/a_22590_n1540# 0.19fF
C9992 divbuf_5/a_22590_n840# divbuf_5/a_23070_n840# 0.07fF
C9993 divbuf_5/a_22952_n240# divbuf_5/OUT4 0.04fF
C9994 divbuf_3/a_54750_n840# divbuf_3/a_54750_n1540# 0.01fF
C9995 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/tspc_1/Z4 0.36fF
C9996 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/and_0/OUT 0.06fF
C9997 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C9998 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C9999 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33150_n840# 0.04fF
C10000 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10001 divbuf_2/a_3422_170# divbuf_2/a_3422_n240# 0.01fF
C10002 divbuf_2/a_23442_170# divbuf_2/a_23922_170# 0.07fF
C10003 divbuf_4/a_17612_n240# divbuf_4/a_17310_n840# 0.00fF
C10004 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C10005 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C10006 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10007 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36510_n840# 0.04fF
C10008 divbuf_0/a_8272_n240# divbuf_0/a_8190_n840# 0.03fF
C10009 divbuf_0/a_17760_n1600# divbuf_0/a_18240_n1600# 0.26fF
C10010 divbuf_2/a_8762_170# divbuf_2/OUT3 0.19fF
C10011 divbuf_2/a_56640_n1600# divbuf_2/a_57120_n1600# 0.26fF
C10012 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10560_n1600# 0.26fF
C10013 divbuf_0/a_10110_n1540# divbuf_0/a_10590_n1540# 0.11fF
C10014 divbuf_0/a_40830_n840# divbuf_0/a_40830_n1540# 0.01fF
C10015 divbuf_2/a_48990_n1540# divbuf_2/a_49470_n1540# 0.11fF
C10016 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/OUT3 0.03fF
C10017 pll_full_0/divbuf_0/a_33150_n840# pll_full_0/divbuf_0/a_33150_n1540# 0.01fF
C10018 pll_full_0/divbuf_0/a_2430_n1540# pll_full_0/divbuf_0/a_2910_n1540# 0.11fF
C10019 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/a_30712_n240# 0.01fF
C10020 divbuf_4/a_13252_170# divbuf_4/a_13742_170# 0.07fF
C10021 divbuf_5/a_21120_n1600# divbuf_5/OUT4 0.00fF
C10022 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/a_34112_n240# 0.01fF
C10023 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_14702_n240# 0.05fF
C10024 divbuf_3/a_19200_n1600# divbuf_3/a_19680_n1600# 0.26fF
C10025 divbuf_3/a_9732_n240# divbuf_3/a_9630_n840# 0.03fF
C10026 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/Z1 0.36fF
C10027 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_22590_n1540# 0.19fF
C10028 pd_div_0/divbuf_0/a_22590_n840# pd_div_0/divbuf_0/a_23070_n840# 0.07fF
C10029 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10030 divbuf_4/a_37502_n240# divbuf_4/a_37470_n840# 0.05fF
C10031 divbuf_4/a_46560_n1600# divbuf_4/a_47040_n1600# 0.26fF
C10032 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_25950_n1540# 0.19fF
C10033 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10034 pll_full_0/divbuf_1/a_25950_n840# pll_full_0/divbuf_1/a_26430_n840# 0.07fF
C10035 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_16350_n840# 0.00fF
C10036 divbuf_3/a_42270_n840# divbuf_3/a_42270_n1540# 0.01fF
C10037 divbuf_3/a_11550_n1540# divbuf_3/a_12030_n1540# 0.11fF
C10038 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n840# 0.04fF
C10039 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C10040 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z1 0.00fF
C10041 divbuf_2/a_9732_n240# divbuf_2/OUT3 0.04fF
C10042 divbuf_2/a_46560_n1600# divbuf_2/a_46590_n840# 0.04fF
C10043 divbuf_4/a_38910_n1540# divbuf_4/a_39390_n1540# 0.11fF
C10044 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C10045 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_22080_n1600# 0.26fF
C10046 divbuf_1/a_20160_n1600# divbuf_1/a_20640_n1600# 0.26fF
C10047 divbuf_5/a_9120_n1600# divbuf_5/a_9600_n1600# 0.26fF
C10048 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/OUT5 0.03fF
C10049 divbuf_3/a_38962_170# divbuf_3/OUT4 0.19fF
C10050 ro_div_0/divbuf_0/a_13950_n1540# ro_div_0/divbuf_0/a_14430_n1540# 0.11fF
C10051 ro_div_0/divbuf_0/a_44670_n840# ro_div_0/divbuf_0/a_44670_n1540# 0.01fF
C10052 divbuf_1/a_43230_n840# divbuf_1/a_43230_n1540# 0.01fF
C10053 divbuf_1/a_12510_n1540# divbuf_1/a_12990_n1540# 0.11fF
C10054 divbuf_5/a_60480_n1600# divbuf_5/OUT5 0.26fF
C10055 divbuf_5/a_32190_n840# divbuf_5/a_32190_n1540# 0.01fF
C10056 divbuf_5/a_1470_n1540# divbuf_5/a_1950_n1540# 0.11fF
C10057 divbuf_3/a_9120_n1600# divbuf_3/a_9150_n840# 0.04fF
C10058 divbuf_0/a_24412_170# divbuf_0/a_24892_170# 0.07fF
C10059 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C10060 divbuf_2/a_24412_n240# divbuf_2/a_24892_n240# 0.05fF
C10061 divbuf_4/a_36480_n1600# divbuf_4/a_36510_n840# 0.04fF
C10062 divbuf_4/a_28772_170# divbuf_4/OUT4 0.19fF
C10063 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/a_18582_170# 0.07fF
C10064 divbuf_0/a_57600_n1600# divbuf_0/a_58080_n1600# 0.26fF
C10065 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/clk 0.12fF
C10066 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z3 0.38fF
C10067 divbuf_2/a_8640_n1600# divbuf_2/OUT3 0.00fF
C10068 divbuf_2/a_36000_n1600# divbuf_2/a_36030_n1540# 0.19fF
C10069 divbuf_2/a_36030_n840# divbuf_2/a_36510_n840# 0.07fF
C10070 divbuf_2/a_5790_n840# divbuf_2/a_5790_n1540# 0.01fF
C10071 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_50400_n1600# 0.26fF
C10072 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/OUT3 0.19fF
C10073 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/a_40830_n840# 0.03fF
C10074 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/a_37022_170# 0.07fF
C10075 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_11550_n840# 0.04fF
C10076 divbuf_0/a_49950_n1540# divbuf_0/a_50430_n1540# 0.11fF
C10077 divbuf_1/a_10080_n1600# divbuf_1/a_10110_n840# 0.04fF
C10078 pll_full_0/divbuf_0/a_42270_n1540# pll_full_0/divbuf_0/a_42750_n1540# 0.11fF
C10079 divbuf_3/a_5852_170# divbuf_3/a_5852_n240# 0.01fF
C10080 divbuf_3/a_25862_170# divbuf_3/a_26352_170# 0.07fF
C10081 divbuf_3/a_39932_n240# divbuf_3/OUT4 0.04fF
C10082 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9600_n1600# 0.26fF
C10083 divbuf_1/a_510_n1540# divbuf_1/OUT 0.11fF
C10084 divbuf_4/a_14222_n240# divbuf_4/a_14702_n240# 0.05fF
C10085 divbuf_4/a_34112_170# divbuf_4/a_34112_n240# 0.01fF
C10086 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12960_n1600# 0.26fF
C10087 divbuf_3/a_59040_n1600# divbuf_3/a_59520_n1600# 0.26fF
C10088 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C10089 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/OUT5 0.26fF
C10090 pd_div_0/divbuf_0/a_32190_n840# pd_div_0/divbuf_0/a_32190_n1540# 0.01fF
C10091 pd_div_0/divbuf_0/a_1470_n1540# pd_div_0/divbuf_0/a_1950_n1540# 0.11fF
C10092 divbuf_4/a_25950_n840# divbuf_4/a_26430_n840# 0.07fF
C10093 divbuf_4/a_29742_n240# divbuf_4/OUT4 0.04fF
C10094 divbuf_4/a_25920_n1600# divbuf_4/a_25950_n1540# 0.19fF
C10095 pll_full_0/divbuf_1/a_4830_n1540# pll_full_0/divbuf_1/a_5310_n1540# 0.11fF
C10096 pll_full_0/divbuf_1/a_35550_n840# pll_full_0/divbuf_1/a_35550_n1540# 0.01fF
C10097 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10098 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/a_18092_n240# 0.01fF
C10099 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n840# 0.04fF
C10100 divbuf_0/a_11802_n240# divbuf_0/OUT4 0.04fF
C10101 divbuf_1/a_492_n240# divbuf_1/a_480_n1600# 0.00fF
C10102 divbuf_1/a_23442_170# divbuf_1/a_23922_170# 0.07fF
C10103 divbuf_1/a_33142_170# divbuf_1/a_33142_n240# 0.01fF
C10104 divbuf_5/a_15672_170# divbuf_5/a_16152_170# 0.07fF
C10105 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_39870_n840# 0.04fF
C10106 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10107 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/a_1470_n840# 0.07fF
C10108 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_990_n1540# 0.19fF
C10109 pd_div_0/pd_0/tspc_r_0/Z2 pd_div_0/pd_0/R 0.21fF
C10110 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_0/z5 0.03fF
C10111 divbuf_1/a_13252_170# divbuf_1/OUT4 0.19fF
C10112 divbuf_1/a_60000_n1600# divbuf_1/a_60480_n1600# 0.26fF
C10113 divbuf_5/a_39932_n240# divbuf_5/a_39870_n840# 0.04fF
C10114 divbuf_5/a_48960_n1600# divbuf_5/a_49440_n1600# 0.26fF
C10115 ro_div_0/divbuf_0/a_53790_n1540# ro_div_0/divbuf_0/a_54270_n1540# 0.11fF
C10116 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2430_n840# 0.04fF
C10117 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/a_33142_n240# 0.01fF
C10118 divbuf_1/a_52350_n1540# divbuf_1/a_52830_n1540# 0.11fF
C10119 divbuf_3/a_48960_n1600# divbuf_3/a_48990_n840# 0.04fF
C10120 divbuf_5/a_41310_n1540# divbuf_5/a_41790_n1540# 0.11fF
C10121 divbuf_0/a_25382_n240# divbuf_0/a_25862_n240# 0.05fF
C10122 divbuf_2/a_13252_n240# divbuf_2/a_13470_n840# 0.02fF
C10123 divbuf_2/a_22560_n1600# divbuf_2/a_23040_n1600# 0.26fF
C10124 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/a_37502_n240# 0.01fF
C10125 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_18092_n240# 0.05fF
C10126 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n1540# 0.19fF
C10127 divbuf_0/a_10560_n1600# divbuf_0/OUT3 0.01fF
C10128 divbuf_0/a_6750_n840# divbuf_0/a_6750_n1540# 0.01fF
C10129 divbuf_0/a_36990_n840# divbuf_0/a_37470_n840# 0.07fF
C10130 divbuf_1/a_25862_170# divbuf_1/a_25862_n240# 0.01fF
C10131 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29310_n1540# 0.19fF
C10132 divbuf_2/a_45630_n840# divbuf_2/a_45630_n1540# 0.01fF
C10133 divbuf_2/a_14910_n1540# divbuf_2/a_15390_n1540# 0.11fF
C10134 pll_full_0/divbuf_0/a_29310_n840# pll_full_0/divbuf_0/a_29790_n840# 0.07fF
C10135 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10136 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51390_n840# 0.04fF
C10137 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/a_16152_170# 0.07fF
C10138 divbuf_1/a_49920_n1600# divbuf_1/a_49950_n840# 0.04fF
C10139 divbuf_1/a_16642_n240# divbuf_1/OUT4 0.04fF
C10140 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/a_19562_170# 0.07fF
C10141 divbuf_3/a_26832_n240# divbuf_3/a_27322_n240# 0.04fF
C10142 divbuf_5/a_38880_n1600# divbuf_5/a_38910_n840# 0.04fF
C10143 divbuf_5/a_33622_170# divbuf_5/OUT4 0.19fF
C10144 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/OUT2 0.19fF
C10145 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/a_39870_n840# 0.04fF
C10146 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_49440_n1600# 0.26fF
C10147 divbuf_4/a_12480_n1600# divbuf_4/a_12960_n1600# 0.26fF
C10148 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_510_n840# 0.00fF
C10149 divbuf_3/a_38430_n840# divbuf_3/a_38910_n840# 0.07fF
C10150 divbuf_3/a_8190_n840# divbuf_3/a_8190_n1540# 0.01fF
C10151 divbuf_3/a_38400_n1600# divbuf_3/a_38430_n1540# 0.19fF
C10152 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52800_n1600# 0.26fF
C10153 pd_div_0/divbuf_0/a_41310_n1540# pd_div_0/divbuf_0/a_41790_n1540# 0.11fF
C10154 divbuf_2/a_12480_n1600# divbuf_2/a_12510_n840# 0.04fF
C10155 divbuf_4/a_35550_n840# divbuf_4/a_35550_n1540# 0.01fF
C10156 divbuf_4/a_4830_n1540# divbuf_4/a_5310_n1540# 0.11fF
C10157 pll_full_0/divbuf_1/a_44670_n1540# pll_full_0/divbuf_1/a_45150_n1540# 0.11fF
C10158 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/a_29742_n240# 0.05fF
C10159 divbuf_1/a_27802_n240# divbuf_1/a_28292_n240# 0.04fF
C10160 divbuf_5/a_16642_n240# divbuf_5/a_17122_n240# 0.05fF
C10161 divbuf_5/a_36532_170# divbuf_5/a_36532_n240# 0.01fF
C10162 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C10163 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_40830_n1540# 0.19fF
C10164 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/a_10590_n1540# 0.01fF
C10165 ro_div_0/divbuf_0/a_40830_n840# ro_div_0/divbuf_0/a_41310_n840# 0.07fF
C10166 divbuf_1/a_39390_n840# divbuf_1/a_39870_n840# 0.07fF
C10167 divbuf_1/a_9150_n840# divbuf_1/a_9150_n1540# 0.01fF
C10168 divbuf_1/a_39360_n1600# divbuf_1/a_39390_n1540# 0.19fF
C10169 divbuf_5/a_28350_n840# divbuf_5/a_28830_n840# 0.07fF
C10170 divbuf_5/a_34592_n240# divbuf_5/OUT4 0.04fF
C10171 divbuf_5/a_28320_n1600# divbuf_5/a_28350_n1540# 0.19fF
C10172 divbuf_3/a_60510_n840# divbuf_3/a_60510_n1540# 0.01fF
C10173 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z1 0.01fF
C10174 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C10175 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C10176 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/and_0/A 0.26fF
C10177 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_38910_n840# 0.04fF
C10178 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10179 divbuf_2/a_29262_170# divbuf_2/a_29742_170# 0.07fF
C10180 divbuf_2/a_9242_170# divbuf_2/a_9242_n240# 0.01fF
C10181 divbuf_4/a_2400_n1600# divbuf_4/a_2430_n840# 0.04fF
C10182 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10183 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42270_n840# 0.04fF
C10184 divbuf_0/a_23520_n1600# divbuf_0/a_24000_n1600# 0.26fF
C10185 divbuf_0/a_14222_n240# divbuf_0/a_14430_n840# 0.02fF
C10186 divbuf_2/a_1920_n1600# divbuf_2/a_1950_n1540# 0.19fF
C10187 divbuf_2/a_20532_170# divbuf_2/OUT4 0.19fF
C10188 divbuf_2/a_1950_n840# divbuf_2/a_2430_n840# 0.07fF
C10189 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_16320_n1600# 0.26fF
C10190 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/a_6270_n840# 0.04fF
C10191 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C10192 divbuf_0/a_15870_n1540# divbuf_0/a_16350_n1540# 0.11fF
C10193 divbuf_0/a_46590_n840# divbuf_0/a_46590_n1540# 0.01fF
C10194 pll_full_0/divbuf_0/a_8190_n1540# pll_full_0/divbuf_0/a_8670_n1540# 0.11fF
C10195 pll_full_0/divbuf_0/a_38910_n840# pll_full_0/divbuf_0/a_38910_n1540# 0.01fF
C10196 divbuf_2/a_54750_n1540# divbuf_2/a_55230_n1540# 0.11fF
C10197 divbuf_3/a_10212_170# divbuf_3/OUT3 0.19fF
C10198 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_17122_n240# 0.05fF
C10199 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/a_36532_n240# 0.01fF
C10200 divbuf_3/a_15672_n240# divbuf_3/a_15870_n840# 0.02fF
C10201 divbuf_3/a_24960_n1600# divbuf_3/a_25440_n1600# 0.26fF
C10202 divbuf_4/a_19072_170# divbuf_4/a_19562_170# 0.07fF
C10203 divbuf_5/a_32640_n1600# divbuf_5/OUT4 0.00fF
C10204 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/a_20532_n240# 0.04fF
C10205 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/a_39932_n240# 0.01fF
C10206 divbuf_0/a_17122_170# divbuf_0/a_17122_n240# 0.01fF
C10207 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C10208 pd_div_0/divbuf_0/a_28350_n840# pd_div_0/divbuf_0/a_28830_n840# 0.07fF
C10209 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10210 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28350_n1540# 0.19fF
C10211 divbuf_4/a_52320_n1600# divbuf_4/a_52800_n1600# 0.26fF
C10212 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C10213 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C10214 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10215 pll_full_0/divbuf_1/a_1470_n840# pll_full_0/divbuf_1/a_1470_n1540# 0.01fF
C10216 pll_full_0/divbuf_1/a_31710_n840# pll_full_0/divbuf_1/a_32190_n840# 0.07fF
C10217 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_31710_n1540# 0.19fF
C10218 divbuf_3/a_48030_n840# divbuf_3/a_48030_n1540# 0.01fF
C10219 divbuf_3/a_17310_n1540# divbuf_3/a_17790_n1540# 0.11fF
C10220 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n840# 0.04fF
C10221 divbuf_2/a_52320_n1600# divbuf_2/a_52350_n840# 0.04fF
C10222 divbuf_2/a_21502_n240# divbuf_2/OUT4 0.04fF
C10223 divbuf_4/a_44670_n1540# divbuf_4/a_45150_n1540# 0.11fF
C10224 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_5790_n840# 0.04fF
C10225 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C10226 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_1/A 1.21fF
C10227 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27840_n1600# 0.26fF
C10228 divbuf_1/a_16642_n240# divbuf_1/a_16830_n840# 0.02fF
C10229 divbuf_1/a_25920_n1600# divbuf_1/a_26400_n1600# 0.26fF
C10230 divbuf_5/a_5362_n240# divbuf_5/a_5310_n840# 0.04fF
C10231 divbuf_5/a_14880_n1600# divbuf_5/a_15360_n1600# 0.26fF
C10232 divbuf_3/a_11312_n240# divbuf_3/OUT4 0.07fF
C10233 ro_div_0/divbuf_0/a_19710_n1540# ro_div_0/divbuf_0/a_20190_n1540# 0.11fF
C10234 ro_div_0/divbuf_0/a_50430_n840# ro_div_0/divbuf_0/a_50430_n1540# 0.01fF
C10235 divbuf_1/a_48990_n840# divbuf_1/a_48990_n1540# 0.01fF
C10236 divbuf_1/a_18270_n1540# divbuf_1/a_18750_n1540# 0.11fF
C10237 divbuf_5/a_37950_n840# divbuf_5/a_37950_n1540# 0.01fF
C10238 divbuf_5/a_7230_n1540# divbuf_5/a_7710_n1540# 0.11fF
C10239 divbuf_3/a_14880_n1600# divbuf_3/a_14910_n840# 0.04fF
C10240 divbuf_0/a_30232_170# divbuf_0/a_30712_170# 0.07fF
C10241 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/a_22952_170# 0.07fF
C10242 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C10243 divbuf_2/a_30232_n240# divbuf_2/a_30712_n240# 0.05fF
C10244 divbuf_4/a_42240_n1600# divbuf_4/a_42270_n840# 0.04fF
C10245 divbuf_4/a_40412_170# divbuf_4/OUT4 0.19fF
C10246 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/OUT3 0.23fF
C10247 divbuf_0/a_22472_170# divbuf_0/OUT4 0.19fF
C10248 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n1540# 0.19fF
C10249 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/a_2322_n240# 0.01fF
C10250 divbuf_0/a_2910_n840# divbuf_0/a_3390_n840# 0.07fF
C10251 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/clk 0.60fF
C10252 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z2 0.01fF
C10253 divbuf_2/a_41760_n1600# divbuf_2/a_41790_n1540# 0.19fF
C10254 divbuf_2/a_41790_n840# divbuf_2/a_42270_n840# 0.07fF
C10255 divbuf_2/a_11550_n840# divbuf_2/a_11550_n1540# 0.01fF
C10256 divbuf_2/a_19680_n1600# divbuf_2/OUT4 0.00fF
C10257 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_56160_n1600# 0.26fF
C10258 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/a_2322_n240# 0.05fF
C10259 divbuf_0/a_55710_n1540# divbuf_0/a_56190_n1540# 0.11fF
C10260 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17310_n840# 0.04fF
C10261 divbuf_1/a_15840_n1600# divbuf_1/a_15870_n840# 0.04fF
C10262 divbuf_5/a_4800_n1600# divbuf_5/a_4830_n840# 0.04fF
C10263 divbuf_3/a_31682_170# divbuf_3/a_32172_170# 0.07fF
C10264 divbuf_3/a_12282_170# divbuf_3/a_12282_n240# 0.01fF
C10265 pll_full_0/divbuf_0/a_48030_n1540# pll_full_0/divbuf_0/a_48510_n1540# 0.11fF
C10266 divbuf_3/a_10080_n1600# divbuf_3/OUT3 0.00fF
C10267 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/a_5310_n840# 0.04fF
C10268 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_15360_n1600# 0.26fF
C10269 divbuf_4/a_39932_170# divbuf_4/a_39932_n240# 0.01fF
C10270 divbuf_4/a_20042_n240# divbuf_4/a_20532_n240# 0.04fF
C10271 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/a_8670_n840# 0.03fF
C10272 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18720_n1600# 0.26fF
C10273 divbuf_3/a_4350_n840# divbuf_3/a_4830_n840# 0.07fF
C10274 divbuf_3/a_4320_n1600# divbuf_3/a_4350_n1540# 0.19fF
C10275 pd_div_0/divbuf_0/a_37950_n840# pd_div_0/divbuf_0/a_37950_n1540# 0.01fF
C10276 pd_div_0/divbuf_0/a_7230_n1540# pd_div_0/divbuf_0/a_7710_n1540# 0.11fF
C10277 divbuf_4/a_31680_n1600# divbuf_4/a_31710_n1540# 0.19fF
C10278 divbuf_4/a_31710_n840# divbuf_4/a_32190_n840# 0.07fF
C10279 divbuf_4/a_1470_n840# divbuf_4/a_1470_n1540# 0.01fF
C10280 divbuf_4/a_41382_n240# divbuf_4/OUT4 0.04fF
C10281 pll_full_0/divbuf_1/a_10590_n1540# pll_full_0/divbuf_1/a_11070_n1540# 0.11fF
C10282 pll_full_0/divbuf_1/a_41310_n840# pll_full_0/divbuf_1/a_41310_n1540# 0.01fF
C10283 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10284 divbuf_0/a_23442_n240# divbuf_0/OUT4 0.04fF
C10285 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n840# 0.04fF
C10286 divbuf_1/a_29262_170# divbuf_1/a_29742_170# 0.07fF
C10287 divbuf_5/a_21502_170# divbuf_5/a_21982_170# 0.07fF
C10288 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_45630_n840# 0.04fF
C10289 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C10290 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_6750_n1540# 0.19fF
C10291 ro_div_0/divbuf_0/a_6750_n840# ro_div_0/divbuf_0/a_7230_n840# 0.07fF
C10292 pd_div_0/pd_0/DOWN pd_div_0/pd_0/and_pd_0/Z1 0.07fF
C10293 divbuf_1/a_5310_n840# divbuf_1/a_5790_n840# 0.07fF
C10294 divbuf_1/a_23922_170# divbuf_1/OUT4 0.19fF
C10295 divbuf_1/a_5280_n1600# divbuf_1/a_5310_n1540# 0.19fF
C10296 divbuf_5/a_4882_170# divbuf_5/OUT3 0.19fF
C10297 divbuf_5/a_54720_n1600# divbuf_5/a_55200_n1600# 0.26fF
C10298 divbuf_3/a_56640_n1600# divbuf_3/a_56670_n1540# 0.19fF
C10299 ro_div_0/divbuf_0/a_59550_n1540# ro_div_0/divbuf_0/a_60030_n1540# 0.11fF
C10300 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_4830_n840# 0.04fF
C10301 divbuf_1/a_58110_n1540# divbuf_1/a_58590_n1540# 0.11fF
C10302 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8190_n840# 0.04fF
C10303 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/a_38962_n240# 0.01fF
C10304 divbuf_3/a_54720_n1600# divbuf_3/a_54750_n840# 0.04fF
C10305 divbuf_5/a_47070_n1540# divbuf_5/a_47550_n1540# 0.11fF
C10306 divbuf_0/a_31202_n240# divbuf_0/a_31682_n240# 0.05fF
C10307 divbuf_2/a_28320_n1600# divbuf_2/a_28800_n1600# 0.26fF
C10308 divbuf_2/a_19072_n240# divbuf_2/a_19230_n840# 0.02fF
C10309 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/a_23922_n240# 0.05fF
C10310 gnd pll_full_0/divider_0/tspc_0/Z4 0.44fF
C10311 divbuf_0/a_21600_n1600# divbuf_0/OUT4 0.01fF
C10312 divbuf_0/a_12510_n840# divbuf_0/a_12510_n1540# 0.01fF
C10313 divbuf_0/a_42750_n840# divbuf_0/a_43230_n840# 0.07fF
C10314 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n1540# 0.19fF
C10315 divbuf_5/a_492_n240# divbuf_5/a_480_n1600# 0.00fF
C10316 pll_full_0/divbuf_0/a_4830_n840# pll_full_0/divbuf_0/a_4830_n1540# 0.01fF
C10317 pll_full_0/divbuf_0/a_35070_n840# pll_full_0/divbuf_0/a_35550_n840# 0.07fF
C10318 divbuf_2/a_51390_n840# divbuf_2/a_51390_n1540# 0.01fF
C10319 divbuf_2/a_20670_n1540# divbuf_2/a_21150_n1540# 0.11fF
C10320 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35070_n1540# 0.19fF
C10321 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57150_n840# 0.04fF
C10322 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10323 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_5362_n240# 0.01fF
C10324 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/a_21982_170# 0.07fF
C10325 pd_div_0/divbuf_0/a_1352_170# pd_div_0/divbuf_0/a_1352_n240# 0.01fF
C10326 divbuf_1/a_28292_n240# divbuf_1/OUT4 0.04fF
C10327 divbuf_1/a_55680_n1600# divbuf_1/a_55710_n840# 0.04fF
C10328 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/a_25382_170# 0.07fF
C10329 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/a_4882_n240# 0.01fF
C10330 divbuf_3/a_32652_n240# divbuf_3/a_33142_n240# 0.04fF
C10331 divbuf_5/a_5852_n240# divbuf_5/OUT3 0.04fF
C10332 divbuf_5/a_44640_n1600# divbuf_5/a_44670_n840# 0.04fF
C10333 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_55200_n1600# 0.26fF
C10334 divbuf_4/a_18240_n1600# divbuf_4/a_18720_n1600# 0.26fF
C10335 divbuf_4/a_8762_n240# divbuf_4/a_8670_n840# 0.03fF
C10336 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58560_n1600# 0.26fF
C10337 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10338 divbuf_3/a_44160_n1600# divbuf_3/a_44190_n1540# 0.19fF
C10339 divbuf_3/a_44190_n840# divbuf_3/a_44670_n840# 0.07fF
C10340 divbuf_3/a_13950_n840# divbuf_3/a_13950_n1540# 0.01fF
C10341 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C10342 pd_div_0/divbuf_0/a_47070_n1540# pd_div_0/divbuf_0/a_47550_n1540# 0.11fF
C10343 divbuf_4/a_41310_n840# divbuf_4/a_41310_n1540# 0.01fF
C10344 divbuf_4/a_10590_n1540# divbuf_4/a_11070_n1540# 0.11fF
C10345 divbuf_2/a_18240_n1600# divbuf_2/a_18270_n840# 0.04fF
C10346 pll_full_0/divbuf_1/a_50430_n1540# pll_full_0/divbuf_1/a_50910_n1540# 0.11fF
C10347 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/a_35562_n240# 0.05fF
C10348 divbuf_1/a_33622_n240# divbuf_1/a_34112_n240# 0.04fF
C10349 divbuf_5/a_22472_n240# divbuf_5/a_22952_n240# 0.05fF
C10350 ro_div_0/divbuf_0/a_16350_n840# ro_div_0/divbuf_0/a_16350_n1540# 0.01fF
C10351 ro_div_0/divbuf_0/a_46590_n840# ro_div_0/divbuf_0/a_47070_n840# 0.07fF
C10352 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_46590_n1540# 0.19fF
C10353 divbuf_1/a_45120_n1600# divbuf_1/a_45150_n1540# 0.19fF
C10354 divbuf_1/a_45150_n840# divbuf_1/a_45630_n840# 0.07fF
C10355 divbuf_1/a_14910_n840# divbuf_1/a_14910_n1540# 0.01fF
C10356 divbuf_5/a_34080_n1600# divbuf_5/a_34110_n1540# 0.19fF
C10357 divbuf_5/a_34110_n840# divbuf_5/a_34590_n840# 0.07fF
C10358 divbuf_5/a_3870_n840# divbuf_5/a_3870_n1540# 0.01fF
C10359 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/and_0/B 0.08fF
C10360 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C10361 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_44670_n840# 0.04fF
C10362 divbuf_4/a_8160_n1600# divbuf_4/a_8190_n840# 0.04fF
C10363 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/a_7710_n840# 0.03fF
C10364 divbuf_2/a_15672_170# divbuf_2/a_15672_n240# 0.01fF
C10365 divbuf_2/a_35082_170# divbuf_2/a_35562_170# 0.07fF
C10366 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48030_n840# 0.04fF
C10367 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10368 divbuf_0/a_20042_n240# divbuf_0/a_20190_n840# 0.03fF
C10369 divbuf_0/a_29280_n1600# divbuf_0/a_29760_n1600# 0.26fF
C10370 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12510_n840# 0.02fF
C10371 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_22080_n1600# 0.26fF
C10372 divbuf_2/a_7680_n1600# divbuf_2/a_7710_n1540# 0.19fF
C10373 divbuf_2/a_32172_170# divbuf_2/OUT4 0.19fF
C10374 divbuf_2/a_7710_n840# divbuf_2/a_8190_n840# 0.07fF
C10375 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/a_6822_170# 0.07fF
C10376 ro_div_0/ro_complete_0/cbank_1/switch_4/vin ro_div_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C10377 divbuf_0/a_21630_n1540# divbuf_0/a_22110_n1540# 0.11fF
C10378 divbuf_0/a_52350_n840# divbuf_0/a_52350_n1540# 0.01fF
C10379 divbuf_1/a_1842_n240# divbuf_1/a_1950_n840# 0.03fF
C10380 divbuf_2/a_60510_n1540# divbuf_2/a_60990_n1540# 0.11fF
C10381 pll_full_0/divbuf_0/a_44670_n840# pll_full_0/divbuf_0/a_44670_n1540# 0.01fF
C10382 pll_full_0/divbuf_0/a_13950_n1540# pll_full_0/divbuf_0/a_14430_n1540# 0.11fF
C10383 divbuf_3/a_21982_170# divbuf_3/OUT4 0.19fF
C10384 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/a_22952_n240# 0.05fF
C10385 divbuf_4/a_4882_170# divbuf_4/a_4882_n240# 0.01fF
C10386 divbuf_4/a_24892_170# divbuf_4/a_25382_170# 0.07fF
C10387 divbuf_3/a_30720_n1600# divbuf_3/a_31200_n1600# 0.26fF
C10388 divbuf_3/a_21502_n240# divbuf_3/a_21630_n840# 0.03fF
C10389 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/a_26352_n240# 0.04fF
C10390 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C10391 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34110_n1540# 0.19fF
C10392 pd_div_0/divbuf_0/a_34110_n840# pd_div_0/divbuf_0/a_34590_n840# 0.07fF
C10393 pd_div_0/divbuf_0/a_3870_n840# pd_div_0/divbuf_0/a_3870_n1540# 0.01fF
C10394 divbuf_3/a_23070_n1540# divbuf_3/a_23550_n1540# 0.11fF
C10395 divbuf_4/a_11802_170# divbuf_4/OUT4 0.19fF
C10396 divbuf_4/a_58080_n1600# divbuf_4/a_58560_n1600# 0.26fF
C10397 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37470_n1540# 0.19fF
C10398 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C10399 pll_full_0/divbuf_1/a_7230_n840# pll_full_0/divbuf_1/a_7230_n1540# 0.01fF
C10400 pll_full_0/divbuf_1/a_37470_n840# pll_full_0/divbuf_1/a_37950_n840# 0.07fF
C10401 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n840# 0.04fF
C10402 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_11550_n840# 0.04fF
C10403 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C10404 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C10405 pd_div_0/divider_0/tspc_1/a_630_n680# gnd 0.62fF
C10406 divbuf_2/a_33142_n240# divbuf_2/OUT4 0.04fF
C10407 divbuf_2/a_58080_n1600# divbuf_2/a_58110_n840# 0.04fF
C10408 divbuf_4/a_50430_n1540# divbuf_4/a_50910_n1540# 0.11fF
C10409 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z3 0.65fF
C10410 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/a_24030_n840# 0.03fF
C10411 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33600_n1600# 0.26fF
C10412 divbuf_1/a_31680_n1600# divbuf_1/a_32160_n1600# 0.26fF
C10413 divbuf_1/a_22472_n240# divbuf_1/a_22590_n840# 0.03fF
C10414 divbuf_5/a_20640_n1600# divbuf_5/a_21120_n1600# 0.26fF
C10415 divbuf_5/a_11312_n240# divbuf_5/a_11550_n840# 0.02fF
C10416 divbuf_3/a_22952_n240# divbuf_3/OUT4 0.04fF
C10417 ro_div_0/divbuf_0/a_25470_n1540# ro_div_0/divbuf_0/a_25950_n1540# 0.11fF
C10418 ro_div_0/divbuf_0/a_56190_n840# ro_div_0/divbuf_0/a_56190_n1540# 0.01fF
C10419 divbuf_1/a_54750_n840# divbuf_1/a_54750_n1540# 0.01fF
C10420 divbuf_1/a_24030_n1540# divbuf_1/a_24510_n1540# 0.11fF
C10421 divbuf_3/a_20640_n1600# divbuf_3/a_20670_n840# 0.04fF
C10422 divbuf_5/a_43710_n840# divbuf_5/a_43710_n1540# 0.01fF
C10423 divbuf_5/a_12990_n1540# divbuf_5/a_13470_n1540# 0.11fF
C10424 divbuf_0/a_36052_170# divbuf_0/a_36532_170# 0.07fF
C10425 divbuf_2/a_36052_n240# divbuf_2/a_36532_n240# 0.05fF
C10426 divbuf_4/a_12772_n240# divbuf_4/OUT4 0.04fF
C10427 divbuf_4/a_48000_n1600# divbuf_4/a_48030_n840# 0.04fF
C10428 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/a_28772_170# 0.07fF
C10429 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/OUT3 0.19fF
C10430 divbuf_0/a_8670_n840# divbuf_0/a_9150_n840# 0.07fF
C10431 divbuf_0/a_34112_170# divbuf_0/OUT4 0.19fF
C10432 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n1540# 0.19fF
C10433 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/A 0.01fF
C10434 divbuf_2/a_31200_n1600# divbuf_2/OUT4 0.00fF
C10435 divbuf_2/a_47520_n1600# divbuf_2/a_47550_n1540# 0.19fF
C10436 divbuf_2/a_47550_n840# divbuf_2/a_48030_n840# 0.07fF
C10437 divbuf_2/a_17310_n840# divbuf_2/a_17310_n1540# 0.01fF
C10438 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/a_1470_n840# 0.07fF
C10439 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_990_n1540# 0.19fF
C10440 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/a_8762_n240# 0.04fF
C10441 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23070_n840# 0.04fF
C10442 divbuf_1/a_21600_n1600# divbuf_1/a_21630_n840# 0.04fF
C10443 divbuf_3/a_18092_170# divbuf_3/a_18092_n240# 0.01fF
C10444 divbuf_3/a_37502_170# divbuf_3/a_37992_170# 0.07fF
C10445 divbuf_5/a_10560_n1600# divbuf_5/a_10590_n840# 0.04fF
C10446 pll_full_0/divbuf_0/a_53790_n1540# pll_full_0/divbuf_0/a_54270_n1540# 0.11fF
C10447 divbuf_3/a_21120_n1600# divbuf_3/OUT4 0.00fF
C10448 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_21120_n1600# 0.26fF
C10449 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11550_n840# 0.02fF
C10450 divbuf_4/a_25862_n240# divbuf_4/a_26352_n240# 0.04fF
C10451 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24480_n1600# 0.26fF
C10452 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_14910_n840# 0.02fF
C10453 divbuf_3/a_10080_n1600# divbuf_3/a_10110_n1540# 0.19fF
C10454 divbuf_3/a_10110_n840# divbuf_3/a_10590_n840# 0.07fF
C10455 pd_div_0/divbuf_0/a_43710_n840# pd_div_0/divbuf_0/a_43710_n1540# 0.01fF
C10456 pd_div_0/divbuf_0/a_12990_n1540# pd_div_0/divbuf_0/a_13470_n1540# 0.11fF
C10457 divbuf_4/a_37470_n840# divbuf_4/a_37950_n840# 0.07fF
C10458 divbuf_4/a_7230_n840# divbuf_4/a_7230_n1540# 0.01fF
C10459 divbuf_4/a_11040_n1600# divbuf_4/OUT4 0.00fF
C10460 divbuf_4/a_37440_n1600# divbuf_4/a_37470_n1540# 0.19fF
C10461 pll_full_0/divbuf_1/a_16350_n1540# pll_full_0/divbuf_1/a_16830_n1540# 0.11fF
C10462 pll_full_0/divbuf_1/a_47070_n840# pll_full_0/divbuf_1/a_47070_n1540# 0.01fF
C10463 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10464 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n840# 0.04fF
C10465 divbuf_0/a_35082_n240# divbuf_0/OUT4 0.04fF
C10466 divbuf_1/a_38472_170# divbuf_1/a_38962_170# 0.07fF
C10467 divbuf_2/a_10590_n840# divbuf_2/OUT4 0.03fF
C10468 divbuf_5/a_27322_170# divbuf_5/a_27802_170# 0.07fF
C10469 divbuf_5/a_7302_170# divbuf_5/a_7302_n240# 0.01fF
C10470 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10471 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51390_n840# 0.04fF
C10472 ro_div_0/divider_0/prescaler_0/tspc_0/D gnd 0.05fF
C10473 ro_div_0/divbuf_0/a_12510_n840# ro_div_0/divbuf_0/a_12990_n840# 0.07fF
C10474 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12510_n1540# 0.19fF
C10475 divbuf_1/a_11040_n1600# divbuf_1/a_11070_n1540# 0.19fF
C10476 divbuf_1/a_38962_170# divbuf_1/OUT4 0.19fF
C10477 divbuf_1/a_11070_n840# divbuf_1/a_11550_n840# 0.07fF
C10478 divbuf_5/a_16642_170# divbuf_5/OUT4 0.19fF
C10479 divbuf_3/a_60480_n1600# divbuf_3/OUT5 0.26fF
C10480 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_10590_n840# 0.04fF
C10481 divbuf_1/OUT4 divbuf_1/OUT5 0.26fF
C10482 divbuf_5/a_52830_n1540# divbuf_5/a_53310_n1540# 0.11fF
C10483 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_13950_n840# 0.04fF
C10484 divbuf_3/a_60480_n1600# divbuf_3/a_60510_n840# 0.04fF
C10485 divbuf_0/a_37022_n240# divbuf_0/a_37502_n240# 0.05fF
C10486 divbuf_2/a_24892_n240# divbuf_2/a_24990_n840# 0.03fF
C10487 divbuf_2/a_34080_n1600# divbuf_2/a_34560_n1600# 0.26fF
C10488 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/a_29742_n240# 0.05fF
C10489 gnd pll_full_0/divider_0/tspc_1/Z2 0.16fF
C10490 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n1540# 0.19fF
C10491 divbuf_0/a_33120_n1600# divbuf_0/OUT4 0.01fF
C10492 divbuf_0/a_18270_n840# divbuf_0/a_18270_n1540# 0.01fF
C10493 divbuf_0/a_48510_n840# divbuf_0/a_48990_n840# 0.07fF
C10494 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_40830_n1540# 0.19fF
C10495 divbuf_0/a_1842_170# divbuf_0/OUT2 0.19fF
C10496 divbuf_2/a_57150_n840# divbuf_2/a_57150_n1540# 0.01fF
C10497 divbuf_2/a_26430_n1540# divbuf_2/a_26910_n1540# 0.11fF
C10498 pll_full_0/divbuf_0/a_40830_n840# pll_full_0/divbuf_0/a_41310_n840# 0.07fF
C10499 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/a_10590_n1540# 0.01fF
C10500 ro_div_0/divbuf_0/a_0_n1600# ro_div_0/divbuf_0/OUT 0.26fF
C10501 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C10502 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/a_27802_170# 0.07fF
C10503 divbuf_1/a_39932_n240# divbuf_1/OUT4 0.04fF
C10504 divbuf_3/a_53790_n1540# divbuf_3/a_54270_n1540# 0.11fF
C10505 divbuf_5/a_50400_n1600# divbuf_5/a_50430_n840# 0.04fF
C10506 divbuf_5/a_17612_n240# divbuf_5/OUT4 0.04fF
C10507 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/a_11312_n240# 0.01fF
C10508 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/a_31202_170# 0.07fF
C10509 divbuf_3/a_38472_n240# divbuf_3/a_38962_n240# 0.04fF
C10510 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z4 0.00fF
C10511 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C10512 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C10513 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C10514 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10515 divbuf_4/a_14702_n240# divbuf_4/a_14910_n840# 0.02fF
C10516 divbuf_4/a_24000_n1600# divbuf_4/a_24480_n1600# 0.26fF
C10517 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10518 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3390_n1540# 0.19fF
C10519 pll_full_0/divbuf_1/a_3390_n840# pll_full_0/divbuf_1/a_3870_n840# 0.07fF
C10520 divbuf_3/a_49950_n840# divbuf_3/a_50430_n840# 0.07fF
C10521 divbuf_3/a_19710_n840# divbuf_3/a_19710_n1540# 0.01fF
C10522 divbuf_3/a_49920_n1600# divbuf_3/a_49950_n1540# 0.19fF
C10523 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C10524 pd_div_0/divbuf_0/a_52830_n1540# pd_div_0/divbuf_0/a_53310_n1540# 0.11fF
C10525 divbuf_4/a_47070_n840# divbuf_4/a_47070_n1540# 0.01fF
C10526 divbuf_4/a_16350_n1540# divbuf_4/a_16830_n1540# 0.11fF
C10527 pll_full_0/divbuf_1/a_56190_n1540# pll_full_0/divbuf_1/a_56670_n1540# 0.11fF
C10528 divbuf_2/a_3422_170# divbuf_2/OUT3 0.23fF
C10529 divbuf_2/a_24000_n1600# divbuf_2/a_24030_n840# 0.04fF
C10530 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/a_41382_n240# 0.05fF
C10531 divbuf_1/a_39442_n240# divbuf_1/a_39932_n240# 0.04fF
C10532 divbuf_5/a_28292_n240# divbuf_5/a_28772_n240# 0.05fF
C10533 ro_div_0/divbuf_0/a_22110_n840# ro_div_0/divbuf_0/a_22110_n1540# 0.01fF
C10534 ro_div_0/divbuf_0/a_52350_n840# ro_div_0/divbuf_0/a_52830_n840# 0.07fF
C10535 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52350_n1540# 0.19fF
C10536 divbuf_1/a_50910_n840# divbuf_1/a_51390_n840# 0.07fF
C10537 divbuf_1/a_20670_n840# divbuf_1/a_20670_n1540# 0.01fF
C10538 divbuf_1/a_50880_n1600# divbuf_1/a_50910_n1540# 0.19fF
C10539 divbuf_5/a_39870_n840# divbuf_5/a_40350_n840# 0.07fF
C10540 divbuf_5/a_9630_n840# divbuf_5/a_9630_n1540# 0.01fF
C10541 divbuf_5/a_39840_n1600# divbuf_5/a_39870_n1540# 0.19fF
C10542 divbuf_0/a_6332_170# divbuf_0/a_6332_n240# 0.01fF
C10543 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50430_n840# 0.04fF
C10544 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10545 divbuf_4/a_13920_n1600# divbuf_4/a_13950_n840# 0.04fF
C10546 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10547 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_53790_n840# 0.04fF
C10548 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_13950_n840# 0.02fF
C10549 divbuf_2/a_40902_170# divbuf_2/a_41382_170# 0.07fF
C10550 divbuf_2/a_21502_170# divbuf_2/a_21502_n240# 0.01fF
C10551 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C10552 divbuf_0/a_35040_n1600# divbuf_0/a_35520_n1600# 0.26fF
C10553 divbuf_0/a_18092_170# divbuf_0/OUT4 0.19fF
C10554 divbuf_0/a_25862_n240# divbuf_0/a_25950_n840# 0.03fF
C10555 divbuf_2/a_4392_n240# divbuf_2/OUT3 0.04fF
C10556 divbuf_2/a_13440_n1600# divbuf_2/a_13470_n1540# 0.19fF
C10557 divbuf_2/a_13470_n840# divbuf_2/a_13950_n840# 0.07fF
C10558 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27840_n1600# 0.26fF
C10559 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_18270_n840# 0.02fF
C10560 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C10561 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/a_15672_170# 0.07fF
C10562 divbuf_0/a_27390_n1540# divbuf_0/a_27870_n1540# 0.11fF
C10563 divbuf_0/a_58110_n840# divbuf_0/a_58110_n1540# 0.01fF
C10564 pll_full_0/divbuf_0/a_19710_n1540# pll_full_0/divbuf_0/a_20190_n1540# 0.11fF
C10565 pll_full_0/divbuf_0/a_50430_n840# pll_full_0/divbuf_0/a_50430_n1540# 0.01fF
C10566 divbuf_3/a_1842_170# divbuf_3/a_2322_170# 0.07fF
C10567 divbuf_3/a_33622_170# divbuf_3/OUT4 0.19fF
C10568 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/a_28772_n240# 0.05fF
C10569 divbuf_4/a_30712_170# divbuf_4/a_31202_170# 0.07fF
C10570 divbuf_4/a_11312_170# divbuf_4/a_11312_n240# 0.01fF
C10571 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/a_32172_n240# 0.04fF
C10572 divbuf_3/a_27322_n240# divbuf_3/a_27390_n840# 0.04fF
C10573 divbuf_3/a_36480_n1600# divbuf_3/a_36960_n1600# 0.26fF
C10574 pd_div_0/divbuf_0/a_39870_n840# pd_div_0/divbuf_0/a_40350_n840# 0.07fF
C10575 pd_div_0/divbuf_0/a_9630_n840# pd_div_0/divbuf_0/a_9630_n1540# 0.01fF
C10576 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_39870_n1540# 0.19fF
C10577 divbuf_4/a_3390_n840# divbuf_4/a_3870_n840# 0.07fF
C10578 divbuf_4/a_3360_n1600# divbuf_4/a_3390_n1540# 0.19fF
C10579 divbuf_4/a_23442_170# divbuf_4/OUT4 0.19fF
C10580 divbuf_3/a_28830_n1540# divbuf_3/a_29310_n1540# 0.11fF
C10581 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C10582 pll_full_0/divbuf_1/a_12990_n840# pll_full_0/divbuf_1/a_12990_n1540# 0.01fF
C10583 pll_full_0/divbuf_1/a_43230_n840# pll_full_0/divbuf_1/a_43710_n840# 0.07fF
C10584 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43230_n1540# 0.19fF
C10585 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n840# 0.04fF
C10586 divbuf_0/a_8272_170# divbuf_0/OUT3 0.19fF
C10587 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 0.63fF
C10588 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C10589 divbuf_4/a_56190_n1540# divbuf_4/a_56670_n1540# 0.11fF
C10590 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17310_n840# 0.04fF
C10591 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/OUT3 0.19fF
C10592 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C10593 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/a_15182_n240# 0.01fF
C10594 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/a_29790_n840# 0.04fF
C10595 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_39360_n1600# 0.26fF
C10596 divbuf_1/a_28292_n240# divbuf_1/a_28350_n840# 0.04fF
C10597 divbuf_1/a_37440_n1600# divbuf_1/a_37920_n1600# 0.26fF
C10598 divbuf_5/a_26400_n1600# divbuf_5/a_26880_n1600# 0.26fF
C10599 divbuf_5/a_17122_n240# divbuf_5/a_17310_n840# 0.02fF
C10600 divbuf_3/a_34592_n240# divbuf_3/OUT4 0.04fF
C10601 ro_div_0/divbuf_0/a_31230_n1540# ro_div_0/divbuf_0/a_31710_n1540# 0.11fF
C10602 divbuf_1/a_60510_n840# divbuf_1/a_60510_n1540# 0.01fF
C10603 divbuf_1/a_29790_n1540# divbuf_1/a_30270_n1540# 0.11fF
C10604 divbuf_3/a_26400_n1600# divbuf_3/a_26430_n840# 0.04fF
C10605 divbuf_5/a_49470_n840# divbuf_5/a_49470_n1540# 0.01fF
C10606 divbuf_5/a_18750_n1540# divbuf_5/a_19230_n1540# 0.11fF
C10607 divbuf_0/a_22472_170# divbuf_0/a_22472_n240# 0.01fF
C10608 divbuf_0/a_1352_n240# divbuf_0/a_1842_n240# 0.04fF
C10609 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C10610 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C10611 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/a_34592_170# 0.07fF
C10612 divbuf_2/a_0_n1600# divbuf_2/a_480_n1600# 0.26fF
C10613 divbuf_4/a_53760_n1600# divbuf_4/a_53790_n840# 0.04fF
C10614 divbuf_4/a_24412_n240# divbuf_4/OUT4 0.04fF
C10615 divbuf_0/a_1842_170# divbuf_0/a_1352_170# 0.07fF
C10616 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10617 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n1540# 0.19fF
C10618 divbuf_0/a_6332_n240# divbuf_0/OUT3 0.04fF
C10619 divbuf_0/a_14430_n840# divbuf_0/a_14910_n840# 0.07fF
C10620 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_6750_n1540# 0.19fF
C10621 divbuf_1/a_3912_170# divbuf_1/a_3912_n240# 0.01fF
C10622 divbuf_2/a_53280_n1600# divbuf_2/a_53310_n1540# 0.19fF
C10623 divbuf_2/a_53310_n840# divbuf_2/a_53790_n840# 0.07fF
C10624 divbuf_2/a_23070_n840# divbuf_2/a_23070_n1540# 0.01fF
C10625 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10626 pll_full_0/divbuf_0/a_6750_n840# pll_full_0/divbuf_0/a_7230_n840# 0.07fF
C10627 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_15182_n240# 0.05fF
C10628 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_28830_n840# 0.04fF
C10629 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Qbar1 0.38fF
C10630 divbuf_1/a_27360_n1600# divbuf_1/a_27390_n840# 0.04fF
C10631 divbuf_3/a_3422_n240# divbuf_3/a_3912_n240# 0.04fF
C10632 divbuf_3/a_23922_170# divbuf_3/a_23922_n240# 0.01fF
C10633 divbuf_5/a_16320_n1600# divbuf_5/a_16350_n840# 0.04fF
C10634 pll_full_0/divbuf_0/a_59550_n1540# pll_full_0/divbuf_0/a_60030_n1540# 0.11fF
C10635 divbuf_3/a_32640_n1600# divbuf_3/OUT4 0.00fF
C10636 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26880_n1600# 0.26fF
C10637 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_17310_n840# 0.02fF
C10638 divbuf_3/a_15870_n840# divbuf_3/a_16350_n840# 0.07fF
C10639 divbuf_3/a_15840_n1600# divbuf_3/a_15870_n1540# 0.19fF
C10640 divbuf_4/a_31682_n240# divbuf_4/a_32172_n240# 0.04fF
C10641 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/a_20670_n840# 0.03fF
C10642 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_30240_n1600# 0.26fF
C10643 pd_div_0/divbuf_0/a_49470_n840# pd_div_0/divbuf_0/a_49470_n1540# 0.01fF
C10644 pd_div_0/divbuf_0/a_18750_n1540# pd_div_0/divbuf_0/a_19230_n1540# 0.11fF
C10645 divbuf_4/a_43200_n1600# divbuf_4/a_43230_n1540# 0.19fF
C10646 divbuf_4/a_43230_n840# divbuf_4/a_43710_n840# 0.07fF
C10647 divbuf_4/a_12990_n840# divbuf_4/a_12990_n1540# 0.01fF
C10648 divbuf_4/a_22560_n1600# divbuf_4/OUT4 0.01fF
C10649 pll_full_0/divbuf_1/a_22110_n1540# pll_full_0/divbuf_1/a_22590_n1540# 0.11fF
C10650 pll_full_0/divbuf_1/a_52830_n840# pll_full_0/divbuf_1/a_52830_n1540# 0.01fF
C10651 divbuf_1/a_4392_n240# divbuf_1/a_4882_n240# 0.04fF
C10652 divbuf_5/a_33142_170# divbuf_5/a_33622_170# 0.07fF
C10653 divbuf_5/a_13742_170# divbuf_5/a_13742_n240# 0.01fF
C10654 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57150_n840# 0.04fF
C10655 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10656 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C10657 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C10658 ro_div_0/divider_0/and_0/out1 gnd 0.29fF
C10659 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18270_n1540# 0.19fF
C10660 ro_div_0/divbuf_0/a_18270_n840# ro_div_0/divbuf_0/a_18750_n840# 0.07fF
C10661 divbuf_1/a_16830_n840# divbuf_1/a_17310_n840# 0.07fF
C10662 divbuf_1/a_11312_n240# divbuf_1/OUT4 0.07fF
C10663 divbuf_1/a_16800_n1600# divbuf_1/a_16830_n1540# 0.19fF
C10664 divbuf_5/a_5790_n840# divbuf_5/a_6270_n840# 0.07fF
C10665 divbuf_5/a_5760_n1600# divbuf_5/a_5790_n1540# 0.19fF
C10666 divbuf_5/a_28292_170# divbuf_5/OUT4 0.19fF
C10667 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16350_n840# 0.04fF
C10668 divbuf_2/a_5852_170# divbuf_2/a_6332_170# 0.07fF
C10669 divbuf_5/a_58590_n1540# divbuf_5/a_59070_n1540# 0.11fF
C10670 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_19710_n840# 0.04fF
C10671 divbuf_0/a_960_n1600# divbuf_0/a_1440_n1600# 0.26fF
C10672 divbuf_2/a_39840_n1600# divbuf_2/a_40320_n1600# 0.26fF
C10673 divbuf_2/a_30712_n240# divbuf_2/a_30750_n840# 0.05fF
C10674 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/a_35562_n240# 0.05fF
C10675 divbuf_0/a_24030_n840# divbuf_0/a_24030_n1540# 0.01fF
C10676 divbuf_0/a_54270_n840# divbuf_0/a_54750_n840# 0.07fF
C10677 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n1540# 0.19fF
C10678 divbuf_2/a_32190_n1540# divbuf_2/a_32670_n1540# 0.11fF
C10679 pll_full_0/divbuf_0/a_16350_n840# pll_full_0/divbuf_0/a_16350_n1540# 0.01fF
C10680 pll_full_0/divbuf_0/a_46590_n840# pll_full_0/divbuf_0/a_47070_n840# 0.07fF
C10681 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_46590_n1540# 0.19fF
C10682 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C10683 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/a_33622_170# 0.07fF
C10684 divbuf_1/a_10080_n1600# divbuf_1/OUT3 0.00fF
C10685 divbuf_3/a_59550_n1540# divbuf_3/a_60030_n1540# 0.11fF
C10686 divbuf_5/a_29262_n240# divbuf_5/OUT4 0.04fF
C10687 divbuf_5/a_56160_n1600# divbuf_5/a_56190_n840# 0.04fF
C10688 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/a_37022_170# 0.07fF
C10689 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/a_17122_n240# 0.01fF
C10690 divbuf_3/a_2400_n1600# divbuf_3/a_2880_n1600# 0.26fF
C10691 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C10692 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C10693 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C10694 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/and_0/OUT 0.06fF
C10695 pd_div_0/divbuf_0/a_5790_n840# pd_div_0/divbuf_0/a_6270_n840# 0.07fF
C10696 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_5790_n1540# 0.19fF
C10697 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10698 divbuf_1/a_1352_170# divbuf_1/a_1842_170# 0.07fF
C10699 divbuf_4/a_29760_n1600# divbuf_4/a_30240_n1600# 0.26fF
C10700 divbuf_4/a_20532_n240# divbuf_4/a_20670_n840# 0.03fF
C10701 pll_full_0/divbuf_1/a_9150_n840# pll_full_0/divbuf_1/a_9630_n840# 0.07fF
C10702 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10703 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9150_n1540# 0.19fF
C10704 divbuf_3/a_55710_n840# divbuf_3/a_56190_n840# 0.07fF
C10705 divbuf_3/a_25470_n840# divbuf_3/a_25470_n1540# 0.01fF
C10706 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C10707 divbuf_0/a_11802_n240# divbuf_0/a_11550_n840# 0.02fF
C10708 pd_div_0/divbuf_0/a_58590_n1540# pd_div_0/divbuf_0/a_59070_n1540# 0.11fF
C10709 divbuf_2/a_29760_n1600# divbuf_2/a_29790_n840# 0.04fF
C10710 divbuf_2/a_15182_170# divbuf_2/OUT4 0.19fF
C10711 divbuf_4/a_52830_n840# divbuf_4/a_52830_n1540# 0.01fF
C10712 divbuf_4/a_22110_n1540# divbuf_4/a_22590_n1540# 0.11fF
C10713 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/a1 0.14fF
C10714 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C10715 ro_div_0/ro_complete_0/cbank_0/switch_2/vin ro_div_0/ro_complete_0/a3 0.09fF
C10716 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_5280_n1600# 0.26fF
C10717 divbuf_1/a_3360_n1600# divbuf_1/a_3840_n1600# 0.26fF
C10718 divbuf_5/a_34112_n240# divbuf_5/a_34592_n240# 0.05fF
C10719 divbuf_3/a_4882_170# divbuf_3/OUT3 0.19fF
C10720 ro_div_0/divbuf_0/a_27870_n840# ro_div_0/divbuf_0/a_27870_n1540# 0.01fF
C10721 ro_div_0/divbuf_0/a_58110_n840# ro_div_0/divbuf_0/a_58590_n840# 0.07fF
C10722 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58110_n1540# 0.19fF
C10723 divbuf_1/a_56640_n1600# divbuf_1/a_56670_n1540# 0.19fF
C10724 divbuf_1/a_56670_n840# divbuf_1/a_57150_n840# 0.07fF
C10725 divbuf_1/a_26430_n840# divbuf_1/a_26430_n1540# 0.01fF
C10726 divbuf_3/a_13252_n240# divbuf_3/a_12990_n840# 0.01fF
C10727 divbuf_5/a_45600_n1600# divbuf_5/a_45630_n1540# 0.19fF
C10728 divbuf_5/a_45630_n840# divbuf_5/a_46110_n840# 0.07fF
C10729 divbuf_5/a_15390_n840# divbuf_5/a_15390_n1540# 0.01fF
C10730 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10731 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56190_n840# 0.04fF
C10732 divbuf_2/a_27322_170# divbuf_2/a_27322_n240# 0.01fF
C10733 divbuf_2/a_6822_n240# divbuf_2/a_7302_n240# 0.05fF
C10734 divbuf_4/a_19680_n1600# divbuf_4/a_19710_n840# 0.04fF
C10735 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_59550_n840# 0.04fF
C10736 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10737 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/a_19710_n840# 0.03fF
C10738 divbuf_0/a_31682_n240# divbuf_0/a_31710_n840# 0.05fF
C10739 divbuf_0/a_40800_n1600# divbuf_0/a_41280_n1600# 0.26fF
C10740 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C10741 divbuf_1/a_16152_170# divbuf_1/a_15672_170# 0.07fF
C10742 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C10743 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C10744 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C10745 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/a_24030_n840# 0.03fF
C10746 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33600_n1600# 0.26fF
C10747 divbuf_2/a_19200_n1600# divbuf_2/a_19230_n1540# 0.19fF
C10748 divbuf_2/a_19230_n840# divbuf_2/a_19710_n840# 0.07fF
C10749 divbuf_2/a_16152_n240# divbuf_2/OUT4 0.04fF
C10750 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C10751 divbuf_0/a_33150_n1540# divbuf_0/a_33630_n1540# 0.11fF
C10752 divbuf_1/a_14222_n240# divbuf_1/a_13950_n840# 0.01fF
C10753 divbuf_3/a_8272_170# divbuf_3/a_8762_170# 0.07fF
C10754 divbuf_5/a_2322_n240# divbuf_5/a_2430_n840# 0.03fF
C10755 pll_full_0/divbuf_0/a_56190_n840# pll_full_0/divbuf_0/a_56190_n1540# 0.01fF
C10756 pll_full_0/divbuf_0/a_25470_n1540# pll_full_0/divbuf_0/a_25950_n1540# 0.11fF
C10757 divbuf_3/a_5852_n240# divbuf_3/OUT3 0.04fF
C10758 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/a_34592_n240# 0.05fF
C10759 divbuf_4/a_17122_170# divbuf_4/a_17122_n240# 0.01fF
C10760 divbuf_4/a_36532_170# divbuf_4/a_37022_170# 0.07fF
C10761 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/a_37992_n240# 0.04fF
C10762 divbuf_3/a_42240_n1600# divbuf_3/a_42720_n1600# 0.26fF
C10763 divbuf_3/a_33142_n240# divbuf_3/a_33150_n840# 0.06fF
C10764 divbuf_0/a_5852_170# divbuf_0/a_5852_n240# 0.01fF
C10765 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_45630_n1540# 0.19fF
C10766 pd_div_0/divbuf_0/a_45630_n840# pd_div_0/divbuf_0/a_46110_n840# 0.07fF
C10767 pd_div_0/divbuf_0/a_15390_n840# pd_div_0/divbuf_0/a_15390_n1540# 0.01fF
C10768 divbuf_4/a_9120_n1600# divbuf_4/a_9150_n1540# 0.19fF
C10769 divbuf_4/a_35082_170# divbuf_4/OUT4 0.19fF
C10770 divbuf_4/a_9150_n840# divbuf_4/a_9630_n840# 0.07fF
C10771 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_48990_n1540# 0.19fF
C10772 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C10773 pll_full_0/divbuf_1/a_18750_n840# pll_full_0/divbuf_1/a_18750_n1540# 0.01fF
C10774 pll_full_0/divbuf_1/a_48990_n840# pll_full_0/divbuf_1/a_49470_n840# 0.07fF
C10775 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/a_9732_n240# 0.01fF
C10776 divbuf_3/a_34590_n1540# divbuf_3/a_35070_n1540# 0.11fF
C10777 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n840# 0.04fF
C10778 divbuf_0/a_14702_170# divbuf_0/OUT4 0.19fF
C10779 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/clk 0.12fF
C10780 gnd pd_div_0/divider_0/prescaler_0/nand_1/z1 0.16fF
C10781 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_0/Z2 0.23fF
C10782 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23070_n840# 0.04fF
C10783 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10784 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C10785 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z3 0.38fF
C10786 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C10787 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/a_35550_n840# 0.05fF
C10788 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_45120_n1600# 0.26fF
C10789 divbuf_1/a_33142_170# divbuf_1/OUT4 0.19fF
C10790 divbuf_1/a_43200_n1600# divbuf_1/a_43680_n1600# 0.26fF
C10791 divbuf_1/a_34112_n240# divbuf_1/a_34110_n840# 0.06fF
C10792 divbuf_5/a_32160_n1600# divbuf_5/a_32640_n1600# 0.26fF
C10793 divbuf_5/a_22952_n240# divbuf_5/a_23070_n840# 0.03fF
C10794 ro_div_0/divbuf_0/a_36990_n1540# ro_div_0/divbuf_0/a_37470_n1540# 0.11fF
C10795 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/a_2430_n840# 0.03fF
C10796 divbuf_1/a_35550_n1540# divbuf_1/a_36030_n1540# 0.11fF
C10797 divbuf_3/a_32160_n1600# divbuf_3/a_32190_n840# 0.04fF
C10798 divbuf_5/a_55230_n840# divbuf_5/a_55230_n1540# 0.01fF
C10799 divbuf_5/a_24510_n1540# divbuf_5/a_24990_n1540# 0.11fF
C10800 divbuf_0/a_7792_n240# divbuf_0/a_8272_n240# 0.05fF
C10801 divbuf_0/a_28292_170# divbuf_0/a_28292_n240# 0.01fF
C10802 divbuf_4/a_36052_n240# divbuf_4/OUT4 0.04fF
C10803 divbuf_4/a_59520_n1600# divbuf_4/a_59550_n840# 0.04fF
C10804 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/a_20532_n240# 0.01fF
C10805 divbuf_2/a_5760_n1600# divbuf_2/a_6240_n1600# 0.26fF
C10806 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/a_40412_170# 0.07fF
C10807 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10808 divbuf_0/a_18092_n240# divbuf_0/OUT4 0.04fF
C10809 divbuf_0/a_20190_n840# divbuf_0/a_20670_n840# 0.07fF
C10810 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n1540# 0.19fF
C10811 pll_full_0/divbuf_0/a_12510_n840# pll_full_0/divbuf_0/a_12990_n840# 0.07fF
C10812 divbuf_2/a_59040_n1600# divbuf_2/a_59070_n1540# 0.19fF
C10813 divbuf_2/a_59070_n840# divbuf_2/a_59550_n840# 0.07fF
C10814 divbuf_2/a_28830_n840# divbuf_2/a_28830_n1540# 0.01fF
C10815 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/OUT5 0.07fF
C10816 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/OUT2 0.04fF
C10817 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12510_n1540# 0.19fF
C10818 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_34590_n840# 0.04fF
C10819 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 gnd 0.27fF
C10820 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/a_6332_170# 0.07fF
C10821 divbuf_1/a_33120_n1600# divbuf_1/a_33150_n840# 0.04fF
C10822 divbuf_3/a_29742_170# divbuf_3/a_29742_n240# 0.01fF
C10823 divbuf_3/a_9242_n240# divbuf_3/a_9732_n240# 0.04fF
C10824 divbuf_5/a_22080_n1600# divbuf_5/a_22110_n840# 0.04fF
C10825 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32640_n1600# 0.26fF
C10826 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/a_23070_n840# 0.03fF
C10827 divbuf_4/a_37502_n240# divbuf_4/a_37992_n240# 0.04fF
C10828 divbuf_3/a_21600_n1600# divbuf_3/a_21630_n1540# 0.19fF
C10829 divbuf_3/a_21630_n840# divbuf_3/a_22110_n840# 0.07fF
C10830 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_36000_n1600# 0.26fF
C10831 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/a_26430_n840# 0.04fF
C10832 pd_div_0/divbuf_0/a_55230_n840# pd_div_0/divbuf_0/a_55230_n1540# 0.01fF
C10833 pd_div_0/divbuf_0/a_24510_n1540# pd_div_0/divbuf_0/a_24990_n1540# 0.11fF
C10834 divbuf_2/a_16642_n240# divbuf_2/a_16350_n840# 0.00fF
C10835 divbuf_4/a_48990_n840# divbuf_4/a_49470_n840# 0.07fF
C10836 divbuf_4/a_18750_n840# divbuf_4/a_18750_n1540# 0.01fF
C10837 divbuf_4/a_34080_n1600# divbuf_4/OUT4 0.01fF
C10838 divbuf_4/a_48960_n1600# divbuf_4/a_48990_n1540# 0.19fF
C10839 pll_full_0/divbuf_1/a_27870_n1540# pll_full_0/divbuf_1/a_28350_n1540# 0.11fF
C10840 pll_full_0/divbuf_1/a_58590_n840# pll_full_0/divbuf_1/a_58590_n1540# 0.01fF
C10841 divbuf_5/a_38962_170# divbuf_5/a_39442_170# 0.07fF
C10842 divbuf_5/a_19562_170# divbuf_5/a_19562_n240# 0.01fF
C10843 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C10844 ro_div_0/divbuf_0/a_24030_n840# ro_div_0/divbuf_0/a_24510_n840# 0.07fF
C10845 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24030_n1540# 0.19fF
C10846 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10847 divbuf_1/a_22560_n1600# divbuf_1/a_22590_n1540# 0.19fF
C10848 divbuf_1/a_22590_n840# divbuf_1/a_23070_n840# 0.07fF
C10849 divbuf_1/a_22952_n240# divbuf_1/OUT4 0.04fF
C10850 divbuf_5/a_11520_n1600# divbuf_5/a_11550_n1540# 0.19fF
C10851 divbuf_5/a_39932_170# divbuf_5/OUT4 0.19fF
C10852 divbuf_5/a_11550_n840# divbuf_5/a_12030_n840# 0.07fF
C10853 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/a2 0.09fF
C10854 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C10855 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22110_n840# 0.04fF
C10856 divbuf_2/a_12282_170# divbuf_2/a_12772_170# 0.07fF
C10857 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25470_n840# 0.04fF
C10858 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/OUT3 0.19fF
C10859 divbuf_0/a_6720_n1600# divbuf_0/a_7200_n1600# 0.26fF
C10860 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/a_41382_n240# 0.05fF
C10861 divbuf_2/a_36532_n240# divbuf_2/a_36510_n840# 0.05fF
C10862 divbuf_2/a_45600_n1600# divbuf_2/a_46080_n1600# 0.26fF
C10863 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n1540# 0.19fF
C10864 divbuf_0/a_29790_n840# divbuf_0/a_29790_n1540# 0.01fF
C10865 divbuf_0/a_60030_n840# divbuf_0/a_60510_n840# 0.07fF
C10866 divbuf_2/a_37950_n1540# divbuf_2/a_38430_n1540# 0.11fF
C10867 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52350_n1540# 0.19fF
C10868 pll_full_0/divbuf_0/a_52350_n840# pll_full_0/divbuf_0/a_52830_n840# 0.07fF
C10869 pll_full_0/divbuf_0/a_22110_n840# pll_full_0/divbuf_0/a_22110_n1540# 0.01fF
C10870 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C10871 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_480_n1600# 0.00fF
C10872 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/a_39442_170# 0.07fF
C10873 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/a_19562_n240# 0.01fF
C10874 divbuf_1/a_21120_n1600# divbuf_1/OUT4 0.00fF
C10875 divbuf_3/a_8160_n1600# divbuf_3/a_8640_n1600# 0.26fF
C10876 divbuf_5/a_480_n1600# gpio_analog[7] 0.00fF
C10877 divbuf_5/a_40902_n240# divbuf_5/OUT4 0.04fF
C10878 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/a_2322_n240# 0.05fF
C10879 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/a_22952_n240# 0.01fF
C10880 divbuf_0/a_19562_170# divbuf_0/a_20042_170# 0.07fF
C10881 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C10882 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/tspc_0/Z2 0.01fF
C10883 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C10884 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C10885 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_11550_n1540# 0.19fF
C10886 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10887 pd_div_0/divbuf_0/a_11550_n840# pd_div_0/divbuf_0/a_12030_n840# 0.07fF
C10888 divbuf_4/a_26352_n240# divbuf_4/a_26430_n840# 0.04fF
C10889 divbuf_4/a_35520_n1600# divbuf_4/a_36000_n1600# 0.26fF
C10890 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_14910_n1540# 0.19fF
C10891 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C10892 pll_full_0/divbuf_1/a_14910_n840# pll_full_0/divbuf_1/a_15390_n840# 0.07fF
C10893 divbuf_3/a_31230_n840# divbuf_3/a_31230_n1540# 0.01fF
C10894 divbuf_3/a_510_n1540# divbuf_3/a_990_n1540# 0.11fF
C10895 divbuf_0/a_17612_n240# divbuf_0/a_17310_n840# 0.00fF
C10896 divbuf_2/a_35520_n1600# divbuf_2/a_35550_n840# 0.04fF
C10897 divbuf_2/a_26832_170# divbuf_2/OUT4 0.19fF
C10898 divbuf_4/a_58590_n840# divbuf_4/a_58590_n1540# 0.01fF
C10899 divbuf_4/a_27870_n1540# divbuf_4/a_28350_n1540# 0.11fF
C10900 ro_div_0/ro_complete_0/cbank_0/switch_5/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C10901 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_11040_n1600# 0.26fF
C10902 divbuf_1/a_9120_n1600# divbuf_1/a_9600_n1600# 0.26fF
C10903 divbuf_5/a_39932_n240# divbuf_5/a_40412_n240# 0.05fF
C10904 divbuf_3/a_16642_170# divbuf_3/OUT4 0.19fF
C10905 ro_div_0/divbuf_0/a_2910_n1540# ro_div_0/divbuf_0/a_3390_n1540# 0.11fF
C10906 ro_div_0/divbuf_0/a_33630_n840# ro_div_0/divbuf_0/a_33630_n1540# 0.01fF
C10907 divbuf_1/a_60480_n1600# divbuf_1/OUT5 0.26fF
C10908 divbuf_1/a_32190_n840# divbuf_1/a_32190_n1540# 0.01fF
C10909 divbuf_1/a_1470_n1540# divbuf_1/a_1950_n1540# 0.11fF
C10910 divbuf_5/a_51390_n840# divbuf_5/a_51870_n840# 0.07fF
C10911 divbuf_5/a_21150_n840# divbuf_5/a_21150_n1540# 0.01fF
C10912 divbuf_5/a_51360_n1600# divbuf_5/a_51390_n1540# 0.19fF
C10913 divbuf_0/a_12772_170# divbuf_0/a_13252_170# 0.07fF
C10914 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C10915 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.44fF
C10916 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10917 divbuf_2/a_13252_n240# divbuf_2/a_13742_n240# 0.04fF
C10918 divbuf_2/a_33142_170# divbuf_2/a_33142_n240# 0.01fF
C10919 divbuf_4/a_6332_170# divbuf_4/OUT3 0.19fF
C10920 divbuf_4/a_25440_n1600# divbuf_4/a_25470_n840# 0.04fF
C10921 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C10922 divbuf_0/a_46560_n1600# divbuf_0/a_47040_n1600# 0.26fF
C10923 divbuf_0/a_10212_170# divbuf_0/OUT4 0.07fF
C10924 divbuf_0/a_37502_n240# divbuf_0/a_37470_n840# 0.05fF
C10925 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/nor_0/B 0.06fF
C10926 divbuf_2/a_27802_n240# divbuf_2/OUT4 0.04fF
C10927 divbuf_2/a_24960_n1600# divbuf_2/a_24990_n1540# 0.19fF
C10928 divbuf_2/a_24990_n840# divbuf_2/a_25470_n840# 0.07fF
C10929 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_39360_n1600# 0.26fF
C10930 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/a_29790_n840# 0.04fF
C10931 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/a_25862_170# 0.07fF
C10932 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_510_n840# 0.04fF
C10933 divbuf_0/a_38910_n1540# divbuf_0/a_39390_n1540# 0.11fF
C10934 pll_full_0/divbuf_0/a_31230_n1540# pll_full_0/divbuf_0/a_31710_n1540# 0.11fF
C10935 divbuf_3/a_14702_170# divbuf_3/a_15182_170# 0.07fF
C10936 divbuf_3/a_17612_n240# divbuf_3/OUT4 0.04fF
C10937 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/a_40412_n240# 0.05fF
C10938 divbuf_4/a_22952_170# divbuf_4/a_22952_n240# 0.01fF
C10939 divbuf_4/a_1842_n240# divbuf_4/a_2322_n240# 0.05fF
C10940 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1920_n1600# 0.26fF
C10941 divbuf_3/a_38962_n240# divbuf_3/a_38910_n840# 0.04fF
C10942 divbuf_3/a_48000_n1600# divbuf_3/a_48480_n1600# 0.26fF
C10943 divbuf_0/a_13742_170# divbuf_0/a_13742_n240# 0.01fF
C10944 pd_div_0/divbuf_0/a_51390_n840# pd_div_0/divbuf_0/a_51870_n840# 0.07fF
C10945 pd_div_0/divbuf_0/a_21150_n840# pd_div_0/divbuf_0/a_21150_n1540# 0.01fF
C10946 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51390_n1540# 0.19fF
C10947 divbuf_4/a_14910_n840# divbuf_4/a_15390_n840# 0.07fF
C10948 divbuf_4/a_7302_n240# divbuf_4/OUT3 0.04fF
C10949 divbuf_4/a_14880_n1600# divbuf_4/a_14910_n1540# 0.19fF
C10950 pll_full_0/divbuf_1/a_24510_n840# pll_full_0/divbuf_1/a_24510_n1540# 0.01fF
C10951 pll_full_0/divbuf_1/a_54750_n840# pll_full_0/divbuf_1/a_55230_n840# 0.07fF
C10952 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_54750_n1540# 0.19fF
C10953 divbuf_3/a_40350_n1540# divbuf_3/a_40830_n1540# 0.11fF
C10954 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/a_5852_n240# 0.01fF
C10955 divbuf_0/a_28772_170# divbuf_0/OUT4 0.19fF
C10956 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n840# 0.04fF
C10957 gnd pd_div_0/divider_0/and_0/Z1 0.32fF
C10958 divbuf_1/a_8272_170# divbuf_1/a_8272_n240# 0.01fF
C10959 divbuf_1/a_13252_170# divbuf_1/a_13742_170# 0.07fF
C10960 divbuf_5/a_3912_170# divbuf_5/a_4392_170# 0.07fF
C10961 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_28830_n840# 0.04fF
C10962 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10963 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/a_41310_n840# 0.03fF
C10964 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50880_n1600# 0.26fF
C10965 divbuf_1/a_10212_170# divbuf_1/OUT4 0.07fF
C10966 divbuf_1/a_39932_n240# divbuf_1/a_39870_n840# 0.04fF
C10967 divbuf_1/a_48960_n1600# divbuf_1/a_49440_n1600# 0.26fF
C10968 divbuf_5/a_37920_n1600# divbuf_5/a_38400_n1600# 0.26fF
C10969 divbuf_5/a_28772_n240# divbuf_5/a_28830_n840# 0.04fF
C10970 ro_div_0/divbuf_0/a_42750_n1540# ro_div_0/divbuf_0/a_43230_n1540# 0.11fF
C10971 divbuf_1/a_41310_n1540# divbuf_1/a_41790_n1540# 0.11fF
C10972 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12030_n840# 0.02fF
C10973 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/a_21982_n240# 0.01fF
C10974 divbuf_3/a_37920_n1600# divbuf_3/a_37950_n840# 0.04fF
C10975 divbuf_5/a_60990_n840# divbuf_5/a_60990_n1540# 0.01fF
C10976 divbuf_5/a_30270_n1540# divbuf_5/a_30750_n1540# 0.11fF
C10977 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/OUT3 0.19fF
C10978 divbuf_0/a_34112_170# divbuf_0/a_34112_n240# 0.01fF
C10979 divbuf_0/a_14222_n240# divbuf_0/a_14702_n240# 0.05fF
C10980 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C10981 divbuf_2/a_11520_n1600# divbuf_2/a_12000_n1600# 0.26fF
C10982 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/a_26352_n240# 0.01fF
C10983 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/a_6332_n240# 0.05fF
C10984 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n1540# 0.19fF
C10985 divbuf_0/a_29742_n240# divbuf_0/OUT4 0.04fF
C10986 divbuf_0/a_25950_n840# divbuf_0/a_26430_n840# 0.07fF
C10987 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18270_n1540# 0.19fF
C10988 divbuf_2/a_34590_n840# divbuf_2/a_34590_n1540# 0.01fF
C10989 divbuf_2/a_3870_n1540# divbuf_2/a_4350_n1540# 0.11fF
C10990 pll_full_0/divbuf_0/a_18270_n840# pll_full_0/divbuf_0/a_18750_n840# 0.07fF
C10991 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10992 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40350_n840# 0.04fF
C10993 pd_div_0/pd_0/tspc_r_1/Z4 pd_div_0/pd_0/tspc_r_1/z5 0.04fF
C10994 divbuf_1/a_30232_170# divbuf_1/OUT4 0.19fF
C10995 divbuf_1/a_38880_n1600# divbuf_1/a_38910_n840# 0.04fF
C10996 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/a_7792_170# 0.07fF
C10997 cp_0/upbar io_analog[1] 0.02fF
C10998 divbuf_3/a_15672_n240# divbuf_3/a_16152_n240# 0.05fF
C10999 divbuf_3/a_35562_170# divbuf_3/a_35562_n240# 0.01fF
C11000 divbuf_5/a_27840_n1600# divbuf_5/a_27870_n840# 0.04fF
C11001 divbuf_5/a_11312_170# divbuf_5/OUT4 0.23fF
C11002 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_38400_n1600# 0.26fF
C11003 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/a_28830_n840# 0.04fF
C11004 divbuf_4/a_1440_n1600# divbuf_4/a_1920_n1600# 0.26fF
C11005 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/a_32190_n840# 0.06fF
C11006 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41760_n1600# 0.26fF
C11007 divbuf_3/a_27390_n840# divbuf_3/a_27870_n840# 0.07fF
C11008 divbuf_3/a_27360_n1600# divbuf_3/a_27390_n1540# 0.19fF
C11009 pd_div_0/divbuf_0/a_60990_n840# pd_div_0/divbuf_0/a_60990_n1540# 0.01fF
C11010 pd_div_0/divbuf_0/a_30270_n1540# pd_div_0/divbuf_0/a_30750_n1540# 0.11fF
C11011 divbuf_2/a_1440_n1600# divbuf_2/a_1470_n840# 0.04fF
C11012 divbuf_4/a_54720_n1600# divbuf_4/a_54750_n1540# 0.19fF
C11013 divbuf_4/a_54750_n840# divbuf_4/a_55230_n840# 0.07fF
C11014 divbuf_4/a_24510_n840# divbuf_4/a_24510_n1540# 0.01fF
C11015 pll_full_0/divbuf_1/a_33630_n1540# pll_full_0/divbuf_1/a_34110_n1540# 0.11fF
C11016 divbuf_1/a_16642_n240# divbuf_1/a_17122_n240# 0.05fF
C11017 divbuf_1/a_36532_170# divbuf_1/a_36532_n240# 0.01fF
C11018 divbuf_5/a_25382_170# divbuf_5/a_25382_n240# 0.01fF
C11019 divbuf_5/a_4882_n240# divbuf_5/a_5362_n240# 0.05fF
C11020 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C11021 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11022 ro_div_0/divbuf_0/a_29790_n840# ro_div_0/divbuf_0/a_30270_n840# 0.07fF
C11023 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_29790_n1540# 0.19fF
C11024 divbuf_1/a_28350_n840# divbuf_1/a_28830_n840# 0.07fF
C11025 divbuf_1/a_34592_n240# divbuf_1/OUT4 0.04fF
C11026 divbuf_1/a_28320_n1600# divbuf_1/a_28350_n1540# 0.19fF
C11027 divbuf_5/a_17310_n840# divbuf_5/a_17790_n840# 0.07fF
C11028 divbuf_5/a_12282_n240# divbuf_5/OUT4 0.04fF
C11029 divbuf_5/a_17280_n1600# divbuf_5/a_17310_n1540# 0.19fF
C11030 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C11031 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C11032 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_27870_n840# 0.04fF
C11033 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/OUT3 0.19fF
C11034 divbuf_2/a_18092_170# divbuf_2/a_18582_170# 0.07fF
C11035 divbuf_4/a_12282_n240# divbuf_4/a_12030_n840# 0.02fF
C11036 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11037 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31230_n840# 0.04fF
C11038 divbuf_0/a_12480_n1600# divbuf_0/a_12960_n1600# 0.26fF
C11039 divbuf_2/a_51360_n1600# divbuf_2/a_51840_n1600# 0.26fF
C11040 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_5280_n1600# 0.26fF
C11041 divbuf_0/a_4830_n1540# divbuf_0/a_5310_n1540# 0.11fF
C11042 divbuf_0/a_35550_n840# divbuf_0/a_35550_n1540# 0.01fF
C11043 pll_full_0/divbuf_0/a_27870_n840# pll_full_0/divbuf_0/a_27870_n1540# 0.01fF
C11044 pll_full_0/divbuf_0/a_58110_n840# pll_full_0/divbuf_0/a_58590_n840# 0.07fF
C11045 divbuf_2/a_43710_n1540# divbuf_2/a_44190_n1540# 0.11fF
C11046 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58110_n1540# 0.19fF
C11047 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C11048 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/a_25382_n240# 0.01fF
C11049 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/a_5362_n240# 0.05fF
C11050 divbuf_4/a_7302_170# divbuf_4/a_7792_170# 0.07fF
C11051 divbuf_1/a_32640_n1600# divbuf_1/OUT4 0.00fF
C11052 divbuf_3/a_4392_n240# divbuf_3/a_4350_n840# 0.04fF
C11053 divbuf_3/a_13920_n1600# divbuf_3/a_14400_n1600# 0.26fF
C11054 divbuf_5/a_11040_n1600# divbuf_5/OUT3 0.00fF
C11055 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/a_8762_n240# 0.04fF
C11056 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/a_28772_n240# 0.01fF
C11057 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z4 0.00fF
C11058 pd_div_0/divbuf_0/a_17310_n840# pd_div_0/divbuf_0/a_17790_n840# 0.07fF
C11059 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11060 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17310_n1540# 0.19fF
C11061 divbuf_4/a_41280_n1600# divbuf_4/a_41760_n1600# 0.26fF
C11062 divbuf_4/a_32172_n240# divbuf_4/a_32190_n840# 0.06fF
C11063 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11064 pll_full_0/divbuf_1/a_20670_n840# pll_full_0/divbuf_1/a_21150_n840# 0.07fF
C11065 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_20670_n1540# 0.19fF
C11066 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11070_n840# 0.02fF
C11067 divbuf_3/a_36990_n840# divbuf_3/a_36990_n1540# 0.01fF
C11068 divbuf_3/a_6270_n1540# divbuf_3/a_6750_n1540# 0.11fF
C11069 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n840# 0.04fF
C11070 divbuf_1/a_32652_170# divbuf_1/a_33142_170# 0.07fF
C11071 divbuf_2/a_41280_n1600# divbuf_2/a_41310_n840# 0.04fF
C11072 divbuf_2/a_38472_170# divbuf_2/OUT4 0.19fF
C11073 divbuf_4/a_33630_n1540# divbuf_4/a_34110_n1540# 0.11fF
C11074 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_15390_n840# 0.01fF
C11075 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16800_n1600# 0.26fF
C11076 divbuf_1/a_5362_n240# divbuf_1/a_5310_n840# 0.04fF
C11077 divbuf_1/a_14880_n1600# divbuf_1/a_15360_n1600# 0.26fF
C11078 divbuf_5/a_3840_n1600# divbuf_5/a_4320_n1600# 0.26fF
C11079 divbuf_3/a_28292_170# divbuf_3/OUT4 0.19fF
C11080 ro_div_0/divbuf_0/a_8670_n1540# ro_div_0/divbuf_0/a_9150_n1540# 0.11fF
C11081 ro_div_0/divbuf_0/a_39390_n840# ro_div_0/divbuf_0/a_39390_n1540# 0.01fF
C11082 divbuf_1/a_37950_n840# divbuf_1/a_37950_n1540# 0.01fF
C11083 divbuf_1/a_7230_n1540# divbuf_1/a_7710_n1540# 0.11fF
C11084 divbuf_5/a_57120_n1600# divbuf_5/a_57150_n1540# 0.19fF
C11085 divbuf_5/a_57150_n840# divbuf_5/a_57630_n840# 0.07fF
C11086 divbuf_5/a_26910_n840# divbuf_5/a_26910_n1540# 0.01fF
C11087 divbuf_3/a_3840_n1600# divbuf_3/a_3870_n840# 0.04fF
C11088 divbuf_0/a_10212_170# divbuf_0/a_10212_n240# 0.01fF
C11089 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C11090 divbuf_2/a_38962_170# divbuf_2/a_38962_n240# 0.01fF
C11091 divbuf_2/a_19072_n240# divbuf_2/a_19562_n240# 0.04fF
C11092 divbuf_4/a_31200_n1600# divbuf_4/a_31230_n840# 0.04fF
C11093 divbuf_4/a_18092_170# divbuf_4/OUT4 0.19fF
C11094 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C11095 divbuf_0/a_7792_170# divbuf_0/OUT3 0.19fF
C11096 divbuf_0/a_52320_n1600# divbuf_0/a_52800_n1600# 0.26fF
C11097 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/clk 0.01fF
C11098 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C11099 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_0/Z3 0.05fF
C11100 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z2 0.36fF
C11101 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/nor_0/B 0.47fF
C11102 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/and_0/B 0.18fF
C11103 divbuf_2/a_30720_n1600# divbuf_2/a_30750_n1540# 0.19fF
C11104 divbuf_2/a_510_n840# divbuf_2/a_510_n1540# 0.01fF
C11105 divbuf_2/a_30750_n840# divbuf_2/a_31230_n840# 0.07fF
C11106 divbuf_2/a_39442_n240# divbuf_2/OUT4 0.04fF
C11107 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.22fF
C11108 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C11109 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C11110 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/a_35550_n840# 0.05fF
C11111 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_45120_n1600# 0.26fF
C11112 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/a_31682_170# 0.07fF
C11113 divbuf_0/a_44670_n1540# divbuf_0/a_45150_n1540# 0.11fF
C11114 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6270_n840# 0.04fF
C11115 divbuf_1/a_4800_n1600# divbuf_1/a_4830_n840# 0.04fF
C11116 divbuf_5/a_14702_n240# divbuf_5/a_14430_n840# 0.01fF
C11117 divbuf_3/a_20532_170# divbuf_3/a_21012_170# 0.07fF
C11118 pll_full_0/divbuf_0/a_36990_n1540# pll_full_0/divbuf_0/a_37470_n1540# 0.11fF
C11119 divbuf_3/a_29262_n240# divbuf_3/OUT4 0.04fF
C11120 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_4320_n1600# 0.26fF
C11121 divbuf_4/a_28772_170# divbuf_4/a_28772_n240# 0.01fF
C11122 divbuf_4/a_8272_n240# divbuf_4/a_8762_n240# 0.04fF
C11123 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7680_n1600# 0.26fF
C11124 divbuf_3/a_53760_n1600# divbuf_3/a_54240_n1600# 0.26fF
C11125 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57150_n1540# 0.19fF
C11126 pd_div_0/divbuf_0/a_57150_n840# pd_div_0/divbuf_0/a_57630_n840# 0.07fF
C11127 pd_div_0/divbuf_0/a_26910_n840# pd_div_0/divbuf_0/a_26910_n1540# 0.01fF
C11128 divbuf_4/a_20640_n1600# divbuf_4/a_20670_n1540# 0.19fF
C11129 divbuf_4/a_20670_n840# divbuf_4/a_21150_n840# 0.07fF
C11130 divbuf_4/a_19072_n240# divbuf_4/OUT4 0.04fF
C11131 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/a_60510_n1540# 0.19fF
C11132 pll_full_0/divbuf_1/a_30270_n840# pll_full_0/divbuf_1/a_30270_n1540# 0.01fF
C11133 pll_full_0/divbuf_1/a_60510_n840# pll_full_0/divbuf_1/a_60990_n840# 0.07fF
C11134 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11135 divbuf_3/a_46110_n1540# divbuf_3/a_46590_n1540# 0.11fF
C11136 divbuf_0/a_40412_170# divbuf_0/OUT4 0.19fF
C11137 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n840# 0.04fF
C11138 divbuf_1/a_10212_170# divbuf_1/a_10212_n240# 0.01fF
C11139 divbuf_5/a_9732_170# divbuf_5/a_10212_170# 0.07fF
C11140 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11141 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_34590_n840# 0.04fF
C11142 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56640_n1600# 0.26fF
C11143 divbuf_1/a_54720_n1600# divbuf_1/a_55200_n1600# 0.26fF
C11144 divbuf_5/a_43680_n1600# divbuf_5/a_44160_n1600# 0.26fF
C11145 divbuf_5/a_34592_n240# divbuf_5/a_34590_n840# 0.06fF
C11146 ro_div_0/divbuf_0/a_48510_n1540# ro_div_0/divbuf_0/a_48990_n1540# 0.11fF
C11147 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_14430_n840# 0.01fF
C11148 divbuf_1/a_47070_n1540# divbuf_1/a_47550_n1540# 0.11fF
C11149 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_17790_n840# 0.00fF
C11150 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/a_27802_n240# 0.01fF
C11151 divbuf_3/a_43680_n1600# divbuf_3/a_43710_n840# 0.04fF
C11152 divbuf_5/a_36030_n1540# divbuf_5/a_36510_n1540# 0.11fF
C11153 divbuf_0/a_20042_n240# divbuf_0/a_20532_n240# 0.04fF
C11154 divbuf_0/a_39932_170# divbuf_0/a_39932_n240# 0.01fF
C11155 divbuf_2/a_17280_n1600# divbuf_2/a_17760_n1600# 0.26fF
C11156 divbuf_2/a_7792_n240# divbuf_2/a_7710_n840# 0.03fF
C11157 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/a_32172_n240# 0.01fF
C11158 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11159 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12772_n240# 0.04fF
C11160 divbuf_0/a_41382_n240# divbuf_0/OUT4 0.04fF
C11161 divbuf_0/a_1470_n840# divbuf_0/a_1470_n1540# 0.01fF
C11162 divbuf_0/a_31710_n840# divbuf_0/a_32190_n840# 0.07fF
C11163 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n1540# 0.19fF
C11164 divbuf_1/a_20532_170# divbuf_1/a_20532_n240# 0.01fF
C11165 pll_full_0/divbuf_0/a_24030_n840# pll_full_0/divbuf_0/a_24510_n840# 0.07fF
C11166 divbuf_2/a_40350_n840# divbuf_2/a_40350_n1540# 0.01fF
C11167 divbuf_2/a_9630_n1540# divbuf_2/a_10110_n1540# 0.11fF
C11168 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11169 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24030_n1540# 0.19fF
C11170 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46110_n840# 0.04fF
C11171 ro_div_0/divider_0/tspc_2/a_630_n680# gnd 0.61fF
C11172 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/a_7792_170# 0.07fF
C11173 divbuf_1/a_5852_n240# divbuf_1/OUT3 0.04fF
C11174 divbuf_1/a_44640_n1600# divbuf_1/a_44670_n840# 0.04fF
C11175 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/a_14222_170# 0.07fF
C11176 divbuf_3/a_41382_170# divbuf_3/a_41382_n240# 0.01fF
C11177 divbuf_3/a_21502_n240# divbuf_3/a_21982_n240# 0.05fF
C11178 divbuf_5/a_33600_n1600# divbuf_5/a_33630_n840# 0.04fF
C11179 divbuf_5/a_22952_170# divbuf_5/OUT4 0.19fF
C11180 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/switch_3/vin 0.20fF
C11181 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_44160_n1600# 0.26fF
C11182 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/a_34590_n840# 0.06fF
C11183 divbuf_4/a_7200_n1600# divbuf_4/a_7680_n1600# 0.26fF
C11184 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47520_n1600# 0.26fF
C11185 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/a_37950_n840# 0.04fF
C11186 divbuf_3/a_33120_n1600# divbuf_3/a_33150_n1540# 0.19fF
C11187 divbuf_3/a_33150_n840# divbuf_3/a_33630_n840# 0.07fF
C11188 divbuf_3/a_2910_n840# divbuf_3/a_2910_n1540# 0.01fF
C11189 pd_div_0/divbuf_0/a_36030_n1540# pd_div_0/divbuf_0/a_36510_n1540# 0.11fF
C11190 divbuf_4/a_60510_n840# divbuf_4/a_60990_n840# 0.07fF
C11191 divbuf_4/a_30270_n840# divbuf_4/a_30270_n1540# 0.01fF
C11192 divbuf_4/a_60480_n1600# divbuf_4/a_60510_n1540# 0.19fF
C11193 divbuf_2/a_7200_n1600# divbuf_2/a_7230_n840# 0.04fF
C11194 pll_full_0/divbuf_1/a_39390_n1540# pll_full_0/divbuf_1/a_39870_n1540# 0.11fF
C11195 gnd pll_full_0/divider_0/tspc_1/Z4 0.44fF
C11196 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/a_24412_n240# 0.04fF
C11197 divbuf_1/a_22472_n240# divbuf_1/a_22952_n240# 0.05fF
C11198 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C11199 divbuf_5/a_31202_170# divbuf_5/a_31202_n240# 0.01fF
C11200 divbuf_5/a_11312_n240# divbuf_5/a_11802_n240# 0.04fF
C11201 ro_div_0/divbuf_0/a_5310_n840# ro_div_0/divbuf_0/a_5310_n1540# 0.01fF
C11202 ro_div_0/divbuf_0/a_35550_n840# ro_div_0/divbuf_0/a_36030_n840# 0.07fF
C11203 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_35550_n1540# 0.19fF
C11204 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/a_14702_n240# 0.01fF
C11205 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/a_9242_n240# 0.01fF
C11206 divbuf_1/a_34080_n1600# divbuf_1/a_34110_n1540# 0.19fF
C11207 divbuf_1/a_34110_n840# divbuf_1/a_34590_n840# 0.07fF
C11208 divbuf_1/a_3870_n840# divbuf_1/a_3870_n1540# 0.01fF
C11209 divbuf_5/a_23040_n1600# divbuf_5/a_23070_n1540# 0.19fF
C11210 divbuf_5/a_23070_n840# divbuf_5/a_23550_n840# 0.07fF
C11211 divbuf_5/a_23922_n240# divbuf_5/OUT4 0.04fF
C11212 divbuf_3/a_55230_n840# divbuf_3/a_55230_n1540# 0.01fF
C11213 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/nor_0/B 0.00fF
C11214 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/nor_1/A 0.35fF
C11215 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C11216 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C11217 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C11218 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_33630_n840# 0.04fF
C11219 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11220 divbuf_4/a_18092_n240# divbuf_4/a_17790_n840# 0.00fF
C11221 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11222 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_36990_n840# 0.04fF
C11223 divbuf_2/a_3912_170# divbuf_2/a_3912_n240# 0.01fF
C11224 divbuf_2/a_23922_170# divbuf_2/a_24412_170# 0.07fF
C11225 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C11226 divbuf_0/a_8762_n240# divbuf_0/a_8670_n840# 0.03fF
C11227 divbuf_0/a_18240_n1600# divbuf_0/a_18720_n1600# 0.26fF
C11228 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_11040_n1600# 0.26fF
C11229 divbuf_2/a_9732_170# divbuf_2/OUT3 0.19fF
C11230 divbuf_2/a_57120_n1600# divbuf_2/a_57600_n1600# 0.26fF
C11231 divbuf_0/a_10590_n1540# divbuf_0/a_11070_n1540# 0.11fF
C11232 divbuf_0/a_41310_n840# divbuf_0/a_41310_n1540# 0.01fF
C11233 divbuf_2/a_49470_n1540# divbuf_2/a_49950_n1540# 0.11fF
C11234 pll_full_0/divbuf_0/a_33630_n840# pll_full_0/divbuf_0/a_33630_n1540# 0.01fF
C11235 pll_full_0/divbuf_0/a_2910_n1540# pll_full_0/divbuf_0/a_3390_n1540# 0.11fF
C11236 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/a_31202_n240# 0.01fF
C11237 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11802_n240# 0.04fF
C11238 divbuf_4/a_13742_170# divbuf_4/a_14222_170# 0.07fF
C11239 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/a_34592_n240# 0.01fF
C11240 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_15182_n240# 0.05fF
C11241 divbuf_3/a_19680_n1600# divbuf_3/a_20160_n1600# 0.26fF
C11242 divbuf_3/a_10212_n240# divbuf_3/a_10110_n840# 0.03fF
C11243 divbuf_5/a_22080_n1600# divbuf_5/OUT4 0.01fF
C11244 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23070_n1540# 0.19fF
C11245 pd_div_0/divbuf_0/a_23070_n840# pd_div_0/divbuf_0/a_23550_n840# 0.07fF
C11246 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11247 divbuf_3/a_42750_n840# divbuf_3/a_42750_n1540# 0.01fF
C11248 divbuf_3/a_12030_n1540# divbuf_3/a_12510_n1540# 0.11fF
C11249 divbuf_4/a_37992_n240# divbuf_4/a_37950_n840# 0.04fF
C11250 divbuf_4/a_47040_n1600# divbuf_4/a_47520_n1600# 0.26fF
C11251 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C11252 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26430_n1540# 0.19fF
C11253 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11254 pll_full_0/divbuf_1/a_26430_n840# pll_full_0/divbuf_1/a_26910_n840# 0.07fF
C11255 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_16830_n840# 0.00fF
C11256 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n840# 0.04fF
C11257 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C11258 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C11259 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/nor_1/B 0.22fF
C11260 divbuf_2/a_10212_n240# divbuf_2/OUT4 0.04fF
C11261 divbuf_2/a_47040_n1600# divbuf_2/a_47070_n840# 0.04fF
C11262 divbuf_4/a_39390_n1540# divbuf_4/a_39870_n1540# 0.11fF
C11263 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_510_n840# 0.04fF
C11264 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C11265 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22560_n1600# 0.26fF
C11266 divbuf_1/a_20640_n1600# divbuf_1/a_21120_n1600# 0.26fF
C11267 divbuf_1/a_11312_n240# divbuf_1/a_11550_n840# 0.02fF
C11268 divbuf_5/a_9600_n1600# divbuf_5/a_10080_n1600# 0.26fF
C11269 divbuf_3/a_39932_170# divbuf_3/OUT4 0.19fF
C11270 ro_div_0/divbuf_0/a_14430_n1540# ro_div_0/divbuf_0/a_14910_n1540# 0.11fF
C11271 ro_div_0/divbuf_0/a_45150_n840# ro_div_0/divbuf_0/a_45150_n1540# 0.01fF
C11272 divbuf_1/a_43710_n840# divbuf_1/a_43710_n1540# 0.01fF
C11273 divbuf_1/a_12990_n1540# divbuf_1/a_13470_n1540# 0.11fF
C11274 divbuf_3/a_9600_n1600# divbuf_3/a_9630_n840# 0.04fF
C11275 divbuf_5/a_32670_n840# divbuf_5/a_32670_n1540# 0.01fF
C11276 divbuf_5/a_1950_n1540# divbuf_5/a_2430_n1540# 0.11fF
C11277 divbuf_0/a_24892_170# divbuf_0/a_25382_170# 0.07fF
C11278 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C11279 divbuf_2/a_24892_n240# divbuf_2/a_25382_n240# 0.04fF
C11280 divbuf_4/a_36960_n1600# divbuf_4/a_36990_n840# 0.04fF
C11281 divbuf_4/a_29742_170# divbuf_4/OUT4 0.19fF
C11282 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/a_19072_170# 0.07fF
C11283 divbuf_0/a_58080_n1600# divbuf_0/a_58560_n1600# 0.26fF
C11284 divbuf_0/a_11802_170# divbuf_0/OUT4 0.19fF
C11285 divbuf_2/a_9600_n1600# divbuf_2/OUT3 0.00fF
C11286 divbuf_2/a_36480_n1600# divbuf_2/a_36510_n1540# 0.19fF
C11287 divbuf_2/a_36510_n840# divbuf_2/a_36990_n840# 0.07fF
C11288 divbuf_2/a_6270_n840# divbuf_2/a_6270_n1540# 0.01fF
C11289 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50880_n1600# 0.26fF
C11290 pll_full_0/divbuf_0/a_4392_170# pll_full_0/divbuf_0/OUT3 0.19fF
C11291 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/a_41310_n840# 0.03fF
C11292 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C11293 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/A 0.01fF
C11294 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/a_37502_170# 0.07fF
C11295 divbuf_0/a_50430_n1540# divbuf_0/a_50910_n1540# 0.11fF
C11296 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12030_n840# 0.04fF
C11297 divbuf_1/a_16642_170# divbuf_1/OUT4 0.19fF
C11298 divbuf_1/a_10560_n1600# divbuf_1/a_10590_n840# 0.04fF
C11299 divbuf_3/a_6332_170# divbuf_3/a_6332_n240# 0.01fF
C11300 divbuf_3/a_26352_170# divbuf_3/a_26832_170# 0.07fF
C11301 pll_full_0/divbuf_0/a_42750_n1540# pll_full_0/divbuf_0/a_43230_n1540# 0.11fF
C11302 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C11303 divbuf_3/a_40902_n240# divbuf_3/OUT4 0.04fF
C11304 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_10080_n1600# 0.26fF
C11305 divbuf_4/a_14702_n240# divbuf_4/a_15182_n240# 0.05fF
C11306 divbuf_4/a_34592_170# divbuf_4/a_34592_n240# 0.01fF
C11307 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_13440_n1600# 0.26fF
C11308 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/a_3390_n840# 0.05fF
C11309 divbuf_3/a_59520_n1600# divbuf_3/a_60000_n1600# 0.26fF
C11310 pd_div_0/divbuf_0/a_32670_n840# pd_div_0/divbuf_0/a_32670_n1540# 0.01fF
C11311 pd_div_0/divbuf_0/a_1950_n1540# pd_div_0/divbuf_0/a_2430_n1540# 0.11fF
C11312 divbuf_4/a_26430_n840# divbuf_4/a_26910_n840# 0.07fF
C11313 divbuf_4/a_30712_n240# divbuf_4/OUT4 0.04fF
C11314 divbuf_4/a_26400_n1600# divbuf_4/a_26430_n1540# 0.19fF
C11315 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/a_18582_n240# 0.01fF
C11316 pll_full_0/divbuf_1/a_5310_n1540# pll_full_0/divbuf_1/a_5790_n1540# 0.11fF
C11317 pll_full_0/divbuf_1/a_36030_n840# pll_full_0/divbuf_1/a_36030_n1540# 0.01fF
C11318 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11319 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n840# 0.04fF
C11320 divbuf_0/a_12772_n240# divbuf_0/OUT4 0.04fF
C11321 divbuf_1/a_23922_170# divbuf_1/a_24412_170# 0.07fF
C11322 divbuf_1/a_33622_170# divbuf_1/a_33622_n240# 0.01fF
C11323 divbuf_5/a_16152_170# divbuf_5/a_16642_170# 0.07fF
C11324 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40350_n840# 0.04fF
C11325 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11326 ro_div_0/divbuf_0/a_1470_n840# ro_div_0/divbuf_0/a_1950_n840# 0.07fF
C11327 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1470_n1540# 0.19fF
C11328 pd_div_0/pd_0/tspc_r_0/Z2 pd_div_0/pd_0/tspc_r_0/Z4 0.14fF
C11329 divbuf_1/a_14222_170# divbuf_1/OUT4 0.19fF
C11330 divbuf_5/a_49440_n1600# divbuf_5/a_49920_n1600# 0.26fF
C11331 divbuf_5/a_40412_n240# divbuf_5/a_40350_n840# 0.04fF
C11332 ro_div_0/divbuf_0/a_54270_n1540# ro_div_0/divbuf_0/a_54750_n1540# 0.11fF
C11333 divbuf_1/a_52830_n1540# divbuf_1/a_53310_n1540# 0.11fF
C11334 divbuf_5/a_41790_n1540# divbuf_5/a_42270_n1540# 0.11fF
C11335 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_2910_n840# 0.04fF
C11336 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/a_33622_n240# 0.01fF
C11337 divbuf_3/a_49440_n1600# divbuf_3/a_49470_n840# 0.04fF
C11338 divbuf_0/a_25862_n240# divbuf_0/a_26352_n240# 0.04fF
C11339 divbuf_2/a_13742_n240# divbuf_2/a_13950_n840# 0.02fF
C11340 divbuf_2/a_23040_n1600# divbuf_2/a_23520_n1600# 0.26fF
C11341 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_18582_n240# 0.04fF
C11342 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/a_37992_n240# 0.01fF
C11343 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n1540# 0.19fF
C11344 divbuf_0/a_11040_n1600# divbuf_0/OUT4 0.00fF
C11345 divbuf_0/a_7230_n840# divbuf_0/a_7230_n1540# 0.01fF
C11346 divbuf_0/a_37470_n840# divbuf_0/a_37950_n840# 0.07fF
C11347 divbuf_1/a_26352_170# divbuf_1/a_26352_n240# 0.01fF
C11348 divbuf_2/a_46110_n840# divbuf_2/a_46110_n1540# 0.01fF
C11349 divbuf_2/a_15390_n1540# divbuf_2/a_15870_n1540# 0.11fF
C11350 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_29790_n1540# 0.19fF
C11351 pll_full_0/divbuf_0/a_29790_n840# pll_full_0/divbuf_0/a_30270_n840# 0.07fF
C11352 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11353 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11354 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_51870_n840# 0.04fF
C11355 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/a_16642_170# 0.07fF
C11356 divbuf_1/a_50400_n1600# divbuf_1/a_50430_n840# 0.04fF
C11357 divbuf_1/a_17612_n240# divbuf_1/OUT4 0.04fF
C11358 divbuf_5/a_39360_n1600# divbuf_5/a_39390_n840# 0.04fF
C11359 divbuf_5/a_34592_170# divbuf_5/OUT4 0.19fF
C11360 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/a_20042_170# 0.07fF
C11361 divbuf_3/a_27322_n240# divbuf_3/a_27802_n240# 0.05fF
C11362 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/a_630_n680# 0.01fF
C11363 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C11364 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49920_n1600# 0.26fF
C11365 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/a_40350_n840# 0.04fF
C11366 divbuf_4/a_3422_n240# divbuf_4/a_3390_n840# 0.05fF
C11367 divbuf_4/a_12960_n1600# divbuf_4/a_13440_n1600# 0.26fF
C11368 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C11369 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_53280_n1600# 0.26fF
C11370 divbuf_3/a_38910_n840# divbuf_3/a_39390_n840# 0.07fF
C11371 divbuf_3/a_8670_n840# divbuf_3/a_8670_n1540# 0.01fF
C11372 divbuf_3/a_38880_n1600# divbuf_3/a_38910_n1540# 0.19fF
C11373 pd_div_0/divbuf_0/a_41790_n1540# pd_div_0/divbuf_0/a_42270_n1540# 0.11fF
C11374 divbuf_4/a_36030_n840# divbuf_4/a_36030_n1540# 0.01fF
C11375 divbuf_4/a_5310_n1540# divbuf_4/a_5790_n1540# 0.11fF
C11376 pll_full_0/divbuf_1/a_45150_n1540# pll_full_0/divbuf_1/a_45630_n1540# 0.11fF
C11377 divbuf_2/a_12960_n1600# divbuf_2/a_12990_n840# 0.04fF
C11378 gnd pll_full_0/divider_0/tspc_2/Z3 0.27fF
C11379 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/a_30232_n240# 0.04fF
C11380 divbuf_1/a_28292_n240# divbuf_1/a_28772_n240# 0.05fF
C11381 divbuf_5/a_37022_170# divbuf_5/a_37022_n240# 0.01fF
C11382 divbuf_5/a_17122_n240# divbuf_5/a_17612_n240# 0.04fF
C11383 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C11384 ro_div_0/divbuf_0/a_11070_n840# ro_div_0/divbuf_0/a_11070_n1540# 0.01fF
C11385 ro_div_0/divbuf_0/a_41310_n840# ro_div_0/divbuf_0/a_41790_n840# 0.07fF
C11386 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41310_n1540# 0.19fF
C11387 divbuf_1/a_39870_n840# divbuf_1/a_40350_n840# 0.07fF
C11388 divbuf_1/a_9630_n840# divbuf_1/a_9630_n1540# 0.01fF
C11389 divbuf_1/a_39840_n1600# divbuf_1/a_39870_n1540# 0.19fF
C11390 divbuf_5/a_28830_n840# divbuf_5/a_29310_n840# 0.07fF
C11391 divbuf_5/a_35562_n240# divbuf_5/OUT4 0.04fF
C11392 divbuf_5/a_28800_n1600# divbuf_5/a_28830_n1540# 0.19fF
C11393 divbuf_3/a_60990_n840# divbuf_3/a_60990_n1540# 0.01fF
C11394 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z3 0.45fF
C11395 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C11396 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/Out 0.08fF
C11397 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39390_n840# 0.04fF
C11398 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11399 divbuf_4/a_2880_n1600# divbuf_4/a_2910_n840# 0.04fF
C11400 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/OUT2 0.04fF
C11401 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11402 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_42750_n840# 0.04fF
C11403 divbuf_2/a_29742_170# divbuf_2/a_30232_170# 0.07fF
C11404 divbuf_2/a_9732_170# divbuf_2/a_9732_n240# 0.01fF
C11405 divbuf_0/a_24000_n1600# divbuf_0/a_24480_n1600# 0.26fF
C11406 divbuf_0/a_14702_n240# divbuf_0/a_14910_n840# 0.02fF
C11407 divbuf_2/a_2400_n1600# divbuf_2/a_2430_n1540# 0.19fF
C11408 divbuf_2/a_21502_170# divbuf_2/OUT4 0.19fF
C11409 divbuf_2/a_2430_n840# divbuf_2/a_2910_n840# 0.07fF
C11410 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16800_n1600# 0.26fF
C11411 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/a_6750_n840# 0.03fF
C11412 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C11413 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C11414 divbuf_0/a_16350_n1540# divbuf_0/a_16830_n1540# 0.11fF
C11415 divbuf_0/a_47070_n840# divbuf_0/a_47070_n1540# 0.01fF
C11416 pll_full_0/divbuf_0/a_8670_n1540# pll_full_0/divbuf_0/a_9150_n1540# 0.11fF
C11417 pll_full_0/divbuf_0/a_39390_n840# pll_full_0/divbuf_0/a_39390_n1540# 0.01fF
C11418 divbuf_2/a_55230_n1540# divbuf_2/a_55710_n1540# 0.11fF
C11419 divbuf_3/a_11312_170# divbuf_3/OUT4 0.23fF
C11420 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/a_37022_n240# 0.01fF
C11421 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_17612_n240# 0.04fF
C11422 divbuf_4/a_19562_170# divbuf_4/a_20042_170# 0.07fF
C11423 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/a_21012_n240# 0.05fF
C11424 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/a_40412_n240# 0.01fF
C11425 divbuf_3/a_16152_n240# divbuf_3/a_16350_n840# 0.02fF
C11426 divbuf_3/a_25440_n1600# divbuf_3/a_25920_n1600# 0.26fF
C11427 divbuf_5/a_33600_n1600# divbuf_5/OUT4 0.01fF
C11428 divbuf_0/a_17612_170# divbuf_0/a_17612_n240# 0.01fF
C11429 pd_div_0/divbuf_0/a_28830_n840# pd_div_0/divbuf_0/a_29310_n840# 0.07fF
C11430 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11431 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_28830_n1540# 0.19fF
C11432 divbuf_4/a_52800_n1600# divbuf_4/a_53280_n1600# 0.26fF
C11433 divbuf_4/a_492_n240# divbuf_4/OUT2 0.42fF
C11434 divbuf_3/a_48510_n840# divbuf_3/a_48510_n1540# 0.01fF
C11435 divbuf_3/a_17790_n1540# divbuf_3/a_18270_n1540# 0.11fF
C11436 pll_full_0/divbuf_1/a_1950_n840# pll_full_0/divbuf_1/a_1950_n1540# 0.01fF
C11437 pll_full_0/divbuf_1/a_32190_n840# pll_full_0/divbuf_1/a_32670_n840# 0.07fF
C11438 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32190_n1540# 0.19fF
C11439 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/OUT2 0.01fF
C11440 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/a5 0.09fF
C11441 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n840# 0.04fF
C11442 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C11443 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/nor_1/A 0.21fF
C11444 divbuf_1/a_9732_170# divbuf_1/a_10212_170# 0.07fF
C11445 divbuf_2/a_52800_n1600# divbuf_2/a_52830_n840# 0.04fF
C11446 divbuf_2/a_22472_n240# divbuf_2/OUT4 0.04fF
C11447 divbuf_4/a_45150_n1540# divbuf_4/a_45630_n1540# 0.11fF
C11448 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6270_n840# 0.04fF
C11449 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_1/A 0.01fF
C11450 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C11451 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C11452 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C11453 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_28320_n1600# 0.26fF
C11454 divbuf_1/a_26400_n1600# divbuf_1/a_26880_n1600# 0.26fF
C11455 divbuf_1/a_17122_n240# divbuf_1/a_17310_n840# 0.02fF
C11456 divbuf_5/a_15360_n1600# divbuf_5/a_15840_n1600# 0.26fF
C11457 divbuf_5/a_5852_n240# divbuf_5/a_5790_n840# 0.04fF
C11458 divbuf_3/a_12282_n240# divbuf_3/OUT4 0.04fF
C11459 ro_div_0/divbuf_0/a_20190_n1540# ro_div_0/divbuf_0/a_20670_n1540# 0.11fF
C11460 ro_div_0/divbuf_0/a_50910_n840# ro_div_0/divbuf_0/a_50910_n1540# 0.01fF
C11461 divbuf_1/a_49470_n840# divbuf_1/a_49470_n1540# 0.01fF
C11462 divbuf_1/a_18750_n1540# divbuf_1/a_19230_n1540# 0.11fF
C11463 divbuf_3/a_15360_n1600# divbuf_3/a_15390_n840# 0.04fF
C11464 divbuf_5/a_38430_n840# divbuf_5/a_38430_n1540# 0.01fF
C11465 divbuf_5/a_7710_n1540# divbuf_5/a_8190_n1540# 0.11fF
C11466 divbuf_0/a_11312_170# divbuf_0/a_11312_n240# 0.01fF
C11467 divbuf_0/a_30712_170# divbuf_0/a_31202_170# 0.07fF
C11468 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C11469 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/a_23442_170# 0.07fF
C11470 divbuf_2/a_30712_n240# divbuf_2/a_31202_n240# 0.04fF
C11471 divbuf_4/a_42720_n1600# divbuf_4/a_42750_n840# 0.04fF
C11472 divbuf_4/a_41382_170# divbuf_4/OUT4 0.19fF
C11473 divbuf_4/a_1842_n240# divbuf_4/OUT2 0.04fF
C11474 divbuf_0/a_23442_170# divbuf_0/OUT4 0.19fF
C11475 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n1540# 0.19fF
C11476 divbuf_0/a_3390_n840# divbuf_0/a_3870_n840# 0.07fF
C11477 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/clk 0.05fF
C11478 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/bufin 0.04fF
C11479 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z2 0.40fF
C11480 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/Z1 0.04fF
C11481 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56640_n1600# 0.26fF
C11482 divbuf_2/a_42240_n1600# divbuf_2/a_42270_n1540# 0.19fF
C11483 divbuf_2/a_42270_n840# divbuf_2/a_42750_n840# 0.07fF
C11484 divbuf_2/a_12030_n840# divbuf_2/a_12030_n1540# 0.01fF
C11485 divbuf_2/a_20640_n1600# divbuf_2/OUT4 0.00fF
C11486 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/OUT3 0.19fF
C11487 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.29fF
C11488 divbuf_0/a_56190_n1540# divbuf_0/a_56670_n1540# 0.11fF
C11489 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_17790_n840# 0.04fF
C11490 divbuf_1/a_16320_n1600# divbuf_1/a_16350_n840# 0.04fF
C11491 divbuf_3/a_32172_170# divbuf_3/a_32652_170# 0.07fF
C11492 divbuf_3/a_12772_170# divbuf_3/a_12772_n240# 0.01fF
C11493 divbuf_5/a_5280_n1600# divbuf_5/a_5310_n840# 0.04fF
C11494 pll_full_0/divbuf_0/a_48510_n1540# pll_full_0/divbuf_0/a_48990_n1540# 0.11fF
C11495 divbuf_3/a_11040_n1600# divbuf_3/OUT3 0.00fF
C11496 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15840_n1600# 0.26fF
C11497 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/a_5790_n840# 0.04fF
C11498 divbuf_3/a_4830_n840# divbuf_3/a_5310_n840# 0.07fF
C11499 divbuf_3/a_4800_n1600# divbuf_3/a_4830_n1540# 0.19fF
C11500 divbuf_4/a_40412_170# divbuf_4/a_40412_n240# 0.01fF
C11501 divbuf_4/a_20532_n240# divbuf_4/a_21012_n240# 0.05fF
C11502 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/a_9150_n840# 0.03fF
C11503 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_19200_n1600# 0.26fF
C11504 pd_div_0/divbuf_0/a_38430_n840# pd_div_0/divbuf_0/a_38430_n1540# 0.01fF
C11505 pd_div_0/divbuf_0/a_7710_n1540# pd_div_0/divbuf_0/a_8190_n1540# 0.11fF
C11506 divbuf_4/a_1440_n1600# divbuf_4/OUT2 0.01fF
C11507 divbuf_4/a_32160_n1600# divbuf_4/a_32190_n1540# 0.19fF
C11508 divbuf_4/a_32190_n840# divbuf_4/a_32670_n840# 0.07fF
C11509 divbuf_4/a_1950_n840# divbuf_4/a_1950_n1540# 0.01fF
C11510 pll_full_0/divbuf_1/a_11070_n1540# pll_full_0/divbuf_1/a_11550_n1540# 0.11fF
C11511 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/a_41790_n1540# 0.01fF
C11512 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11513 divbuf_0/a_24412_n240# divbuf_0/OUT4 0.04fF
C11514 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n840# 0.04fF
C11515 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46110_n840# 0.04fF
C11516 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C11517 divbuf_1/a_29742_170# divbuf_1/a_30232_170# 0.07fF
C11518 divbuf_2/a_990_n840# divbuf_2/OUT2 0.02fF
C11519 divbuf_5/a_21982_170# divbuf_5/a_22472_170# 0.07fF
C11520 divbuf_5/a_1352_170# divbuf_5/a_1352_n240# 0.01fF
C11521 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 gnd 0.27fF
C11522 ro_div_0/divbuf_0/a_7230_n840# ro_div_0/divbuf_0/a_7710_n840# 0.07fF
C11523 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7230_n1540# 0.19fF
C11524 pd_div_0/pd_0/UP pd_div_0/pd_0/tspc_r_1/Qbar 0.21fF
C11525 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z4 0.02fF
C11526 pd_div_0/pd_0/R pd_div_0/pd_0/and_pd_0/Out1 0.33fF
C11527 divbuf_1/a_5790_n840# divbuf_1/a_6270_n840# 0.07fF
C11528 divbuf_1/a_24892_170# divbuf_1/OUT4 0.19fF
C11529 divbuf_1/a_5760_n1600# divbuf_1/a_5790_n1540# 0.19fF
C11530 divbuf_5/a_5852_170# divbuf_5/OUT3 0.19fF
C11531 divbuf_5/a_55200_n1600# divbuf_5/a_55680_n1600# 0.26fF
C11532 divbuf_3/a_57120_n1600# divbuf_3/a_57150_n1540# 0.19fF
C11533 ro_div_0/divbuf_0/a_60030_n1540# ro_div_0/divbuf_0/a_60510_n1540# 0.11fF
C11534 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5310_n840# 0.04fF
C11535 divbuf_1/a_58590_n1540# divbuf_1/a_59070_n1540# 0.11fF
C11536 divbuf_5/a_47550_n1540# divbuf_5/a_48030_n1540# 0.11fF
C11537 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_8670_n840# 0.04fF
C11538 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/a_39442_n240# 0.01fF
C11539 divbuf_3/a_55200_n1600# divbuf_3/a_55230_n840# 0.04fF
C11540 divbuf_0/a_31682_n240# divbuf_0/a_32172_n240# 0.04fF
C11541 divbuf_2/a_28800_n1600# divbuf_2/a_29280_n1600# 0.26fF
C11542 divbuf_2/a_19562_n240# divbuf_2/a_19710_n840# 0.03fF
C11543 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/a_24412_n240# 0.04fF
C11544 divbuf_0/a_22560_n1600# divbuf_0/OUT4 0.01fF
C11545 divbuf_0/a_12990_n840# divbuf_0/a_12990_n1540# 0.01fF
C11546 divbuf_0/a_43230_n840# divbuf_0/a_43710_n840# 0.07fF
C11547 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n1540# 0.19fF
C11548 divbuf_2/a_51870_n840# divbuf_2/a_51870_n1540# 0.01fF
C11549 divbuf_2/a_21150_n1540# divbuf_2/a_21630_n1540# 0.11fF
C11550 pll_full_0/divbuf_0/a_5310_n840# pll_full_0/divbuf_0/a_5310_n1540# 0.01fF
C11551 pll_full_0/divbuf_0/a_35550_n840# pll_full_0/divbuf_0/a_36030_n840# 0.07fF
C11552 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_35550_n1540# 0.19fF
C11553 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_57630_n840# 0.04fF
C11554 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11555 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/a_5852_n240# 0.01fF
C11556 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/a_22472_170# 0.07fF
C11557 divbuf_1/a_29262_n240# divbuf_1/OUT4 0.04fF
C11558 divbuf_1/a_56160_n1600# divbuf_1/a_56190_n840# 0.04fF
C11559 divbuf_5/a_6822_n240# divbuf_5/OUT3 0.04fF
C11560 divbuf_5/a_45120_n1600# divbuf_5/a_45150_n840# 0.04fF
C11561 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/a_25862_170# 0.07fF
C11562 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/a_5362_n240# 0.01fF
C11563 divbuf_3/a_33142_n240# divbuf_3/a_33622_n240# 0.05fF
C11564 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.01fF
C11565 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/a_630_n680# 0.12fF
C11566 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11567 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55680_n1600# 0.26fF
C11568 divbuf_4/a_18720_n1600# divbuf_4/a_19200_n1600# 0.26fF
C11569 divbuf_4/a_9242_n240# divbuf_4/a_9150_n840# 0.03fF
C11570 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C11571 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_59040_n1600# 0.26fF
C11572 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11573 divbuf_3/a_44640_n1600# divbuf_3/a_44670_n1540# 0.19fF
C11574 divbuf_3/a_44670_n840# divbuf_3/a_45150_n840# 0.07fF
C11575 divbuf_3/a_14430_n840# divbuf_3/a_14430_n1540# 0.01fF
C11576 io_clamp_high[1] io_analog[5] 0.53fF
C11577 pd_div_0/divbuf_0/a_47550_n1540# pd_div_0/divbuf_0/a_48030_n1540# 0.11fF
C11578 divbuf_2/a_18720_n1600# divbuf_2/a_18750_n840# 0.04fF
C11579 divbuf_4/a_41790_n840# divbuf_4/a_41790_n1540# 0.01fF
C11580 divbuf_4/a_11070_n1540# divbuf_4/a_11550_n1540# 0.11fF
C11581 pll_full_0/divbuf_1/a_50910_n1540# pll_full_0/divbuf_1/a_51390_n1540# 0.11fF
C11582 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/a_36052_n240# 0.04fF
C11583 divbuf_1/a_34112_n240# divbuf_1/a_34592_n240# 0.05fF
C11584 divbuf_5/a_22952_n240# divbuf_5/a_23442_n240# 0.04fF
C11585 ro_div_0/divbuf_0/a_16830_n840# ro_div_0/divbuf_0/a_16830_n1540# 0.01fF
C11586 ro_div_0/divbuf_0/a_47070_n840# ro_div_0/divbuf_0/a_47550_n840# 0.07fF
C11587 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47070_n1540# 0.19fF
C11588 divbuf_1/a_45600_n1600# divbuf_1/a_45630_n1540# 0.19fF
C11589 divbuf_1/a_45630_n840# divbuf_1/a_46110_n840# 0.07fF
C11590 divbuf_1/a_15390_n840# divbuf_1/a_15390_n1540# 0.01fF
C11591 divbuf_5/a_34560_n1600# divbuf_5/a_34590_n1540# 0.19fF
C11592 divbuf_5/a_34590_n840# divbuf_5/a_35070_n840# 0.07fF
C11593 divbuf_5/a_4350_n840# divbuf_5/a_4350_n1540# 0.01fF
C11594 divbuf_3/a_1352_n240# divbuf_3/a_1470_n840# 0.03fF
C11595 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.45fF
C11596 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C11597 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45150_n840# 0.04fF
C11598 divbuf_2/a_16152_170# divbuf_2/a_16152_n240# 0.01fF
C11599 divbuf_2/a_35562_170# divbuf_2/a_36052_170# 0.07fF
C11600 divbuf_4/a_8640_n1600# divbuf_4/a_8670_n840# 0.04fF
C11601 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48510_n840# 0.04fF
C11602 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11603 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/a_8190_n840# 0.03fF
C11604 divbuf_0/a_20532_n240# divbuf_0/a_20670_n840# 0.03fF
C11605 divbuf_0/a_29760_n1600# divbuf_0/a_30240_n1600# 0.26fF
C11606 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_12990_n840# 0.02fF
C11607 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22560_n1600# 0.26fF
C11608 divbuf_2/a_8160_n1600# divbuf_2/a_8190_n1540# 0.19fF
C11609 divbuf_2/a_33142_170# divbuf_2/OUT4 0.19fF
C11610 divbuf_2/a_8190_n840# divbuf_2/a_8670_n840# 0.07fF
C11611 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/a_7302_170# 0.07fF
C11612 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C11613 divbuf_0/a_22110_n1540# divbuf_0/a_22590_n1540# 0.11fF
C11614 divbuf_0/a_52830_n840# divbuf_0/a_52830_n1540# 0.01fF
C11615 divbuf_1/a_2322_n240# divbuf_1/a_2430_n840# 0.03fF
C11616 pll_full_0/divbuf_0/a_45150_n840# pll_full_0/divbuf_0/a_45150_n1540# 0.01fF
C11617 pll_full_0/divbuf_0/a_14430_n1540# pll_full_0/divbuf_0/a_14910_n1540# 0.11fF
C11618 divbuf_3/a_22952_170# divbuf_3/OUT4 0.19fF
C11619 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/a_23442_n240# 0.04fF
C11620 divbuf_4/a_5362_170# divbuf_4/a_5362_n240# 0.01fF
C11621 divbuf_4/a_25382_170# divbuf_4/a_25862_170# 0.07fF
C11622 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/a_26832_n240# 0.05fF
C11623 divbuf_3/a_31200_n1600# divbuf_3/a_31680_n1600# 0.26fF
C11624 divbuf_3/a_21982_n240# divbuf_3/a_22110_n840# 0.03fF
C11625 divbuf_0/a_9242_170# divbuf_0/a_9242_n240# 0.01fF
C11626 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_34590_n1540# 0.19fF
C11627 pd_div_0/divbuf_0/a_34590_n840# pd_div_0/divbuf_0/a_35070_n840# 0.07fF
C11628 pd_div_0/divbuf_0/a_4350_n840# pd_div_0/divbuf_0/a_4350_n1540# 0.01fF
C11629 divbuf_4/a_12772_170# divbuf_4/OUT4 0.19fF
C11630 divbuf_4/a_58560_n1600# divbuf_4/a_59040_n1600# 0.26fF
C11631 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_37950_n1540# 0.19fF
C11632 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C11633 pll_full_0/divbuf_1/a_7710_n840# pll_full_0/divbuf_1/a_7710_n1540# 0.01fF
C11634 pll_full_0/divbuf_1/a_37950_n840# pll_full_0/divbuf_1/a_38430_n840# 0.07fF
C11635 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/a_1842_170# 0.07fF
C11636 divbuf_3/a_23550_n1540# divbuf_3/a_24030_n1540# 0.11fF
C11637 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n840# 0.04fF
C11638 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C11639 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/nor_1/A 0.15fF
C11640 divbuf_1/a_6332_170# divbuf_1/a_6822_170# 0.07fF
C11641 divbuf_4/a_50910_n1540# divbuf_4/a_51390_n1540# 0.11fF
C11642 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12030_n840# 0.04fF
C11643 divbuf_2/a_34112_n240# divbuf_2/OUT4 0.04fF
C11644 divbuf_2/a_58560_n1600# divbuf_2/a_58590_n840# 0.04fF
C11645 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_34080_n1600# 0.26fF
C11646 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/a_24510_n840# 0.03fF
C11647 divbuf_1/a_32160_n1600# divbuf_1/a_32640_n1600# 0.26fF
C11648 divbuf_1/a_22952_n240# divbuf_1/a_23070_n840# 0.03fF
C11649 divbuf_5/a_21120_n1600# divbuf_5/a_21600_n1600# 0.26fF
C11650 divbuf_5/a_11802_n240# divbuf_5/a_12030_n840# 0.02fF
C11651 divbuf_3/a_23922_n240# divbuf_3/OUT4 0.04fF
C11652 ro_div_0/divbuf_0/a_25950_n1540# ro_div_0/divbuf_0/a_26430_n1540# 0.11fF
C11653 ro_div_0/divbuf_0/a_56670_n840# ro_div_0/divbuf_0/a_56670_n1540# 0.01fF
C11654 divbuf_1/a_55230_n840# divbuf_1/a_55230_n1540# 0.01fF
C11655 divbuf_1/a_24510_n1540# divbuf_1/a_24990_n1540# 0.11fF
C11656 divbuf_3/a_21120_n1600# divbuf_3/a_21150_n840# 0.04fF
C11657 divbuf_5/a_44190_n840# divbuf_5/a_44190_n1540# 0.01fF
C11658 divbuf_5/a_13470_n1540# divbuf_5/a_13950_n1540# 0.11fF
C11659 divbuf_0/a_36532_170# divbuf_0/a_37022_170# 0.07fF
C11660 divbuf_4/a_13742_n240# divbuf_4/OUT4 0.04fF
C11661 divbuf_4/a_48480_n1600# divbuf_4/a_48510_n840# 0.04fF
C11662 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/OUT4 0.07fF
C11663 divbuf_2/a_36532_n240# divbuf_2/a_37022_n240# 0.04fF
C11664 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/a_29262_170# 0.07fF
C11665 divbuf_0/a_9150_n840# divbuf_0/a_9630_n840# 0.07fF
C11666 divbuf_0/a_35082_170# divbuf_0/OUT4 0.19fF
C11667 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n1540# 0.19fF
C11668 pll_full_0/divbuf_0/a_1470_n840# pll_full_0/divbuf_0/a_1950_n840# 0.07fF
C11669 divbuf_2/a_32160_n1600# divbuf_2/OUT4 0.00fF
C11670 divbuf_2/a_48000_n1600# divbuf_2/a_48030_n1540# 0.19fF
C11671 divbuf_2/a_48030_n840# divbuf_2/a_48510_n840# 0.07fF
C11672 divbuf_2/a_17790_n840# divbuf_2/a_17790_n1540# 0.01fF
C11673 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1470_n1540# 0.19fF
C11674 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/a_9242_n240# 0.05fF
C11675 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_23550_n840# 0.04fF
C11676 pll_full_0/divbuf_0/a_54270_n1540# pll_full_0/divbuf_0/a_54750_n1540# 0.11fF
C11677 divbuf_1/a_11802_170# divbuf_1/OUT4 0.19fF
C11678 divbuf_1/a_22080_n1600# divbuf_1/a_22110_n840# 0.04fF
C11679 divbuf_3/a_18582_170# divbuf_3/a_18582_n240# 0.01fF
C11680 divbuf_3/a_37992_170# divbuf_3/a_38472_170# 0.07fF
C11681 divbuf_5/a_11040_n1600# divbuf_5/a_11070_n840# 0.04fF
C11682 divbuf_3/a_22080_n1600# divbuf_3/OUT4 0.01fF
C11683 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21600_n1600# 0.26fF
C11684 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_12030_n840# 0.02fF
C11685 divbuf_4/a_26352_n240# divbuf_4/a_26832_n240# 0.05fF
C11686 divbuf_3/a_10560_n1600# divbuf_3/a_10590_n1540# 0.19fF
C11687 divbuf_3/a_10590_n840# divbuf_3/a_11070_n840# 0.07fF
C11688 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24960_n1600# 0.26fF
C11689 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_15390_n840# 0.02fF
C11690 pd_div_0/divbuf_0/a_44190_n840# pd_div_0/divbuf_0/a_44190_n1540# 0.01fF
C11691 pd_div_0/divbuf_0/a_13470_n1540# pd_div_0/divbuf_0/a_13950_n1540# 0.11fF
C11692 divbuf_4/a_37950_n840# divbuf_4/a_38430_n840# 0.07fF
C11693 divbuf_4/a_7710_n840# divbuf_4/a_7710_n1540# 0.01fF
C11694 divbuf_4/a_12000_n1600# divbuf_4/OUT4 0.00fF
C11695 divbuf_4/a_37920_n1600# divbuf_4/a_37950_n1540# 0.19fF
C11696 pll_full_0/divbuf_1/a_16830_n1540# pll_full_0/divbuf_1/a_17310_n1540# 0.11fF
C11697 pll_full_0/divbuf_1/a_47550_n840# pll_full_0/divbuf_1/a_47550_n1540# 0.01fF
C11698 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11699 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n840# 0.04fF
C11700 divbuf_0/a_36052_n240# divbuf_0/OUT4 0.04fF
C11701 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11702 divbuf_1/a_38962_170# divbuf_1/a_39442_170# 0.07fF
C11703 divbuf_5/a_27802_170# divbuf_5/a_28292_170# 0.07fF
C11704 divbuf_5/a_7792_170# divbuf_5/a_7792_n240# 0.01fF
C11705 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_51870_n840# 0.04fF
C11706 ro_div_0/divider_0/prescaler_0/nand_0/z1 gnd 0.16fF
C11707 ro_div_0/divbuf_0/a_12990_n840# ro_div_0/divbuf_0/a_13470_n840# 0.07fF
C11708 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_12990_n1540# 0.19fF
C11709 divbuf_1/a_11520_n1600# divbuf_1/a_11550_n1540# 0.19fF
C11710 divbuf_1/a_39932_170# divbuf_1/OUT4 0.19fF
C11711 divbuf_1/a_11550_n840# divbuf_1/a_12030_n840# 0.07fF
C11712 divbuf_5/a_480_n1600# divbuf_5/a_510_n1540# 0.19fF
C11713 divbuf_5/a_510_n840# divbuf_5/a_990_n840# 0.07fF
C11714 divbuf_5/a_17612_170# divbuf_5/OUT4 0.19fF
C11715 divbuf_3/a_510_n840# io_analog[9] 0.07fF
C11716 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11070_n840# 0.04fF
C11717 divbuf_5/a_53310_n1540# divbuf_5/a_53790_n1540# 0.11fF
C11718 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14430_n840# 0.04fF
C11719 divbuf_0/a_37502_n240# divbuf_0/a_37992_n240# 0.04fF
C11720 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/a_30232_n240# 0.04fF
C11721 divbuf_2/a_25382_n240# divbuf_2/a_25470_n840# 0.03fF
C11722 divbuf_2/a_34560_n1600# divbuf_2/a_35040_n1600# 0.26fF
C11723 gnd pll_full_0/divider_0/tspc_1/Q 0.33fF
C11724 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n1540# 0.19fF
C11725 divbuf_0/a_34080_n1600# divbuf_0/OUT4 0.01fF
C11726 divbuf_0/a_18750_n840# divbuf_0/a_18750_n1540# 0.01fF
C11727 divbuf_0/a_48990_n840# divbuf_0/a_49470_n840# 0.07fF
C11728 divbuf_2/a_57630_n840# divbuf_2/a_57630_n1540# 0.01fF
C11729 divbuf_2/a_26910_n1540# divbuf_2/a_27390_n1540# 0.11fF
C11730 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41310_n1540# 0.19fF
C11731 pll_full_0/divbuf_0/a_41310_n840# pll_full_0/divbuf_0/a_41790_n840# 0.07fF
C11732 pll_full_0/divbuf_0/a_11070_n840# pll_full_0/divbuf_0/a_11070_n1540# 0.01fF
C11733 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C11734 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/a_28292_170# 0.07fF
C11735 divbuf_1/a_480_n1600# divbuf_1/IN 0.00fF
C11736 divbuf_1/a_40902_n240# divbuf_1/OUT4 0.04fF
C11737 divbuf_3/a_38962_n240# divbuf_3/a_39442_n240# 0.05fF
C11738 divbuf_3/a_54270_n1540# divbuf_3/a_54750_n1540# 0.11fF
C11739 divbuf_5/a_50880_n1600# divbuf_5/a_50910_n840# 0.04fF
C11740 divbuf_5/a_18582_n240# divbuf_5/OUT4 0.04fF
C11741 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/a_11802_n240# 0.01fF
C11742 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/a_31682_170# 0.07fF
C11743 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C11744 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_510_n1540# 0.19fF
C11745 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/a_990_n840# 0.07fF
C11746 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11747 divbuf_4/a_15182_n240# divbuf_4/a_15390_n840# 0.02fF
C11748 divbuf_4/a_24480_n1600# divbuf_4/a_24960_n1600# 0.26fF
C11749 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11750 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_3870_n1540# 0.19fF
C11751 pll_full_0/divbuf_1/a_3870_n840# pll_full_0/divbuf_1/a_4350_n840# 0.07fF
C11752 divbuf_3/a_50430_n840# divbuf_3/a_50910_n840# 0.07fF
C11753 divbuf_3/a_20190_n840# divbuf_3/a_20190_n1540# 0.01fF
C11754 divbuf_3/a_50400_n1600# divbuf_3/a_50430_n1540# 0.19fF
C11755 pd_div_0/divbuf_0/a_53310_n1540# pd_div_0/divbuf_0/a_53790_n1540# 0.11fF
C11756 divbuf_2/a_4392_170# divbuf_2/OUT3 0.19fF
C11757 divbuf_2/a_24480_n1600# divbuf_2/a_24510_n840# 0.04fF
C11758 divbuf_4/a_47550_n840# divbuf_4/a_47550_n1540# 0.01fF
C11759 divbuf_4/a_16830_n1540# divbuf_4/a_17310_n1540# 0.11fF
C11760 pll_full_0/divbuf_1/a_56670_n1540# pll_full_0/divbuf_1/a_57150_n1540# 0.11fF
C11761 divbuf_1/a_39932_n240# divbuf_1/a_40412_n240# 0.05fF
C11762 divbuf_5/a_28772_n240# divbuf_5/a_29262_n240# 0.04fF
C11763 ro_div_0/divbuf_0/a_22590_n840# ro_div_0/divbuf_0/a_22590_n1540# 0.01fF
C11764 ro_div_0/divbuf_0/a_52830_n840# ro_div_0/divbuf_0/a_53310_n840# 0.07fF
C11765 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_52830_n1540# 0.19fF
C11766 divbuf_1/a_51390_n840# divbuf_1/a_51870_n840# 0.07fF
C11767 divbuf_1/a_21150_n840# divbuf_1/a_21150_n1540# 0.01fF
C11768 divbuf_1/a_51360_n1600# divbuf_1/a_51390_n1540# 0.19fF
C11769 divbuf_5/a_40350_n840# divbuf_5/a_40830_n840# 0.07fF
C11770 divbuf_5/a_10110_n840# divbuf_5/a_10110_n1540# 0.01fF
C11771 divbuf_5/a_40320_n1600# divbuf_5/a_40350_n1540# 0.19fF
C11772 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_50910_n840# 0.04fF
C11773 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11774 divbuf_1/a_1352_170# divbuf_1/a_1352_n240# 0.01fF
C11775 divbuf_2/a_21982_170# divbuf_2/a_21982_n240# 0.01fF
C11776 divbuf_4/a_14400_n1600# divbuf_4/a_14430_n840# 0.04fF
C11777 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11778 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54270_n840# 0.04fF
C11779 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_14430_n840# 0.02fF
C11780 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C11781 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C11782 divbuf_0/a_35520_n1600# divbuf_0/a_36000_n1600# 0.26fF
C11783 divbuf_0/a_19072_170# divbuf_0/OUT4 0.19fF
C11784 divbuf_0/a_26352_n240# divbuf_0/a_26430_n840# 0.04fF
C11785 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/nor_1/B 0.18fF
C11786 divbuf_2/a_5362_n240# divbuf_2/OUT3 0.04fF
C11787 divbuf_2/a_13920_n1600# divbuf_2/a_13950_n1540# 0.19fF
C11788 divbuf_2/a_13950_n840# divbuf_2/a_14430_n840# 0.07fF
C11789 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C11790 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_28320_n1600# 0.26fF
C11791 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/a_18750_n840# 0.02fF
C11792 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/a_16152_170# 0.07fF
C11793 ro_div_0/ro_complete_0/cbank_2/switch_2/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C11794 divbuf_0/a_27870_n1540# divbuf_0/a_28350_n1540# 0.11fF
C11795 divbuf_0/a_58590_n840# divbuf_0/a_58590_n1540# 0.01fF
C11796 pll_full_0/divbuf_0/a_20190_n1540# pll_full_0/divbuf_0/a_20670_n1540# 0.11fF
C11797 pll_full_0/divbuf_0/a_50910_n840# pll_full_0/divbuf_0/a_50910_n1540# 0.01fF
C11798 divbuf_3/a_34592_170# divbuf_3/OUT4 0.19fF
C11799 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/a_29262_n240# 0.04fF
C11800 divbuf_4/a_31202_170# divbuf_4/a_31682_170# 0.07fF
C11801 divbuf_4/a_11802_170# divbuf_4/a_11802_n240# 0.01fF
C11802 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/a_32652_n240# 0.05fF
C11803 divbuf_3/a_27802_n240# divbuf_3/a_27870_n840# 0.04fF
C11804 divbuf_3/a_36960_n1600# divbuf_3/a_37440_n1600# 0.26fF
C11805 pd_div_0/divbuf_0/a_40350_n840# pd_div_0/divbuf_0/a_40830_n840# 0.07fF
C11806 pd_div_0/divbuf_0/a_10110_n840# pd_div_0/divbuf_0/a_10110_n1540# 0.01fF
C11807 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40350_n1540# 0.19fF
C11808 divbuf_4/a_3870_n840# divbuf_4/a_4350_n840# 0.07fF
C11809 divbuf_4/a_3840_n1600# divbuf_4/a_3870_n1540# 0.19fF
C11810 divbuf_4/a_24412_170# divbuf_4/OUT4 0.19fF
C11811 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C11812 pll_full_0/divbuf_1/a_13470_n840# pll_full_0/divbuf_1/a_13470_n1540# 0.01fF
C11813 pll_full_0/divbuf_1/a_43710_n840# pll_full_0/divbuf_1/a_44190_n840# 0.07fF
C11814 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_43710_n1540# 0.19fF
C11815 divbuf_3/a_29310_n1540# divbuf_3/a_29790_n1540# 0.11fF
C11816 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n840# 0.04fF
C11817 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/clk 0.01fF
C11818 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C11819 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C11820 divbuf_4/a_56670_n1540# divbuf_4/a_57150_n1540# 0.11fF
C11821 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C11822 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/OUT4 0.07fF
C11823 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_17790_n840# 0.04fF
C11824 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/a_15672_n240# 0.01fF
C11825 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/a_30270_n840# 0.05fF
C11826 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39840_n1600# 0.26fF
C11827 divbuf_1/a_37920_n1600# divbuf_1/a_38400_n1600# 0.26fF
C11828 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C11829 divbuf_1/a_28772_n240# divbuf_1/a_28830_n840# 0.04fF
C11830 divbuf_5/a_26880_n1600# divbuf_5/a_27360_n1600# 0.26fF
C11831 divbuf_5/a_17612_n240# divbuf_5/a_17790_n840# 0.02fF
C11832 divbuf_3/a_35562_n240# divbuf_3/OUT4 0.04fF
C11833 ro_div_0/divbuf_0/a_31710_n1540# ro_div_0/divbuf_0/a_32190_n1540# 0.11fF
C11834 divbuf_1/a_60990_n840# divbuf_1/a_60990_n1540# 0.01fF
C11835 divbuf_1/a_30270_n1540# divbuf_1/a_30750_n1540# 0.11fF
C11836 divbuf_3/a_26880_n1600# divbuf_3/a_26910_n840# 0.04fF
C11837 divbuf_5/a_49950_n840# divbuf_5/a_49950_n1540# 0.01fF
C11838 divbuf_5/a_19230_n1540# divbuf_5/a_19710_n1540# 0.11fF
C11839 divbuf_0/a_1842_n240# divbuf_0/a_2322_n240# 0.05fF
C11840 divbuf_0/a_22952_170# divbuf_0/a_22952_n240# 0.01fF
C11841 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C11842 divbuf_4/a_54240_n1600# divbuf_4/a_54270_n840# 0.04fF
C11843 divbuf_4/a_25382_n240# divbuf_4/OUT4 0.04fF
C11844 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/a_35082_170# 0.07fF
C11845 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11846 divbuf_2/a_480_n1600# divbuf_2/a_960_n1600# 0.26fF
C11847 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n1540# 0.19fF
C11848 divbuf_0/a_7302_n240# divbuf_0/OUT3 0.04fF
C11849 divbuf_0/a_14910_n840# divbuf_0/a_15390_n840# 0.07fF
C11850 divbuf_1/a_11312_170# divbuf_1/a_11312_n240# 0.01fF
C11851 divbuf_2/a_53760_n1600# divbuf_2/a_53790_n1540# 0.19fF
C11852 divbuf_2/a_53790_n840# divbuf_2/a_54270_n840# 0.07fF
C11853 divbuf_2/a_23550_n840# divbuf_2/a_23550_n1540# 0.01fF
C11854 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7230_n1540# 0.19fF
C11855 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11856 pll_full_0/divbuf_0/a_7230_n840# pll_full_0/divbuf_0/a_7710_n840# 0.07fF
C11857 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_15672_n240# 0.04fF
C11858 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29310_n840# 0.04fF
C11859 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/DOWN 0.11fF
C11860 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z1 0.17fF
C11861 divbuf_1/a_27840_n1600# divbuf_1/a_27870_n840# 0.04fF
C11862 divbuf_1/a_1842_170# divbuf_1/OUT2 0.19fF
C11863 divbuf_1/a_12772_170# divbuf_1/OUT4 0.19fF
C11864 divbuf_3/a_3912_n240# divbuf_3/a_4392_n240# 0.05fF
C11865 divbuf_3/a_24412_170# divbuf_3/a_24412_n240# 0.01fF
C11866 divbuf_5/a_16800_n1600# divbuf_5/a_16830_n840# 0.04fF
C11867 pll_full_0/divbuf_0/a_60030_n1540# pll_full_0/divbuf_0/a_60510_n1540# 0.11fF
C11868 divbuf_3/a_33600_n1600# divbuf_3/OUT4 0.01fF
C11869 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_27360_n1600# 0.26fF
C11870 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_17790_n840# 0.02fF
C11871 divbuf_4/a_32172_n240# divbuf_4/a_32652_n240# 0.05fF
C11872 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/a_21150_n840# 0.03fF
C11873 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30720_n1600# 0.26fF
C11874 divbuf_3/a_16350_n840# divbuf_3/a_16830_n840# 0.07fF
C11875 divbuf_3/a_16320_n1600# divbuf_3/a_16350_n1540# 0.19fF
C11876 pd_div_0/divbuf_0/a_49950_n840# pd_div_0/divbuf_0/a_49950_n1540# 0.01fF
C11877 pd_div_0/divbuf_0/a_19230_n1540# pd_div_0/divbuf_0/a_19710_n1540# 0.11fF
C11878 divbuf_4/a_43680_n1600# divbuf_4/a_43710_n1540# 0.19fF
C11879 divbuf_4/a_43710_n840# divbuf_4/a_44190_n840# 0.07fF
C11880 divbuf_4/a_13470_n840# divbuf_4/a_13470_n1540# 0.01fF
C11881 divbuf_4/a_23520_n1600# divbuf_4/OUT4 0.00fF
C11882 ro_div_0/ro_complete_0/cbank_2/v ro_div_0/divider_0/clk 1.36fF
C11883 divbuf_2/a_11312_n240# divbuf_2/a_11070_n840# 0.02fF
C11884 pll_full_0/divbuf_1/a_22590_n1540# pll_full_0/divbuf_1/a_23070_n1540# 0.11fF
C11885 pll_full_0/divbuf_1/a_53310_n840# pll_full_0/divbuf_1/a_53310_n1540# 0.01fF
C11886 divbuf_1/a_4882_n240# divbuf_1/a_5362_n240# 0.05fF
C11887 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_57630_n840# 0.04fF
C11888 divbuf_5/a_14222_170# divbuf_5/a_14222_n240# 0.01fF
C11889 divbuf_5/a_33622_170# divbuf_5/a_34112_170# 0.07fF
C11890 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11891 ro_div_0/divbuf_0/a_18750_n840# ro_div_0/divbuf_0/a_19230_n840# 0.07fF
C11892 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_18750_n1540# 0.19fF
C11893 ro_div_0/divider_0/clk gnd 0.07fF
C11894 divbuf_1/a_17310_n840# divbuf_1/a_17790_n840# 0.07fF
C11895 divbuf_1/a_12282_n240# divbuf_1/OUT4 0.04fF
C11896 divbuf_1/a_17280_n1600# divbuf_1/a_17310_n1540# 0.19fF
C11897 divbuf_5/a_6270_n840# divbuf_5/a_6750_n840# 0.07fF
C11898 divbuf_5/a_6240_n1600# divbuf_5/a_6270_n1540# 0.19fF
C11899 divbuf_5/a_29262_170# divbuf_5/OUT4 0.19fF
C11900 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_16830_n840# 0.04fF
C11901 divbuf_2/a_6332_170# divbuf_2/a_6822_170# 0.07fF
C11902 divbuf_5/a_59070_n1540# divbuf_5/a_59550_n1540# 0.11fF
C11903 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20190_n840# 0.04fF
C11904 divbuf_0/a_1440_n1600# divbuf_0/a_1920_n1600# 0.26fF
C11905 divbuf_2/a_40320_n1600# divbuf_2/a_40800_n1600# 0.26fF
C11906 divbuf_2/a_31202_n240# divbuf_2/a_31230_n840# 0.05fF
C11907 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/a_36052_n240# 0.04fF
C11908 divbuf_0/a_24510_n840# divbuf_0/a_24510_n1540# 0.01fF
C11909 divbuf_0/a_54750_n840# divbuf_0/a_55230_n840# 0.07fF
C11910 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n1540# 0.19fF
C11911 pll_full_0/divbuf_0/a_16830_n840# pll_full_0/divbuf_0/a_16830_n1540# 0.01fF
C11912 pll_full_0/divbuf_0/a_47070_n840# pll_full_0/divbuf_0/a_47550_n840# 0.07fF
C11913 divbuf_2/a_32670_n1540# divbuf_2/a_33150_n1540# 0.11fF
C11914 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47070_n1540# 0.19fF
C11915 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C11916 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/a_34112_170# 0.07fF
C11917 divbuf_3/a_60030_n1540# divbuf_3/a_60510_n1540# 0.11fF
C11918 divbuf_1/a_11040_n1600# divbuf_1/OUT3 0.00fF
C11919 divbuf_3/a_2880_n1600# divbuf_3/a_3360_n1600# 0.26fF
C11920 divbuf_5/a_30232_n240# divbuf_5/OUT4 0.04fF
C11921 divbuf_5/a_56640_n1600# divbuf_5/a_56670_n840# 0.04fF
C11922 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/a_37502_170# 0.07fF
C11923 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/a_17612_n240# 0.01fF
C11924 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/clk 0.11fF
C11925 pd_div_0/divbuf_0/a_6270_n840# pd_div_0/divbuf_0/a_6750_n840# 0.07fF
C11926 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6270_n1540# 0.19fF
C11927 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11928 divbuf_3/a_56190_n840# divbuf_3/a_56670_n840# 0.07fF
C11929 divbuf_3/a_25950_n840# divbuf_3/a_25950_n1540# 0.01fF
C11930 divbuf_4/a_30240_n1600# divbuf_4/a_30720_n1600# 0.26fF
C11931 divbuf_4/a_21012_n240# divbuf_4/a_21150_n840# 0.03fF
C11932 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C11933 pll_full_0/divbuf_1/a_9630_n840# pll_full_0/divbuf_1/a_10110_n840# 0.07fF
C11934 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11935 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_9630_n1540# 0.19fF
C11936 divbuf_0/a_12282_n240# divbuf_0/a_12030_n840# 0.02fF
C11937 pd_div_0/divbuf_0/a_59070_n1540# pd_div_0/divbuf_0/a_59550_n1540# 0.11fF
C11938 divbuf_2/a_30240_n1600# divbuf_2/a_30270_n840# 0.04fF
C11939 divbuf_2/a_16152_170# divbuf_2/OUT4 0.19fF
C11940 divbuf_4/a_53310_n840# divbuf_4/a_53310_n1540# 0.01fF
C11941 divbuf_4/a_22590_n1540# divbuf_4/a_23070_n1540# 0.11fF
C11942 pll_full_0/divbuf_1/a_60990_n1540# pll_full_0/divbuf_1/OUT5 0.19fF
C11943 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/a1 0.14fF
C11944 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5760_n1600# 0.26fF
C11945 divbuf_1/a_3840_n1600# divbuf_1/a_4320_n1600# 0.26fF
C11946 divbuf_5/a_34592_n240# divbuf_5/a_35082_n240# 0.04fF
C11947 divbuf_3/a_5852_170# divbuf_3/OUT3 0.19fF
C11948 ro_div_0/divbuf_0/a_28350_n840# ro_div_0/divbuf_0/a_28350_n1540# 0.01fF
C11949 ro_div_0/divbuf_0/a_58590_n840# ro_div_0/divbuf_0/a_59070_n840# 0.07fF
C11950 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_58590_n1540# 0.19fF
C11951 divbuf_1/a_57120_n1600# divbuf_1/a_57150_n1540# 0.19fF
C11952 divbuf_1/a_57150_n840# divbuf_1/a_57630_n840# 0.07fF
C11953 divbuf_1/a_26910_n840# divbuf_1/a_26910_n1540# 0.01fF
C11954 divbuf_3/a_13742_n240# divbuf_3/a_13470_n840# 0.01fF
C11955 divbuf_5/a_46080_n1600# divbuf_5/a_46110_n1540# 0.19fF
C11956 divbuf_5/a_46110_n840# divbuf_5/a_46590_n840# 0.07fF
C11957 divbuf_5/a_15870_n840# divbuf_5/a_15870_n1540# 0.01fF
C11958 divbuf_0/a_7792_170# divbuf_0/a_7302_170# 0.07fF
C11959 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_13252_170# 0.07fF
C11960 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11961 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_56670_n840# 0.04fF
C11962 divbuf_2/a_27802_170# divbuf_2/a_27802_n240# 0.01fF
C11963 divbuf_2/a_7302_n240# divbuf_2/a_7792_n240# 0.04fF
C11964 divbuf_4/a_20160_n1600# divbuf_4/a_20190_n840# 0.04fF
C11965 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C11966 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/a_6332_170# 0.07fF
C11967 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60030_n840# 0.04fF
C11968 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11969 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/a_20190_n840# 0.03fF
C11970 divbuf_0/a_32172_n240# divbuf_0/a_32190_n840# 0.06fF
C11971 divbuf_0/a_41280_n1600# divbuf_0/a_41760_n1600# 0.26fF
C11972 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z3 0.45fF
C11973 divbuf_1/a_5852_170# divbuf_1/a_5362_170# 0.07fF
C11974 divbuf_2/a_19680_n1600# divbuf_2/a_19710_n1540# 0.19fF
C11975 divbuf_2/a_19710_n840# divbuf_2/a_20190_n840# 0.07fF
C11976 divbuf_2/a_17122_n240# divbuf_2/OUT4 0.04fF
C11977 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C11978 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C11979 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_34080_n1600# 0.26fF
C11980 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/a_24510_n840# 0.03fF
C11981 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/a_20532_170# 0.07fF
C11982 divbuf_0/a_33630_n1540# divbuf_0/a_34110_n1540# 0.11fF
C11983 divbuf_1/a_14702_n240# divbuf_1/a_14430_n840# 0.01fF
C11984 divbuf_3/a_8762_170# divbuf_3/a_9242_170# 0.07fF
C11985 pll_full_0/divbuf_0/a_56670_n840# pll_full_0/divbuf_0/a_56670_n1540# 0.01fF
C11986 pll_full_0/divbuf_0/a_25950_n1540# pll_full_0/divbuf_0/a_26430_n1540# 0.11fF
C11987 divbuf_3/a_6822_n240# divbuf_3/OUT3 0.04fF
C11988 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/a_35082_n240# 0.04fF
C11989 divbuf_4/a_17612_170# divbuf_4/a_17612_n240# 0.01fF
C11990 divbuf_4/a_37022_170# divbuf_4/a_37502_170# 0.07fF
C11991 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/a_38472_n240# 0.05fF
C11992 divbuf_3/a_42720_n1600# divbuf_3/a_43200_n1600# 0.26fF
C11993 divbuf_3/a_33622_n240# divbuf_3/a_33630_n840# 0.06fF
C11994 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46110_n1540# 0.19fF
C11995 pd_div_0/divbuf_0/a_46110_n840# pd_div_0/divbuf_0/a_46590_n840# 0.07fF
C11996 pd_div_0/divbuf_0/a_15870_n840# pd_div_0/divbuf_0/a_15870_n1540# 0.01fF
C11997 divbuf_4/a_9600_n1600# divbuf_4/a_9630_n1540# 0.19fF
C11998 divbuf_4/a_36052_170# divbuf_4/OUT4 0.19fF
C11999 divbuf_4/a_9630_n840# divbuf_4/a_10110_n840# 0.07fF
C12000 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49470_n1540# 0.19fF
C12001 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C12002 pll_full_0/divbuf_1/a_19230_n840# pll_full_0/divbuf_1/a_19230_n1540# 0.01fF
C12003 pll_full_0/divbuf_1/a_49470_n840# pll_full_0/divbuf_1/a_49950_n840# 0.07fF
C12004 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/a_10212_n240# 0.01fF
C12005 divbuf_3/a_35070_n1540# divbuf_3/a_35550_n1540# 0.11fF
C12006 pll_full_0/divbuf_0/a_4392_170# pll_full_0/divbuf_0/a_4392_n240# 0.01fF
C12007 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n840# 0.04fF
C12008 divbuf_0/a_15672_170# divbuf_0/OUT4 0.19fF
C12009 divbuf_4/a_60990_n1540# divbuf_4/OUT5 0.19fF
C12010 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C12011 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z4 0.22fF
C12012 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_23550_n840# 0.04fF
C12013 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45600_n1600# 0.26fF
C12014 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/a_36030_n840# 0.05fF
C12015 divbuf_1/a_7792_170# divbuf_1/OUT3 0.19fF
C12016 divbuf_1/a_43680_n1600# divbuf_1/a_44160_n1600# 0.26fF
C12017 divbuf_1/a_34592_n240# divbuf_1/a_34590_n840# 0.06fF
C12018 divbuf_5/a_32640_n1600# divbuf_5/a_33120_n1600# 0.26fF
C12019 divbuf_5/a_23442_n240# divbuf_5/a_23550_n840# 0.03fF
C12020 ro_div_0/divbuf_0/a_37470_n1540# ro_div_0/divbuf_0/a_37950_n1540# 0.11fF
C12021 divbuf_1/a_36030_n1540# divbuf_1/a_36510_n1540# 0.11fF
C12022 divbuf_3/a_32640_n1600# divbuf_3/a_32670_n840# 0.04fF
C12023 divbuf_5/a_55710_n840# divbuf_5/a_55710_n1540# 0.01fF
C12024 divbuf_5/a_24990_n1540# divbuf_5/a_25470_n1540# 0.11fF
C12025 divbuf_0/a_8272_n240# divbuf_0/a_8762_n240# 0.04fF
C12026 divbuf_0/a_28772_170# divbuf_0/a_28772_n240# 0.01fF
C12027 divbuf_2/a_6240_n1600# divbuf_2/a_6720_n1600# 0.26fF
C12028 divbuf_4/a_37022_n240# divbuf_4/OUT4 0.04fF
C12029 divbuf_4/a_60000_n1600# divbuf_4/a_60030_n840# 0.04fF
C12030 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/a_21012_n240# 0.01fF
C12031 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/OUT4 0.19fF
C12032 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/a_40902_170# 0.07fF
C12033 divbuf_0/a_19072_n240# divbuf_0/OUT4 0.04fF
C12034 divbuf_0/a_20670_n840# divbuf_0/a_21150_n840# 0.07fF
C12035 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n1540# 0.19fF
C12036 pll_full_0/divbuf_0/a_12990_n840# pll_full_0/divbuf_0/a_13470_n840# 0.07fF
C12037 divbuf_2/a_59520_n1600# divbuf_2/a_59550_n1540# 0.19fF
C12038 divbuf_2/a_59550_n840# divbuf_2/a_60030_n840# 0.07fF
C12039 divbuf_2/a_29310_n840# divbuf_2/a_29310_n1540# 0.01fF
C12040 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/OUT3 0.07fF
C12041 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_12990_n1540# 0.19fF
C12042 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35070_n840# 0.04fF
C12043 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.44fF
C12044 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Z2 0.21fF
C12045 divbuf_1/a_19562_170# divbuf_1/OUT4 0.19fF
C12046 divbuf_1/a_33600_n1600# divbuf_1/a_33630_n840# 0.04fF
C12047 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/a_1842_170# 0.07fF
C12048 divbuf_3/a_30232_170# divbuf_3/a_30232_n240# 0.01fF
C12049 divbuf_3/a_9732_n240# divbuf_3/a_10212_n240# 0.05fF
C12050 divbuf_5/a_492_n240# gpio_analog[7] 0.13fF
C12051 divbuf_5/a_22560_n1600# divbuf_5/a_22590_n840# 0.04fF
C12052 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_33120_n1600# 0.26fF
C12053 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/a_23550_n840# 0.03fF
C12054 divbuf_4/a_37992_n240# divbuf_4/a_38472_n240# 0.05fF
C12055 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36480_n1600# 0.26fF
C12056 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/a_26910_n840# 0.04fF
C12057 divbuf_3/a_22080_n1600# divbuf_3/a_22110_n1540# 0.19fF
C12058 divbuf_3/a_22110_n840# divbuf_3/a_22590_n840# 0.07fF
C12059 pd_div_0/divbuf_0/a_55710_n840# pd_div_0/divbuf_0/a_55710_n1540# 0.01fF
C12060 pd_div_0/divbuf_0/a_24990_n1540# pd_div_0/divbuf_0/a_25470_n1540# 0.11fF
C12061 divbuf_4/a_49470_n840# divbuf_4/a_49950_n840# 0.07fF
C12062 divbuf_4/a_19230_n840# divbuf_4/a_19230_n1540# 0.01fF
C12063 divbuf_4/a_35040_n1600# divbuf_4/OUT4 0.00fF
C12064 divbuf_4/a_49440_n1600# divbuf_4/a_49470_n1540# 0.19fF
C12065 pll_full_0/divbuf_1/a_28350_n1540# pll_full_0/divbuf_1/a_28830_n1540# 0.11fF
C12066 pll_full_0/divbuf_1/a_59070_n840# pll_full_0/divbuf_1/a_59070_n1540# 0.01fF
C12067 divbuf_2/a_17122_n240# divbuf_2/a_16830_n840# 0.00fF
C12068 divbuf_1/a_11312_n240# divbuf_1/a_11802_n240# 0.04fF
C12069 divbuf_5/a_39442_170# divbuf_5/a_39932_170# 0.07fF
C12070 divbuf_5/a_20042_170# divbuf_5/a_20042_n240# 0.01fF
C12071 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C12072 ro_div_0/divbuf_0/a_24510_n840# ro_div_0/divbuf_0/a_24990_n840# 0.07fF
C12073 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24510_n1540# 0.19fF
C12074 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C12075 divbuf_1/a_23040_n1600# divbuf_1/a_23070_n1540# 0.19fF
C12076 divbuf_1/a_23070_n840# divbuf_1/a_23550_n840# 0.07fF
C12077 divbuf_1/a_23922_n240# divbuf_1/OUT4 0.04fF
C12078 divbuf_5/a_12000_n1600# divbuf_5/a_12030_n1540# 0.19fF
C12079 divbuf_5/a_40902_170# divbuf_5/OUT4 0.19fF
C12080 divbuf_5/a_12030_n840# divbuf_5/a_12510_n840# 0.07fF
C12081 divbuf_5/a_1352_n240# divbuf_5/OUT2 0.07fF
C12082 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C12083 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/nor_1/B 0.35fF
C12084 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C12085 pd_div_0/divbuf_0/a_1352_170# pd_div_0/divbuf_0/OUT2 0.23fF
C12086 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_22590_n840# 0.04fF
C12087 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_25950_n840# 0.04fF
C12088 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/OUT3 0.19fF
C12089 divbuf_2/a_12772_170# divbuf_2/a_13252_170# 0.07fF
C12090 divbuf_0/a_7200_n1600# divbuf_0/a_7680_n1600# 0.26fF
C12091 divbuf_2/a_37022_n240# divbuf_2/a_36990_n840# 0.05fF
C12092 divbuf_2/a_46080_n1600# divbuf_2/a_46560_n1600# 0.26fF
C12093 gnd pll_full_0/divider_0/and_0/B 0.66fF
C12094 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n1540# 0.19fF
C12095 divbuf_0/a_30270_n840# divbuf_0/a_30270_n1540# 0.01fF
C12096 divbuf_0/a_60510_n840# divbuf_0/a_60990_n840# 0.07fF
C12097 divbuf_2/a_38430_n1540# divbuf_2/a_38910_n1540# 0.11fF
C12098 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_52830_n1540# 0.19fF
C12099 pll_full_0/divbuf_0/a_52830_n840# pll_full_0/divbuf_0/a_53310_n840# 0.07fF
C12100 pll_full_0/divbuf_0/a_22590_n840# pll_full_0/divbuf_0/a_22590_n1540# 0.01fF
C12101 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C12102 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/a_39932_170# 0.07fF
C12103 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/a_20042_n240# 0.01fF
C12104 divbuf_4/a_1352_170# divbuf_4/a_1842_170# 0.07fF
C12105 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/a_23442_n240# 0.01fF
C12106 divbuf_1/a_22080_n1600# divbuf_1/OUT4 0.01fF
C12107 divbuf_3/a_8640_n1600# divbuf_3/a_9120_n1600# 0.26fF
C12108 divbuf_5/a_960_n1600# divbuf_5/OUT2 0.00fF
C12109 divbuf_5/a_41382_n240# divbuf_5/OUT5 0.04fF
C12110 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C12111 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C12112 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12030_n1540# 0.19fF
C12113 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/OUT4 0.19fF
C12114 pd_div_0/divbuf_0/a_12030_n840# pd_div_0/divbuf_0/a_12510_n840# 0.07fF
C12115 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/OUT2 0.07fF
C12116 divbuf_4/a_26832_n240# divbuf_4/a_26910_n840# 0.04fF
C12117 divbuf_4/a_36000_n1600# divbuf_4/a_36480_n1600# 0.26fF
C12118 divbuf_3/a_31710_n840# divbuf_3/a_31710_n1540# 0.01fF
C12119 divbuf_3/a_990_n1540# divbuf_3/a_1470_n1540# 0.11fF
C12120 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/a_9242_170# 0.07fF
C12121 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15390_n1540# 0.19fF
C12122 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C12123 pll_full_0/divbuf_1/a_15390_n840# pll_full_0/divbuf_1/a_15870_n840# 0.07fF
C12124 divbuf_0/a_18092_n240# divbuf_0/a_17790_n840# 0.00fF
C12125 divbuf_1/a_16152_170# divbuf_1/a_16642_170# 0.07fF
C12126 divbuf_2/a_36000_n1600# divbuf_2/a_36030_n840# 0.04fF
C12127 divbuf_2/a_27802_170# divbuf_2/OUT4 0.19fF
C12128 divbuf_4/a_59070_n840# divbuf_4/a_59070_n1540# 0.01fF
C12129 divbuf_4/a_28350_n1540# divbuf_4/a_28830_n1540# 0.11fF
C12130 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C12131 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11520_n1600# 0.26fF
C12132 divbuf_1/a_9600_n1600# divbuf_1/a_10080_n1600# 0.26fF
C12133 divbuf_5/a_40412_n240# divbuf_5/a_40902_n240# 0.04fF
C12134 divbuf_3/a_17612_170# divbuf_3/OUT4 0.19fF
C12135 ro_div_0/divbuf_0/a_3390_n1540# ro_div_0/divbuf_0/a_3870_n1540# 0.11fF
C12136 ro_div_0/divbuf_0/a_34110_n840# ro_div_0/divbuf_0/a_34110_n1540# 0.01fF
C12137 divbuf_1/a_510_n840# divbuf_1/OUT 0.07fF
C12138 divbuf_1/a_32670_n840# divbuf_1/a_32670_n1540# 0.01fF
C12139 divbuf_1/a_1950_n1540# divbuf_1/a_2430_n1540# 0.11fF
C12140 divbuf_5/a_51870_n840# divbuf_5/a_52350_n840# 0.07fF
C12141 divbuf_5/a_21630_n840# divbuf_5/a_21630_n1540# 0.01fF
C12142 divbuf_5/a_51840_n1600# divbuf_5/a_51870_n1540# 0.19fF
C12143 divbuf_0/a_13252_170# divbuf_0/a_13742_170# 0.07fF
C12144 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C12145 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/OUT5 0.04fF
C12146 divbuf_2/a_13742_n240# divbuf_2/a_14222_n240# 0.05fF
C12147 divbuf_2/a_33622_170# divbuf_2/a_33622_n240# 0.01fF
C12148 divbuf_4/a_7302_170# divbuf_4/OUT3 0.19fF
C12149 divbuf_4/a_25920_n1600# divbuf_4/a_25950_n840# 0.04fF
C12150 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C12151 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_7302_170# 0.07fF
C12152 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C12153 divbuf_0/a_47040_n1600# divbuf_0/a_47520_n1600# 0.26fF
C12154 divbuf_0/a_37992_n240# divbuf_0/a_37950_n840# 0.04fF
C12155 pd_div_0/divider_0/nor_1/Z1 gnd 0.01fF
C12156 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/and_0/OUT 0.05fF
C12157 divbuf_2/a_28772_n240# divbuf_2/OUT4 0.04fF
C12158 divbuf_2/a_25440_n1600# divbuf_2/a_25470_n1540# 0.19fF
C12159 divbuf_2/a_25470_n840# divbuf_2/a_25950_n840# 0.07fF
C12160 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39840_n1600# 0.26fF
C12161 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/a_30270_n840# 0.05fF
C12162 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C12163 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C12164 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C12165 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_12772_n240# 0.01fF
C12166 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/a_26352_170# 0.07fF
C12167 divbuf_0/a_39390_n1540# divbuf_0/a_39870_n1540# 0.11fF
C12168 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_990_n840# 0.04fF
C12169 divbuf_3/a_15182_170# divbuf_3/a_15672_170# 0.07fF
C12170 pll_full_0/divbuf_0/a_31710_n1540# pll_full_0/divbuf_0/a_32190_n1540# 0.11fF
C12171 divbuf_3/a_18582_n240# divbuf_3/OUT4 0.04fF
C12172 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/a_40902_n240# 0.04fF
C12173 divbuf_3/a_39442_n240# divbuf_3/a_39390_n840# 0.04fF
C12174 divbuf_3/a_48480_n1600# divbuf_3/a_48960_n1600# 0.26fF
C12175 divbuf_4/a_23442_170# divbuf_4/a_23442_n240# 0.01fF
C12176 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_2400_n1600# 0.26fF
C12177 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/bufin 0.00fF
C12178 pd_div_0/divbuf_0/a_51870_n840# pd_div_0/divbuf_0/a_52350_n840# 0.07fF
C12179 pd_div_0/divbuf_0/a_21630_n840# pd_div_0/divbuf_0/a_21630_n1540# 0.01fF
C12180 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_51870_n1540# 0.19fF
C12181 divbuf_4/a_15390_n840# divbuf_4/a_15870_n840# 0.07fF
C12182 divbuf_4/a_8272_n240# divbuf_4/OUT3 0.04fF
C12183 divbuf_4/a_15360_n1600# divbuf_4/a_15390_n1540# 0.19fF
C12184 pll_full_0/divbuf_1/a_24990_n840# pll_full_0/divbuf_1/a_24990_n1540# 0.01fF
C12185 pll_full_0/divbuf_1/a_55230_n840# pll_full_0/divbuf_1/a_55710_n840# 0.07fF
C12186 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55230_n1540# 0.19fF
C12187 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/OUT2 0.23fF
C12188 divbuf_3/a_40830_n1540# divbuf_3/a_41310_n1540# 0.11fF
C12189 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n840# 0.04fF
C12190 divbuf_0/a_29742_170# divbuf_0/OUT4 0.19fF
C12191 divbuf_1/a_13742_170# divbuf_1/a_14222_170# 0.07fF
C12192 divbuf_5/a_4392_170# divbuf_5/a_4882_170# 0.07fF
C12193 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29310_n840# 0.04fF
C12194 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/OUT4 0.19fF
C12195 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_51360_n1600# 0.26fF
C12196 divbuf_1/a_49440_n1600# divbuf_1/a_49920_n1600# 0.26fF
C12197 divbuf_1/a_40412_n240# divbuf_1/a_40350_n840# 0.04fF
C12198 divbuf_5/a_38400_n1600# divbuf_5/a_38880_n1600# 0.26fF
C12199 divbuf_5/a_29262_n240# divbuf_5/a_29310_n840# 0.04fF
C12200 ro_div_0/divbuf_0/a_43230_n1540# ro_div_0/divbuf_0/a_43710_n1540# 0.11fF
C12201 divbuf_1/a_41790_n1540# divbuf_1/a_42270_n1540# 0.11fF
C12202 divbuf_5/a_30750_n1540# divbuf_5/a_31230_n1540# 0.11fF
C12203 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_12510_n840# 0.01fF
C12204 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/a_22472_n240# 0.01fF
C12205 divbuf_3/a_38400_n1600# divbuf_3/a_38430_n840# 0.04fF
C12206 io_clamp_low[0] io_clamp_high[0] 0.53fF
C12207 divbuf_0/a_34592_170# divbuf_0/a_34592_n240# 0.01fF
C12208 divbuf_0/a_14702_n240# divbuf_0/a_15182_n240# 0.05fF
C12209 divbuf_2/a_12000_n1600# divbuf_2/a_12480_n1600# 0.26fF
C12210 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/a_6822_n240# 0.04fF
C12211 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C12212 ro_div_0/ro_complete_0/cbank_1/switch_2/vin ro_div_0/divider_0/clk 1.30fF
C12213 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/a_26832_n240# 0.01fF
C12214 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n1540# 0.19fF
C12215 divbuf_0/a_30712_n240# divbuf_0/OUT4 0.04fF
C12216 divbuf_0/a_26430_n840# divbuf_0/a_26910_n840# 0.07fF
C12217 divbuf_2/a_35070_n840# divbuf_2/a_35070_n1540# 0.01fF
C12218 divbuf_2/a_4350_n1540# divbuf_2/a_4830_n1540# 0.11fF
C12219 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_18750_n1540# 0.19fF
C12220 pll_full_0/divbuf_0/a_18750_n840# pll_full_0/divbuf_0/a_19230_n840# 0.07fF
C12221 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C12222 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_40830_n840# 0.04fF
C12223 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 gnd 0.27fF
C12224 pd_div_0/pd_0/UP pd_div_0/pd_0/and_pd_0/Z1 0.06fF
C12225 divbuf_1/a_39360_n1600# divbuf_1/a_39390_n840# 0.04fF
C12226 divbuf_1/a_34592_170# divbuf_1/OUT4 0.19fF
C12227 divbuf_5/a_28320_n1600# divbuf_5/a_28350_n840# 0.04fF
C12228 divbuf_5/a_12282_170# divbuf_5/OUT4 0.19fF
C12229 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/a_8272_170# 0.07fF
C12230 divbuf_3/a_16152_n240# divbuf_3/a_16642_n240# 0.04fF
C12231 divbuf_3/a_36052_170# divbuf_3/a_36052_n240# 0.01fF
C12232 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38880_n1600# 0.26fF
C12233 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/a_29310_n840# 0.04fF
C12234 divbuf_4/a_1920_n1600# divbuf_4/a_2400_n1600# 0.26fF
C12235 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/a_32670_n840# 0.06fF
C12236 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_42240_n1600# 0.26fF
C12237 divbuf_3/a_27870_n840# divbuf_3/a_28350_n840# 0.07fF
C12238 divbuf_3/a_27840_n1600# divbuf_3/a_27870_n1540# 0.19fF
C12239 pd_div_0/divbuf_0/a_30750_n1540# pd_div_0/divbuf_0/a_31230_n1540# 0.11fF
C12240 divbuf_2/a_1920_n1600# divbuf_2/a_1950_n840# 0.04fF
C12241 divbuf_4/a_55200_n1600# divbuf_4/a_55230_n1540# 0.19fF
C12242 divbuf_4/a_55230_n840# divbuf_4/a_55710_n840# 0.07fF
C12243 divbuf_4/a_24990_n840# divbuf_4/a_24990_n1540# 0.01fF
C12244 pll_full_0/divbuf_1/a_34110_n1540# pll_full_0/divbuf_1/a_34590_n1540# 0.11fF
C12245 divbuf_1/a_37022_170# divbuf_1/a_37022_n240# 0.01fF
C12246 divbuf_1/a_17122_n240# divbuf_1/a_17612_n240# 0.04fF
C12247 divbuf_5/a_25862_170# divbuf_5/a_25862_n240# 0.01fF
C12248 divbuf_5/a_5362_n240# divbuf_5/a_5852_n240# 0.04fF
C12249 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C12250 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C12251 ro_div_0/divbuf_0/a_30270_n840# ro_div_0/divbuf_0/a_30750_n840# 0.07fF
C12252 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30270_n1540# 0.19fF
C12253 divbuf_1/a_28830_n840# divbuf_1/a_29310_n840# 0.07fF
C12254 divbuf_1/a_35562_n240# divbuf_1/OUT4 0.04fF
C12255 divbuf_1/a_28800_n1600# divbuf_1/a_28830_n1540# 0.19fF
C12256 divbuf_5/a_17790_n840# divbuf_5/a_18270_n840# 0.07fF
C12257 divbuf_5/a_13252_n240# divbuf_5/OUT4 0.04fF
C12258 divbuf_5/a_17760_n1600# divbuf_5/a_17790_n1540# 0.19fF
C12259 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C12260 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28350_n840# 0.04fF
C12261 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/OUT3 0.19fF
C12262 divbuf_2/a_18582_170# divbuf_2/a_19072_170# 0.07fF
C12263 divbuf_4/a_12772_n240# divbuf_4/a_12510_n840# 0.01fF
C12264 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/OUT4 0.19fF
C12265 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_31710_n840# 0.04fF
C12266 divbuf_0/a_12960_n1600# divbuf_0/a_13440_n1600# 0.26fF
C12267 divbuf_0/a_3422_n240# divbuf_0/a_3390_n840# 0.05fF
C12268 divbuf_2/a_51840_n1600# divbuf_2/a_52320_n1600# 0.26fF
C12269 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5760_n1600# 0.26fF
C12270 pd_0/DOWN io_analog[9] 0.41fF
C12271 divbuf_0/a_5310_n1540# divbuf_0/a_5790_n1540# 0.11fF
C12272 divbuf_0/a_36030_n840# divbuf_0/a_36030_n1540# 0.01fF
C12273 pll_full_0/divbuf_0/a_28350_n840# pll_full_0/divbuf_0/a_28350_n1540# 0.01fF
C12274 pll_full_0/divbuf_0/a_58590_n840# pll_full_0/divbuf_0/a_59070_n840# 0.07fF
C12275 divbuf_2/a_44190_n1540# divbuf_2/a_44670_n1540# 0.11fF
C12276 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_58590_n1540# 0.19fF
C12277 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C12278 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/a_25862_n240# 0.01fF
C12279 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/a_5852_n240# 0.04fF
C12280 divbuf_1/a_33600_n1600# divbuf_1/OUT4 0.01fF
C12281 divbuf_4/a_7792_170# divbuf_4/a_8272_170# 0.07fF
C12282 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/a_9242_n240# 0.05fF
C12283 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/a_29262_n240# 0.01fF
C12284 divbuf_3/a_4882_n240# divbuf_3/a_4830_n840# 0.04fF
C12285 divbuf_3/a_14400_n1600# divbuf_3/a_14880_n1600# 0.26fF
C12286 divbuf_5/a_11520_n1600# divbuf_5/OUT4 0.01fF
C12287 ro_div_0/divider_0/tspc_2/Z3 ro_div_0/divider_0/tspc_2/Z4 0.65fF
C12288 pd_div_0/divbuf_0/a_17790_n840# pd_div_0/divbuf_0/a_18270_n840# 0.07fF
C12289 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C12290 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_17790_n1540# 0.19fF
C12291 divbuf_4/a_41760_n1600# divbuf_4/a_42240_n1600# 0.26fF
C12292 divbuf_4/a_32652_n240# divbuf_4/a_32670_n840# 0.06fF
C12293 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C12294 pll_full_0/divbuf_1/a_21150_n840# pll_full_0/divbuf_1/a_21630_n840# 0.07fF
C12295 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21150_n1540# 0.19fF
C12296 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_11550_n840# 0.02fF
C12297 divbuf_3/a_37470_n840# divbuf_3/a_37470_n1540# 0.01fF
C12298 divbuf_3/a_6750_n1540# divbuf_3/a_7230_n1540# 0.11fF
C12299 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n840# 0.04fF
C12300 divbuf_1/a_33142_170# divbuf_1/a_33622_170# 0.07fF
C12301 divbuf_2/a_41760_n1600# divbuf_2/a_41790_n840# 0.04fF
C12302 divbuf_2/a_39442_170# divbuf_2/OUT4 0.19fF
C12303 divbuf_4/a_34110_n1540# divbuf_4/a_34590_n1540# 0.11fF
C12304 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_15870_n840# 0.01fF
C12305 ro_div_0/ro_complete_0/a1 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C12306 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_17280_n1600# 0.26fF
C12307 divbuf_1/a_15360_n1600# divbuf_1/a_15840_n1600# 0.26fF
C12308 divbuf_1/a_5852_n240# divbuf_1/a_5790_n840# 0.04fF
C12309 divbuf_5/a_4320_n1600# divbuf_5/a_4800_n1600# 0.26fF
C12310 divbuf_3/a_29262_170# divbuf_3/OUT4 0.19fF
C12311 ro_div_0/divbuf_0/a_9150_n1540# ro_div_0/divbuf_0/a_9630_n1540# 0.11fF
C12312 ro_div_0/divbuf_0/a_39870_n840# ro_div_0/divbuf_0/a_39870_n1540# 0.01fF
C12313 divbuf_1/a_38430_n840# divbuf_1/a_38430_n1540# 0.01fF
C12314 divbuf_1/a_7710_n1540# divbuf_1/a_8190_n1540# 0.11fF
C12315 divbuf_3/a_4320_n1600# divbuf_3/a_4350_n840# 0.04fF
C12316 divbuf_5/a_57600_n1600# divbuf_5/a_57630_n1540# 0.19fF
C12317 divbuf_5/a_57630_n840# divbuf_5/a_58110_n840# 0.07fF
C12318 divbuf_5/a_27390_n840# divbuf_5/a_27390_n1540# 0.01fF
C12319 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C12320 divbuf_2/a_39442_170# divbuf_2/a_39442_n240# 0.01fF
C12321 divbuf_2/a_19562_n240# divbuf_2/a_20042_n240# 0.05fF
C12322 divbuf_4/a_31680_n1600# divbuf_4/a_31710_n840# 0.04fF
C12323 divbuf_4/a_19072_170# divbuf_4/OUT4 0.19fF
C12324 divbuf_0/a_52800_n1600# divbuf_0/a_53280_n1600# 0.26fF
C12325 divbuf_0/a_2322_170# divbuf_0/OUT3 0.07fF
C12326 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C12327 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 gnd 0.17fF
C12328 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_2/Z2 0.20fF
C12329 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_1/Z4 0.02fF
C12330 divbuf_1/a_2322_170# divbuf_1/a_1842_170# 0.07fF
C12331 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45600_n1600# 0.26fF
C12332 divbuf_2/a_31200_n1600# divbuf_2/a_31230_n1540# 0.19fF
C12333 divbuf_2/a_31230_n840# divbuf_2/a_31710_n840# 0.07fF
C12334 divbuf_2/a_990_n840# divbuf_2/a_990_n1540# 0.01fF
C12335 divbuf_2/a_40412_n240# divbuf_2/OUT4 0.04fF
C12336 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/a_36030_n840# 0.05fF
C12337 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.31fF
C12338 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z2 0.14fF
C12339 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C12340 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/a_32172_170# 0.07fF
C12341 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_6750_n840# 0.04fF
C12342 divbuf_0/a_45150_n1540# divbuf_0/a_45630_n1540# 0.11fF
C12343 divbuf_1/a_5280_n1600# divbuf_1/a_5310_n840# 0.04fF
C12344 divbuf_3/a_21012_170# divbuf_3/a_21502_170# 0.07fF
C12345 divbuf_5/a_15182_n240# divbuf_5/a_14910_n840# 0.01fF
C12346 pll_full_0/divbuf_0/a_37470_n1540# pll_full_0/divbuf_0/a_37950_n1540# 0.11fF
C12347 divbuf_3/a_30232_n240# divbuf_3/OUT4 0.04fF
C12348 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4800_n1600# 0.26fF
C12349 divbuf_4/a_29262_170# divbuf_4/a_29262_n240# 0.01fF
C12350 divbuf_4/a_8762_n240# divbuf_4/a_9242_n240# 0.05fF
C12351 divbuf_3/a_54240_n1600# divbuf_3/a_54720_n1600# 0.26fF
C12352 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_8160_n1600# 0.26fF
C12353 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C12354 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_57630_n1540# 0.19fF
C12355 pd_div_0/divbuf_0/a_57630_n840# pd_div_0/divbuf_0/a_58110_n840# 0.07fF
C12356 pd_div_0/divbuf_0/a_27390_n840# pd_div_0/divbuf_0/a_27390_n1540# 0.01fF
C12357 divbuf_4/a_21120_n1600# divbuf_4/a_21150_n1540# 0.19fF
C12358 divbuf_4/a_21150_n840# divbuf_4/a_21630_n840# 0.07fF
C12359 divbuf_4/a_20042_n240# divbuf_4/OUT4 0.04fF
C12360 pll_full_0/divbuf_1/a_30750_n840# pll_full_0/divbuf_1/a_30750_n1540# 0.01fF
C12361 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/OUT4 0.19fF
C12362 divbuf_3/a_46590_n1540# divbuf_3/a_47070_n1540# 0.11fF
C12363 divbuf_0/a_1842_n240# divbuf_0/OUT2 0.04fF
C12364 divbuf_0/a_41382_170# divbuf_0/OUT4 0.19fF
C12365 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n840# 0.04fF
C12366 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/OUT4 0.19fF
C12367 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35070_n840# 0.04fF
C12368 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_57120_n1600# 0.26fF
C12369 divbuf_1/a_55200_n1600# divbuf_1/a_55680_n1600# 0.26fF
C12370 divbuf_5/a_44160_n1600# divbuf_5/a_44640_n1600# 0.26fF
C12371 divbuf_5/a_35082_n240# divbuf_5/a_35070_n840# 0.05fF
C12372 ro_div_0/divbuf_0/a_48990_n1540# ro_div_0/divbuf_0/a_49470_n1540# 0.11fF
C12373 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_14910_n840# 0.01fF
C12374 divbuf_1/a_47550_n1540# divbuf_1/a_48030_n1540# 0.11fF
C12375 divbuf_5/a_36510_n1540# divbuf_5/a_36990_n1540# 0.11fF
C12376 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/a_28292_n240# 0.01fF
C12377 divbuf_3/a_44160_n1600# divbuf_3/a_44190_n840# 0.04fF
C12378 divbuf_0/a_20532_n240# divbuf_0/a_21012_n240# 0.05fF
C12379 divbuf_0/a_40412_170# divbuf_0/a_40412_n240# 0.01fF
C12380 pd_0/REF divbuf_4/a_510_n1540# 0.11fF
C12381 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/a_32652_n240# 0.01fF
C12382 divbuf_2/a_17760_n1600# divbuf_2/a_18240_n1600# 0.26fF
C12383 divbuf_2/a_8272_n240# divbuf_2/a_8190_n840# 0.03fF
C12384 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_13252_n240# 0.05fF
C12385 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C12386 divbuf_0/a_1950_n840# divbuf_0/a_1950_n1540# 0.01fF
C12387 divbuf_0/a_32190_n840# divbuf_0/a_32670_n840# 0.07fF
C12388 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n1540# 0.19fF
C12389 divbuf_0/a_1440_n1600# divbuf_0/OUT2 0.01fF
C12390 divbuf_1/a_21012_170# divbuf_1/a_21012_n240# 0.01fF
C12391 divbuf_2/a_40830_n840# divbuf_2/a_40830_n1540# 0.01fF
C12392 divbuf_2/a_10110_n1540# divbuf_2/a_10590_n1540# 0.11fF
C12393 pll_full_0/divbuf_0/a_24510_n840# pll_full_0/divbuf_0/a_24990_n840# 0.07fF
C12394 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C12395 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24510_n1540# 0.19fF
C12396 ro_div_0/divider_0/nor_0/B gnd 1.23fF
C12397 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_46590_n840# 0.04fF
C12398 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/a_8272_170# 0.07fF
C12399 divbuf_1/a_6822_n240# divbuf_1/OUT3 0.04fF
C12400 divbuf_1/a_45120_n1600# divbuf_1/a_45150_n840# 0.04fF
C12401 divbuf_5/a_34080_n1600# divbuf_5/a_34110_n840# 0.04fF
C12402 divbuf_5/a_23922_170# divbuf_5/OUT4 0.19fF
C12403 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/a_14702_170# 0.07fF
C12404 divbuf_3/a_21982_n240# divbuf_3/a_22472_n240# 0.04fF
C12405 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44640_n1600# 0.26fF
C12406 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/a_35070_n840# 0.05fF
C12407 divbuf_4/a_7680_n1600# divbuf_4/a_8160_n1600# 0.26fF
C12408 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_48000_n1600# 0.26fF
C12409 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/a_38430_n840# 0.04fF
C12410 divbuf_3/a_33600_n1600# divbuf_3/a_33630_n1540# 0.19fF
C12411 divbuf_3/a_33630_n840# divbuf_3/a_34110_n840# 0.07fF
C12412 divbuf_3/a_3390_n840# divbuf_3/a_3390_n1540# 0.01fF
C12413 pd_div_0/divbuf_0/a_36510_n1540# pd_div_0/divbuf_0/a_36990_n1540# 0.11fF
C12414 divbuf_2/a_7680_n1600# divbuf_2/a_7710_n840# 0.04fF
C12415 divbuf_4/a_30750_n840# divbuf_4/a_30750_n1540# 0.01fF
C12416 pll_full_0/divbuf_1/a_39870_n1540# pll_full_0/divbuf_1/a_40350_n1540# 0.11fF
C12417 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/a_24892_n240# 0.05fF
C12418 divbuf_1/a_22952_n240# divbuf_1/a_23442_n240# 0.04fF
C12419 divbuf_5/a_11802_n240# divbuf_5/a_12282_n240# 0.05fF
C12420 divbuf_5/a_31682_170# divbuf_5/a_31682_n240# 0.01fF
C12421 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C12422 ro_div_0/divbuf_0/a_5790_n840# ro_div_0/divbuf_0/a_5790_n1540# 0.01fF
C12423 ro_div_0/divbuf_0/a_36030_n840# ro_div_0/divbuf_0/a_36510_n840# 0.07fF
C12424 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36030_n1540# 0.19fF
C12425 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C12426 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/a_9732_n240# 0.01fF
C12427 divbuf_1/a_34560_n1600# divbuf_1/a_34590_n1540# 0.19fF
C12428 divbuf_1/a_34590_n840# divbuf_1/a_35070_n840# 0.07fF
C12429 divbuf_1/a_4350_n840# divbuf_1/a_4350_n1540# 0.01fF
C12430 divbuf_5/a_23520_n1600# divbuf_5/a_23550_n1540# 0.19fF
C12431 divbuf_5/a_23550_n840# divbuf_5/a_24030_n840# 0.07fF
C12432 divbuf_5/a_24892_n240# divbuf_5/OUT4 0.04fF
C12433 divbuf_3/a_55710_n840# divbuf_3/a_55710_n1540# 0.01fF
C12434 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C12435 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C12436 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34110_n840# 0.04fF
C12437 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/OUT4 0.19fF
C12438 divbuf_2/a_4392_170# divbuf_2/a_4392_n240# 0.01fF
C12439 divbuf_2/a_24412_170# divbuf_2/a_24892_170# 0.07fF
C12440 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37470_n840# 0.04fF
C12441 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/OUT4 0.19fF
C12442 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C12443 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C12444 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C12445 divbuf_0/a_9242_n240# divbuf_0/a_9150_n840# 0.03fF
C12446 divbuf_0/a_18720_n1600# divbuf_0/a_19200_n1600# 0.26fF
C12447 divbuf_2/a_10212_170# divbuf_2/OUT4 0.07fF
C12448 divbuf_2/a_57600_n1600# divbuf_2/a_58080_n1600# 0.26fF
C12449 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11520_n1600# 0.26fF
C12450 divbuf_0/a_11070_n1540# divbuf_0/a_11550_n1540# 0.11fF
C12451 divbuf_0/a_41790_n840# divbuf_0/a_41790_n1540# 0.01fF
C12452 divbuf_2/a_49950_n1540# divbuf_2/a_50430_n1540# 0.11fF
C12453 pll_full_0/divbuf_0/a_34110_n840# pll_full_0/divbuf_0/a_34110_n1540# 0.01fF
C12454 pll_full_0/divbuf_0/a_3390_n1540# pll_full_0/divbuf_0/a_3870_n1540# 0.11fF
C12455 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_12282_n240# 0.05fF
C12456 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/a_31682_n240# 0.01fF
C12457 divbuf_4/a_14222_170# divbuf_4/a_14702_170# 0.07fF
C12458 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/a_35082_n240# 0.01fF
C12459 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_15672_n240# 0.04fF
C12460 divbuf_3/a_20160_n1600# divbuf_3/a_20640_n1600# 0.26fF
C12461 divbuf_5/a_23040_n1600# divbuf_5/OUT4 0.01fF
C12462 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_23550_n1540# 0.19fF
C12463 pd_div_0/divbuf_0/a_23550_n840# pd_div_0/divbuf_0/a_24030_n840# 0.07fF
C12464 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C12465 divbuf_4/a_38472_n240# divbuf_4/a_38430_n840# 0.04fF
C12466 divbuf_4/a_47520_n1600# divbuf_4/a_48000_n1600# 0.26fF
C12467 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_26910_n1540# 0.19fF
C12468 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C12469 pll_full_0/divbuf_1/a_26910_n840# pll_full_0/divbuf_1/a_27390_n840# 0.07fF
C12470 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_17310_n840# 0.00fF
C12471 divbuf_3/a_43230_n840# divbuf_3/a_43230_n1540# 0.01fF
C12472 divbuf_3/a_12510_n1540# divbuf_3/a_12990_n1540# 0.11fF
C12473 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C12474 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n840# 0.04fF
C12475 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C12476 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C12477 divbuf_1/a_5852_170# divbuf_1/a_6332_170# 0.07fF
C12478 divbuf_4/a_39870_n1540# divbuf_4/a_40350_n1540# 0.11fF
C12479 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_990_n840# 0.04fF
C12480 divbuf_2/a_11802_n240# divbuf_2/OUT4 0.04fF
C12481 divbuf_2/a_47520_n1600# divbuf_2/a_47550_n840# 0.04fF
C12482 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C12483 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_23040_n1600# 0.26fF
C12484 divbuf_1/a_21120_n1600# divbuf_1/a_21600_n1600# 0.26fF
C12485 divbuf_1/a_11802_n240# divbuf_1/a_12030_n840# 0.02fF
C12486 divbuf_5/a_10080_n1600# divbuf_5/a_10560_n1600# 0.26fF
C12487 divbuf_3/a_40902_170# divbuf_3/OUT4 0.19fF
C12488 divbuf_3/a_1352_n240# divbuf_3/OUT2 0.07fF
C12489 ro_div_0/divbuf_0/a_14910_n1540# ro_div_0/divbuf_0/a_15390_n1540# 0.11fF
C12490 ro_div_0/divbuf_0/a_45630_n840# ro_div_0/divbuf_0/a_45630_n1540# 0.01fF
C12491 divbuf_1/a_44190_n840# divbuf_1/a_44190_n1540# 0.01fF
C12492 divbuf_1/a_13470_n1540# divbuf_1/a_13950_n1540# 0.11fF
C12493 divbuf_3/a_10080_n1600# divbuf_3/a_10110_n840# 0.04fF
C12494 divbuf_5/a_2910_n840# divbuf_5/OUT3 0.03fF
C12495 divbuf_5/a_33150_n840# divbuf_5/a_33150_n1540# 0.01fF
C12496 divbuf_5/a_2430_n1540# divbuf_5/a_2910_n1540# 0.11fF
C12497 divbuf_0/a_25382_170# divbuf_0/a_25862_170# 0.07fF
C12498 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C12499 divbuf_4/a_30712_170# divbuf_4/OUT4 0.19fF
C12500 divbuf_4/a_37440_n1600# divbuf_4/a_37470_n840# 0.04fF
C12501 divbuf_2/a_25382_n240# divbuf_2/a_25862_n240# 0.05fF
C12502 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/a_19562_170# 0.07fF
C12503 divbuf_0/a_58560_n1600# divbuf_0/a_59040_n1600# 0.26fF
C12504 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/clk 0.14fF
C12505 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C12506 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/Out 0.01fF
C12507 divbuf_2/a_36990_n840# divbuf_2/a_37470_n840# 0.07fF
C12508 divbuf_2/a_6750_n840# divbuf_2/a_6750_n1540# 0.01fF
C12509 divbuf_2/a_10560_n1600# divbuf_2/OUT3 0.01fF
C12510 divbuf_2/a_36960_n1600# divbuf_2/a_36990_n1540# 0.19fF
C12511 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_51360_n1600# 0.26fF
C12512 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.05fF
C12513 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/a_37992_170# 0.07fF
C12514 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12510_n840# 0.04fF
C12515 divbuf_0/a_50910_n1540# divbuf_0/a_51390_n1540# 0.11fF
C12516 divbuf_1/a_17612_170# divbuf_1/OUT4 0.19fF
C12517 divbuf_1/a_11040_n1600# divbuf_1/a_11070_n840# 0.04fF
C12518 pll_full_0/divbuf_0/a_43230_n1540# pll_full_0/divbuf_0/a_43710_n1540# 0.11fF
C12519 divbuf_3/a_6822_170# divbuf_3/a_6822_n240# 0.01fF
C12520 divbuf_3/a_26832_170# divbuf_3/a_27322_170# 0.07fF
C12521 divbuf_3/a_960_n1600# divbuf_3/OUT2 0.00fF
C12522 divbuf_3/a_41382_n240# divbuf_3/OUT5 0.04fF
C12523 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10560_n1600# 0.26fF
C12524 divbuf_4/a_15182_n240# divbuf_4/a_15672_n240# 0.04fF
C12525 divbuf_4/a_35082_170# divbuf_4/a_35082_n240# 0.01fF
C12526 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13920_n1600# 0.26fF
C12527 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/a_3870_n840# 0.04fF
C12528 divbuf_3/a_60000_n1600# divbuf_3/a_60480_n1600# 0.26fF
C12529 divbuf_5/a_41790_n840# divbuf_5/OUT5 0.03fF
C12530 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C12531 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/OUT3 0.03fF
C12532 pd_div_0/divbuf_0/a_33150_n840# pd_div_0/divbuf_0/a_33150_n1540# 0.01fF
C12533 pd_div_0/divbuf_0/a_2430_n1540# pd_div_0/divbuf_0/a_2910_n1540# 0.11fF
C12534 divbuf_4/a_26910_n840# divbuf_4/a_27390_n840# 0.07fF
C12535 divbuf_4/a_31682_n240# divbuf_4/OUT4 0.04fF
C12536 divbuf_4/a_26880_n1600# divbuf_4/a_26910_n1540# 0.19fF
C12537 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/a_19072_n240# 0.01fF
C12538 pll_full_0/divbuf_1/a_5790_n1540# pll_full_0/divbuf_1/a_6270_n1540# 0.11fF
C12539 pll_full_0/divbuf_1/a_36510_n840# pll_full_0/divbuf_1/a_36510_n1540# 0.01fF
C12540 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/OUT4 0.19fF
C12541 divbuf_0/a_13742_n240# divbuf_0/OUT4 0.04fF
C12542 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n840# 0.04fF
C12543 divbuf_1/a_24412_170# divbuf_1/a_24892_170# 0.07fF
C12544 divbuf_5/a_16642_170# divbuf_5/a_17122_170# 0.07fF
C12545 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_40830_n840# 0.04fF
C12546 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/OUT4 0.19fF
C12547 ro_div_0/divider_0/tspc_0/Q gnd 0.33fF
C12548 ro_div_0/divbuf_0/a_1950_n840# ro_div_0/divbuf_0/a_2430_n840# 0.07fF
C12549 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_1950_n1540# 0.19fF
C12550 divbuf_1/a_480_n1600# divbuf_1/a_510_n1540# 0.19fF
C12551 divbuf_1/a_510_n840# divbuf_1/a_990_n840# 0.07fF
C12552 divbuf_5/a_49920_n1600# divbuf_5/a_50400_n1600# 0.26fF
C12553 divbuf_5/a_40902_n240# divbuf_5/a_40830_n840# 0.03fF
C12554 divbuf_3/a_51840_n1600# divbuf_3/a_51870_n1540# 0.19fF
C12555 ro_div_0/divbuf_0/a_54750_n1540# ro_div_0/divbuf_0/a_55230_n1540# 0.11fF
C12556 divbuf_1/a_53310_n1540# divbuf_1/a_53790_n1540# 0.11fF
C12557 divbuf_3/a_49920_n1600# divbuf_3/a_49950_n840# 0.04fF
C12558 divbuf_5/a_42270_n1540# divbuf_5/a_42750_n1540# 0.11fF
C12559 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3390_n840# 0.04fF
C12560 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/a_34112_n240# 0.01fF
C12561 divbuf_0/a_26352_n240# divbuf_0/a_26832_n240# 0.05fF
C12562 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/OUT5 0.03fF
C12563 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/a_19072_n240# 0.04fF
C12564 divbuf_2/a_14222_n240# divbuf_2/a_14430_n840# 0.02fF
C12565 divbuf_2/a_23520_n1600# divbuf_2/a_24000_n1600# 0.26fF
C12566 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/a_38472_n240# 0.01fF
C12567 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n1540# 0.19fF
C12568 divbuf_0/a_12000_n1600# divbuf_0/OUT4 0.00fF
C12569 divbuf_0/a_7710_n840# divbuf_0/a_7710_n1540# 0.01fF
C12570 divbuf_0/a_37950_n840# divbuf_0/a_38430_n840# 0.07fF
C12571 divbuf_1/a_26832_170# divbuf_1/a_26832_n240# 0.01fF
C12572 divbuf_2/a_46590_n840# divbuf_2/a_46590_n1540# 0.01fF
C12573 divbuf_2/a_15870_n1540# divbuf_2/a_16350_n1540# 0.11fF
C12574 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30270_n1540# 0.19fF
C12575 pll_full_0/divbuf_0/a_30270_n840# pll_full_0/divbuf_0/a_30750_n840# 0.07fF
C12576 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C12577 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C12578 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C12579 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52350_n840# 0.04fF
C12580 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/a_17122_170# 0.07fF
C12581 divbuf_1/a_50880_n1600# divbuf_1/a_50910_n840# 0.04fF
C12582 divbuf_1/a_18582_n240# divbuf_1/OUT4 0.04fF
C12583 divbuf_3/a_27802_n240# divbuf_3/a_28292_n240# 0.04fF
C12584 divbuf_5/a_39840_n1600# divbuf_5/a_39870_n840# 0.04fF
C12585 divbuf_5/a_35562_170# divbuf_5/OUT4 0.19fF
C12586 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/a_20532_170# 0.07fF
C12587 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C12588 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_50400_n1600# 0.26fF
C12589 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/a_40830_n840# 0.03fF
C12590 divbuf_4/a_3912_n240# divbuf_4/a_3870_n840# 0.04fF
C12591 divbuf_4/a_13440_n1600# divbuf_4/a_13920_n1600# 0.26fF
C12592 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53760_n1600# 0.26fF
C12593 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/OUT2 0.19fF
C12594 divbuf_3/a_39390_n840# divbuf_3/a_39870_n840# 0.07fF
C12595 divbuf_3/a_9150_n840# divbuf_3/a_9150_n1540# 0.01fF
C12596 divbuf_3/a_39360_n1600# divbuf_3/a_39390_n1540# 0.19fF
C12597 pd_div_0/divbuf_0/a_42270_n1540# pd_div_0/divbuf_0/a_42750_n1540# 0.11fF
C12598 divbuf_2/a_13440_n1600# divbuf_2/a_13470_n840# 0.04fF
C12599 divbuf_4/a_36510_n840# divbuf_4/a_36510_n1540# 0.01fF
C12600 divbuf_4/a_5790_n1540# divbuf_4/a_6270_n1540# 0.11fF
C12601 pll_full_0/divbuf_1/a_45630_n1540# pll_full_0/divbuf_1/a_46110_n1540# 0.11fF
C12602 gnd pll_full_0/divider_0/tspc_2/Z4 0.44fF
C12603 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/a_30712_n240# 0.05fF
C12604 divbuf_1/a_28772_n240# divbuf_1/a_29262_n240# 0.04fF
C12605 divbuf_5/a_37502_170# divbuf_5/a_37502_n240# 0.01fF
C12606 divbuf_5/a_17612_n240# divbuf_5/a_18092_n240# 0.05fF
C12607 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C12608 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C12609 ro_div_0/divbuf_0/a_11550_n840# ro_div_0/divbuf_0/a_11550_n1540# 0.01fF
C12610 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/a_42270_n840# 0.07fF
C12611 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_41790_n1540# 0.19fF
C12612 divbuf_1/a_40350_n840# divbuf_1/a_40830_n840# 0.07fF
C12613 divbuf_1/a_10110_n840# divbuf_1/a_10110_n1540# 0.01fF
C12614 divbuf_1/a_40320_n1600# divbuf_1/a_40350_n1540# 0.19fF
C12615 divbuf_5/a_29310_n840# divbuf_5/a_29790_n840# 0.07fF
C12616 divbuf_5/a_36532_n240# divbuf_5/OUT4 0.04fF
C12617 divbuf_5/a_29280_n1600# divbuf_5/a_29310_n1540# 0.19fF
C12618 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C12619 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z4 0.15fF
C12620 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/Out 0.11fF
C12621 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/clk 0.11fF
C12622 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_39870_n840# 0.04fF
C12623 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/OUT4 0.19fF
C12624 divbuf_2/a_30232_170# divbuf_2/a_30712_170# 0.07fF
C12625 divbuf_2/a_10212_170# divbuf_2/a_10212_n240# 0.01fF
C12626 divbuf_4/a_3360_n1600# divbuf_4/a_3390_n840# 0.04fF
C12627 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43230_n840# 0.04fF
C12628 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C12629 divbuf_0/a_24480_n1600# divbuf_0/a_24960_n1600# 0.26fF
C12630 divbuf_0/a_15182_n240# divbuf_0/a_15390_n840# 0.02fF
C12631 divbuf_2/a_2880_n1600# divbuf_2/a_2910_n1540# 0.19fF
C12632 divbuf_2/a_22472_170# divbuf_2/OUT4 0.19fF
C12633 divbuf_2/a_2910_n840# divbuf_2/a_3390_n840# 0.07fF
C12634 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_17280_n1600# 0.26fF
C12635 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/a_7230_n840# 0.03fF
C12636 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/a0 0.13fF
C12637 divbuf_0/a_16830_n1540# divbuf_0/a_17310_n1540# 0.11fF
C12638 divbuf_0/a_47550_n840# divbuf_0/a_47550_n1540# 0.01fF
C12639 pll_full_0/divbuf_0/a_9150_n1540# pll_full_0/divbuf_0/a_9630_n1540# 0.11fF
C12640 pll_full_0/divbuf_0/a_39870_n840# pll_full_0/divbuf_0/a_39870_n1540# 0.01fF
C12641 divbuf_2/a_55710_n1540# divbuf_2/a_56190_n1540# 0.11fF
C12642 divbuf_3/a_12282_170# divbuf_3/OUT4 0.19fF
C12643 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/a_37502_n240# 0.01fF
C12644 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_18092_n240# 0.05fF
C12645 divbuf_4/a_20042_170# divbuf_4/a_20532_170# 0.07fF
C12646 divbuf_5/a_34560_n1600# divbuf_5/OUT4 0.01fF
C12647 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/a_21502_n240# 0.04fF
C12648 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/a_40902_n240# 0.01fF
C12649 divbuf_3/a_16642_n240# divbuf_3/a_16830_n840# 0.02fF
C12650 divbuf_3/a_25920_n1600# divbuf_3/a_26400_n1600# 0.26fF
C12651 divbuf_0/a_18092_170# divbuf_0/a_18092_n240# 0.01fF
C12652 pd_div_0/divbuf_0/a_29310_n840# pd_div_0/divbuf_0/a_29790_n840# 0.07fF
C12653 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C12654 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29310_n1540# 0.19fF
C12655 divbuf_4/a_1842_170# divbuf_4/OUT2 0.19fF
C12656 divbuf_4/a_53280_n1600# divbuf_4/a_53760_n1600# 0.26fF
C12657 pll_full_0/divbuf_1/a_2430_n840# pll_full_0/divbuf_1/a_2430_n1540# 0.01fF
C12658 pll_full_0/divbuf_1/a_32670_n840# pll_full_0/divbuf_1/a_33150_n840# 0.07fF
C12659 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_32670_n1540# 0.19fF
C12660 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C12661 divbuf_3/a_48990_n840# divbuf_3/a_48990_n1540# 0.01fF
C12662 divbuf_3/a_18270_n1540# divbuf_3/a_18750_n1540# 0.11fF
C12663 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n840# 0.04fF
C12664 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C12665 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C12666 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z3 0.38fF
C12667 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z2 1.07fF
C12668 divbuf_4/a_45630_n1540# divbuf_4/a_46110_n1540# 0.11fF
C12669 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C12670 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C12671 divbuf_2/a_53280_n1600# divbuf_2/a_53310_n840# 0.04fF
C12672 divbuf_2/a_23442_n240# divbuf_2/OUT4 0.04fF
C12673 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_6750_n840# 0.04fF
C12674 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28800_n1600# 0.26fF
C12675 divbuf_1/a_26880_n1600# divbuf_1/a_27360_n1600# 0.26fF
C12676 divbuf_1/a_17612_n240# divbuf_1/a_17790_n840# 0.02fF
C12677 divbuf_5/a_15840_n1600# divbuf_5/a_16320_n1600# 0.26fF
C12678 divbuf_5/a_6332_n240# divbuf_5/a_6270_n840# 0.04fF
C12679 divbuf_3/a_13252_n240# divbuf_3/OUT4 0.04fF
C12680 ro_div_0/divbuf_0/a_20670_n1540# ro_div_0/divbuf_0/a_21150_n1540# 0.11fF
C12681 ro_div_0/divbuf_0/a_51390_n840# ro_div_0/divbuf_0/a_51390_n1540# 0.01fF
C12682 divbuf_1/a_49950_n840# divbuf_1/a_49950_n1540# 0.01fF
C12683 divbuf_1/a_19230_n1540# divbuf_1/a_19710_n1540# 0.11fF
C12684 divbuf_3/a_15840_n1600# divbuf_3/a_15870_n840# 0.04fF
C12685 divbuf_5/a_38910_n840# divbuf_5/a_38910_n1540# 0.01fF
C12686 divbuf_5/a_8190_n1540# divbuf_5/a_8670_n1540# 0.11fF
C12687 divbuf_0/a_11802_170# divbuf_0/a_11802_n240# 0.01fF
C12688 divbuf_0/a_7302_170# divbuf_0/a_7302_n240# 0.01fF
C12689 divbuf_0/a_31202_170# divbuf_0/a_31682_170# 0.07fF
C12690 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C12691 divbuf_4/a_2322_n240# divbuf_4/OUT3 0.04fF
C12692 divbuf_4/a_43200_n1600# divbuf_4/a_43230_n840# 0.04fF
C12693 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/a_23922_170# 0.07fF
C12694 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/OUT4 0.19fF
C12695 divbuf_2/a_31202_n240# divbuf_2/a_31682_n240# 0.05fF
C12696 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_8272_170# 0.07fF
C12697 divbuf_0/a_24412_170# divbuf_0/OUT4 0.19fF
C12698 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n1540# 0.19fF
C12699 divbuf_0/a_3870_n840# divbuf_0/a_4350_n840# 0.07fF
C12700 gnd pd_div_0/divider_0/prescaler_0/Out 0.46fF
C12701 pd_div_0/divider_0/prescaler_0/tspc_2/D pd_div_0/divider_0/clk 0.29fF
C12702 pd_div_0/divider_0/nor_0/B pd_div_0/bufin 0.29fF
C12703 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z3 0.06fF
C12704 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_57120_n1600# 0.26fF
C12705 divbuf_2/a_42720_n1600# divbuf_2/a_42750_n1540# 0.19fF
C12706 divbuf_2/a_42750_n840# divbuf_2/a_43230_n840# 0.07fF
C12707 divbuf_2/a_12510_n840# divbuf_2/a_12510_n1540# 0.01fF
C12708 divbuf_2/a_21600_n1600# divbuf_2/OUT4 0.01fF
C12709 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/a_3912_n240# 0.04fF
C12710 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18270_n840# 0.04fF
C12711 divbuf_0/a_56670_n1540# divbuf_0/a_57150_n1540# 0.11fF
C12712 divbuf_1/a_16800_n1600# divbuf_1/a_16830_n840# 0.04fF
C12713 divbuf_3/a_32652_170# divbuf_3/a_33142_170# 0.07fF
C12714 divbuf_3/a_13252_170# divbuf_3/a_13252_n240# 0.01fF
C12715 divbuf_5/a_5760_n1600# divbuf_5/a_5790_n840# 0.04fF
C12716 pll_full_0/divbuf_0/a_48990_n1540# pll_full_0/divbuf_0/a_49470_n1540# 0.11fF
C12717 divbuf_3/a_11520_n1600# divbuf_3/OUT4 0.01fF
C12718 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_16320_n1600# 0.26fF
C12719 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/a_6270_n840# 0.04fF
C12720 divbuf_4/a_40902_170# divbuf_4/a_40902_n240# 0.01fF
C12721 divbuf_4/a_21012_n240# divbuf_4/a_21502_n240# 0.04fF
C12722 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/a_9630_n840# 0.03fF
C12723 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19680_n1600# 0.26fF
C12724 divbuf_3/a_5310_n840# divbuf_3/a_5790_n840# 0.07fF
C12725 divbuf_3/a_5280_n1600# divbuf_3/a_5310_n1540# 0.19fF
C12726 pd_div_0/divbuf_0/a_38910_n840# pd_div_0/divbuf_0/a_38910_n1540# 0.01fF
C12727 pd_div_0/divbuf_0/a_8190_n1540# pd_div_0/divbuf_0/a_8670_n1540# 0.11fF
C12728 divbuf_4/a_2400_n1600# divbuf_4/OUT2 0.00fF
C12729 divbuf_4/a_32640_n1600# divbuf_4/a_32670_n1540# 0.19fF
C12730 divbuf_4/a_32670_n840# divbuf_4/a_33150_n840# 0.07fF
C12731 divbuf_4/a_2430_n840# divbuf_4/a_2430_n1540# 0.01fF
C12732 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/OUT4 0.19fF
C12733 pll_full_0/divbuf_1/a_11550_n1540# pll_full_0/divbuf_1/a_12030_n1540# 0.11fF
C12734 pll_full_0/divbuf_1/a_42270_n840# pll_full_0/divbuf_1/a_42270_n1540# 0.01fF
C12735 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n840# 0.04fF
C12736 divbuf_0/a_25382_n240# divbuf_0/OUT4 0.04fF
C12737 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_46590_n840# 0.04fF
C12738 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C12739 divbuf_5/a_22472_170# divbuf_5/a_22952_170# 0.07fF
C12740 divbuf_5/a_1842_170# divbuf_5/a_1842_n240# 0.01fF
C12741 ro_div_0/divbuf_0/a_7710_n840# ro_div_0/divbuf_0/a_8190_n840# 0.07fF
C12742 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_7710_n1540# 0.19fF
C12743 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.44fF
C12744 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/z5 0.11fF
C12745 divbuf_1/a_6270_n840# divbuf_1/a_6750_n840# 0.07fF
C12746 divbuf_1/a_25862_170# divbuf_1/OUT4 0.19fF
C12747 divbuf_1/a_6240_n1600# divbuf_1/a_6270_n1540# 0.19fF
C12748 divbuf_5/a_6822_170# divbuf_5/OUT3 0.19fF
C12749 divbuf_5/a_55680_n1600# divbuf_5/a_56160_n1600# 0.26fF
C12750 divbuf_3/a_57600_n1600# divbuf_3/a_57630_n1540# 0.19fF
C12751 ro_div_0/divbuf_0/a_60510_n1540# ro_div_0/divbuf_0/a_60990_n1540# 0.11fF
C12752 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_5790_n840# 0.04fF
C12753 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/a_20532_n240# 0.04fF
C12754 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/a_39932_n240# 0.01fF
C12755 divbuf_1/a_59070_n1540# divbuf_1/a_59550_n1540# 0.11fF
C12756 divbuf_3/a_55680_n1600# divbuf_3/a_55710_n840# 0.04fF
C12757 divbuf_5/a_48030_n1540# divbuf_5/a_48510_n1540# 0.11fF
C12758 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9150_n840# 0.04fF
C12759 divbuf_0/a_32172_n240# divbuf_0/a_32652_n240# 0.05fF
C12760 divbuf_2/a_29280_n1600# divbuf_2/a_29760_n1600# 0.26fF
C12761 divbuf_2/a_20042_n240# divbuf_2/a_20190_n840# 0.03fF
C12762 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/a_24892_n240# 0.05fF
C12763 divbuf_0/a_23520_n1600# divbuf_0/OUT4 0.00fF
C12764 divbuf_0/a_13470_n840# divbuf_0/a_13470_n1540# 0.01fF
C12765 divbuf_0/a_43710_n840# divbuf_0/a_44190_n840# 0.07fF
C12766 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n1540# 0.19fF
C12767 pll_full_0/divbuf_0/a_5790_n840# pll_full_0/divbuf_0/a_5790_n1540# 0.01fF
C12768 pll_full_0/divbuf_0/a_36030_n840# pll_full_0/divbuf_0/a_36510_n840# 0.07fF
C12769 divbuf_2/a_52350_n840# divbuf_2/a_52350_n1540# 0.01fF
C12770 divbuf_2/a_21630_n1540# divbuf_2/a_22110_n1540# 0.11fF
C12771 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C12772 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36030_n1540# 0.19fF
C12773 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58110_n840# 0.04fF
C12774 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C12775 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/a_6332_n240# 0.01fF
C12776 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/a_22952_170# 0.07fF
C12777 divbuf_1/a_30232_n240# divbuf_1/OUT4 0.04fF
C12778 divbuf_1/a_56640_n1600# divbuf_1/a_56670_n840# 0.04fF
C12779 divbuf_3/a_33622_n240# divbuf_3/a_34112_n240# 0.04fF
C12780 divbuf_5/a_7792_n240# divbuf_5/OUT3 0.04fF
C12781 divbuf_5/a_45600_n1600# divbuf_5/a_45630_n840# 0.04fF
C12782 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/a_26352_170# 0.07fF
C12783 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/a_5852_n240# 0.01fF
C12784 divbuf_0/a_6332_170# divbuf_0/a_6822_170# 0.07fF
C12785 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z3 0.05fF
C12786 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C12787 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/OUT4 0.19fF
C12788 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_56160_n1600# 0.26fF
C12789 divbuf_3/a_45120_n1600# divbuf_3/a_45150_n1540# 0.19fF
C12790 divbuf_3/a_45150_n840# divbuf_3/a_45630_n840# 0.07fF
C12791 divbuf_3/a_14910_n840# divbuf_3/a_14910_n1540# 0.01fF
C12792 divbuf_4/a_19200_n1600# divbuf_4/a_19680_n1600# 0.26fF
C12793 divbuf_4/a_9732_n240# divbuf_4/a_9630_n840# 0.03fF
C12794 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C12795 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C12796 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59520_n1600# 0.26fF
C12797 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/OUT4 0.19fF
C12798 pd_div_0/divbuf_0/a_48030_n1540# pd_div_0/divbuf_0/a_48510_n1540# 0.11fF
C12799 divbuf_2/a_19200_n1600# divbuf_2/a_19230_n840# 0.04fF
C12800 divbuf_4/a_42270_n840# divbuf_4/a_42270_n1540# 0.01fF
C12801 divbuf_4/a_11550_n1540# divbuf_4/a_12030_n1540# 0.11fF
C12802 pll_full_0/divbuf_1/a_51390_n1540# pll_full_0/divbuf_1/a_51870_n1540# 0.11fF
C12803 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/a_36532_n240# 0.05fF
C12804 divbuf_1/a_34592_n240# divbuf_1/a_35082_n240# 0.04fF
C12805 divbuf_5/a_23442_n240# divbuf_5/a_23922_n240# 0.05fF
C12806 ro_div_0/divbuf_0/a_17310_n840# ro_div_0/divbuf_0/a_17310_n1540# 0.01fF
C12807 ro_div_0/divbuf_0/a_47550_n840# ro_div_0/divbuf_0/a_48030_n840# 0.07fF
C12808 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_47550_n1540# 0.19fF
C12809 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C12810 divbuf_1/a_46080_n1600# divbuf_1/a_46110_n1540# 0.19fF
C12811 divbuf_1/a_46110_n840# divbuf_1/a_46590_n840# 0.07fF
C12812 divbuf_1/a_15870_n840# divbuf_1/a_15870_n1540# 0.01fF
C12813 divbuf_3/a_1842_n240# divbuf_3/a_1950_n840# 0.03fF
C12814 divbuf_5/a_35040_n1600# divbuf_5/a_35070_n1540# 0.19fF
C12815 divbuf_5/a_35070_n840# divbuf_5/a_35550_n840# 0.07fF
C12816 divbuf_5/a_4830_n840# divbuf_5/a_4830_n1540# 0.01fF
C12817 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C12818 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C12819 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_45630_n840# 0.04fF
C12820 divbuf_2/a_16642_170# divbuf_2/a_16642_n240# 0.01fF
C12821 divbuf_2/a_36052_170# divbuf_2/a_36532_170# 0.07fF
C12822 divbuf_4/a_9120_n1600# divbuf_4/a_9150_n840# 0.04fF
C12823 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C12824 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_48990_n840# 0.04fF
C12825 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/a_8670_n840# 0.03fF
C12826 divbuf_0/a_21012_n240# divbuf_0/a_21150_n840# 0.03fF
C12827 divbuf_0/a_30240_n1600# divbuf_0/a_30720_n1600# 0.26fF
C12828 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_23040_n1600# 0.26fF
C12829 divbuf_2/a_8640_n1600# divbuf_2/a_8670_n1540# 0.19fF
C12830 divbuf_2/a_34112_170# divbuf_2/OUT4 0.19fF
C12831 divbuf_2/a_8670_n840# divbuf_2/a_9150_n840# 0.07fF
C12832 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_13470_n840# 0.02fF
C12833 divbuf_0/a_22590_n1540# divbuf_0/a_23070_n1540# 0.11fF
C12834 divbuf_0/a_53310_n840# divbuf_0/a_53310_n1540# 0.01fF
C12835 pll_full_0/divbuf_0/a_45630_n840# pll_full_0/divbuf_0/a_45630_n1540# 0.01fF
C12836 pll_full_0/divbuf_0/a_14910_n1540# pll_full_0/divbuf_0/a_15390_n1540# 0.11fF
C12837 divbuf_3/a_23922_170# divbuf_3/OUT4 0.19fF
C12838 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/OUT4 0.03fF
C12839 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/a_23922_n240# 0.05fF
C12840 divbuf_4/a_5852_170# divbuf_4/a_5852_n240# 0.01fF
C12841 divbuf_4/a_25862_170# divbuf_4/a_26352_170# 0.07fF
C12842 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/a_27322_n240# 0.04fF
C12843 divbuf_3/a_31680_n1600# divbuf_3/a_32160_n1600# 0.26fF
C12844 divbuf_3/a_22472_n240# divbuf_3/a_22590_n840# 0.03fF
C12845 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C12846 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35070_n1540# 0.19fF
C12847 pd_div_0/divbuf_0/a_35070_n840# pd_div_0/divbuf_0/a_35550_n840# 0.07fF
C12848 pd_div_0/divbuf_0/a_4830_n840# pd_div_0/divbuf_0/a_4830_n1540# 0.01fF
C12849 divbuf_4/a_13742_170# divbuf_4/OUT4 0.19fF
C12850 divbuf_4/a_59040_n1600# divbuf_4/a_59520_n1600# 0.26fF
C12851 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C12852 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38430_n1540# 0.19fF
C12853 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C12854 pll_full_0/divbuf_1/a_8190_n840# pll_full_0/divbuf_1/a_8190_n1540# 0.01fF
C12855 pll_full_0/divbuf_1/a_38430_n840# pll_full_0/divbuf_1/a_38910_n840# 0.07fF
C12856 divbuf_3/a_24030_n1540# divbuf_3/a_24510_n1540# 0.11fF
C12857 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n840# 0.04fF
C12858 divbuf_0/a_6822_170# divbuf_0/OUT3 0.19fF
C12859 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C12860 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C12861 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/and_0/OUT 0.06fF
C12862 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/tspc_1/Z4 0.36fF
C12863 divbuf_1/a_11312_170# divbuf_1/a_11802_170# 0.07fF
C12864 divbuf_2/a_35082_n240# divbuf_2/OUT4 0.04fF
C12865 divbuf_2/a_59040_n1600# divbuf_2/a_59070_n840# 0.04fF
C12866 divbuf_4/a_51390_n1540# divbuf_4/a_51870_n1540# 0.11fF
C12867 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z4 0.02fF
C12868 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12510_n840# 0.04fF
C12869 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34560_n1600# 0.26fF
C12870 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/a_24990_n840# 0.03fF
C12871 divbuf_1/a_32640_n1600# divbuf_1/a_33120_n1600# 0.26fF
C12872 divbuf_1/a_23442_n240# divbuf_1/a_23550_n840# 0.03fF
C12873 divbuf_5/a_21600_n1600# divbuf_5/a_22080_n1600# 0.26fF
C12874 divbuf_5/a_12282_n240# divbuf_5/a_12510_n840# 0.02fF
C12875 divbuf_3/a_24892_n240# divbuf_3/OUT4 0.04fF
C12876 ro_div_0/divbuf_0/a_26430_n1540# ro_div_0/divbuf_0/a_26910_n1540# 0.11fF
C12877 ro_div_0/divbuf_0/a_57150_n840# ro_div_0/divbuf_0/a_57150_n1540# 0.01fF
C12878 divbuf_1/a_55710_n840# divbuf_1/a_55710_n1540# 0.01fF
C12879 divbuf_1/a_24990_n1540# divbuf_1/a_25470_n1540# 0.11fF
C12880 divbuf_5/a_44670_n840# divbuf_5/a_44670_n1540# 0.01fF
C12881 divbuf_5/a_13950_n1540# divbuf_5/a_14430_n1540# 0.11fF
C12882 divbuf_3/a_21600_n1600# divbuf_3/a_21630_n840# 0.04fF
C12883 divbuf_0/a_37022_170# divbuf_0/a_37502_170# 0.07fF
C12884 divbuf_0/a_492_n240# divbuf_0/a_480_n1600# 0.00fF
C12885 divbuf_2/a_37022_n240# divbuf_2/a_37502_n240# 0.05fF
C12886 divbuf_4/a_48960_n1600# divbuf_4/a_48990_n840# 0.04fF
C12887 divbuf_4/a_14702_n240# divbuf_4/OUT4 0.04fF
C12888 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/a_29742_170# 0.07fF
C12889 divbuf_0/a_9630_n840# divbuf_0/a_10110_n840# 0.07fF
C12890 divbuf_0/a_36052_170# divbuf_0/OUT4 0.19fF
C12891 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n1540# 0.19fF
C12892 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/Z1 0.36fF
C12893 pll_full_0/divbuf_0/a_1950_n840# pll_full_0/divbuf_0/a_2430_n840# 0.07fF
C12894 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/OUT4 0.19fF
C12895 divbuf_2/a_48510_n840# divbuf_2/a_48990_n840# 0.07fF
C12896 divbuf_2/a_18270_n840# divbuf_2/a_18270_n1540# 0.01fF
C12897 divbuf_2/a_33120_n1600# divbuf_2/OUT4 0.01fF
C12898 divbuf_2/a_48480_n1600# divbuf_2/a_48510_n1540# 0.19fF
C12899 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_1950_n1540# 0.19fF
C12900 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/a_9732_n240# 0.04fF
C12901 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24030_n840# 0.04fF
C12902 divbuf_0/a_60990_n1540# divbuf_0/OUT5 0.19fF
C12903 divbuf_1/a_22560_n1600# divbuf_1/a_22590_n840# 0.04fF
C12904 divbuf_5/a_11520_n1600# divbuf_5/a_11550_n840# 0.04fF
C12905 pll_full_0/divbuf_0/a_54750_n1540# pll_full_0/divbuf_0/a_55230_n1540# 0.11fF
C12906 divbuf_3/a_19072_170# divbuf_3/a_19072_n240# 0.01fF
C12907 divbuf_3/a_38472_170# divbuf_3/a_38962_170# 0.07fF
C12908 divbuf_3/a_23040_n1600# divbuf_3/OUT4 0.01fF
C12909 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_22080_n1600# 0.26fF
C12910 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12510_n840# 0.02fF
C12911 divbuf_4/a_26832_n240# divbuf_4/a_27322_n240# 0.04fF
C12912 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_25440_n1600# 0.26fF
C12913 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_15870_n840# 0.02fF
C12914 divbuf_3/a_11040_n1600# divbuf_3/a_11070_n1540# 0.19fF
C12915 divbuf_3/a_11070_n840# divbuf_3/a_11550_n840# 0.07fF
C12916 pd_div_0/divbuf_0/a_44670_n840# pd_div_0/divbuf_0/a_44670_n1540# 0.01fF
C12917 pd_div_0/divbuf_0/a_13950_n1540# pd_div_0/divbuf_0/a_14430_n1540# 0.11fF
C12918 divbuf_4/a_38430_n840# divbuf_4/a_38910_n840# 0.07fF
C12919 divbuf_4/a_8190_n840# divbuf_4/a_8190_n1540# 0.01fF
C12920 divbuf_4/a_12960_n1600# divbuf_4/OUT4 0.00fF
C12921 divbuf_4/a_38400_n1600# divbuf_4/a_38430_n1540# 0.19fF
C12922 pll_full_0/divbuf_1/a_17310_n1540# pll_full_0/divbuf_1/a_17790_n1540# 0.11fF
C12923 pll_full_0/divbuf_1/a_48030_n840# pll_full_0/divbuf_1/a_48030_n1540# 0.01fF
C12924 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C12925 divbuf_0/a_37022_n240# divbuf_0/OUT4 0.04fF
C12926 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n840# 0.04fF
C12927 divbuf_1/a_39442_170# divbuf_1/a_39932_170# 0.07fF
C12928 divbuf_5/a_28292_170# divbuf_5/a_28772_170# 0.07fF
C12929 divbuf_5/a_8272_170# divbuf_5/a_8272_n240# 0.01fF
C12930 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C12931 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52350_n840# 0.04fF
C12932 ro_div_0/divbuf_0/a_13470_n840# ro_div_0/divbuf_0/a_13950_n840# 0.07fF
C12933 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13470_n1540# 0.19fF
C12934 ro_div_0/divider_0/prescaler_0/tspc_1/Q gnd 0.83fF
C12935 divbuf_1/a_12000_n1600# divbuf_1/a_12030_n1540# 0.19fF
C12936 divbuf_1/a_40902_170# divbuf_1/OUT4 0.19fF
C12937 divbuf_1/a_12030_n840# divbuf_1/a_12510_n840# 0.07fF
C12938 divbuf_1/a_1352_n240# divbuf_1/OUT2 0.07fF
C12939 divbuf_5/a_960_n1600# divbuf_5/a_990_n1540# 0.19fF
C12940 divbuf_5/a_18582_170# divbuf_5/OUT4 0.19fF
C12941 divbuf_5/a_990_n840# divbuf_5/a_1470_n840# 0.07fF
C12942 divbuf_3/a_2910_n840# divbuf_3/OUT3 0.03fF
C12943 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C12944 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_11550_n840# 0.04fF
C12945 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_14910_n840# 0.04fF
C12946 divbuf_5/a_53790_n1540# divbuf_5/a_54270_n1540# 0.11fF
C12947 divbuf_0/a_37992_n240# divbuf_0/a_38472_n240# 0.05fF
C12948 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/a_30712_n240# 0.05fF
C12949 divbuf_2/a_25862_n240# divbuf_2/a_25950_n840# 0.03fF
C12950 divbuf_2/a_35040_n1600# divbuf_2/a_35520_n1600# 0.26fF
C12951 gnd pll_full_0/divider_0/tspc_0/a_630_n680# 0.62fF
C12952 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n1540# 0.19fF
C12953 divbuf_0/a_35040_n1600# divbuf_0/OUT4 0.00fF
C12954 divbuf_0/a_19230_n840# divbuf_0/a_19230_n1540# 0.01fF
C12955 divbuf_0/a_49470_n840# divbuf_0/a_49950_n840# 0.07fF
C12956 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C12957 divbuf_2/a_58110_n840# divbuf_2/a_58110_n1540# 0.01fF
C12958 divbuf_2/a_27390_n1540# divbuf_2/a_27870_n1540# 0.11fF
C12959 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_41790_n1540# 0.19fF
C12960 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/a_42270_n840# 0.07fF
C12961 pll_full_0/divbuf_0/a_11550_n840# pll_full_0/divbuf_0/a_11550_n1540# 0.01fF
C12962 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/a_28772_170# 0.07fF
C12963 divbuf_3/a_54750_n1540# divbuf_3/a_55230_n1540# 0.11fF
C12964 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/a_12282_n240# 0.01fF
C12965 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/a_32172_170# 0.07fF
C12966 divbuf_1/a_960_n1600# divbuf_1/OUT2 0.00fF
C12967 divbuf_1/a_41382_n240# divbuf_1/OUT5 0.04fF
C12968 divbuf_3/a_39442_n240# divbuf_3/a_39932_n240# 0.04fF
C12969 divbuf_5/a_51360_n1600# divbuf_5/a_51390_n840# 0.04fF
C12970 divbuf_5/a_19562_n240# divbuf_5/OUT4 0.04fF
C12971 divbuf_3/a_41790_n840# divbuf_3/OUT5 0.03fF
C12972 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_990_n1540# 0.19fF
C12973 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/OUT4 0.19fF
C12974 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/a_1470_n840# 0.07fF
C12975 divbuf_4/a_15672_n240# divbuf_4/a_15870_n840# 0.02fF
C12976 divbuf_4/a_24960_n1600# divbuf_4/a_25440_n1600# 0.26fF
C12977 divbuf_3/a_50910_n840# divbuf_3/a_51390_n840# 0.07fF
C12978 divbuf_3/a_20670_n840# divbuf_3/a_20670_n1540# 0.01fF
C12979 divbuf_3/a_50880_n1600# divbuf_3/a_50910_n1540# 0.19fF
C12980 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C12981 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/OUT4 0.19fF
C12982 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4350_n1540# 0.19fF
C12983 pll_full_0/divbuf_1/a_4350_n840# pll_full_0/divbuf_1/a_4830_n840# 0.07fF
C12984 pd_div_0/divbuf_0/a_53790_n1540# pd_div_0/divbuf_0/a_54270_n1540# 0.11fF
C12985 divbuf_2/a_5362_170# divbuf_2/OUT3 0.19fF
C12986 divbuf_2/a_24960_n1600# divbuf_2/a_24990_n840# 0.04fF
C12987 divbuf_4/a_48030_n840# divbuf_4/a_48030_n1540# 0.01fF
C12988 divbuf_4/a_17310_n1540# divbuf_4/a_17790_n1540# 0.11fF
C12989 pll_full_0/divbuf_1/a_57150_n1540# pll_full_0/divbuf_1/a_57630_n1540# 0.11fF
C12990 ro_div_0/divbuf_0/a_0_n1600# ro_div_0/divbuf_0/a_480_n1600# 0.26fF
C12991 divbuf_1/a_40412_n240# divbuf_1/a_40902_n240# 0.04fF
C12992 divbuf_5/a_29262_n240# divbuf_5/a_29742_n240# 0.05fF
C12993 ro_div_0/divbuf_0/a_23070_n840# ro_div_0/divbuf_0/a_23070_n1540# 0.01fF
C12994 ro_div_0/divbuf_0/a_53310_n840# ro_div_0/divbuf_0/a_53790_n840# 0.07fF
C12995 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53310_n1540# 0.19fF
C12996 divbuf_1/a_51870_n840# divbuf_1/a_52350_n840# 0.07fF
C12997 divbuf_1/a_21630_n840# divbuf_1/a_21630_n1540# 0.01fF
C12998 divbuf_1/a_51840_n1600# divbuf_1/a_51870_n1540# 0.19fF
C12999 divbuf_5/a_40830_n840# divbuf_5/a_41310_n840# 0.07fF
C13000 divbuf_5/a_10590_n840# divbuf_5/a_10590_n1540# 0.01fF
C13001 divbuf_5/a_40800_n1600# divbuf_5/a_40830_n1540# 0.19fF
C13002 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/clk 0.51fF
C13003 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51390_n840# 0.04fF
C13004 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C13005 divbuf_2/a_492_n240# divbuf_2/a_960_n1600# 0.00fF
C13006 divbuf_2/a_1352_n240# divbuf_2/a_1842_n240# 0.04fF
C13007 divbuf_2/a_22472_170# divbuf_2/a_22472_n240# 0.01fF
C13008 divbuf_4/a_14880_n1600# divbuf_4/a_14910_n840# 0.04fF
C13009 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C13010 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_7302_170# 0.07fF
C13011 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_54750_n840# 0.04fF
C13012 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C13013 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_14910_n840# 0.02fF
C13014 divbuf_0/a_36000_n1600# divbuf_0/a_36480_n1600# 0.26fF
C13015 divbuf_0/a_26832_n240# divbuf_0/a_26910_n840# 0.04fF
C13016 divbuf_2/a_14430_n840# divbuf_2/a_14910_n840# 0.07fF
C13017 divbuf_2/a_6332_n240# divbuf_2/OUT3 0.04fF
C13018 divbuf_2/a_14400_n1600# divbuf_2/a_14430_n1540# 0.19fF
C13019 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28800_n1600# 0.26fF
C13020 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/a_19230_n840# 0.02fF
C13021 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C13022 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/a_16642_170# 0.07fF
C13023 ro_div_0/ro_complete_0/cbank_2/switch_4/vin ro_div_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C13024 divbuf_0/a_28350_n1540# divbuf_0/a_28830_n1540# 0.11fF
C13025 divbuf_0/a_59070_n840# divbuf_0/a_59070_n1540# 0.01fF
C13026 divbuf_3/a_3422_170# divbuf_3/a_3912_170# 0.07fF
C13027 pll_full_0/divbuf_0/a_20670_n1540# pll_full_0/divbuf_0/a_21150_n1540# 0.11fF
C13028 pll_full_0/divbuf_0/a_51390_n840# pll_full_0/divbuf_0/a_51390_n1540# 0.01fF
C13029 divbuf_3/a_35562_170# divbuf_3/OUT4 0.19fF
C13030 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/a_29742_n240# 0.05fF
C13031 divbuf_3/a_28292_n240# divbuf_3/a_28350_n840# 0.04fF
C13032 divbuf_3/a_37440_n1600# divbuf_3/a_37920_n1600# 0.26fF
C13033 divbuf_4/a_31682_170# divbuf_4/a_32172_170# 0.07fF
C13034 divbuf_4/a_12282_170# divbuf_4/a_12282_n240# 0.01fF
C13035 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/a_33142_n240# 0.04fF
C13036 pd_div_0/divbuf_0/a_40830_n840# pd_div_0/divbuf_0/a_41310_n840# 0.07fF
C13037 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/a_10590_n1540# 0.01fF
C13038 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_40830_n1540# 0.19fF
C13039 divbuf_4/a_4350_n840# divbuf_4/a_4830_n840# 0.07fF
C13040 divbuf_4/a_4320_n1600# divbuf_4/a_4350_n1540# 0.19fF
C13041 divbuf_4/a_25382_170# divbuf_4/OUT4 0.19fF
C13042 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C13043 pll_full_0/divbuf_1/a_13950_n840# pll_full_0/divbuf_1/a_13950_n1540# 0.01fF
C13044 pll_full_0/divbuf_1/a_44190_n840# pll_full_0/divbuf_1/a_44670_n840# 0.07fF
C13045 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44190_n1540# 0.19fF
C13046 divbuf_3/a_29790_n1540# divbuf_3/a_30270_n1540# 0.11fF
C13047 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n840# 0.04fF
C13048 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/and_0/A 0.26fF
C13049 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C13050 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 gnd 0.16fF
C13051 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C13052 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z1 0.01fF
C13053 divbuf_1/a_11802_170# divbuf_1/a_12282_170# 0.07fF
C13054 divbuf_4/a_57150_n1540# divbuf_4/a_57630_n1540# 0.11fF
C13055 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C13056 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/OUT3 0.19fF
C13057 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18270_n840# 0.04fF
C13058 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/a_16152_n240# 0.01fF
C13059 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/a_30750_n840# 0.05fF
C13060 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_40320_n1600# 0.26fF
C13061 divbuf_1/a_38400_n1600# divbuf_1/a_38880_n1600# 0.26fF
C13062 divbuf_1/a_29262_n240# divbuf_1/a_29310_n840# 0.04fF
C13063 divbuf_5/a_27360_n1600# divbuf_5/a_27840_n1600# 0.26fF
C13064 divbuf_5/a_18092_n240# divbuf_5/a_18270_n840# 0.02fF
C13065 divbuf_3/a_36532_n240# divbuf_3/OUT4 0.04fF
C13066 ro_div_0/divbuf_0/a_32190_n1540# ro_div_0/divbuf_0/a_32670_n1540# 0.11fF
C13067 divbuf_1/a_30750_n1540# divbuf_1/a_31230_n1540# 0.11fF
C13068 divbuf_5/a_50430_n840# divbuf_5/a_50430_n1540# 0.01fF
C13069 divbuf_5/a_19710_n1540# divbuf_5/a_20190_n1540# 0.11fF
C13070 divbuf_3/a_27360_n1600# divbuf_3/a_27390_n840# 0.04fF
C13071 divbuf_0/a_23442_170# divbuf_0/a_23442_n240# 0.01fF
C13072 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C13073 divbuf_2/a_960_n1600# divbuf_2/a_1440_n1600# 0.26fF
C13074 divbuf_4/a_26352_n240# divbuf_4/OUT4 0.04fF
C13075 divbuf_4/a_54720_n1600# divbuf_4/a_54750_n840# 0.04fF
C13076 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/a_35562_170# 0.07fF
C13077 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/OUT4 0.19fF
C13078 io_analog[10] gpio_analog[7] 2.28fF
C13079 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n1540# 0.19fF
C13080 divbuf_0/a_8272_n240# divbuf_0/OUT3 0.04fF
C13081 divbuf_0/a_15390_n840# divbuf_0/a_15870_n840# 0.07fF
C13082 divbuf_1/a_4882_170# divbuf_1/a_4882_n240# 0.01fF
C13083 divbuf_1/a_11802_170# divbuf_1/a_11802_n240# 0.01fF
C13084 divbuf_2/a_54240_n1600# divbuf_2/a_54270_n1540# 0.19fF
C13085 divbuf_2/a_54270_n840# divbuf_2/a_54750_n840# 0.07fF
C13086 divbuf_2/a_24030_n840# divbuf_2/a_24030_n1540# 0.01fF
C13087 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_7710_n1540# 0.19fF
C13088 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/OUT4 0.19fF
C13089 pll_full_0/divbuf_0/a_7710_n840# pll_full_0/divbuf_0/a_8190_n840# 0.07fF
C13090 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_16152_n240# 0.05fF
C13091 ro_div_0/divider_0/nor_0/Z1 gnd 0.01fF
C13092 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_29790_n840# 0.04fF
C13093 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z2 0.25fF
C13094 divbuf_1/a_28320_n1600# divbuf_1/a_28350_n840# 0.04fF
C13095 divbuf_5/a_17280_n1600# divbuf_5/a_17310_n840# 0.04fF
C13096 divbuf_3/a_4392_n240# divbuf_3/a_4882_n240# 0.04fF
C13097 divbuf_3/a_24892_170# divbuf_3/a_24892_n240# 0.01fF
C13098 pll_full_0/divbuf_0/a_60510_n1540# pll_full_0/divbuf_0/a_60990_n1540# 0.11fF
C13099 divbuf_3/a_34560_n1600# divbuf_3/OUT4 0.01fF
C13100 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27840_n1600# 0.26fF
C13101 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_18270_n840# 0.02fF
C13102 divbuf_4/a_32652_n240# divbuf_4/a_33142_n240# 0.04fF
C13103 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/a_21630_n840# 0.03fF
C13104 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_31200_n1600# 0.26fF
C13105 divbuf_3/a_16830_n840# divbuf_3/a_17310_n840# 0.07fF
C13106 divbuf_3/a_16800_n1600# divbuf_3/a_16830_n1540# 0.19fF
C13107 pd_div_0/divbuf_0/a_50430_n840# pd_div_0/divbuf_0/a_50430_n1540# 0.01fF
C13108 pd_div_0/divbuf_0/a_19710_n1540# pd_div_0/divbuf_0/a_20190_n1540# 0.11fF
C13109 divbuf_2/a_11802_n240# divbuf_2/a_11550_n840# 0.02fF
C13110 divbuf_4/a_44160_n1600# divbuf_4/a_44190_n1540# 0.19fF
C13111 divbuf_4/a_44190_n840# divbuf_4/a_44670_n840# 0.07fF
C13112 divbuf_4/a_13950_n840# divbuf_4/a_13950_n1540# 0.01fF
C13113 divbuf_4/a_24480_n1600# divbuf_4/OUT4 0.00fF
C13114 pll_full_0/divbuf_1/a_23070_n1540# pll_full_0/divbuf_1/a_23550_n1540# 0.11fF
C13115 pll_full_0/divbuf_1/a_53790_n840# pll_full_0/divbuf_1/a_53790_n1540# 0.01fF
C13116 divbuf_1/a_5362_n240# divbuf_1/a_5852_n240# 0.04fF
C13117 divbuf_5/a_14702_170# divbuf_5/a_14702_n240# 0.01fF
C13118 divbuf_5/a_34112_170# divbuf_5/a_34592_170# 0.07fF
C13119 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58110_n840# 0.04fF
C13120 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C13121 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C13122 ro_div_0/divbuf_0/a_19230_n840# ro_div_0/divbuf_0/a_19710_n840# 0.07fF
C13123 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19230_n1540# 0.19fF
C13124 ro_div_0/divider_0/tspc_0/Z3 gnd 0.27fF
C13125 divbuf_1/a_17790_n840# divbuf_1/a_18270_n840# 0.07fF
C13126 divbuf_1/a_13252_n240# divbuf_1/OUT4 0.04fF
C13127 divbuf_1/a_17760_n1600# divbuf_1/a_17790_n1540# 0.19fF
C13128 divbuf_5/a_30232_170# divbuf_5/OUT4 0.19fF
C13129 divbuf_5/a_6750_n840# divbuf_5/a_7230_n840# 0.07fF
C13130 divbuf_5/a_6720_n1600# divbuf_5/a_6750_n1540# 0.19fF
C13131 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17310_n840# 0.04fF
C13132 divbuf_2/a_6822_170# divbuf_2/a_7302_170# 0.07fF
C13133 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_20670_n840# 0.04fF
C13134 divbuf_5/a_59550_n1540# divbuf_5/a_60030_n1540# 0.11fF
C13135 divbuf_0/a_1920_n1600# divbuf_0/a_2400_n1600# 0.26fF
C13136 divbuf_2/a_40800_n1600# divbuf_2/a_41280_n1600# 0.26fF
C13137 divbuf_2/a_31682_n240# divbuf_2/a_31710_n840# 0.05fF
C13138 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/a_36532_n240# 0.05fF
C13139 divbuf_0/a_24990_n840# divbuf_0/a_24990_n1540# 0.01fF
C13140 divbuf_0/a_55230_n840# divbuf_0/a_55710_n840# 0.07fF
C13141 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n1540# 0.19fF
C13142 pll_full_0/divbuf_0/a_17310_n840# pll_full_0/divbuf_0/a_17310_n1540# 0.01fF
C13143 pll_full_0/divbuf_0/a_47550_n840# pll_full_0/divbuf_0/a_48030_n840# 0.07fF
C13144 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_47550_n1540# 0.19fF
C13145 divbuf_2/a_33150_n1540# divbuf_2/a_33630_n1540# 0.11fF
C13146 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C13147 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/a_34592_170# 0.07fF
C13148 divbuf_1/a_11520_n1600# divbuf_1/OUT4 0.01fF
C13149 divbuf_3/a_60510_n1540# divbuf_3/a_60990_n1540# 0.11fF
C13150 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/a_37992_170# 0.07fF
C13151 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/a_18092_n240# 0.01fF
C13152 divbuf_3/a_3360_n1600# divbuf_3/a_3840_n1600# 0.26fF
C13153 divbuf_5/a_31202_n240# divbuf_5/OUT4 0.04fF
C13154 divbuf_5/a_57120_n1600# divbuf_5/a_57150_n840# 0.04fF
C13155 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C13156 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C13157 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/OUT4 0.19fF
C13158 pd_div_0/divbuf_0/a_6750_n840# pd_div_0/divbuf_0/a_7230_n840# 0.07fF
C13159 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_6750_n1540# 0.19fF
C13160 divbuf_4/a_30720_n1600# divbuf_4/a_31200_n1600# 0.26fF
C13161 divbuf_4/a_21502_n240# divbuf_4/a_21630_n840# 0.03fF
C13162 pll_full_0/divbuf_1/a_10110_n840# pll_full_0/divbuf_1/a_10590_n840# 0.07fF
C13163 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/OUT4 0.19fF
C13164 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10110_n1540# 0.19fF
C13165 divbuf_3/a_56670_n840# divbuf_3/a_57150_n840# 0.07fF
C13166 divbuf_3/a_26430_n840# divbuf_3/a_26430_n1540# 0.01fF
C13167 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C13168 divbuf_0/a_12772_n240# divbuf_0/a_12510_n840# 0.01fF
C13169 pd_div_0/divbuf_0/a_59550_n1540# pd_div_0/divbuf_0/a_60030_n1540# 0.11fF
C13170 divbuf_4/a_53790_n840# divbuf_4/a_53790_n1540# 0.01fF
C13171 divbuf_4/a_23070_n1540# divbuf_4/a_23550_n1540# 0.11fF
C13172 divbuf_2/a_30720_n1600# divbuf_2/a_30750_n840# 0.04fF
C13173 divbuf_2/a_17122_170# divbuf_2/OUT4 0.19fF
C13174 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 0.36fF
C13175 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C13176 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C13177 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_6240_n1600# 0.26fF
C13178 divbuf_1/a_4320_n1600# divbuf_1/a_4800_n1600# 0.26fF
C13179 divbuf_5/a_35082_n240# divbuf_5/a_35562_n240# 0.05fF
C13180 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/OUT4 0.03fF
C13181 divbuf_3/a_6822_170# divbuf_3/OUT3 0.19fF
C13182 ro_div_0/divbuf_0/a_28830_n840# ro_div_0/divbuf_0/a_28830_n1540# 0.01fF
C13183 ro_div_0/divbuf_0/a_59070_n840# ro_div_0/divbuf_0/a_59550_n840# 0.07fF
C13184 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59070_n1540# 0.19fF
C13185 divbuf_1/a_57600_n1600# divbuf_1/a_57630_n1540# 0.19fF
C13186 divbuf_1/a_57630_n840# divbuf_1/a_58110_n840# 0.07fF
C13187 divbuf_1/a_27390_n840# divbuf_1/a_27390_n1540# 0.01fF
C13188 divbuf_3/a_14222_n240# divbuf_3/a_13950_n840# 0.01fF
C13189 divbuf_5/a_46560_n1600# divbuf_5/a_46590_n1540# 0.19fF
C13190 divbuf_5/a_46590_n840# divbuf_5/a_47070_n840# 0.07fF
C13191 divbuf_5/a_16350_n840# divbuf_5/a_16350_n1540# 0.01fF
C13192 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C13193 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57150_n840# 0.04fF
C13194 divbuf_4/a_20640_n1600# divbuf_4/a_20670_n840# 0.04fF
C13195 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/a_13742_170# 0.07fF
C13196 divbuf_2/a_28292_170# divbuf_2/a_28292_n240# 0.01fF
C13197 divbuf_2/a_7792_n240# divbuf_2/a_8272_n240# 0.05fF
C13198 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C13199 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/a_60510_n840# 0.04fF
C13200 divbuf_0/a_32652_n240# divbuf_0/a_32670_n840# 0.06fF
C13201 divbuf_0/a_41760_n1600# divbuf_0/a_42240_n1600# 0.26fF
C13202 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34560_n1600# 0.26fF
C13203 divbuf_2/a_20160_n1600# divbuf_2/a_20190_n1540# 0.19fF
C13204 divbuf_2/a_20190_n840# divbuf_2/a_20670_n840# 0.07fF
C13205 divbuf_2/a_18092_n240# divbuf_2/OUT4 0.04fF
C13206 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/a_24990_n840# 0.03fF
C13207 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C13208 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C13209 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/a_21012_170# 0.07fF
C13210 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_4882_n240# 0.01fF
C13211 divbuf_0/a_34110_n1540# divbuf_0/a_34590_n1540# 0.11fF
C13212 divbuf_1/a_15182_n240# divbuf_1/a_14910_n840# 0.01fF
C13213 divbuf_3/a_9242_170# divbuf_3/a_9732_170# 0.07fF
C13214 pll_full_0/divbuf_0/a_57150_n840# pll_full_0/divbuf_0/a_57150_n1540# 0.01fF
C13215 pll_full_0/divbuf_0/a_26430_n1540# pll_full_0/divbuf_0/a_26910_n1540# 0.11fF
C13216 divbuf_3/a_7792_n240# divbuf_3/OUT3 0.04fF
C13217 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/a_35562_n240# 0.05fF
C13218 divbuf_4/a_18092_170# divbuf_4/a_18092_n240# 0.01fF
C13219 divbuf_4/a_37502_170# divbuf_4/a_37992_170# 0.07fF
C13220 divbuf_3/a_43200_n1600# divbuf_3/a_43680_n1600# 0.26fF
C13221 divbuf_3/a_34112_n240# divbuf_3/a_34110_n840# 0.06fF
C13222 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/a_38962_n240# 0.04fF
C13223 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_46590_n1540# 0.19fF
C13224 pd_div_0/divbuf_0/a_46590_n840# pd_div_0/divbuf_0/a_47070_n840# 0.07fF
C13225 pd_div_0/divbuf_0/a_16350_n840# pd_div_0/divbuf_0/a_16350_n1540# 0.01fF
C13226 divbuf_3/a_35550_n1540# divbuf_3/a_36030_n1540# 0.11fF
C13227 divbuf_4/a_10080_n1600# divbuf_4/a_10110_n1540# 0.19fF
C13228 divbuf_4/a_37022_170# divbuf_4/OUT4 0.19fF
C13229 divbuf_4/a_10110_n840# divbuf_4/a_10590_n840# 0.07fF
C13230 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_49950_n1540# 0.19fF
C13231 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C13232 pll_full_0/divbuf_1/a_19710_n840# pll_full_0/divbuf_1/a_19710_n1540# 0.01fF
C13233 pll_full_0/divbuf_1/a_49950_n840# pll_full_0/divbuf_1/a_50430_n840# 0.07fF
C13234 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n840# 0.04fF
C13235 divbuf_0/a_16642_170# divbuf_0/OUT4 0.19fF
C13236 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24030_n840# 0.04fF
C13237 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/and_0/B 0.08fF
C13238 divbuf_1/a_12282_170# divbuf_1/a_12772_170# 0.07fF
C13239 divbuf_4/OUT2 divbuf_4/OUT3 0.36fF
C13240 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C13241 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divbuf_0/IN 0.05fF
C13242 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_46080_n1600# 0.26fF
C13243 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/a_36510_n840# 0.05fF
C13244 divbuf_1/a_44160_n1600# divbuf_1/a_44640_n1600# 0.26fF
C13245 divbuf_1/a_35082_n240# divbuf_1/a_35070_n840# 0.05fF
C13246 divbuf_5/a_33120_n1600# divbuf_5/a_33600_n1600# 0.26fF
C13247 divbuf_5/a_23922_n240# divbuf_5/a_24030_n840# 0.03fF
C13248 ro_div_0/divbuf_0/a_37950_n1540# ro_div_0/divbuf_0/a_38430_n1540# 0.11fF
C13249 divbuf_1/a_36510_n1540# divbuf_1/a_36990_n1540# 0.11fF
C13250 divbuf_3/a_33120_n1600# divbuf_3/a_33150_n840# 0.04fF
C13251 divbuf_5/a_56190_n840# divbuf_5/a_56190_n1540# 0.01fF
C13252 divbuf_5/a_25470_n1540# divbuf_5/a_25950_n1540# 0.11fF
C13253 divbuf_0/a_8762_n240# divbuf_0/a_9242_n240# 0.05fF
C13254 divbuf_0/a_29262_170# divbuf_0/a_29262_n240# 0.01fF
C13255 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/a_21502_n240# 0.01fF
C13256 divbuf_2/a_6720_n1600# divbuf_2/a_7200_n1600# 0.26fF
C13257 divbuf_4/a_60480_n1600# divbuf_4/a_60510_n840# 0.04fF
C13258 divbuf_4/a_37992_n240# divbuf_4/OUT4 0.04fF
C13259 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/a_41382_170# 0.07fF
C13260 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/OUT4 0.19fF
C13261 divbuf_0/a_20042_n240# divbuf_0/OUT4 0.04fF
C13262 divbuf_0/a_21150_n840# divbuf_0/a_21630_n840# 0.07fF
C13263 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n1540# 0.19fF
C13264 divbuf_1/a_12282_170# divbuf_1/a_12282_n240# 0.01fF
C13265 divbuf_2/a_60030_n840# divbuf_2/a_60510_n840# 0.07fF
C13266 divbuf_2/a_29790_n840# divbuf_2/a_29790_n1540# 0.01fF
C13267 divbuf_2/a_60000_n1600# divbuf_2/a_60030_n1540# 0.19fF
C13268 pll_full_0/divbuf_0/a_13470_n840# pll_full_0/divbuf_0/a_13950_n840# 0.07fF
C13269 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C13270 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13470_n1540# 0.19fF
C13271 ro_div_0/divider_0/nor_1/B gnd 1.17fF
C13272 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_35550_n840# 0.04fF
C13273 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z3 0.65fF
C13274 divbuf_1/a_20532_170# divbuf_1/OUT4 0.19fF
C13275 divbuf_1/a_34080_n1600# divbuf_1/a_34110_n840# 0.04fF
C13276 divbuf_3/a_30712_170# divbuf_3/a_30712_n240# 0.01fF
C13277 divbuf_5/a_1352_170# divbuf_5/OUT2 0.23fF
C13278 divbuf_5/a_23040_n1600# divbuf_5/a_23070_n840# 0.04fF
C13279 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/a_2322_170# 0.07fF
C13280 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33600_n1600# 0.26fF
C13281 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/a_24030_n840# 0.03fF
C13282 divbuf_4/a_38472_n240# divbuf_4/a_38962_n240# 0.04fF
C13283 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36960_n1600# 0.26fF
C13284 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/a_27390_n840# 0.04fF
C13285 divbuf_3/a_22560_n1600# divbuf_3/a_22590_n1540# 0.19fF
C13286 divbuf_3/a_22590_n840# divbuf_3/a_23070_n840# 0.07fF
C13287 pd_div_0/divbuf_0/a_56190_n840# pd_div_0/divbuf_0/a_56190_n1540# 0.01fF
C13288 pd_div_0/divbuf_0/a_25470_n1540# pd_div_0/divbuf_0/a_25950_n1540# 0.11fF
C13289 divbuf_2/a_17612_n240# divbuf_2/a_17310_n840# 0.00fF
C13290 divbuf_4/a_49950_n840# divbuf_4/a_50430_n840# 0.07fF
C13291 divbuf_4/a_19710_n840# divbuf_4/a_19710_n1540# 0.01fF
C13292 divbuf_4/a_36000_n1600# divbuf_4/OUT4 0.00fF
C13293 divbuf_4/a_49920_n1600# divbuf_4/a_49950_n1540# 0.19fF
C13294 pll_full_0/divbuf_1/a_28830_n1540# pll_full_0/divbuf_1/a_29310_n1540# 0.11fF
C13295 pll_full_0/divbuf_1/a_59550_n840# pll_full_0/divbuf_1/a_59550_n1540# 0.01fF
C13296 divbuf_1/a_11802_n240# divbuf_1/a_12282_n240# 0.05fF
C13297 divbuf_5/a_39932_170# divbuf_5/a_40412_170# 0.07fF
C13298 divbuf_5/a_20532_170# divbuf_5/a_20532_n240# 0.01fF
C13299 ro_div_0/divbuf_0/a_24990_n840# ro_div_0/divbuf_0/a_25470_n840# 0.07fF
C13300 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_24990_n1540# 0.19fF
C13301 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C13302 divbuf_1/a_23520_n1600# divbuf_1/a_23550_n1540# 0.19fF
C13303 divbuf_1/a_23550_n840# divbuf_1/a_24030_n840# 0.07fF
C13304 divbuf_1/a_24892_n240# divbuf_1/OUT4 0.04fF
C13305 divbuf_5/a_41382_170# divbuf_5/OUT5 0.07fF
C13306 divbuf_5/a_2322_n240# divbuf_5/OUT2 0.04fF
C13307 divbuf_5/a_12480_n1600# divbuf_5/a_12510_n1540# 0.19fF
C13308 divbuf_5/a_12510_n840# divbuf_5/a_12990_n840# 0.07fF
C13309 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23070_n840# 0.04fF
C13310 divbuf_2/a_13252_170# divbuf_2/a_13742_170# 0.07fF
C13311 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/OUT3 0.19fF
C13312 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26430_n840# 0.04fF
C13313 divbuf_0/a_7680_n1600# divbuf_0/a_8160_n1600# 0.26fF
C13314 divbuf_2/a_37502_n240# divbuf_2/a_37470_n840# 0.05fF
C13315 divbuf_2/a_46560_n1600# divbuf_2/a_47040_n1600# 0.26fF
C13316 pll_full_0/divbuf_0/a_0_n1600# pll_full_0/divbuf_0/a_480_n1600# 0.26fF
C13317 divbuf_0/a_30750_n840# divbuf_0/a_30750_n1540# 0.01fF
C13318 divbuf_2/a_38910_n1540# divbuf_2/a_39390_n1540# 0.11fF
C13319 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53310_n1540# 0.19fF
C13320 pll_full_0/divbuf_0/a_53310_n840# pll_full_0/divbuf_0/a_53790_n840# 0.07fF
C13321 pll_full_0/divbuf_0/a_23070_n840# pll_full_0/divbuf_0/a_23070_n1540# 0.01fF
C13322 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/a_40412_170# 0.07fF
C13323 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/a_20532_n240# 0.01fF
C13324 divbuf_1/a_23040_n1600# divbuf_1/OUT4 0.01fF
C13325 divbuf_4/a_1842_170# divbuf_4/a_2322_170# 0.07fF
C13326 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/a_23922_n240# 0.01fF
C13327 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/a_3912_n240# 0.04fF
C13328 divbuf_3/a_9120_n1600# divbuf_3/a_9600_n1600# 0.26fF
C13329 divbuf_5/a_1920_n1600# divbuf_5/OUT2 0.00fF
C13330 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C13331 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/clk 0.11fF
C13332 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/Out 0.05fF
C13333 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/OUT5 0.07fF
C13334 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/OUT2 0.04fF
C13335 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12510_n1540# 0.19fF
C13336 pd_div_0/divbuf_0/a_12510_n840# pd_div_0/divbuf_0/a_12990_n840# 0.07fF
C13337 divbuf_4/a_27322_n240# divbuf_4/a_27390_n840# 0.04fF
C13338 divbuf_4/a_36480_n1600# divbuf_4/a_36960_n1600# 0.26fF
C13339 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_15870_n1540# 0.19fF
C13340 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C13341 pll_full_0/divbuf_1/a_15870_n840# pll_full_0/divbuf_1/a_16350_n840# 0.07fF
C13342 divbuf_3/a_32190_n840# divbuf_3/a_32190_n1540# 0.01fF
C13343 divbuf_3/a_1470_n1540# divbuf_3/a_1950_n1540# 0.11fF
C13344 divbuf_1/a_16642_170# divbuf_1/a_17122_170# 0.07fF
C13345 divbuf_4/a_59550_n840# divbuf_4/a_59550_n1540# 0.01fF
C13346 divbuf_4/a_28830_n1540# divbuf_4/a_29310_n1540# 0.11fF
C13347 divbuf_2/a_36480_n1600# divbuf_2/a_36510_n840# 0.04fF
C13348 divbuf_2/a_28772_170# divbuf_2/OUT4 0.19fF
C13349 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C13350 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_12000_n1600# 0.26fF
C13351 divbuf_1/a_10080_n1600# divbuf_1/a_10560_n1600# 0.26fF
C13352 divbuf_5/a_40902_n240# divbuf_5/a_41382_n240# 0.05fF
C13353 divbuf_3/a_18582_170# divbuf_3/OUT4 0.19fF
C13354 ro_div_0/divbuf_0/a_3870_n1540# ro_div_0/divbuf_0/a_4350_n1540# 0.11fF
C13355 ro_div_0/divbuf_0/a_34590_n840# ro_div_0/divbuf_0/a_34590_n1540# 0.01fF
C13356 divbuf_1/a_2910_n840# divbuf_1/OUT3 0.03fF
C13357 divbuf_1/a_33150_n840# divbuf_1/a_33150_n1540# 0.01fF
C13358 divbuf_1/a_2430_n1540# divbuf_1/a_2910_n1540# 0.11fF
C13359 divbuf_5/a_52320_n1600# divbuf_5/a_52350_n1540# 0.19fF
C13360 divbuf_5/a_52350_n840# divbuf_5/a_52830_n840# 0.07fF
C13361 divbuf_5/a_22110_n840# divbuf_5/a_22110_n1540# 0.01fF
C13362 pd_0/DOWN divbuf_2/a_480_n1600# 0.00fF
C13363 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C13364 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C13365 divbuf_4/a_26400_n1600# divbuf_4/a_26430_n840# 0.04fF
C13366 divbuf_4/a_8272_170# divbuf_4/OUT3 0.19fF
C13367 divbuf_2/a_14222_n240# divbuf_2/a_14702_n240# 0.05fF
C13368 divbuf_2/a_34112_170# divbuf_2/a_34112_n240# 0.01fF
C13369 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C13370 divbuf_0/a_47520_n1600# divbuf_0/a_48000_n1600# 0.26fF
C13371 divbuf_0/a_38472_n240# divbuf_0/a_38430_n840# 0.04fF
C13372 divbuf_0/a_3912_170# divbuf_0/OUT3 0.19fF
C13373 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C13374 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C13375 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C13376 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z4 0.00fF
C13377 divbuf_2/a_25950_n840# divbuf_2/a_26430_n840# 0.07fF
C13378 divbuf_2/a_29742_n240# divbuf_2/OUT4 0.04fF
C13379 divbuf_2/a_25920_n1600# divbuf_2/a_25950_n1540# 0.19fF
C13380 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_40320_n1600# 0.26fF
C13381 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/a_30750_n840# 0.05fF
C13382 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/a_13252_n240# 0.01fF
C13383 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/a_26832_170# 0.07fF
C13384 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1470_n840# 0.04fF
C13385 divbuf_0/a_39870_n1540# divbuf_0/a_40350_n1540# 0.11fF
C13386 pll_full_0/divbuf_0/a_32190_n1540# pll_full_0/divbuf_0/a_32670_n1540# 0.11fF
C13387 divbuf_3/a_15672_170# divbuf_3/a_16152_170# 0.07fF
C13388 divbuf_3/a_19562_n240# divbuf_3/OUT4 0.04fF
C13389 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/a_41382_n240# 0.05fF
C13390 divbuf_4/a_3422_n240# divbuf_4/a_3912_n240# 0.04fF
C13391 divbuf_4/a_23922_170# divbuf_4/a_23922_n240# 0.01fF
C13392 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2880_n1600# 0.26fF
C13393 divbuf_1/a_41790_n840# divbuf_1/OUT5 0.03fF
C13394 divbuf_3/a_39932_n240# divbuf_3/a_39870_n840# 0.04fF
C13395 divbuf_3/a_48960_n1600# divbuf_3/a_49440_n1600# 0.26fF
C13396 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52350_n1540# 0.19fF
C13397 pd_div_0/divbuf_0/a_52350_n840# pd_div_0/divbuf_0/a_52830_n840# 0.07fF
C13398 pd_div_0/divbuf_0/a_22110_n840# pd_div_0/divbuf_0/a_22110_n1540# 0.01fF
C13399 divbuf_4/a_15870_n840# divbuf_4/a_16350_n840# 0.07fF
C13400 divbuf_4/a_9242_n240# divbuf_4/OUT3 0.04fF
C13401 divbuf_4/a_15840_n1600# divbuf_4/a_15870_n1540# 0.19fF
C13402 divbuf_3/a_41310_n1540# divbuf_3/a_41790_n1540# 0.11fF
C13403 pll_full_0/divbuf_1/a_25470_n840# pll_full_0/divbuf_1/a_25470_n1540# 0.01fF
C13404 pll_full_0/divbuf_1/a_55710_n840# pll_full_0/divbuf_1/a_56190_n840# 0.07fF
C13405 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_55710_n1540# 0.19fF
C13406 divbuf_0/a_30712_170# divbuf_0/OUT4 0.19fF
C13407 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n840# 0.04fF
C13408 divbuf_1/a_7302_170# divbuf_1/a_7302_n240# 0.01fF
C13409 divbuf_5/a_4882_170# divbuf_5/a_5362_170# 0.07fF
C13410 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_29790_n840# 0.04fF
C13411 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/OUT4 0.19fF
C13412 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C13413 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51840_n1600# 0.26fF
C13414 divbuf_1/a_49920_n1600# divbuf_1/a_50400_n1600# 0.26fF
C13415 divbuf_1/a_40902_n240# divbuf_1/a_40830_n840# 0.03fF
C13416 divbuf_5/a_38880_n1600# divbuf_5/a_39360_n1600# 0.26fF
C13417 divbuf_5/a_29742_n240# divbuf_5/a_29790_n840# 0.04fF
C13418 ro_div_0/divbuf_0/a_43710_n1540# ro_div_0/divbuf_0/a_44190_n1540# 0.11fF
C13419 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/a_22952_n240# 0.01fF
C13420 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_960_n1600# 0.00fF
C13421 divbuf_1/a_42270_n1540# divbuf_1/a_42750_n1540# 0.11fF
C13422 divbuf_3/a_38880_n1600# divbuf_3/a_38910_n840# 0.04fF
C13423 divbuf_5/a_31230_n1540# divbuf_5/a_31710_n1540# 0.11fF
C13424 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_12990_n840# 0.01fF
C13425 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/OUT4 0.23fF
C13426 divbuf_0/a_35082_170# divbuf_0/a_35082_n240# 0.01fF
C13427 divbuf_0/a_15182_n240# divbuf_0/a_15672_n240# 0.04fF
C13428 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/a_7302_n240# 0.05fF
C13429 divbuf_2/a_12480_n1600# divbuf_2/a_12960_n1600# 0.26fF
C13430 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/a_27322_n240# 0.01fF
C13431 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C13432 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n1540# 0.19fF
C13433 divbuf_0/a_31682_n240# divbuf_0/OUT4 0.04fF
C13434 divbuf_0/a_26910_n840# divbuf_0/a_27390_n840# 0.07fF
C13435 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C13436 divbuf_2/a_35550_n840# divbuf_2/a_35550_n1540# 0.01fF
C13437 divbuf_2/a_4830_n1540# divbuf_2/a_5310_n1540# 0.11fF
C13438 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19230_n1540# 0.19fF
C13439 pll_full_0/divbuf_0/a_19230_n840# pll_full_0/divbuf_0/a_19710_n840# 0.07fF
C13440 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.44fF
C13441 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41310_n840# 0.04fF
C13442 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_13252_170# 0.07fF
C13443 divbuf_1/a_39840_n1600# divbuf_1/a_39870_n840# 0.04fF
C13444 divbuf_1/a_35562_170# divbuf_1/OUT4 0.19fF
C13445 divbuf_3/a_16642_n240# divbuf_3/a_17122_n240# 0.05fF
C13446 divbuf_3/a_36532_170# divbuf_3/a_36532_n240# 0.01fF
C13447 divbuf_5/a_28800_n1600# divbuf_5/a_28830_n840# 0.04fF
C13448 divbuf_5/a_13252_170# divbuf_5/OUT4 0.19fF
C13449 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/a_8762_170# 0.07fF
C13450 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_39360_n1600# 0.26fF
C13451 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/a_29790_n840# 0.04fF
C13452 divbuf_3/a_28350_n840# divbuf_3/a_28830_n840# 0.07fF
C13453 divbuf_3/a_28320_n1600# divbuf_3/a_28350_n1540# 0.19fF
C13454 divbuf_4/a_2400_n1600# divbuf_4/a_2880_n1600# 0.26fF
C13455 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/a_33150_n840# 0.06fF
C13456 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42720_n1600# 0.26fF
C13457 pd_div_0/divbuf_0/a_31230_n1540# pd_div_0/divbuf_0/a_31710_n1540# 0.11fF
C13458 divbuf_2/a_2400_n1600# divbuf_2/a_2430_n840# 0.04fF
C13459 divbuf_4/a_55680_n1600# divbuf_4/a_55710_n1540# 0.19fF
C13460 divbuf_4/a_55710_n840# divbuf_4/a_56190_n840# 0.07fF
C13461 divbuf_4/a_25470_n840# divbuf_4/a_25470_n1540# 0.01fF
C13462 pll_full_0/divbuf_1/a_34590_n1540# pll_full_0/divbuf_1/a_35070_n1540# 0.11fF
C13463 divbuf_1/a_37502_170# divbuf_1/a_37502_n240# 0.01fF
C13464 divbuf_1/a_17612_n240# divbuf_1/a_18092_n240# 0.05fF
C13465 divbuf_5/a_26352_170# divbuf_5/a_26352_n240# 0.01fF
C13466 divbuf_5/a_5852_n240# divbuf_5/a_6332_n240# 0.05fF
C13467 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C13468 ro_div_0/divbuf_0/a_30750_n840# ro_div_0/divbuf_0/a_31230_n840# 0.07fF
C13469 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/a_510_n1540# 0.01fF
C13470 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_30750_n1540# 0.19fF
C13471 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/a_3422_n240# 0.01fF
C13472 divbuf_1/a_29310_n840# divbuf_1/a_29790_n840# 0.07fF
C13473 divbuf_1/a_36532_n240# divbuf_1/OUT4 0.04fF
C13474 divbuf_1/a_29280_n1600# divbuf_1/a_29310_n1540# 0.19fF
C13475 divbuf_5/a_18270_n840# divbuf_5/a_18750_n840# 0.07fF
C13476 divbuf_5/a_14222_n240# divbuf_5/OUT4 0.04fF
C13477 divbuf_5/a_18240_n1600# divbuf_5/a_18270_n1540# 0.19fF
C13478 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C13479 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/OUT4 0.07fF
C13480 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_28830_n840# 0.04fF
C13481 divbuf_2/a_19072_170# divbuf_2/a_19562_170# 0.07fF
C13482 divbuf_4/a_13252_n240# divbuf_4/a_12990_n840# 0.01fF
C13483 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/OUT4 0.19fF
C13484 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32190_n840# 0.04fF
C13485 divbuf_0/a_13440_n1600# divbuf_0/a_13920_n1600# 0.26fF
C13486 divbuf_0/a_3912_n240# divbuf_0/a_3870_n840# 0.04fF
C13487 divbuf_2/a_52320_n1600# divbuf_2/a_52800_n1600# 0.26fF
C13488 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_6240_n1600# 0.26fF
C13489 divbuf_0/a_5790_n1540# divbuf_0/a_6270_n1540# 0.11fF
C13490 divbuf_0/a_36510_n840# divbuf_0/a_36510_n1540# 0.01fF
C13491 divbuf_2/a_44670_n1540# divbuf_2/a_45150_n1540# 0.11fF
C13492 pll_full_0/divbuf_0/a_28830_n840# pll_full_0/divbuf_0/a_28830_n1540# 0.01fF
C13493 pll_full_0/divbuf_0/a_59070_n840# pll_full_0/divbuf_0/a_59550_n840# 0.07fF
C13494 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59070_n1540# 0.19fF
C13495 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/a_26352_n240# 0.01fF
C13496 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/a_6332_n240# 0.05fF
C13497 divbuf_1/a_34560_n1600# divbuf_1/OUT4 0.01fF
C13498 divbuf_4/a_8272_170# divbuf_4/a_8762_170# 0.07fF
C13499 divbuf_5/a_12480_n1600# divbuf_5/OUT4 0.00fF
C13500 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/a_9732_n240# 0.04fF
C13501 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/a_29742_n240# 0.01fF
C13502 divbuf_3/a_5362_n240# divbuf_3/a_5310_n840# 0.04fF
C13503 divbuf_3/a_14880_n1600# divbuf_3/a_15360_n1600# 0.26fF
C13504 pd_div_0/divbuf_0/a_18270_n840# pd_div_0/divbuf_0/a_18750_n840# 0.07fF
C13505 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C13506 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18270_n1540# 0.19fF
C13507 divbuf_4/a_42240_n1600# divbuf_4/a_42720_n1600# 0.26fF
C13508 divbuf_4/a_33142_n240# divbuf_4/a_33150_n840# 0.06fF
C13509 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C13510 pll_full_0/divbuf_1/a_21630_n840# pll_full_0/divbuf_1/a_22110_n840# 0.07fF
C13511 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_21630_n1540# 0.19fF
C13512 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12030_n840# 0.02fF
C13513 divbuf_3/a_37950_n840# divbuf_3/a_37950_n1540# 0.01fF
C13514 divbuf_3/a_7230_n1540# divbuf_3/a_7710_n1540# 0.11fF
C13515 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C13516 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n840# 0.04fF
C13517 divbuf_1/a_1352_170# divbuf_1/OUT2 0.23fF
C13518 divbuf_2/a_42240_n1600# divbuf_2/a_42270_n840# 0.04fF
C13519 divbuf_2/a_40412_170# divbuf_2/OUT4 0.19fF
C13520 divbuf_4/a_34590_n1540# divbuf_4/a_35070_n1540# 0.11fF
C13521 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_16350_n840# 0.00fF
C13522 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17760_n1600# 0.26fF
C13523 divbuf_1/a_15840_n1600# divbuf_1/a_16320_n1600# 0.26fF
C13524 divbuf_1/a_6332_n240# divbuf_1/a_6270_n840# 0.04fF
C13525 divbuf_5/a_4800_n1600# divbuf_5/a_5280_n1600# 0.26fF
C13526 divbuf_3/a_30232_170# divbuf_3/OUT4 0.19fF
C13527 ro_div_0/divbuf_0/a_9630_n1540# ro_div_0/divbuf_0/a_10110_n1540# 0.11fF
C13528 ro_div_0/divbuf_0/a_40350_n840# ro_div_0/divbuf_0/a_40350_n1540# 0.01fF
C13529 divbuf_1/a_38910_n840# divbuf_1/a_38910_n1540# 0.01fF
C13530 divbuf_1/a_8190_n1540# divbuf_1/a_8670_n1540# 0.11fF
C13531 divbuf_3/a_4800_n1600# divbuf_3/a_4830_n840# 0.04fF
C13532 divbuf_5/a_58080_n1600# divbuf_5/a_58110_n1540# 0.19fF
C13533 divbuf_5/a_58110_n840# divbuf_5/a_58590_n840# 0.07fF
C13534 divbuf_5/a_27870_n840# divbuf_5/a_27870_n1540# 0.01fF
C13535 divbuf_0/a_20042_170# divbuf_0/a_20532_170# 0.07fF
C13536 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C13537 divbuf_2/a_39932_170# divbuf_2/a_39932_n240# 0.01fF
C13538 divbuf_2/a_20042_n240# divbuf_2/a_20532_n240# 0.04fF
C13539 divbuf_4/a_32160_n1600# divbuf_4/a_32190_n840# 0.04fF
C13540 divbuf_4/a_20042_170# divbuf_4/OUT4 0.19fF
C13541 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C13542 divbuf_0/a_53280_n1600# divbuf_0/a_53760_n1600# 0.26fF
C13543 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/and_0/OUT 0.06fF
C13544 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C13545 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C13546 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/Out 0.19fF
C13547 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_46080_n1600# 0.26fF
C13548 divbuf_2/a_31680_n1600# divbuf_2/a_31710_n1540# 0.19fF
C13549 divbuf_2/a_31710_n840# divbuf_2/a_32190_n840# 0.07fF
C13550 divbuf_2/a_1470_n840# divbuf_2/a_1470_n1540# 0.01fF
C13551 divbuf_2/a_41382_n240# divbuf_2/OUT4 0.04fF
C13552 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/a_36510_n840# 0.05fF
C13553 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/a_32652_170# 0.07fF
C13554 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7230_n840# 0.04fF
C13555 divbuf_0/a_45630_n1540# divbuf_0/a_46110_n1540# 0.11fF
C13556 divbuf_1/a_5760_n1600# divbuf_1/a_5790_n840# 0.04fF
C13557 divbuf_3/a_21502_170# divbuf_3/a_21982_170# 0.07fF
C13558 divbuf_5/a_15672_n240# divbuf_5/a_15390_n840# 0.01fF
C13559 pll_full_0/divbuf_0/a_37950_n1540# pll_full_0/divbuf_0/a_38430_n1540# 0.11fF
C13560 divbuf_3/a_31202_n240# divbuf_3/OUT4 0.04fF
C13561 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_5280_n1600# 0.26fF
C13562 divbuf_4/a_29742_170# divbuf_4/a_29742_n240# 0.01fF
C13563 divbuf_4/a_9242_n240# divbuf_4/a_9732_n240# 0.04fF
C13564 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8640_n1600# 0.26fF
C13565 divbuf_3/a_54720_n1600# divbuf_3/a_55200_n1600# 0.26fF
C13566 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C13567 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58110_n1540# 0.19fF
C13568 pd_div_0/divbuf_0/a_58110_n840# pd_div_0/divbuf_0/a_58590_n840# 0.07fF
C13569 pd_div_0/divbuf_0/a_27870_n840# pd_div_0/divbuf_0/a_27870_n1540# 0.01fF
C13570 divbuf_4/a_21600_n1600# divbuf_4/a_21630_n1540# 0.19fF
C13571 divbuf_4/a_21630_n840# divbuf_4/a_22110_n840# 0.07fF
C13572 divbuf_4/a_21012_n240# divbuf_4/OUT4 0.04fF
C13573 pll_full_0/divbuf_1/a_510_n1540# pll_full_0/divbuf_1/a_990_n1540# 0.11fF
C13574 pll_full_0/divbuf_1/a_31230_n840# pll_full_0/divbuf_1/a_31230_n1540# 0.01fF
C13575 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/OUT4 0.19fF
C13576 ro_div_0/divbuf_0/a_1842_170# ro_div_0/divbuf_0/OUT2 0.19fF
C13577 divbuf_3/a_47070_n1540# divbuf_3/a_47550_n1540# 0.11fF
C13578 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n840# 0.04fF
C13579 divbuf_0/a_2322_n240# divbuf_0/OUT3 0.04fF
C13580 divbuf_1/a_19072_170# divbuf_1/a_19562_170# 0.07fF
C13581 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/OUT4 0.19fF
C13582 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_35550_n840# 0.04fF
C13583 divbuf_5/a_11312_170# divbuf_5/a_11802_170# 0.07fF
C13584 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57600_n1600# 0.26fF
C13585 divbuf_1/a_55680_n1600# divbuf_1/a_56160_n1600# 0.26fF
C13586 divbuf_3/a_492_n240# divbuf_3/a_480_n1600# 0.00fF
C13587 divbuf_5/a_44640_n1600# divbuf_5/a_45120_n1600# 0.26fF
C13588 divbuf_5/a_35562_n240# divbuf_5/a_35550_n840# 0.05fF
C13589 ro_div_0/divbuf_0/a_49470_n1540# ro_div_0/divbuf_0/a_49950_n1540# 0.11fF
C13590 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_15390_n840# 0.01fF
C13591 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/a_28772_n240# 0.01fF
C13592 divbuf_1/a_48030_n1540# divbuf_1/a_48510_n1540# 0.11fF
C13593 divbuf_3/a_44640_n1600# divbuf_3/a_44670_n840# 0.04fF
C13594 divbuf_5/a_36990_n1540# divbuf_5/a_37470_n1540# 0.11fF
C13595 divbuf_0/a_21012_n240# divbuf_0/a_21502_n240# 0.04fF
C13596 divbuf_0/a_40902_170# divbuf_0/a_40902_n240# 0.01fF
C13597 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/a_33142_n240# 0.01fF
C13598 divbuf_2/a_18240_n1600# divbuf_2/a_18720_n1600# 0.26fF
C13599 divbuf_2/a_8762_n240# divbuf_2/a_8670_n840# 0.03fF
C13600 divbuf_4/a_19200_n1600# divbuf_4/OUT4 0.00fF
C13601 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_13742_n240# 0.04fF
C13602 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C13603 divbuf_0/a_2430_n840# divbuf_0/a_2430_n1540# 0.01fF
C13604 divbuf_0/a_32670_n840# divbuf_0/a_33150_n840# 0.07fF
C13605 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n1540# 0.19fF
C13606 divbuf_0/a_2400_n1600# divbuf_0/OUT2 0.00fF
C13607 divbuf_1/a_21502_170# divbuf_1/a_21502_n240# 0.01fF
C13608 pll_full_0/divbuf_0/a_24990_n840# pll_full_0/divbuf_0/a_25470_n840# 0.07fF
C13609 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_24990_n1540# 0.19fF
C13610 divbuf_2/a_41310_n840# divbuf_2/a_41310_n1540# 0.01fF
C13611 divbuf_2/a_10590_n1540# divbuf_2/a_11070_n1540# 0.11fF
C13612 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C13613 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47070_n840# 0.04fF
C13614 ro_div_0/divider_0/tspc_2/Z2 gnd 0.16fF
C13615 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/a_8762_170# 0.07fF
C13616 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/a_15182_170# 0.07fF
C13617 divbuf_1/a_7792_n240# divbuf_1/OUT3 0.04fF
C13618 divbuf_1/a_45600_n1600# divbuf_1/a_45630_n840# 0.04fF
C13619 divbuf_3/a_22472_n240# divbuf_3/a_22952_n240# 0.05fF
C13620 divbuf_5/a_34560_n1600# divbuf_5/a_34590_n840# 0.04fF
C13621 divbuf_5/a_24892_170# divbuf_5/OUT4 0.19fF
C13622 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_3/vin 0.20fF
C13623 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_45120_n1600# 0.26fF
C13624 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/a_35550_n840# 0.05fF
C13625 divbuf_3/a_34080_n1600# divbuf_3/a_34110_n1540# 0.19fF
C13626 divbuf_3/a_34110_n840# divbuf_3/a_34590_n840# 0.07fF
C13627 divbuf_3/a_3870_n840# divbuf_3/a_3870_n1540# 0.01fF
C13628 divbuf_4/a_8160_n1600# divbuf_4/a_8640_n1600# 0.26fF
C13629 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48480_n1600# 0.26fF
C13630 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/a_38910_n840# 0.04fF
C13631 pd_div_0/divbuf_0/a_36990_n1540# pd_div_0/divbuf_0/a_37470_n1540# 0.11fF
C13632 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_510_n840# 0.00fF
C13633 divbuf_2/a_8160_n1600# divbuf_2/a_8190_n840# 0.04fF
C13634 divbuf_4/a_31230_n840# divbuf_4/a_31230_n1540# 0.01fF
C13635 divbuf_4/a_510_n1540# divbuf_4/a_990_n1540# 0.11fF
C13636 pll_full_0/divbuf_1/a_40350_n1540# pll_full_0/divbuf_1/a_40830_n1540# 0.11fF
C13637 gnd pll_full_0/divider_0/and_0/OUT 0.32fF
C13638 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/a_25382_n240# 0.04fF
C13639 divbuf_1/a_23442_n240# divbuf_1/a_23922_n240# 0.05fF
C13640 divbuf_5/a_12282_n240# divbuf_5/a_12772_n240# 0.04fF
C13641 divbuf_5/a_32172_170# divbuf_5/a_32172_n240# 0.01fF
C13642 ro_div_0/divbuf_0/a_6270_n840# ro_div_0/divbuf_0/a_6270_n1540# 0.01fF
C13643 ro_div_0/divbuf_0/a_36510_n840# ro_div_0/divbuf_0/a_36990_n840# 0.07fF
C13644 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36510_n1540# 0.19fF
C13645 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C13646 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/a_10212_n240# 0.01fF
C13647 divbuf_1/a_35040_n1600# divbuf_1/a_35070_n1540# 0.19fF
C13648 divbuf_1/a_35070_n840# divbuf_1/a_35550_n840# 0.07fF
C13649 divbuf_1/a_4830_n840# divbuf_1/a_4830_n1540# 0.01fF
C13650 divbuf_5/a_25862_n240# divbuf_5/OUT4 0.04fF
C13651 divbuf_5/a_24000_n1600# divbuf_5/a_24030_n1540# 0.19fF
C13652 divbuf_5/a_24030_n840# divbuf_5/a_24510_n840# 0.07fF
C13653 divbuf_3/a_56190_n840# divbuf_3/a_56190_n1540# 0.01fF
C13654 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C13655 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C13656 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_34590_n840# 0.04fF
C13657 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/OUT4 0.19fF
C13658 divbuf_2/a_4882_170# divbuf_2/a_4882_n240# 0.01fF
C13659 divbuf_2/a_24892_170# divbuf_2/a_25382_170# 0.07fF
C13660 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C13661 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C13662 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/OUT4 0.19fF
C13663 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_37950_n840# 0.04fF
C13664 divbuf_0/a_9732_n240# divbuf_0/a_9630_n840# 0.03fF
C13665 divbuf_0/a_19200_n1600# divbuf_0/a_19680_n1600# 0.26fF
C13666 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_12000_n1600# 0.26fF
C13667 divbuf_2/a_11802_170# divbuf_2/OUT4 0.19fF
C13668 divbuf_2/a_58080_n1600# divbuf_2/a_58560_n1600# 0.26fF
C13669 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C13670 divbuf_0/a_11550_n1540# divbuf_0/a_12030_n1540# 0.11fF
C13671 divbuf_0/a_42270_n840# divbuf_0/a_42270_n1540# 0.01fF
C13672 divbuf_2/a_50430_n1540# divbuf_2/a_50910_n1540# 0.11fF
C13673 pll_full_0/divbuf_0/a_34590_n840# pll_full_0/divbuf_0/a_34590_n1540# 0.01fF
C13674 pll_full_0/divbuf_0/a_3870_n1540# pll_full_0/divbuf_0/a_4350_n1540# 0.11fF
C13675 divbuf_3/a_1352_170# divbuf_3/OUT2 0.23fF
C13676 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12772_n240# 0.04fF
C13677 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/a_32172_n240# 0.01fF
C13678 divbuf_4/a_14702_170# divbuf_4/a_15182_170# 0.07fF
C13679 divbuf_5/a_24000_n1600# divbuf_5/OUT4 0.00fF
C13680 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/a_35562_n240# 0.01fF
C13681 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_16152_n240# 0.05fF
C13682 divbuf_3/a_20640_n1600# divbuf_3/a_21120_n1600# 0.26fF
C13683 divbuf_3/a_11312_n240# divbuf_3/a_11550_n840# 0.02fF
C13684 divbuf_0/a_6822_170# divbuf_0/a_7302_170# 0.07fF
C13685 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C13686 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C13687 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C13688 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24030_n1540# 0.19fF
C13689 pd_div_0/divbuf_0/a_24030_n840# pd_div_0/divbuf_0/a_24510_n840# 0.07fF
C13690 divbuf_4/a_38962_n240# divbuf_4/a_38910_n840# 0.04fF
C13691 divbuf_4/a_48000_n1600# divbuf_4/a_48480_n1600# 0.26fF
C13692 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27390_n1540# 0.19fF
C13693 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C13694 pll_full_0/divbuf_1/a_27390_n840# pll_full_0/divbuf_1/a_27870_n840# 0.07fF
C13695 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_17790_n840# 0.00fF
C13696 divbuf_3/a_43710_n840# divbuf_3/a_43710_n1540# 0.01fF
C13697 divbuf_3/a_12990_n1540# divbuf_3/a_13470_n1540# 0.11fF
C13698 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n840# 0.04fF
C13699 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C13700 divbuf_2/a_12772_n240# divbuf_2/OUT4 0.04fF
C13701 divbuf_2/a_48000_n1600# divbuf_2/a_48030_n840# 0.04fF
C13702 divbuf_4/a_40350_n1540# divbuf_4/a_40830_n1540# 0.11fF
C13703 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C13704 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1470_n840# 0.04fF
C13705 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23520_n1600# 0.26fF
C13706 divbuf_1/a_21600_n1600# divbuf_1/a_22080_n1600# 0.26fF
C13707 divbuf_1/a_12282_n240# divbuf_1/a_12510_n840# 0.02fF
C13708 divbuf_5/a_10560_n1600# divbuf_5/a_11040_n1600# 0.26fF
C13709 divbuf_3/a_41382_170# divbuf_3/OUT5 0.07fF
C13710 divbuf_3/a_2322_n240# divbuf_3/OUT2 0.04fF
C13711 ro_div_0/divbuf_0/a_15390_n1540# ro_div_0/divbuf_0/a_15870_n1540# 0.11fF
C13712 ro_div_0/divbuf_0/a_46110_n840# ro_div_0/divbuf_0/a_46110_n1540# 0.01fF
C13713 divbuf_1/a_44670_n840# divbuf_1/a_44670_n1540# 0.01fF
C13714 divbuf_1/a_13950_n1540# divbuf_1/a_14430_n1540# 0.11fF
C13715 divbuf_5/a_33630_n840# divbuf_5/a_33630_n1540# 0.01fF
C13716 divbuf_5/a_2910_n1540# divbuf_5/a_3390_n1540# 0.11fF
C13717 divbuf_3/a_10560_n1600# divbuf_3/a_10590_n840# 0.04fF
C13718 divbuf_0/a_25862_170# divbuf_0/a_26352_170# 0.07fF
C13719 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C13720 divbuf_2/a_25862_n240# divbuf_2/a_26352_n240# 0.04fF
C13721 divbuf_4/a_37920_n1600# divbuf_4/a_37950_n840# 0.04fF
C13722 divbuf_4/a_31682_170# divbuf_4/OUT4 0.19fF
C13723 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_4882_n240# 0.01fF
C13724 divbuf_0/a_59040_n1600# divbuf_0/a_59520_n1600# 0.26fF
C13725 divbuf_0/a_13252_170# divbuf_0/OUT4 0.19fF
C13726 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C13727 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C13728 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/tspc_0/Z2 0.01fF
C13729 divbuf_2/a_37470_n840# divbuf_2/a_37950_n840# 0.07fF
C13730 divbuf_2/a_7230_n840# divbuf_2/a_7230_n1540# 0.01fF
C13731 divbuf_2/a_11040_n1600# divbuf_2/OUT4 0.00fF
C13732 divbuf_2/a_37440_n1600# divbuf_2/a_37470_n1540# 0.19fF
C13733 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.26fF
C13734 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/OUT3 0.07fF
C13735 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51840_n1600# 0.26fF
C13736 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/a_38472_170# 0.07fF
C13737 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_12990_n840# 0.04fF
C13738 divbuf_0/a_51390_n1540# divbuf_0/a_51870_n1540# 0.11fF
C13739 divbuf_1/a_18582_170# divbuf_1/OUT4 0.19fF
C13740 divbuf_1/a_11520_n1600# divbuf_1/a_11550_n840# 0.04fF
C13741 divbuf_5/a_480_n1600# divbuf_5/a_510_n840# 0.04fF
C13742 pll_full_0/divbuf_0/a_43710_n1540# pll_full_0/divbuf_0/a_44190_n1540# 0.11fF
C13743 divbuf_3/a_27322_170# divbuf_3/a_27802_170# 0.07fF
C13744 divbuf_3/a_7302_170# divbuf_3/a_7302_n240# 0.01fF
C13745 divbuf_3/a_1920_n1600# divbuf_3/OUT2 0.00fF
C13746 divbuf_3/a_0_n1600# io_analog[9] 0.26fF
C13747 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_11040_n1600# 0.26fF
C13748 divbuf_4/a_15672_n240# divbuf_4/a_16152_n240# 0.05fF
C13749 divbuf_4/a_35562_170# divbuf_4/a_35562_n240# 0.01fF
C13750 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_14400_n1600# 0.26fF
C13751 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/a_4350_n840# 0.04fF
C13752 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C13753 pd_div_0/divbuf_0/a_33630_n840# pd_div_0/divbuf_0/a_33630_n1540# 0.01fF
C13754 pd_div_0/divbuf_0/a_2910_n1540# pd_div_0/divbuf_0/a_3390_n1540# 0.11fF
C13755 divbuf_4/a_27390_n840# divbuf_4/a_27870_n840# 0.07fF
C13756 divbuf_4/a_32652_n240# divbuf_4/OUT4 0.04fF
C13757 divbuf_4/a_27360_n1600# divbuf_4/a_27390_n1540# 0.19fF
C13758 pll_full_0/divbuf_1/a_6270_n1540# pll_full_0/divbuf_1/a_6750_n1540# 0.11fF
C13759 pll_full_0/divbuf_1/a_36990_n840# pll_full_0/divbuf_1/a_36990_n1540# 0.01fF
C13760 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/OUT4 0.19fF
C13761 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/a_19562_n240# 0.01fF
C13762 divbuf_0/a_14702_n240# divbuf_0/OUT4 0.04fF
C13763 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n840# 0.04fF
C13764 divbuf_1/a_14702_170# divbuf_1/a_14702_n240# 0.01fF
C13765 divbuf_1/a_24892_170# divbuf_1/a_25382_170# 0.07fF
C13766 divbuf_5/a_17122_170# divbuf_5/a_17612_170# 0.07fF
C13767 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41310_n840# 0.04fF
C13768 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/OUT4 0.19fF
C13769 ro_div_0/divbuf_0/a_2430_n840# ro_div_0/divbuf_0/a_2910_n840# 0.07fF
C13770 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2430_n1540# 0.19fF
C13771 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 0.22fF
C13772 divbuf_1/a_960_n1600# divbuf_1/a_990_n1540# 0.19fF
C13773 divbuf_1/a_990_n840# divbuf_1/a_1470_n840# 0.07fF
C13774 divbuf_5/a_50400_n1600# divbuf_5/a_50880_n1600# 0.26fF
C13775 divbuf_5/a_41382_n240# divbuf_5/a_41310_n840# 0.03fF
C13776 divbuf_3/a_52320_n1600# divbuf_3/a_52350_n1540# 0.19fF
C13777 ro_div_0/divbuf_0/a_55230_n1540# ro_div_0/divbuf_0/a_55710_n1540# 0.11fF
C13778 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_510_n840# 0.04fF
C13779 divbuf_1/a_53790_n1540# divbuf_1/a_54270_n1540# 0.11fF
C13780 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_3870_n840# 0.04fF
C13781 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/a_34592_n240# 0.01fF
C13782 divbuf_3/a_50400_n1600# divbuf_3/a_50430_n840# 0.04fF
C13783 divbuf_5/a_42750_n1540# divbuf_5/a_43230_n1540# 0.11fF
C13784 divbuf_0/a_26832_n240# divbuf_0/a_27322_n240# 0.04fF
C13785 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/a_19562_n240# 0.04fF
C13786 divbuf_2/a_14702_n240# divbuf_2/a_14910_n840# 0.02fF
C13787 divbuf_2/a_24000_n1600# divbuf_2/a_24480_n1600# 0.26fF
C13788 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/a_38962_n240# 0.01fF
C13789 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n1540# 0.19fF
C13790 divbuf_0/a_12960_n1600# divbuf_0/OUT4 0.00fF
C13791 divbuf_0/a_8190_n840# divbuf_0/a_8190_n1540# 0.01fF
C13792 divbuf_0/a_38430_n840# divbuf_0/a_38910_n840# 0.07fF
C13793 divbuf_1/a_27322_170# divbuf_1/a_27322_n240# 0.01fF
C13794 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C13795 divbuf_2/a_47070_n840# divbuf_2/a_47070_n1540# 0.01fF
C13796 divbuf_2/a_16350_n1540# divbuf_2/a_16830_n1540# 0.11fF
C13797 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_30750_n1540# 0.19fF
C13798 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/a_510_n1540# 0.01fF
C13799 pll_full_0/divbuf_0/a_30750_n840# pll_full_0/divbuf_0/a_31230_n840# 0.07fF
C13800 ashish_0/a_150_n710# ashish_0/vop 9.14fF
C13801 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C13802 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_52830_n840# 0.04fF
C13803 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/a_17612_170# 0.07fF
C13804 divbuf_1/a_51360_n1600# divbuf_1/a_51390_n840# 0.04fF
C13805 divbuf_1/a_19562_n240# divbuf_1/OUT4 0.04fF
C13806 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/a_21012_170# 0.07fF
C13807 divbuf_3/a_28292_n240# divbuf_3/a_28772_n240# 0.05fF
C13808 divbuf_5/a_40320_n1600# divbuf_5/a_40350_n840# 0.04fF
C13809 divbuf_5/a_36532_170# divbuf_5/OUT4 0.19fF
C13810 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.11fF
C13811 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/nor_1/B 0.06fF
C13812 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50880_n1600# 0.26fF
C13813 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/a_41310_n840# 0.03fF
C13814 divbuf_4/a_4392_n240# divbuf_4/a_4350_n840# 0.04fF
C13815 divbuf_4/a_13920_n1600# divbuf_4/a_14400_n1600# 0.26fF
C13816 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_54240_n1600# 0.26fF
C13817 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/OUT3 0.07fF
C13818 divbuf_3/a_39870_n840# divbuf_3/a_40350_n840# 0.07fF
C13819 divbuf_3/a_9630_n840# divbuf_3/a_9630_n1540# 0.01fF
C13820 divbuf_3/a_39840_n1600# divbuf_3/a_39870_n1540# 0.19fF
C13821 pd_div_0/divbuf_0/a_42750_n1540# pd_div_0/divbuf_0/a_43230_n1540# 0.11fF
C13822 divbuf_2/a_13920_n1600# divbuf_2/a_13950_n840# 0.04fF
C13823 divbuf_4/a_36990_n840# divbuf_4/a_36990_n1540# 0.01fF
C13824 divbuf_4/a_6270_n1540# divbuf_4/a_6750_n1540# 0.11fF
C13825 pll_full_0/divbuf_1/a_46110_n1540# pll_full_0/divbuf_1/a_46590_n1540# 0.11fF
C13826 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/a_31202_n240# 0.04fF
C13827 divbuf_1/a_29262_n240# divbuf_1/a_29742_n240# 0.05fF
C13828 divbuf_5/a_37992_170# divbuf_5/a_37992_n240# 0.01fF
C13829 divbuf_5/a_18092_n240# divbuf_5/a_18582_n240# 0.04fF
C13830 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C13831 ro_div_0/divbuf_0/a_12030_n840# ro_div_0/divbuf_0/a_12030_n1540# 0.01fF
C13832 ro_div_0/divbuf_0/a_42270_n840# ro_div_0/divbuf_0/a_42750_n840# 0.07fF
C13833 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42270_n1540# 0.19fF
C13834 divbuf_1/a_40830_n840# divbuf_1/a_41310_n840# 0.07fF
C13835 divbuf_1/a_10590_n840# divbuf_1/a_10590_n1540# 0.01fF
C13836 divbuf_1/a_40800_n1600# divbuf_1/a_40830_n1540# 0.19fF
C13837 divbuf_5/a_29760_n1600# divbuf_5/a_29790_n1540# 0.19fF
C13838 divbuf_5/a_29790_n840# divbuf_5/a_30270_n840# 0.07fF
C13839 divbuf_5/a_37502_n240# divbuf_5/OUT4 0.04fF
C13840 divbuf_0/a_17122_170# divbuf_0/a_16642_170# 0.07fF
C13841 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/prescaler_0/Out 0.28fF
C13842 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40350_n840# 0.04fF
C13843 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/OUT4 0.19fF
C13844 pd_div_0/divbuf_0/a_492_n240# pd_div_0/bufin 0.13fF
C13845 divbuf_2/a_30712_170# divbuf_2/a_31202_170# 0.07fF
C13846 divbuf_2/a_11312_170# divbuf_2/a_11312_n240# 0.01fF
C13847 divbuf_4/a_3840_n1600# divbuf_4/a_3870_n840# 0.04fF
C13848 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C13849 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_43710_n840# 0.04fF
C13850 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C13851 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/a_3390_n840# 0.05fF
C13852 divbuf_0/a_24960_n1600# divbuf_0/a_25440_n1600# 0.26fF
C13853 divbuf_0/a_15672_n240# divbuf_0/a_15870_n840# 0.02fF
C13854 divbuf_2/a_3390_n840# divbuf_2/a_3870_n840# 0.07fF
C13855 divbuf_2/a_3360_n1600# divbuf_2/a_3390_n1540# 0.19fF
C13856 divbuf_2/a_23442_170# divbuf_2/OUT4 0.19fF
C13857 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17760_n1600# 0.26fF
C13858 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/a_7710_n840# 0.03fF
C13859 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C13860 divbuf_0/a_17310_n1540# divbuf_0/a_17790_n1540# 0.11fF
C13861 divbuf_0/a_48030_n840# divbuf_0/a_48030_n1540# 0.01fF
C13862 pll_full_0/divbuf_0/a_9630_n1540# pll_full_0/divbuf_0/a_10110_n1540# 0.11fF
C13863 pll_full_0/divbuf_0/a_40350_n840# pll_full_0/divbuf_0/a_40350_n1540# 0.01fF
C13864 divbuf_2/a_56190_n1540# divbuf_2/a_56670_n1540# 0.11fF
C13865 divbuf_3/a_13252_170# divbuf_3/OUT4 0.19fF
C13866 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/OUT2 0.02fF
C13867 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/a_37992_n240# 0.01fF
C13868 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_18582_n240# 0.04fF
C13869 divbuf_3/a_26400_n1600# divbuf_3/a_26880_n1600# 0.26fF
C13870 divbuf_3/a_17122_n240# divbuf_3/a_17310_n840# 0.02fF
C13871 divbuf_4/a_20532_170# divbuf_4/a_21012_170# 0.07fF
C13872 divbuf_5/a_35520_n1600# divbuf_5/OUT4 0.00fF
C13873 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/a_21982_n240# 0.05fF
C13874 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/a_41382_n240# 0.01fF
C13875 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/IN 0.00fF
C13876 divbuf_0/a_18582_170# divbuf_0/a_18582_n240# 0.01fF
C13877 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_29790_n1540# 0.19fF
C13878 pd_div_0/divbuf_0/a_29790_n840# pd_div_0/divbuf_0/a_30270_n840# 0.07fF
C13879 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C13880 divbuf_4/a_2322_170# divbuf_4/OUT3 0.07fF
C13881 divbuf_4/a_53760_n1600# divbuf_4/a_54240_n1600# 0.26fF
C13882 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/a_2910_n1540# 0.01fF
C13883 pll_full_0/divbuf_1/a_33150_n840# pll_full_0/divbuf_1/a_33630_n840# 0.07fF
C13884 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33150_n1540# 0.19fF
C13885 divbuf_3/a_49470_n840# divbuf_3/a_49470_n1540# 0.01fF
C13886 divbuf_3/a_18750_n1540# divbuf_3/a_19230_n1540# 0.11fF
C13887 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/a_12772_170# 0.07fF
C13888 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n840# 0.04fF
C13889 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C13890 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C13891 divbuf_2/a_53760_n1600# divbuf_2/a_53790_n840# 0.04fF
C13892 divbuf_2/a_24412_n240# divbuf_2/OUT4 0.04fF
C13893 divbuf_4/a_46110_n1540# divbuf_4/a_46590_n1540# 0.11fF
C13894 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7230_n840# 0.04fF
C13895 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C13896 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_29280_n1600# 0.26fF
C13897 divbuf_1/a_27360_n1600# divbuf_1/a_27840_n1600# 0.26fF
C13898 divbuf_1/a_18092_n240# divbuf_1/a_18270_n840# 0.02fF
C13899 divbuf_5/a_16320_n1600# divbuf_5/a_16800_n1600# 0.26fF
C13900 divbuf_5/a_6822_n240# divbuf_5/a_6750_n840# 0.03fF
C13901 divbuf_3/a_14222_n240# divbuf_3/OUT4 0.04fF
C13902 ro_div_0/divbuf_0/a_21150_n1540# ro_div_0/divbuf_0/a_21630_n1540# 0.11fF
C13903 ro_div_0/divbuf_0/a_51870_n840# ro_div_0/divbuf_0/a_51870_n1540# 0.01fF
C13904 divbuf_1/a_50430_n840# divbuf_1/a_50430_n1540# 0.01fF
C13905 divbuf_1/a_19710_n1540# divbuf_1/a_20190_n1540# 0.11fF
C13906 divbuf_5/a_39390_n840# divbuf_5/a_39390_n1540# 0.01fF
C13907 divbuf_5/a_8670_n1540# divbuf_5/a_9150_n1540# 0.11fF
C13908 divbuf_3/a_16320_n1600# divbuf_3/a_16350_n840# 0.04fF
C13909 divbuf_0/a_12282_170# divbuf_0/a_12282_n240# 0.01fF
C13910 divbuf_0/a_31682_170# divbuf_0/a_32172_170# 0.07fF
C13911 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/a_24412_170# 0.07fF
C13912 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C13913 divbuf_2/a_31682_n240# divbuf_2/a_32172_n240# 0.04fF
C13914 divbuf_4/a_3912_n240# divbuf_4/OUT3 0.04fF
C13915 divbuf_4/a_43680_n1600# divbuf_4/a_43710_n840# 0.04fF
C13916 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/a_1352_n240# 0.01fF
C13917 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/OUT4 0.19fF
C13918 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/a_8762_170# 0.07fF
C13919 divbuf_0/a_25382_170# divbuf_0/OUT4 0.19fF
C13920 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n1540# 0.19fF
C13921 divbuf_0/a_4350_n840# divbuf_0/a_4830_n840# 0.07fF
C13922 gnd pd_div_0/divider_0/tspc_0/Z2 0.16fF
C13923 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z4 0.00fF
C13924 divbuf_2/a_43200_n1600# divbuf_2/a_43230_n1540# 0.19fF
C13925 divbuf_2/a_43230_n840# divbuf_2/a_43710_n840# 0.07fF
C13926 divbuf_2/a_12990_n840# divbuf_2/a_12990_n1540# 0.01fF
C13927 divbuf_2/a_22560_n1600# divbuf_2/OUT4 0.01fF
C13928 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57600_n1600# 0.26fF
C13929 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/OUT4 0.23fF
C13930 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/a_4392_n240# 0.05fF
C13931 divbuf_0/a_57150_n1540# divbuf_0/a_57630_n1540# 0.11fF
C13932 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_18750_n840# 0.04fF
C13933 divbuf_1/a_17280_n1600# divbuf_1/a_17310_n840# 0.04fF
C13934 divbuf_5/a_6240_n1600# divbuf_5/a_6270_n840# 0.04fF
C13935 divbuf_3/a_33142_170# divbuf_3/a_33622_170# 0.07fF
C13936 divbuf_3/a_13742_170# divbuf_3/a_13742_n240# 0.01fF
C13937 pll_full_0/divbuf_0/a_49470_n1540# pll_full_0/divbuf_0/a_49950_n1540# 0.11fF
C13938 divbuf_3/a_12480_n1600# divbuf_3/OUT4 0.00fF
C13939 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16800_n1600# 0.26fF
C13940 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/a_6750_n840# 0.03fF
C13941 divbuf_4/a_41382_170# divbuf_4/a_41382_n240# 0.01fF
C13942 divbuf_4/a_21502_n240# divbuf_4/a_21982_n240# 0.05fF
C13943 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/a_10110_n840# 0.03fF
C13944 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_20160_n1600# 0.26fF
C13945 divbuf_3/a_5790_n840# divbuf_3/a_6270_n840# 0.07fF
C13946 divbuf_3/a_5760_n1600# divbuf_3/a_5790_n1540# 0.19fF
C13947 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/OUT2 0.19fF
C13948 pd_div_0/divbuf_0/a_39390_n840# pd_div_0/divbuf_0/a_39390_n1540# 0.01fF
C13949 pd_div_0/divbuf_0/a_8670_n1540# pd_div_0/divbuf_0/a_9150_n1540# 0.11fF
C13950 divbuf_4/a_33120_n1600# divbuf_4/a_33150_n1540# 0.19fF
C13951 divbuf_4/a_33150_n840# divbuf_4/a_33630_n840# 0.07fF
C13952 divbuf_4/a_2910_n840# divbuf_4/a_2910_n1540# 0.01fF
C13953 pll_full_0/divbuf_1/a_12030_n1540# pll_full_0/divbuf_1/a_12510_n1540# 0.11fF
C13954 pll_full_0/divbuf_1/a_42750_n840# pll_full_0/divbuf_1/a_42750_n1540# 0.01fF
C13955 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/OUT2 0.04fF
C13956 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/OUT4 0.19fF
C13957 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/divider_0/clk 1.30fF
C13958 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n840# 0.04fF
C13959 divbuf_0/a_26352_n240# divbuf_0/OUT4 0.04fF
C13960 divbuf_1/a_34112_170# divbuf_1/a_34592_170# 0.07fF
C13961 divbuf_5/a_2322_170# divbuf_5/a_2322_n240# 0.01fF
C13962 divbuf_5/a_22952_170# divbuf_5/a_23442_170# 0.07fF
C13963 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47070_n840# 0.04fF
C13964 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C13965 ro_div_0/divbuf_0/a_8190_n840# ro_div_0/divbuf_0/a_8670_n840# 0.07fF
C13966 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8190_n1540# 0.19fF
C13967 ro_div_0/divider_0/tspc_1/Z3 gnd 0.27fF
C13968 pd_div_0/pd_0/UP pd_div_0/pd_0/tspc_r_1/z5 0.03fF
C13969 divbuf_1/a_6750_n840# divbuf_1/a_7230_n840# 0.07fF
C13970 divbuf_1/a_26832_170# divbuf_1/OUT4 0.19fF
C13971 divbuf_1/a_6720_n1600# divbuf_1/a_6750_n1540# 0.19fF
C13972 divbuf_5/a_7792_170# divbuf_5/OUT3 0.19fF
C13973 divbuf_5/a_56160_n1600# divbuf_5/a_56640_n1600# 0.26fF
C13974 divbuf_3/a_58080_n1600# divbuf_3/a_58110_n1540# 0.19fF
C13975 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6270_n840# 0.04fF
C13976 divbuf_1/a_59550_n1540# divbuf_1/a_60030_n1540# 0.11fF
C13977 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_9630_n840# 0.04fF
C13978 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/a_40412_n240# 0.01fF
C13979 divbuf_3/a_56160_n1600# divbuf_3/a_56190_n840# 0.04fF
C13980 divbuf_5/a_48510_n1540# divbuf_5/a_48990_n1540# 0.11fF
C13981 divbuf_0/a_32652_n240# divbuf_0/a_33142_n240# 0.04fF
C13982 pll_full_0/divbuf_1/a_60990_n840# pll_full_0/divbuf_1/OUT5 0.04fF
C13983 divbuf_2/a_29760_n1600# divbuf_2/a_30240_n1600# 0.26fF
C13984 divbuf_2/a_20532_n240# divbuf_2/a_20670_n840# 0.03fF
C13985 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/a_25382_n240# 0.04fF
C13986 divbuf_0/a_24480_n1600# divbuf_0/OUT4 0.00fF
C13987 divbuf_0/a_13950_n840# divbuf_0/a_13950_n1540# 0.01fF
C13988 divbuf_0/a_44190_n840# divbuf_0/a_44670_n840# 0.07fF
C13989 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n1540# 0.19fF
C13990 pll_full_0/divbuf_0/a_6270_n840# pll_full_0/divbuf_0/a_6270_n1540# 0.01fF
C13991 pll_full_0/divbuf_0/a_36510_n840# pll_full_0/divbuf_0/a_36990_n840# 0.07fF
C13992 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36510_n1540# 0.19fF
C13993 divbuf_2/a_52830_n840# divbuf_2/a_52830_n1540# 0.01fF
C13994 divbuf_2/a_22110_n1540# divbuf_2/a_22590_n1540# 0.11fF
C13995 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C13996 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_58590_n840# 0.04fF
C13997 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C13998 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/a_23442_170# 0.07fF
C13999 divbuf_1/a_31202_n240# divbuf_1/OUT4 0.04fF
C14000 divbuf_1/a_57120_n1600# divbuf_1/a_57150_n840# 0.04fF
C14001 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/a_26832_170# 0.07fF
C14002 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/a_6332_n240# 0.01fF
C14003 divbuf_3/a_34112_n240# divbuf_3/a_34592_n240# 0.05fF
C14004 divbuf_5/a_8762_n240# divbuf_5/OUT3 0.04fF
C14005 divbuf_5/a_46080_n1600# divbuf_5/a_46110_n840# 0.04fF
C14006 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/OUT3 0.23fF
C14007 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56640_n1600# 0.26fF
C14008 divbuf_4/a_19680_n1600# divbuf_4/a_20160_n1600# 0.26fF
C14009 divbuf_4/a_10212_n240# divbuf_4/a_10110_n840# 0.03fF
C14010 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_60000_n1600# 0.26fF
C14011 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/OUT4 0.19fF
C14012 divbuf_3/a_45600_n1600# divbuf_3/a_45630_n1540# 0.19fF
C14013 divbuf_3/a_45630_n840# divbuf_3/a_46110_n840# 0.07fF
C14014 divbuf_3/a_15390_n840# divbuf_3/a_15390_n1540# 0.01fF
C14015 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C14016 pd_div_0/divbuf_0/a_48510_n1540# pd_div_0/divbuf_0/a_48990_n1540# 0.11fF
C14017 divbuf_4/a_42750_n840# divbuf_4/a_42750_n1540# 0.01fF
C14018 divbuf_4/a_12030_n1540# divbuf_4/a_12510_n1540# 0.11fF
C14019 divbuf_2/a_19680_n1600# divbuf_2/a_19710_n840# 0.04fF
C14020 pll_full_0/divbuf_1/a_51870_n1540# pll_full_0/divbuf_1/a_52350_n1540# 0.11fF
C14021 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/a_37022_n240# 0.04fF
C14022 divbuf_1/a_35082_n240# divbuf_1/a_35562_n240# 0.05fF
C14023 divbuf_5/a_23922_n240# divbuf_5/a_24412_n240# 0.04fF
C14024 ro_div_0/divbuf_0/a_17790_n840# ro_div_0/divbuf_0/a_17790_n1540# 0.01fF
C14025 ro_div_0/divbuf_0/a_48030_n840# ro_div_0/divbuf_0/a_48510_n840# 0.07fF
C14026 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48030_n1540# 0.19fF
C14027 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C14028 divbuf_1/a_46560_n1600# divbuf_1/a_46590_n1540# 0.19fF
C14029 divbuf_1/a_46590_n840# divbuf_1/a_47070_n840# 0.07fF
C14030 divbuf_1/a_16350_n840# divbuf_1/a_16350_n1540# 0.01fF
C14031 divbuf_3/a_2322_n240# divbuf_3/a_2430_n840# 0.03fF
C14032 divbuf_5/a_35520_n1600# divbuf_5/a_35550_n1540# 0.19fF
C14033 divbuf_5/a_35550_n840# divbuf_5/a_36030_n840# 0.07fF
C14034 divbuf_5/a_5310_n840# divbuf_5/a_5310_n1540# 0.01fF
C14035 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/B 0.01fF
C14036 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/Out 0.91fF
C14037 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C14038 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46110_n840# 0.04fF
C14039 divbuf_4/a_9600_n1600# divbuf_4/a_9630_n840# 0.04fF
C14040 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/a_9150_n840# 0.03fF
C14041 divbuf_2/a_17122_170# divbuf_2/a_17122_n240# 0.01fF
C14042 divbuf_2/a_36532_170# divbuf_2/a_37022_170# 0.07fF
C14043 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C14044 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49470_n840# 0.04fF
C14045 divbuf_0/a_21502_n240# divbuf_0/a_21630_n840# 0.03fF
C14046 divbuf_0/a_30720_n1600# divbuf_0/a_31200_n1600# 0.26fF
C14047 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23520_n1600# 0.26fF
C14048 divbuf_2/a_9120_n1600# divbuf_2/a_9150_n1540# 0.19fF
C14049 divbuf_2/a_35082_170# divbuf_2/OUT4 0.19fF
C14050 divbuf_2/a_9150_n840# divbuf_2/a_9630_n840# 0.07fF
C14051 divbuf_4/a_60990_n840# divbuf_4/OUT5 0.04fF
C14052 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_13950_n840# 0.02fF
C14053 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_2/v 0.08fF
C14054 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C14055 divbuf_0/a_23070_n1540# divbuf_0/a_23550_n1540# 0.11fF
C14056 divbuf_0/a_53790_n840# divbuf_0/a_53790_n1540# 0.01fF
C14057 pll_full_0/divbuf_0/a_46110_n840# pll_full_0/divbuf_0/a_46110_n1540# 0.01fF
C14058 pll_full_0/divbuf_0/a_15390_n1540# pll_full_0/divbuf_0/a_15870_n1540# 0.11fF
C14059 divbuf_3/a_24892_170# divbuf_3/OUT4 0.19fF
C14060 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/a_24412_n240# 0.04fF
C14061 divbuf_4/a_6332_170# divbuf_4/a_6332_n240# 0.01fF
C14062 divbuf_4/a_26352_170# divbuf_4/a_26832_170# 0.07fF
C14063 divbuf_3/a_32160_n1600# divbuf_3/a_32640_n1600# 0.26fF
C14064 divbuf_3/a_22952_n240# divbuf_3/a_23070_n840# 0.03fF
C14065 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/a_27802_n240# 0.05fF
C14066 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_35550_n1540# 0.19fF
C14067 pd_div_0/divbuf_0/a_35550_n840# pd_div_0/divbuf_0/a_36030_n840# 0.07fF
C14068 pd_div_0/divbuf_0/a_5310_n840# pd_div_0/divbuf_0/a_5310_n1540# 0.01fF
C14069 divbuf_3/a_24510_n1540# divbuf_3/a_24990_n1540# 0.11fF
C14070 divbuf_4/a_14702_170# divbuf_4/OUT4 0.19fF
C14071 divbuf_4/a_59520_n1600# divbuf_4/a_60000_n1600# 0.26fF
C14072 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_38910_n1540# 0.19fF
C14073 pll_full_0/divbuf_1/a_8670_n840# pll_full_0/divbuf_1/a_8670_n1540# 0.01fF
C14074 pll_full_0/divbuf_1/a_38910_n840# pll_full_0/divbuf_1/a_39390_n840# 0.07fF
C14075 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n840# 0.04fF
C14076 divbuf_0/a_4392_170# divbuf_0/OUT3 0.19fF
C14077 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C14078 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C14079 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C14080 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/nor_1/A 0.35fF
C14081 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/nor_0/B 0.00fF
C14082 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_12990_n840# 0.04fF
C14083 divbuf_2/a_36052_n240# divbuf_2/OUT4 0.04fF
C14084 divbuf_2/a_59520_n1600# divbuf_2/a_59550_n840# 0.04fF
C14085 divbuf_4/a_51870_n1540# divbuf_4/a_52350_n1540# 0.11fF
C14086 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/OUT3 0.19fF
C14087 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.45fF
C14088 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_35040_n1600# 0.26fF
C14089 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/a_25470_n840# 0.03fF
C14090 divbuf_1/a_33120_n1600# divbuf_1/a_33600_n1600# 0.26fF
C14091 divbuf_1/a_23922_n240# divbuf_1/a_24030_n840# 0.03fF
C14092 divbuf_5/a_22080_n1600# divbuf_5/a_22560_n1600# 0.26fF
C14093 divbuf_5/a_12772_n240# divbuf_5/a_12990_n840# 0.02fF
C14094 divbuf_3/a_25862_n240# divbuf_3/OUT4 0.04fF
C14095 ro_div_0/divbuf_0/a_26910_n1540# ro_div_0/divbuf_0/a_27390_n1540# 0.11fF
C14096 ro_div_0/divbuf_0/a_57630_n840# ro_div_0/divbuf_0/a_57630_n1540# 0.01fF
C14097 divbuf_1/a_56190_n840# divbuf_1/a_56190_n1540# 0.01fF
C14098 divbuf_1/a_25470_n1540# divbuf_1/a_25950_n1540# 0.11fF
C14099 divbuf_3/a_22080_n1600# divbuf_3/a_22110_n840# 0.04fF
C14100 divbuf_5/a_45150_n840# divbuf_5/a_45150_n1540# 0.01fF
C14101 divbuf_5/a_14430_n1540# divbuf_5/a_14910_n1540# 0.11fF
C14102 divbuf_0/a_37502_170# divbuf_0/a_37992_170# 0.07fF
C14103 divbuf_2/a_37502_n240# divbuf_2/a_37992_n240# 0.04fF
C14104 divbuf_4/a_49440_n1600# divbuf_4/a_49470_n840# 0.04fF
C14105 divbuf_4/a_15672_n240# divbuf_4/OUT4 0.04fF
C14106 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/a_30232_170# 0.07fF
C14107 divbuf_0/a_10110_n840# divbuf_0/a_10590_n840# 0.07fF
C14108 divbuf_0/a_37022_170# divbuf_0/OUT4 0.19fF
C14109 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n1540# 0.19fF
C14110 pll_full_0/divbuf_0/a_2430_n840# pll_full_0/divbuf_0/a_2910_n840# 0.07fF
C14111 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/OUT4 0.19fF
C14112 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2430_n1540# 0.19fF
C14113 divbuf_2/a_48990_n840# divbuf_2/a_49470_n840# 0.07fF
C14114 divbuf_2/a_18750_n840# divbuf_2/a_18750_n1540# 0.01fF
C14115 divbuf_2/a_34080_n1600# divbuf_2/OUT4 0.01fF
C14116 divbuf_2/a_48960_n1600# divbuf_2/a_48990_n1540# 0.19fF
C14117 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/a_10212_n240# 0.05fF
C14118 divbuf_0/OUT2 divbuf_0/OUT3 0.36fF
C14119 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24510_n840# 0.04fF
C14120 divbuf_1/a_23040_n1600# divbuf_1/a_23070_n840# 0.04fF
C14121 divbuf_3/a_38962_170# divbuf_3/a_39442_170# 0.07fF
C14122 divbuf_3/a_19562_170# divbuf_3/a_19562_n240# 0.01fF
C14123 divbuf_5/a_12000_n1600# divbuf_5/a_12030_n840# 0.04fF
C14124 pll_full_0/divbuf_0/a_55230_n1540# pll_full_0/divbuf_0/a_55710_n1540# 0.11fF
C14125 divbuf_3/a_24000_n1600# divbuf_3/OUT4 0.00fF
C14126 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22560_n1600# 0.26fF
C14127 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_12990_n840# 0.02fF
C14128 divbuf_4/a_27322_n240# divbuf_4/a_27802_n240# 0.05fF
C14129 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25920_n1600# 0.26fF
C14130 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_16350_n840# 0.02fF
C14131 divbuf_3/a_11520_n1600# divbuf_3/a_11550_n1540# 0.19fF
C14132 divbuf_3/a_11550_n840# divbuf_3/a_12030_n840# 0.07fF
C14133 pd_div_0/divbuf_0/a_45150_n840# pd_div_0/divbuf_0/a_45150_n1540# 0.01fF
C14134 pd_div_0/divbuf_0/a_14430_n1540# pd_div_0/divbuf_0/a_14910_n1540# 0.11fF
C14135 divbuf_4/a_38910_n840# divbuf_4/a_39390_n840# 0.07fF
C14136 divbuf_4/a_8670_n840# divbuf_4/a_8670_n1540# 0.01fF
C14137 divbuf_4/a_38880_n1600# divbuf_4/a_38910_n1540# 0.19fF
C14138 pll_full_0/divbuf_1/a_17790_n1540# pll_full_0/divbuf_1/a_18270_n1540# 0.11fF
C14139 pll_full_0/divbuf_1/a_48510_n840# pll_full_0/divbuf_1/a_48510_n1540# 0.01fF
C14140 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C14141 divbuf_0/a_37992_n240# divbuf_0/OUT4 0.04fF
C14142 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n840# 0.04fF
C14143 divbuf_1/a_39932_170# divbuf_1/a_40412_170# 0.07fF
C14144 divbuf_5/a_28772_170# divbuf_5/a_29262_170# 0.07fF
C14145 divbuf_5/a_8762_170# divbuf_5/a_8762_n240# 0.01fF
C14146 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C14147 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_52830_n840# 0.04fF
C14148 ro_div_0/divider_0/prescaler_0/tspc_0/Q gnd 0.35fF
C14149 ro_div_0/divbuf_0/a_13950_n840# ro_div_0/divbuf_0/a_14430_n840# 0.07fF
C14150 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_13950_n1540# 0.19fF
C14151 divbuf_1/a_41382_170# divbuf_1/OUT5 0.07fF
C14152 divbuf_1/a_2322_n240# divbuf_1/OUT2 0.04fF
C14153 divbuf_1/a_12480_n1600# divbuf_1/a_12510_n1540# 0.19fF
C14154 divbuf_1/a_12510_n840# divbuf_1/a_12990_n840# 0.07fF
C14155 divbuf_5/a_1440_n1600# divbuf_5/a_1470_n1540# 0.19fF
C14156 divbuf_5/a_19562_170# divbuf_5/OUT4 0.19fF
C14157 divbuf_5/a_1470_n840# divbuf_5/a_1950_n840# 0.07fF
C14158 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12030_n840# 0.04fF
C14159 divbuf_5/a_54270_n1540# divbuf_5/a_54750_n1540# 0.11fF
C14160 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15390_n840# 0.04fF
C14161 divbuf_0/a_38472_n240# divbuf_0/a_38962_n240# 0.04fF
C14162 divbuf_2/a_26352_n240# divbuf_2/a_26430_n840# 0.04fF
C14163 divbuf_2/a_35520_n1600# divbuf_2/a_36000_n1600# 0.26fF
C14164 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/a_31202_n240# 0.04fF
C14165 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n1540# 0.19fF
C14166 divbuf_0/a_36000_n1600# divbuf_0/OUT4 0.00fF
C14167 divbuf_0/a_19710_n840# divbuf_0/a_19710_n1540# 0.01fF
C14168 divbuf_0/a_49950_n840# divbuf_0/a_50430_n840# 0.07fF
C14169 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C14170 divbuf_2/a_58590_n840# divbuf_2/a_58590_n1540# 0.01fF
C14171 divbuf_2/a_27870_n1540# divbuf_2/a_28350_n1540# 0.11fF
C14172 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42270_n1540# 0.19fF
C14173 pll_full_0/divbuf_0/a_42270_n840# pll_full_0/divbuf_0/a_42750_n840# 0.07fF
C14174 pll_full_0/divbuf_0/a_12030_n840# pll_full_0/divbuf_0/a_12030_n1540# 0.01fF
C14175 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/a_29262_170# 0.07fF
C14176 divbuf_1/a_1920_n1600# divbuf_1/OUT2 0.00fF
C14177 divbuf_1/a_0_n1600# divbuf_1/OUT 0.26fF
C14178 divbuf_3/a_55230_n1540# divbuf_3/a_55710_n1540# 0.11fF
C14179 divbuf_5/a_51840_n1600# divbuf_5/a_51870_n840# 0.04fF
C14180 divbuf_5/a_20532_n240# divbuf_5/OUT4 0.04fF
C14181 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/a_12772_n240# 0.01fF
C14182 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/a_32652_170# 0.07fF
C14183 divbuf_3/a_39932_n240# divbuf_3/a_40412_n240# 0.05fF
C14184 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C14185 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1470_n1540# 0.19fF
C14186 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/OUT4 0.19fF
C14187 pd_div_0/divbuf_0/a_1470_n840# pd_div_0/divbuf_0/a_1950_n840# 0.07fF
C14188 divbuf_4/a_16152_n240# divbuf_4/a_16350_n840# 0.02fF
C14189 divbuf_4/a_25440_n1600# divbuf_4/a_25920_n1600# 0.26fF
C14190 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/OUT4 0.19fF
C14191 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_4830_n1540# 0.19fF
C14192 pll_full_0/divbuf_1/a_4830_n840# pll_full_0/divbuf_1/a_5310_n840# 0.07fF
C14193 divbuf_3/a_51390_n840# divbuf_3/a_51870_n840# 0.07fF
C14194 divbuf_3/a_21150_n840# divbuf_3/a_21150_n1540# 0.01fF
C14195 divbuf_3/a_51360_n1600# divbuf_3/a_51390_n1540# 0.19fF
C14196 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C14197 pd_div_0/divbuf_0/a_54270_n1540# pd_div_0/divbuf_0/a_54750_n1540# 0.11fF
C14198 divbuf_4/a_48510_n840# divbuf_4/a_48510_n1540# 0.01fF
C14199 divbuf_4/a_17790_n1540# divbuf_4/a_18270_n1540# 0.11fF
C14200 pll_full_0/divbuf_1/a_57630_n1540# pll_full_0/divbuf_1/a_58110_n1540# 0.11fF
C14201 divbuf_2/a_6332_170# divbuf_2/OUT3 0.19fF
C14202 divbuf_2/a_25440_n1600# divbuf_2/a_25470_n840# 0.04fF
C14203 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_4392_170# 0.07fF
C14204 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C14205 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_960_n1600# 0.26fF
C14206 divbuf_1/a_40902_n240# divbuf_1/a_41382_n240# 0.05fF
C14207 divbuf_5/a_29742_n240# divbuf_5/a_30232_n240# 0.04fF
C14208 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/OUT2 0.02fF
C14209 ro_div_0/divbuf_0/a_23550_n840# ro_div_0/divbuf_0/a_23550_n1540# 0.01fF
C14210 ro_div_0/divbuf_0/a_53790_n840# ro_div_0/divbuf_0/a_54270_n840# 0.07fF
C14211 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_53790_n1540# 0.19fF
C14212 divbuf_1/a_52320_n1600# divbuf_1/a_52350_n1540# 0.19fF
C14213 divbuf_1/a_52350_n840# divbuf_1/a_52830_n840# 0.07fF
C14214 divbuf_1/a_22110_n840# divbuf_1/a_22110_n1540# 0.01fF
C14215 divbuf_5/a_41280_n1600# divbuf_5/a_41310_n1540# 0.19fF
C14216 divbuf_5/a_41310_n840# divbuf_5/a_41790_n840# 0.07fF
C14217 divbuf_5/a_11070_n840# divbuf_5/a_11070_n1540# 0.01fF
C14218 divbuf_0/a_7792_170# divbuf_0/a_8272_170# 0.07fF
C14219 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/tspc_0/Z3 0.45fF
C14220 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_51870_n840# 0.04fF
C14221 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C14222 divbuf_4/a_15360_n1600# divbuf_4/a_15390_n840# 0.04fF
C14223 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55230_n840# 0.04fF
C14224 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C14225 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_15390_n840# 0.02fF
C14226 divbuf_2/a_22952_170# divbuf_2/a_22952_n240# 0.01fF
C14227 divbuf_2/a_1842_n240# divbuf_2/a_2322_n240# 0.05fF
C14228 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C14229 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C14230 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C14231 divbuf_0/a_36480_n1600# divbuf_0/a_36960_n1600# 0.26fF
C14232 divbuf_0/a_27322_n240# divbuf_0/a_27390_n840# 0.04fF
C14233 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C14234 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/a_630_n680# 0.01fF
C14235 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/a_19710_n840# 0.03fF
C14236 divbuf_2/a_14910_n840# divbuf_2/a_15390_n840# 0.07fF
C14237 divbuf_2/a_7302_n240# divbuf_2/OUT3 0.04fF
C14238 divbuf_2/a_14880_n1600# divbuf_2/a_14910_n1540# 0.19fF
C14239 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_29280_n1600# 0.26fF
C14240 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C14241 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/a_17122_170# 0.07fF
C14242 ro_div_0/ro_complete_0/cbank_2/switch_4/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C14243 divbuf_0/a_28830_n1540# divbuf_0/a_29310_n1540# 0.11fF
C14244 divbuf_0/a_59550_n840# divbuf_0/a_59550_n1540# 0.01fF
C14245 pll_full_0/divbuf_0/a_21150_n1540# pll_full_0/divbuf_0/a_21630_n1540# 0.11fF
C14246 pll_full_0/divbuf_0/a_51870_n840# pll_full_0/divbuf_0/a_51870_n1540# 0.01fF
C14247 divbuf_3/a_3912_170# divbuf_3/a_4392_170# 0.07fF
C14248 divbuf_3/a_36532_170# divbuf_3/OUT4 0.19fF
C14249 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/a_30232_n240# 0.04fF
C14250 divbuf_4/a_32172_170# divbuf_4/a_32652_170# 0.07fF
C14251 divbuf_4/a_12772_170# divbuf_4/a_12772_n240# 0.01fF
C14252 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/a_33622_n240# 0.05fF
C14253 divbuf_3/a_37920_n1600# divbuf_3/a_38400_n1600# 0.26fF
C14254 divbuf_3/a_28772_n240# divbuf_3/a_28830_n840# 0.04fF
C14255 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41310_n1540# 0.19fF
C14256 pd_div_0/divbuf_0/a_41310_n840# pd_div_0/divbuf_0/a_41790_n840# 0.07fF
C14257 pd_div_0/divbuf_0/a_11070_n840# pd_div_0/divbuf_0/a_11070_n1540# 0.01fF
C14258 divbuf_4/a_4830_n840# divbuf_4/a_5310_n840# 0.07fF
C14259 divbuf_4/a_4800_n1600# divbuf_4/a_4830_n1540# 0.19fF
C14260 divbuf_4/a_26352_170# divbuf_4/OUT4 0.19fF
C14261 divbuf_3/a_30270_n1540# divbuf_3/a_30750_n1540# 0.11fF
C14262 pll_full_0/divbuf_1/a_14430_n840# pll_full_0/divbuf_1/a_14430_n1540# 0.01fF
C14263 pll_full_0/divbuf_1/a_44670_n840# pll_full_0/divbuf_1/a_45150_n840# 0.07fF
C14264 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_44670_n1540# 0.19fF
C14265 divbuf_0/a_4882_170# divbuf_0/OUT3 0.19fF
C14266 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n840# 0.04fF
C14267 pd_div_0/divider_0/nor_1/A gnd 1.05fF
C14268 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/Out 0.08fF
C14269 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C14270 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z3 0.45fF
C14271 divbuf_4/a_57630_n1540# divbuf_4/a_58110_n1540# 0.11fF
C14272 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_18750_n840# 0.04fF
C14273 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/a_16642_n240# 0.01fF
C14274 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/a_31230_n840# 0.05fF
C14275 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40800_n1600# 0.26fF
C14276 divbuf_1/a_38880_n1600# divbuf_1/a_39360_n1600# 0.26fF
C14277 divbuf_1/a_4392_170# divbuf_1/OUT3 0.19fF
C14278 divbuf_1/a_29742_n240# divbuf_1/a_29790_n840# 0.04fF
C14279 divbuf_5/a_27840_n1600# divbuf_5/a_28320_n1600# 0.26fF
C14280 divbuf_5/a_18582_n240# divbuf_5/a_18750_n840# 0.02fF
C14281 divbuf_3/a_37502_n240# divbuf_3/OUT4 0.04fF
C14282 ro_div_0/divbuf_0/a_32670_n1540# ro_div_0/divbuf_0/a_33150_n1540# 0.11fF
C14283 divbuf_1/a_31230_n1540# divbuf_1/a_31710_n1540# 0.11fF
C14284 divbuf_3/a_27840_n1600# divbuf_3/a_27870_n840# 0.04fF
C14285 divbuf_5/a_50910_n840# divbuf_5/a_50910_n1540# 0.01fF
C14286 divbuf_5/a_20190_n1540# divbuf_5/a_20670_n1540# 0.11fF
C14287 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/a_1470_n840# 0.03fF
C14288 divbuf_0/a_23922_170# divbuf_0/a_23922_n240# 0.01fF
C14289 divbuf_0/a_3422_n240# divbuf_0/a_3912_n240# 0.04fF
C14290 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C14291 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/a_36052_170# 0.07fF
C14292 divbuf_2/a_1440_n1600# divbuf_2/a_1920_n1600# 0.26fF
C14293 divbuf_4/a_27322_n240# divbuf_4/OUT4 0.04fF
C14294 divbuf_4/a_55200_n1600# divbuf_4/a_55230_n840# 0.04fF
C14295 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/OUT4 0.19fF
C14296 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n1540# 0.19fF
C14297 divbuf_0/a_9242_n240# divbuf_0/OUT3 0.04fF
C14298 divbuf_0/a_15870_n840# divbuf_0/a_16350_n840# 0.07fF
C14299 divbuf_2/a_54720_n1600# divbuf_2/a_54750_n1540# 0.19fF
C14300 divbuf_2/a_54750_n840# divbuf_2/a_55230_n840# 0.07fF
C14301 divbuf_2/a_24510_n840# divbuf_2/a_24510_n1540# 0.01fF
C14302 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8190_n1540# 0.19fF
C14303 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/OUT4 0.19fF
C14304 pll_full_0/divbuf_0/a_8190_n840# pll_full_0/divbuf_0/a_8670_n840# 0.07fF
C14305 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_16642_n240# 0.04fF
C14306 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30270_n840# 0.04fF
C14307 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/R 0.27fF
C14308 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/tspc_r_0/Qbar 0.01fF
C14309 divbuf_1/a_28800_n1600# divbuf_1/a_28830_n840# 0.04fF
C14310 divbuf_3/a_25382_170# divbuf_3/a_25382_n240# 0.01fF
C14311 divbuf_3/a_4882_n240# divbuf_3/a_5362_n240# 0.05fF
C14312 divbuf_5/a_17760_n1600# divbuf_5/a_17790_n840# 0.04fF
C14313 divbuf_3/a_35520_n1600# divbuf_3/OUT4 0.00fF
C14314 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_28320_n1600# 0.26fF
C14315 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/a_18750_n840# 0.02fF
C14316 divbuf_3/a_17310_n840# divbuf_3/a_17790_n840# 0.07fF
C14317 divbuf_3/a_17280_n1600# divbuf_3/a_17310_n1540# 0.19fF
C14318 divbuf_4/a_33142_n240# divbuf_4/a_33622_n240# 0.05fF
C14319 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/a_22110_n840# 0.03fF
C14320 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31680_n1600# 0.26fF
C14321 pd_div_0/divbuf_0/a_50910_n840# pd_div_0/divbuf_0/a_50910_n1540# 0.01fF
C14322 pd_div_0/divbuf_0/a_20190_n1540# pd_div_0/divbuf_0/a_20670_n1540# 0.11fF
C14323 divbuf_2/a_12282_n240# divbuf_2/a_12030_n840# 0.02fF
C14324 divbuf_4/a_44640_n1600# divbuf_4/a_44670_n1540# 0.19fF
C14325 divbuf_4/a_44670_n840# divbuf_4/a_45150_n840# 0.07fF
C14326 divbuf_4/a_14430_n840# divbuf_4/a_14430_n1540# 0.01fF
C14327 pll_full_0/divbuf_1/a_23550_n1540# pll_full_0/divbuf_1/a_24030_n1540# 0.11fF
C14328 pll_full_0/divbuf_1/a_54270_n840# pll_full_0/divbuf_1/a_54270_n1540# 0.01fF
C14329 divbuf_1/a_5852_n240# divbuf_1/a_6332_n240# 0.05fF
C14330 divbuf_5/a_15182_170# divbuf_5/a_15182_n240# 0.01fF
C14331 divbuf_5/a_34592_170# divbuf_5/a_35082_170# 0.07fF
C14332 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_58590_n840# 0.04fF
C14333 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C14334 cp_0/a_1710_0# io_analog[0] 0.84fF
C14335 ro_div_0/divider_0/and_0/A gnd 0.69fF
C14336 ro_div_0/divbuf_0/a_19710_n840# ro_div_0/divbuf_0/a_20190_n840# 0.07fF
C14337 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_19710_n1540# 0.19fF
C14338 divbuf_1/a_18270_n840# divbuf_1/a_18750_n840# 0.07fF
C14339 divbuf_1/a_14222_n240# divbuf_1/OUT4 0.04fF
C14340 divbuf_1/a_18240_n1600# divbuf_1/a_18270_n1540# 0.19fF
C14341 divbuf_5/a_7200_n1600# divbuf_5/a_7230_n1540# 0.19fF
C14342 divbuf_5/a_31202_170# divbuf_5/OUT4 0.19fF
C14343 divbuf_5/a_7230_n840# divbuf_5/a_7710_n840# 0.07fF
C14344 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/OUT3 0.07fF
C14345 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_17790_n840# 0.04fF
C14346 divbuf_2/a_7302_170# divbuf_2/a_7792_170# 0.07fF
C14347 divbuf_4/a_1352_n240# divbuf_4/a_1470_n840# 0.03fF
C14348 divbuf_5/a_60030_n1540# divbuf_5/a_60510_n1540# 0.11fF
C14349 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21150_n840# 0.04fF
C14350 divbuf_0/a_2400_n1600# divbuf_0/a_2880_n1600# 0.26fF
C14351 divbuf_2/a_41280_n1600# divbuf_2/a_41760_n1600# 0.26fF
C14352 divbuf_2/a_32172_n240# divbuf_2/a_32190_n840# 0.06fF
C14353 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/a_37022_n240# 0.04fF
C14354 divbuf_0/a_25470_n840# divbuf_0/a_25470_n1540# 0.01fF
C14355 divbuf_0/a_55710_n840# divbuf_0/a_56190_n840# 0.07fF
C14356 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n1540# 0.19fF
C14357 divbuf_2/a_33630_n1540# divbuf_2/a_34110_n1540# 0.11fF
C14358 pll_full_0/divbuf_0/a_17790_n840# pll_full_0/divbuf_0/a_17790_n1540# 0.01fF
C14359 pll_full_0/divbuf_0/a_48030_n840# pll_full_0/divbuf_0/a_48510_n840# 0.07fF
C14360 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48030_n1540# 0.19fF
C14361 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C14362 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/a_15182_n240# 0.01fF
C14363 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/a_35082_170# 0.07fF
C14364 divbuf_1/a_12480_n1600# divbuf_1/OUT4 0.00fF
C14365 divbuf_5/a_32172_n240# divbuf_5/OUT4 0.04fF
C14366 divbuf_5/a_57600_n1600# divbuf_5/a_57630_n840# 0.04fF
C14367 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/a_38472_170# 0.07fF
C14368 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/a_18582_n240# 0.01fF
C14369 divbuf_3/a_3840_n1600# divbuf_3/a_4320_n1600# 0.26fF
C14370 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C14371 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/a0 0.09fF
C14372 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/tspc_0/Z3 0.06fF
C14373 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C14374 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7230_n1540# 0.19fF
C14375 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/OUT4 0.19fF
C14376 pd_div_0/divbuf_0/a_7230_n840# pd_div_0/divbuf_0/a_7710_n840# 0.07fF
C14377 divbuf_4/a_31200_n1600# divbuf_4/a_31680_n1600# 0.26fF
C14378 divbuf_4/a_21982_n240# divbuf_4/a_22110_n840# 0.03fF
C14379 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/a_11070_n840# 0.07fF
C14380 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/OUT4 0.19fF
C14381 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_10590_n1540# 0.19fF
C14382 divbuf_3/a_57150_n840# divbuf_3/a_57630_n840# 0.07fF
C14383 divbuf_3/a_26910_n840# divbuf_3/a_26910_n1540# 0.01fF
C14384 ashish_0/vop ashish_0/Gnd 0.33fF
C14385 divbuf_0/a_13252_n240# divbuf_0/a_12990_n840# 0.01fF
C14386 pd_div_0/divbuf_0/a_60030_n1540# pd_div_0/divbuf_0/a_60510_n1540# 0.11fF
C14387 divbuf_2/a_31200_n1600# divbuf_2/a_31230_n840# 0.04fF
C14388 divbuf_2/a_18092_170# divbuf_2/OUT4 0.19fF
C14389 divbuf_4/a_54270_n840# divbuf_4/a_54270_n1540# 0.01fF
C14390 divbuf_4/a_23550_n1540# divbuf_4/a_24030_n1540# 0.11fF
Xashish_0 ashish_0/von ashish_0/vop ashish_0/Gnd ashish
Xpd_0 vssa1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xcp_0 vssa1 vssa1 vssa1 io_analog[0] io_analog[1] cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_div_0/ro_complete_0 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/a1 ro_div_0/ro_complete_0/a5
+ ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/a2 ro_complete
Xro_div_0/divbuf_0 VDD ro_div_0/divbuf_0/IN ro_div_0/divbuf_0/OUT ro_div_0/divbuf_0/OUT2
+ ro_div_0/divbuf_0/OUT3 ro_div_0/divbuf_0/OUT4 ro_div_0/divbuf_0/OUT5 vssa1 divbuf
Xro_div_0/divider_0 gnd vdd ro_div_0/divbuf_0/IN ro_div_0/divider_0/clk gnd divider
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xdivbuf_0 VDD divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ vssa1 divbuf
Xpd_div_0 pd_div_0/div pd_div_0/bufin pd_div
Xdivbuf_1 VDD divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4 divbuf_1/OUT5
+ vssa1 divbuf
Xdivbuf_2 vssa1 pd_0/DOWN io_analog[10] divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4
+ divbuf_2/OUT5 vssa1 divbuf
Xdivbuf_3 vssa1 pd_0/UP io_analog[9] divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4 divbuf_3/OUT5
+ vssa1 divbuf
Xdivbuf_4 vssa1 vssa1 pd_0/REF divbuf_4/OUT2 divbuf_4/OUT3 divbuf_4/OUT4 divbuf_4/OUT5
+ vssa1 divbuf
Xdivbuf_5 vssa1 gpio_analog[7] pd_0/DIV divbuf_5/OUT2 divbuf_5/OUT3 divbuf_5/OUT4
+ divbuf_5/OUT5 vssa1 divbuf
Xpll_full_0 vdd pll_full
C14391 io_analog[5] vdd 25.05fF
C14392 io_analog[6] vdd 25.05fF
C14393 io_in_3v3[0] vdd 0.61fF
C14394 io_oeb[26] vdd 0.61fF
C14395 io_in[0] vdd 0.61fF
C14396 io_out[26] vdd 0.61fF
C14397 io_out[0] vdd 0.61fF
C14398 io_in[26] vdd 0.61fF
C14399 io_oeb[0] vdd 0.61fF
C14400 io_in_3v3[26] vdd 0.61fF
C14401 io_in_3v3[1] vdd 0.61fF
C14402 io_oeb[25] vdd 0.61fF
C14403 io_in[1] vdd 0.61fF
C14404 io_out[25] vdd 0.61fF
C14405 io_out[1] vdd 0.61fF
C14406 io_in[25] vdd 0.61fF
C14407 io_oeb[1] vdd 0.61fF
C14408 io_in_3v3[25] vdd 0.61fF
C14409 io_in_3v3[2] vdd 0.61fF
C14410 io_oeb[24] vdd 0.61fF
C14411 io_in[2] vdd 0.61fF
C14412 io_out[24] vdd 0.61fF
C14413 io_out[2] vdd 0.61fF
C14414 io_in[24] vdd 0.61fF
C14415 io_oeb[2] vdd 0.61fF
C14416 io_in_3v3[24] vdd 0.61fF
C14417 io_in_3v3[3] vdd 0.61fF
C14418 gpio_noesd[17] vdd 0.61fF
C14419 io_in[3] vdd 0.61fF
C14420 gpio_analog[17] vdd 0.61fF
C14421 io_out[3] vdd 0.61fF
C14422 io_oeb[3] vdd 0.61fF
C14423 io_in_3v3[4] vdd 0.61fF
C14424 io_in[4] vdd 0.61fF
C14425 io_out[4] vdd 0.61fF
C14426 io_oeb[4] vdd 0.61fF
C14427 io_oeb[23] vdd 0.61fF
C14428 io_out[23] vdd 0.61fF
C14429 io_in[23] vdd 0.61fF
C14430 io_in_3v3[23] vdd 0.61fF
C14431 gpio_noesd[16] vdd 0.61fF
C14432 gpio_analog[16] vdd 0.61fF
C14433 io_in_3v3[5] vdd 0.61fF
C14434 io_in[5] vdd 0.61fF
C14435 io_out[5] vdd 0.61fF
C14436 io_oeb[5] vdd 0.61fF
C14437 io_oeb[22] vdd 0.61fF
C14438 io_out[22] vdd 0.61fF
C14439 io_in[22] vdd 0.61fF
C14440 io_in_3v3[22] vdd 0.61fF
C14441 gpio_noesd[15] vdd 0.61fF
C14442 gpio_analog[15] vdd 0.61fF
C14443 io_in_3v3[6] vdd 0.61fF
C14444 io_in[6] vdd 0.61fF
C14445 io_out[6] vdd 0.61fF
C14446 io_oeb[6] vdd 0.61fF
C14447 io_oeb[21] vdd 0.61fF
C14448 io_out[21] vdd 0.61fF
C14449 io_in[21] vdd 0.61fF
C14450 io_in_3v3[21] vdd 0.61fF
C14451 gpio_noesd[14] vdd 0.61fF
C14452 gpio_analog[14] vdd 0.61fF
C14453 vssd2 vdd 13.04fF
C14454 vssd1 vdd 13.04fF
C14455 vdda2 vdd 13.04fF
C14456 io_oeb[20] vdd 0.61fF
C14457 io_out[20] vdd 0.61fF
C14458 io_in[20] vdd 0.61fF
C14459 io_in_3v3[20] vdd 0.61fF
C14460 gpio_noesd[13] vdd 0.61fF
C14461 gpio_analog[13] vdd 0.61fF
C14462 gpio_analog[0] vdd 0.61fF
C14463 gpio_noesd[0] vdd 0.61fF
C14464 io_in_3v3[7] vdd 0.61fF
C14465 io_in[7] vdd 0.61fF
C14466 io_out[7] vdd 0.61fF
C14467 io_oeb[7] vdd 0.61fF
C14468 io_oeb[19] vdd 0.61fF
C14469 io_out[19] vdd 0.61fF
C14470 io_in[19] vdd 0.61fF
C14471 io_in_3v3[19] vdd 0.61fF
C14472 gpio_noesd[12] vdd 0.61fF
C14473 gpio_analog[12] vdd 0.61fF
C14474 gpio_analog[1] vdd 0.61fF
C14475 gpio_noesd[1] vdd 0.61fF
C14476 io_in_3v3[8] vdd 0.61fF
C14477 io_in[8] vdd 0.61fF
C14478 io_out[8] vdd 0.61fF
C14479 io_oeb[8] vdd 0.61fF
C14480 io_oeb[18] vdd 0.61fF
C14481 io_out[18] vdd 0.61fF
C14482 io_in[18] vdd 0.61fF
C14483 io_in_3v3[18] vdd 0.61fF
C14484 gpio_noesd[11] vdd 0.61fF
C14485 gpio_analog[11] vdd 0.61fF
C14486 gpio_analog[2] vdd 0.61fF
C14487 gpio_noesd[2] vdd 0.61fF
C14488 io_in_3v3[9] vdd 0.61fF
C14489 io_in[9] vdd 0.61fF
C14490 io_out[9] vdd 0.61fF
C14491 io_oeb[9] vdd 0.61fF
C14492 io_oeb[17] vdd 0.61fF
C14493 io_out[17] vdd 0.61fF
C14494 io_in[17] vdd 0.61fF
C14495 io_in_3v3[17] vdd 0.61fF
C14496 gpio_noesd[10] vdd 0.61fF
C14497 gpio_analog[10] vdd 0.61fF
C14498 gpio_analog[3] vdd 0.61fF
C14499 gpio_noesd[3] vdd 0.61fF
C14500 io_in_3v3[10] vdd 0.61fF
C14501 io_in[10] vdd 0.61fF
C14502 io_out[10] vdd 0.61fF
C14503 io_oeb[10] vdd 0.61fF
C14504 io_oeb[16] vdd 0.61fF
C14505 io_out[16] vdd 0.61fF
C14506 io_in[16] vdd 0.61fF
C14507 io_in_3v3[16] vdd 0.61fF
C14508 gpio_noesd[9] vdd 0.61fF
C14509 gpio_analog[9] vdd 0.61fF
C14510 gpio_analog[4] vdd 0.61fF
C14511 gpio_noesd[4] vdd 0.61fF
C14512 io_in_3v3[11] vdd 0.61fF
C14513 io_in[11] vdd 0.61fF
C14514 io_out[11] vdd 0.61fF
C14515 io_oeb[11] vdd 0.61fF
C14516 io_oeb[15] vdd 0.61fF
C14517 io_out[15] vdd 0.61fF
C14518 io_in[15] vdd 0.61fF
C14519 io_in_3v3[15] vdd 0.61fF
C14520 gpio_noesd[8] vdd 0.61fF
C14521 gpio_analog[8] vdd 0.61fF
C14522 gpio_analog[5] vdd 0.61fF
C14523 gpio_noesd[5] vdd 0.61fF
C14524 io_in_3v3[12] vdd 0.61fF
C14525 io_in[12] vdd 0.61fF
C14526 io_out[12] vdd 0.61fF
C14527 io_oeb[12] vdd 0.61fF
C14528 io_oeb[14] vdd 0.61fF
C14529 io_out[14] vdd 0.61fF
C14530 io_in[14] vdd 0.61fF
C14531 io_in_3v3[14] vdd 0.61fF
C14532 gpio_noesd[7] vdd 0.61fF
C14533 vssa2 vdd 13.04fF
C14534 gpio_analog[6] vdd 0.61fF
C14535 gpio_noesd[6] vdd 0.61fF
C14536 io_in_3v3[13] vdd 0.61fF
C14537 io_in[13] vdd 0.61fF
C14538 io_out[13] vdd 0.61fF
C14539 io_oeb[13] vdd 0.61fF
C14540 vccd1 vdd 13.04fF
C14541 vccd2 vdd 13.04fF
C14542 io_analog[3] vdd 6.86fF
C14543 io_clamp_high[0] vdd 4.10fF
C14544 io_clamp_low[0] vdd 4.10fF
C14545 io_clamp_high[1] vdd 3.58fF
C14546 io_clamp_low[1] vdd 3.58fF
C14547 io_clamp_high[2] vdd 3.58fF
C14548 io_clamp_low[2] vdd 3.58fF
C14549 io_analog[7] vdd 6.83fF
C14550 io_analog[8] vdd 6.83fF
C14551 user_irq[2] vdd 0.63fF
C14552 user_irq[1] vdd 0.63fF
C14553 user_irq[0] vdd 0.63fF
C14554 user_clock2 vdd 0.63fF
C14555 la_oenb[127] vdd 0.63fF
C14556 la_data_out[127] vdd 0.63fF
C14557 la_data_in[127] vdd 0.63fF
C14558 la_oenb[126] vdd 0.63fF
C14559 la_data_out[126] vdd 0.63fF
C14560 la_data_in[126] vdd 0.63fF
C14561 la_oenb[125] vdd 0.63fF
C14562 la_data_out[125] vdd 0.63fF
C14563 la_data_in[125] vdd 0.63fF
C14564 la_oenb[124] vdd 0.63fF
C14565 la_data_out[124] vdd 0.63fF
C14566 la_data_in[124] vdd 0.63fF
C14567 la_oenb[123] vdd 0.63fF
C14568 la_data_out[123] vdd 0.63fF
C14569 la_data_in[123] vdd 0.63fF
C14570 la_oenb[122] vdd 0.63fF
C14571 la_data_out[122] vdd 0.63fF
C14572 la_data_in[122] vdd 0.63fF
C14573 la_oenb[121] vdd 0.63fF
C14574 la_data_out[121] vdd 0.63fF
C14575 la_data_in[121] vdd 0.63fF
C14576 la_oenb[120] vdd 0.63fF
C14577 la_data_out[120] vdd 0.63fF
C14578 la_data_in[120] vdd 0.63fF
C14579 la_oenb[119] vdd 0.63fF
C14580 la_data_out[119] vdd 0.63fF
C14581 la_data_in[119] vdd 0.63fF
C14582 la_oenb[118] vdd 0.63fF
C14583 la_data_out[118] vdd 0.63fF
C14584 la_data_in[118] vdd 0.63fF
C14585 la_oenb[117] vdd 0.63fF
C14586 la_data_out[117] vdd 0.63fF
C14587 la_data_in[117] vdd 0.63fF
C14588 la_oenb[116] vdd 0.63fF
C14589 la_data_out[116] vdd 0.63fF
C14590 la_data_in[116] vdd 0.63fF
C14591 la_oenb[115] vdd 0.63fF
C14592 la_data_out[115] vdd 0.63fF
C14593 la_data_in[115] vdd 0.63fF
C14594 la_oenb[114] vdd 0.63fF
C14595 la_data_out[114] vdd 0.63fF
C14596 la_data_in[114] vdd 0.63fF
C14597 la_oenb[113] vdd 0.63fF
C14598 la_data_out[113] vdd 0.63fF
C14599 la_data_in[113] vdd 0.63fF
C14600 la_oenb[112] vdd 0.63fF
C14601 la_data_out[112] vdd 0.63fF
C14602 la_data_in[112] vdd 0.63fF
C14603 la_oenb[111] vdd 0.63fF
C14604 la_data_out[111] vdd 0.63fF
C14605 la_data_in[111] vdd 0.63fF
C14606 la_oenb[110] vdd 0.63fF
C14607 la_data_out[110] vdd 0.63fF
C14608 la_data_in[110] vdd 0.63fF
C14609 la_oenb[109] vdd 0.63fF
C14610 la_data_out[109] vdd 0.63fF
C14611 la_data_in[109] vdd 0.63fF
C14612 la_oenb[108] vdd 0.63fF
C14613 la_data_out[108] vdd 0.63fF
C14614 la_data_in[108] vdd 0.63fF
C14615 la_oenb[107] vdd 0.63fF
C14616 la_data_out[107] vdd 0.63fF
C14617 la_data_in[107] vdd 0.63fF
C14618 la_oenb[106] vdd 0.63fF
C14619 la_data_out[106] vdd 0.63fF
C14620 la_data_in[106] vdd 0.63fF
C14621 la_oenb[105] vdd 0.63fF
C14622 la_data_out[105] vdd 0.63fF
C14623 la_data_in[105] vdd 0.63fF
C14624 la_oenb[104] vdd 0.63fF
C14625 la_data_out[104] vdd 0.63fF
C14626 la_data_in[104] vdd 0.63fF
C14627 la_oenb[103] vdd 0.63fF
C14628 la_data_out[103] vdd 0.63fF
C14629 la_data_in[103] vdd 0.63fF
C14630 la_oenb[102] vdd 0.63fF
C14631 la_data_out[102] vdd 0.63fF
C14632 la_data_in[102] vdd 0.63fF
C14633 la_oenb[101] vdd 0.63fF
C14634 la_data_out[101] vdd 0.63fF
C14635 la_data_in[101] vdd 0.63fF
C14636 la_oenb[100] vdd 0.63fF
C14637 la_data_out[100] vdd 0.63fF
C14638 la_data_in[100] vdd 0.63fF
C14639 la_oenb[99] vdd 0.63fF
C14640 la_data_out[99] vdd 0.63fF
C14641 la_data_in[99] vdd 0.63fF
C14642 la_oenb[98] vdd 0.63fF
C14643 la_data_out[98] vdd 0.63fF
C14644 la_data_in[98] vdd 0.63fF
C14645 la_oenb[97] vdd 0.63fF
C14646 la_data_out[97] vdd 0.63fF
C14647 la_data_in[97] vdd 0.63fF
C14648 la_oenb[96] vdd 0.63fF
C14649 la_data_out[96] vdd 0.63fF
C14650 la_data_in[96] vdd 0.63fF
C14651 la_oenb[95] vdd 0.63fF
C14652 la_data_out[95] vdd 0.63fF
C14653 la_data_in[95] vdd 0.63fF
C14654 la_oenb[94] vdd 0.63fF
C14655 la_data_out[94] vdd 0.63fF
C14656 la_data_in[94] vdd 0.63fF
C14657 la_oenb[93] vdd 0.63fF
C14658 la_data_out[93] vdd 0.63fF
C14659 la_data_in[93] vdd 0.63fF
C14660 la_oenb[92] vdd 0.63fF
C14661 la_data_out[92] vdd 0.63fF
C14662 la_data_in[92] vdd 0.63fF
C14663 la_oenb[91] vdd 0.63fF
C14664 la_data_out[91] vdd 0.63fF
C14665 la_data_in[91] vdd 0.63fF
C14666 la_oenb[90] vdd 0.63fF
C14667 la_data_out[90] vdd 0.63fF
C14668 la_data_in[90] vdd 0.63fF
C14669 la_oenb[89] vdd 0.63fF
C14670 la_data_out[89] vdd 0.63fF
C14671 la_data_in[89] vdd 0.63fF
C14672 la_oenb[88] vdd 0.63fF
C14673 la_data_out[88] vdd 0.63fF
C14674 la_data_in[88] vdd 0.63fF
C14675 la_oenb[87] vdd 0.63fF
C14676 la_data_out[87] vdd 0.63fF
C14677 la_data_in[87] vdd 0.63fF
C14678 la_oenb[86] vdd 0.63fF
C14679 la_data_out[86] vdd 0.63fF
C14680 la_data_in[86] vdd 0.63fF
C14681 la_oenb[85] vdd 0.63fF
C14682 la_data_out[85] vdd 0.63fF
C14683 la_data_in[85] vdd 0.63fF
C14684 la_oenb[84] vdd 0.63fF
C14685 la_data_out[84] vdd 0.63fF
C14686 la_data_in[84] vdd 0.63fF
C14687 la_oenb[83] vdd 0.63fF
C14688 la_data_out[83] vdd 0.63fF
C14689 la_data_in[83] vdd 0.63fF
C14690 la_oenb[82] vdd 0.63fF
C14691 la_data_out[82] vdd 0.63fF
C14692 la_data_in[82] vdd 0.63fF
C14693 la_oenb[81] vdd 0.63fF
C14694 la_data_out[81] vdd 0.63fF
C14695 la_data_in[81] vdd 0.63fF
C14696 la_oenb[80] vdd 0.63fF
C14697 la_data_out[80] vdd 0.63fF
C14698 la_data_in[80] vdd 0.63fF
C14699 la_oenb[79] vdd 0.63fF
C14700 la_data_out[79] vdd 0.63fF
C14701 la_data_in[79] vdd 0.63fF
C14702 la_oenb[78] vdd 0.63fF
C14703 la_data_out[78] vdd 0.63fF
C14704 la_data_in[78] vdd 0.63fF
C14705 la_oenb[77] vdd 0.63fF
C14706 la_data_out[77] vdd 0.63fF
C14707 la_data_in[77] vdd 0.63fF
C14708 la_oenb[76] vdd 0.63fF
C14709 la_data_out[76] vdd 0.63fF
C14710 la_data_in[76] vdd 0.63fF
C14711 la_oenb[75] vdd 0.63fF
C14712 la_data_out[75] vdd 0.63fF
C14713 la_data_in[75] vdd 0.63fF
C14714 la_oenb[74] vdd 0.63fF
C14715 la_data_out[74] vdd 0.63fF
C14716 la_data_in[74] vdd 0.63fF
C14717 la_oenb[73] vdd 0.63fF
C14718 la_data_out[73] vdd 0.63fF
C14719 la_data_in[73] vdd 0.63fF
C14720 la_oenb[72] vdd 0.63fF
C14721 la_data_out[72] vdd 0.63fF
C14722 la_data_in[72] vdd 0.63fF
C14723 la_oenb[71] vdd 0.63fF
C14724 la_data_out[71] vdd 0.63fF
C14725 la_data_in[71] vdd 0.63fF
C14726 la_oenb[70] vdd 0.63fF
C14727 la_data_out[70] vdd 0.63fF
C14728 la_data_in[70] vdd 0.63fF
C14729 la_oenb[69] vdd 0.63fF
C14730 la_data_out[69] vdd 0.63fF
C14731 la_data_in[69] vdd 0.63fF
C14732 la_oenb[68] vdd 0.63fF
C14733 la_data_out[68] vdd 0.63fF
C14734 la_data_in[68] vdd 0.63fF
C14735 la_oenb[67] vdd 0.63fF
C14736 la_data_out[67] vdd 0.63fF
C14737 la_data_in[67] vdd 0.63fF
C14738 la_oenb[66] vdd 0.63fF
C14739 la_data_out[66] vdd 0.63fF
C14740 la_data_in[66] vdd 0.63fF
C14741 la_oenb[65] vdd 0.63fF
C14742 la_data_out[65] vdd 0.63fF
C14743 la_data_in[65] vdd 0.63fF
C14744 la_oenb[64] vdd 0.63fF
C14745 la_data_out[64] vdd 0.63fF
C14746 la_data_in[64] vdd 0.63fF
C14747 la_oenb[63] vdd 0.63fF
C14748 la_data_out[63] vdd 0.63fF
C14749 la_data_in[63] vdd 0.63fF
C14750 la_oenb[62] vdd 0.63fF
C14751 la_data_out[62] vdd 0.63fF
C14752 la_data_in[62] vdd 0.63fF
C14753 la_oenb[61] vdd 0.63fF
C14754 la_data_out[61] vdd 0.63fF
C14755 la_data_in[61] vdd 0.63fF
C14756 la_oenb[60] vdd 0.63fF
C14757 la_data_out[60] vdd 0.63fF
C14758 la_data_in[60] vdd 0.63fF
C14759 la_oenb[59] vdd 0.63fF
C14760 la_data_out[59] vdd 0.63fF
C14761 la_data_in[59] vdd 0.63fF
C14762 la_oenb[58] vdd 0.63fF
C14763 la_data_out[58] vdd 0.63fF
C14764 la_data_in[58] vdd 0.63fF
C14765 la_oenb[57] vdd 0.63fF
C14766 la_data_out[57] vdd 0.63fF
C14767 la_data_in[57] vdd 0.63fF
C14768 la_oenb[56] vdd 0.63fF
C14769 la_data_out[56] vdd 0.63fF
C14770 la_data_in[56] vdd 0.63fF
C14771 la_oenb[55] vdd 0.63fF
C14772 la_data_out[55] vdd 0.63fF
C14773 la_data_in[55] vdd 0.63fF
C14774 la_oenb[54] vdd 0.63fF
C14775 la_data_out[54] vdd 0.63fF
C14776 la_data_in[54] vdd 0.63fF
C14777 la_oenb[53] vdd 0.63fF
C14778 la_data_out[53] vdd 0.63fF
C14779 la_data_in[53] vdd 0.63fF
C14780 la_oenb[52] vdd 0.63fF
C14781 la_data_out[52] vdd 0.63fF
C14782 la_data_in[52] vdd 0.63fF
C14783 la_oenb[51] vdd 0.63fF
C14784 la_data_out[51] vdd 0.63fF
C14785 la_data_in[51] vdd 0.63fF
C14786 la_oenb[50] vdd 0.63fF
C14787 la_data_out[50] vdd 0.63fF
C14788 la_data_in[50] vdd 0.63fF
C14789 la_oenb[49] vdd 0.63fF
C14790 la_data_out[49] vdd 0.63fF
C14791 la_data_in[49] vdd 0.63fF
C14792 la_oenb[48] vdd 0.63fF
C14793 la_data_out[48] vdd 0.63fF
C14794 la_data_in[48] vdd 0.63fF
C14795 la_oenb[47] vdd 0.63fF
C14796 la_data_out[47] vdd 0.63fF
C14797 la_data_in[47] vdd 0.63fF
C14798 la_oenb[46] vdd 0.63fF
C14799 la_data_out[46] vdd 0.63fF
C14800 la_data_in[46] vdd 0.63fF
C14801 la_oenb[45] vdd 0.63fF
C14802 la_data_out[45] vdd 0.63fF
C14803 la_data_in[45] vdd 0.63fF
C14804 la_oenb[44] vdd 0.63fF
C14805 la_data_out[44] vdd 0.63fF
C14806 la_data_in[44] vdd 0.63fF
C14807 la_oenb[43] vdd 0.63fF
C14808 la_data_out[43] vdd 0.63fF
C14809 la_data_in[43] vdd 0.63fF
C14810 la_oenb[42] vdd 0.63fF
C14811 la_data_out[42] vdd 0.63fF
C14812 la_data_in[42] vdd 0.63fF
C14813 la_oenb[41] vdd 0.63fF
C14814 la_data_out[41] vdd 0.63fF
C14815 la_data_in[41] vdd 0.63fF
C14816 la_oenb[40] vdd 0.63fF
C14817 la_data_out[40] vdd 0.63fF
C14818 la_data_in[40] vdd 0.63fF
C14819 la_oenb[39] vdd 0.63fF
C14820 la_data_out[39] vdd 0.63fF
C14821 la_data_in[39] vdd 0.63fF
C14822 la_oenb[38] vdd 0.63fF
C14823 la_data_out[38] vdd 0.63fF
C14824 la_data_in[38] vdd 0.63fF
C14825 la_oenb[37] vdd 0.63fF
C14826 la_data_out[37] vdd 0.63fF
C14827 la_data_in[37] vdd 0.63fF
C14828 la_oenb[36] vdd 0.63fF
C14829 la_data_out[36] vdd 0.63fF
C14830 la_data_in[36] vdd 0.63fF
C14831 la_oenb[35] vdd 0.63fF
C14832 la_data_out[35] vdd 0.63fF
C14833 la_data_in[35] vdd 0.63fF
C14834 la_oenb[34] vdd 0.63fF
C14835 la_data_out[34] vdd 0.63fF
C14836 la_data_in[34] vdd 0.63fF
C14837 la_oenb[33] vdd 0.63fF
C14838 la_data_out[33] vdd 0.63fF
C14839 la_data_in[33] vdd 0.63fF
C14840 la_oenb[32] vdd 0.63fF
C14841 la_data_out[32] vdd 0.63fF
C14842 la_data_in[32] vdd 0.63fF
C14843 la_oenb[31] vdd 0.63fF
C14844 la_data_out[31] vdd 0.63fF
C14845 la_data_in[31] vdd 0.63fF
C14846 la_oenb[30] vdd 0.63fF
C14847 la_data_out[30] vdd 0.63fF
C14848 la_data_in[30] vdd 0.63fF
C14849 la_oenb[29] vdd 0.63fF
C14850 la_data_out[29] vdd 0.63fF
C14851 la_data_in[29] vdd 0.63fF
C14852 la_oenb[28] vdd 0.63fF
C14853 la_data_out[28] vdd 0.63fF
C14854 la_data_in[28] vdd 0.63fF
C14855 la_oenb[27] vdd 0.63fF
C14856 la_data_out[27] vdd 0.63fF
C14857 la_data_in[27] vdd 0.63fF
C14858 la_oenb[26] vdd 0.63fF
C14859 la_data_out[26] vdd 0.63fF
C14860 la_data_in[26] vdd 0.63fF
C14861 la_oenb[25] vdd 0.63fF
C14862 la_data_out[25] vdd 0.63fF
C14863 la_data_in[25] vdd 0.63fF
C14864 la_oenb[24] vdd 0.63fF
C14865 la_data_out[24] vdd 0.63fF
C14866 la_data_in[24] vdd 0.63fF
C14867 la_oenb[23] vdd 0.63fF
C14868 la_data_out[23] vdd 0.63fF
C14869 la_data_in[23] vdd 0.63fF
C14870 la_oenb[22] vdd 0.63fF
C14871 la_data_out[22] vdd 0.63fF
C14872 la_data_in[22] vdd 0.63fF
C14873 la_oenb[21] vdd 0.63fF
C14874 la_data_out[21] vdd 0.63fF
C14875 la_data_in[21] vdd 0.63fF
C14876 la_oenb[20] vdd 0.63fF
C14877 la_data_out[20] vdd 0.63fF
C14878 la_data_in[20] vdd 0.63fF
C14879 la_oenb[19] vdd 0.63fF
C14880 la_data_out[19] vdd 0.63fF
C14881 la_data_in[19] vdd 0.63fF
C14882 la_oenb[18] vdd 0.63fF
C14883 la_data_out[18] vdd 0.63fF
C14884 la_data_in[18] vdd 0.63fF
C14885 la_oenb[17] vdd 0.63fF
C14886 la_data_out[17] vdd 0.63fF
C14887 la_data_in[17] vdd 0.63fF
C14888 la_oenb[16] vdd 0.63fF
C14889 la_data_out[16] vdd 0.63fF
C14890 la_data_in[16] vdd 0.63fF
C14891 la_oenb[15] vdd 0.63fF
C14892 la_data_out[15] vdd 0.63fF
C14893 la_data_in[15] vdd 0.63fF
C14894 la_oenb[14] vdd 0.63fF
C14895 la_data_out[14] vdd 0.63fF
C14896 la_data_in[14] vdd 0.63fF
C14897 la_oenb[13] vdd 0.63fF
C14898 la_data_out[13] vdd 0.63fF
C14899 la_data_in[13] vdd 0.63fF
C14900 la_oenb[12] vdd 0.63fF
C14901 la_data_out[12] vdd 0.63fF
C14902 la_data_in[12] vdd 0.63fF
C14903 la_oenb[11] vdd 0.63fF
C14904 la_data_out[11] vdd 0.63fF
C14905 la_data_in[11] vdd 0.63fF
C14906 la_oenb[10] vdd 0.63fF
C14907 la_data_out[10] vdd 0.63fF
C14908 la_data_in[10] vdd 0.63fF
C14909 la_oenb[9] vdd 0.63fF
C14910 la_data_out[9] vdd 0.63fF
C14911 la_data_in[9] vdd 0.63fF
C14912 la_oenb[8] vdd 0.63fF
C14913 la_data_out[8] vdd 0.63fF
C14914 la_data_in[8] vdd 0.63fF
C14915 la_oenb[7] vdd 0.63fF
C14916 la_data_out[7] vdd 0.63fF
C14917 la_data_in[7] vdd 0.63fF
C14918 la_oenb[6] vdd 0.63fF
C14919 la_data_out[6] vdd 0.63fF
C14920 la_data_in[6] vdd 0.63fF
C14921 la_oenb[5] vdd 0.63fF
C14922 la_data_out[5] vdd 0.63fF
C14923 la_data_in[5] vdd 0.63fF
C14924 la_oenb[4] vdd 0.63fF
C14925 la_data_out[4] vdd 0.63fF
C14926 la_data_in[4] vdd 0.63fF
C14927 la_oenb[3] vdd 0.63fF
C14928 la_data_out[3] vdd 0.63fF
C14929 la_data_in[3] vdd 0.63fF
C14930 la_oenb[2] vdd 0.63fF
C14931 la_data_out[2] vdd 0.63fF
C14932 la_data_in[2] vdd 0.63fF
C14933 la_oenb[1] vdd 0.63fF
C14934 la_data_out[1] vdd 0.63fF
C14935 la_data_in[1] vdd 0.63fF
C14936 la_oenb[0] vdd 0.63fF
C14937 la_data_out[0] vdd 0.63fF
C14938 la_data_in[0] vdd 0.63fF
C14939 wbs_dat_o[31] vdd 0.63fF
C14940 wbs_dat_i[31] vdd 0.63fF
C14941 wbs_adr_i[31] vdd 0.63fF
C14942 wbs_dat_o[30] vdd 0.63fF
C14943 wbs_dat_i[30] vdd 0.63fF
C14944 wbs_adr_i[30] vdd 0.63fF
C14945 wbs_dat_o[29] vdd 0.63fF
C14946 wbs_dat_i[29] vdd 0.63fF
C14947 wbs_adr_i[29] vdd 0.63fF
C14948 wbs_dat_o[28] vdd 0.63fF
C14949 wbs_dat_i[28] vdd 0.63fF
C14950 wbs_adr_i[28] vdd 0.63fF
C14951 wbs_dat_o[27] vdd 0.63fF
C14952 wbs_dat_i[27] vdd 0.63fF
C14953 wbs_adr_i[27] vdd 0.63fF
C14954 wbs_dat_o[26] vdd 0.63fF
C14955 wbs_dat_i[26] vdd 0.63fF
C14956 wbs_adr_i[26] vdd 0.63fF
C14957 wbs_dat_o[25] vdd 0.63fF
C14958 wbs_dat_i[25] vdd 0.63fF
C14959 wbs_adr_i[25] vdd 0.63fF
C14960 wbs_dat_o[24] vdd 0.63fF
C14961 wbs_dat_i[24] vdd 0.63fF
C14962 wbs_adr_i[24] vdd 0.63fF
C14963 wbs_dat_o[23] vdd 0.63fF
C14964 wbs_dat_i[23] vdd 0.63fF
C14965 wbs_adr_i[23] vdd 0.63fF
C14966 wbs_dat_o[22] vdd 0.63fF
C14967 wbs_dat_i[22] vdd 0.63fF
C14968 wbs_adr_i[22] vdd 0.63fF
C14969 wbs_dat_o[21] vdd 0.63fF
C14970 wbs_dat_i[21] vdd 0.63fF
C14971 wbs_adr_i[21] vdd 0.63fF
C14972 wbs_dat_o[20] vdd 0.63fF
C14973 wbs_dat_i[20] vdd 0.63fF
C14974 wbs_adr_i[20] vdd 0.63fF
C14975 wbs_dat_o[19] vdd 0.63fF
C14976 wbs_dat_i[19] vdd 0.63fF
C14977 wbs_adr_i[19] vdd 0.63fF
C14978 wbs_dat_o[18] vdd 0.63fF
C14979 wbs_dat_i[18] vdd 0.63fF
C14980 wbs_adr_i[18] vdd 0.63fF
C14981 wbs_dat_o[17] vdd 0.63fF
C14982 wbs_dat_i[17] vdd 0.63fF
C14983 wbs_adr_i[17] vdd 0.63fF
C14984 wbs_dat_o[16] vdd 0.63fF
C14985 wbs_dat_i[16] vdd 0.63fF
C14986 wbs_adr_i[16] vdd 0.63fF
C14987 wbs_dat_o[15] vdd 0.63fF
C14988 wbs_dat_i[15] vdd 0.63fF
C14989 wbs_adr_i[15] vdd 0.63fF
C14990 wbs_dat_o[14] vdd 0.63fF
C14991 wbs_dat_i[14] vdd 0.63fF
C14992 wbs_adr_i[14] vdd 0.63fF
C14993 wbs_dat_o[13] vdd 0.63fF
C14994 wbs_dat_i[13] vdd 0.63fF
C14995 wbs_adr_i[13] vdd 0.63fF
C14996 wbs_dat_o[12] vdd 0.63fF
C14997 wbs_dat_i[12] vdd 0.63fF
C14998 wbs_adr_i[12] vdd 0.63fF
C14999 wbs_dat_o[11] vdd 0.63fF
C15000 wbs_dat_i[11] vdd 0.63fF
C15001 wbs_adr_i[11] vdd 0.63fF
C15002 wbs_dat_o[10] vdd 0.63fF
C15003 wbs_dat_i[10] vdd 0.63fF
C15004 wbs_adr_i[10] vdd 0.63fF
C15005 wbs_dat_o[9] vdd 0.63fF
C15006 wbs_dat_i[9] vdd 0.63fF
C15007 wbs_adr_i[9] vdd 0.63fF
C15008 wbs_dat_o[8] vdd 0.63fF
C15009 wbs_dat_i[8] vdd 0.63fF
C15010 wbs_adr_i[8] vdd 0.63fF
C15011 wbs_dat_o[7] vdd 0.63fF
C15012 wbs_dat_i[7] vdd 0.63fF
C15013 wbs_adr_i[7] vdd 0.63fF
C15014 wbs_dat_o[6] vdd 0.63fF
C15015 wbs_dat_i[6] vdd 0.63fF
C15016 wbs_adr_i[6] vdd 0.63fF
C15017 wbs_dat_o[5] vdd 0.63fF
C15018 wbs_dat_i[5] vdd 0.63fF
C15019 wbs_adr_i[5] vdd 0.63fF
C15020 wbs_dat_o[4] vdd 0.63fF
C15021 wbs_dat_i[4] vdd 0.63fF
C15022 wbs_adr_i[4] vdd 0.63fF
C15023 wbs_sel_i[3] vdd 0.63fF
C15024 wbs_dat_o[3] vdd 0.63fF
C15025 wbs_dat_i[3] vdd 0.63fF
C15026 wbs_adr_i[3] vdd 0.63fF
C15027 wbs_sel_i[2] vdd 0.63fF
C15028 wbs_dat_o[2] vdd 0.63fF
C15029 wbs_dat_i[2] vdd 0.63fF
C15030 wbs_adr_i[2] vdd 0.63fF
C15031 wbs_sel_i[1] vdd 0.63fF
C15032 wbs_dat_o[1] vdd 0.63fF
C15033 wbs_dat_i[1] vdd 0.63fF
C15034 wbs_adr_i[1] vdd 0.63fF
C15035 wbs_sel_i[0] vdd 0.63fF
C15036 wbs_dat_o[0] vdd 0.63fF
C15037 wbs_dat_i[0] vdd 0.63fF
C15038 wbs_adr_i[0] vdd 0.63fF
C15039 wbs_we_i vdd 0.63fF
C15040 wbs_stb_i vdd 0.63fF
C15041 wbs_cyc_i vdd 0.63fF
C15042 wbs_ack_o vdd 0.63fF
C15043 wb_rst_i vdd 0.63fF
C15044 wb_clk_i vdd 0.63fF
C15045 io_analog[2] vdd 133.63fF
C15046 li_17838_664356# vdd 0.75fF **FLOATING
C15047 li_17806_665450# vdd 1.77fF **FLOATING
C15048 pll_full_0/divider_0/and_0/Z1 vdd 0.33fF
C15049 pll_full_0/divider_0/and_0/B vdd 1.79fF
C15050 pll_full_0/divider_0/and_0/A vdd 1.66fF
C15051 pll_full_0/divider_0/and_0/out1 vdd 2.71fF
C15052 pll_full_0/divider_0/tspc_2/Z4 vdd 0.42fF
C15053 pll_full_0/divbuf_0/IN vdd 6.23fF
C15054 pll_full_0/divider_0/tspc_2/Z3 vdd 2.00fF
C15055 pll_full_0/divider_0/tspc_2/Z2 vdd 1.29fF
C15056 pll_full_0/divider_0/tspc_2/Z1 vdd 0.99fF
C15057 pll_full_0/divider_0/nor_0/B vdd 5.25fF
C15058 pll_full_0/divider_0/tspc_2/a_630_n680# vdd 0.53fF **FLOATING
C15059 pll_full_0/divider_0/tspc_1/Z4 vdd 0.42fF
C15060 pll_full_0/divider_0/tspc_1/Q vdd 2.79fF
C15061 pll_full_0/divider_0/tspc_1/Z3 vdd 2.00fF
C15062 pll_full_0/divider_0/tspc_1/Z2 vdd 1.29fF
C15063 pll_full_0/divider_0/tspc_1/Z1 vdd 0.99fF
C15064 pll_full_0/divider_0/nor_1/B vdd 5.95fF
C15065 pll_full_0/divider_0/tspc_1/a_630_n680# vdd 0.53fF **FLOATING
C15066 pll_full_0/divider_0/tspc_0/Z4 vdd 0.42fF
C15067 pll_full_0/divider_0/tspc_0/Q vdd 2.81fF
C15068 pll_full_0/divider_0/tspc_0/Z3 vdd 2.00fF
C15069 pll_full_0/divider_0/tspc_0/Z2 vdd 1.30fF
C15070 pll_full_0/divider_0/tspc_0/Z1 vdd 0.99fF
C15071 pll_full_0/divider_0/nor_1/A vdd 6.02fF
C15072 pll_full_0/divider_0/tspc_0/a_630_n680# vdd 0.53fF **FLOATING
C15073 pll_full_0/divider_0/clk vdd 31.77fF
C15074 pll_full_0/divider_0/prescaler_0/Out vdd 4.13fF
C15075 pll_full_0/divider_0/prescaler_0/nand_1/z1 vdd 0.20fF
C15076 pll_full_0/divider_0/prescaler_0/tspc_2/D vdd 2.59fF
C15077 pll_full_0/divider_0/prescaler_0/tspc_0/Q vdd 3.30fF
C15078 pll_full_0/divider_0/prescaler_0/tspc_1/Q vdd 2.78fF
C15079 pll_full_0/divider_0/prescaler_0/nand_0/z1 vdd 0.20fF
C15080 pll_full_0/divider_0/prescaler_0/tspc_0/D vdd 3.07fF
C15081 pll_full_0/divider_0/and_0/OUT vdd 5.35fF
C15082 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.42fF
C15083 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.00fF
C15084 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.30fF
C15085 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C15086 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 0.53fF **FLOATING
C15087 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 1.89fF **FLOATING
C15088 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.42fF
C15089 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.00fF
C15090 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.31fF
C15091 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C15092 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 0.53fF **FLOATING
C15093 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vdd 3.99fF **FLOATING
C15094 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.42fF
C15095 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.00fF
C15096 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.30fF
C15097 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C15098 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 0.53fF **FLOATING
C15099 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 1.89fF **FLOATING
C15100 pll_full_0/divider_0/nor_1/Z1 vdd 1.33fF
C15101 pll_full_0/divider_0/nor_0/Z1 vdd 1.33fF
C15102 pll_full_0/divbuf_1/OUT vdd 3.28fF
C15103 pll_full_0/divbuf_1/OUT5 vdd 16.40fF
C15104 pll_full_0/divbuf_1/OUT4 vdd 100.06fF
C15105 pll_full_0/divbuf_1/OUT3 vdd 27.01fF
C15106 pll_full_0/divbuf_1/OUT2 vdd 8.71fF
C15107 pll_full_0/divbuf_1/a_60990_n1540# vdd 1.57fF **FLOATING
C15108 pll_full_0/divbuf_1/a_60510_n1540# vdd 1.62fF **FLOATING
C15109 pll_full_0/divbuf_1/a_60030_n1540# vdd 1.62fF **FLOATING
C15110 pll_full_0/divbuf_1/a_59550_n1540# vdd 1.62fF **FLOATING
C15111 pll_full_0/divbuf_1/a_59070_n1540# vdd 1.62fF **FLOATING
C15112 pll_full_0/divbuf_1/a_58590_n1540# vdd 1.62fF **FLOATING
C15113 pll_full_0/divbuf_1/a_58110_n1540# vdd 1.62fF **FLOATING
C15114 pll_full_0/divbuf_1/a_57630_n1540# vdd 1.62fF **FLOATING
C15115 pll_full_0/divbuf_1/a_57150_n1540# vdd 1.62fF **FLOATING
C15116 pll_full_0/divbuf_1/a_56670_n1540# vdd 1.62fF **FLOATING
C15117 pll_full_0/divbuf_1/a_56190_n1540# vdd 1.62fF **FLOATING
C15118 pll_full_0/divbuf_1/a_55710_n1540# vdd 1.62fF **FLOATING
C15119 pll_full_0/divbuf_1/a_55230_n1540# vdd 1.62fF **FLOATING
C15120 pll_full_0/divbuf_1/a_54750_n1540# vdd 1.62fF **FLOATING
C15121 pll_full_0/divbuf_1/a_54270_n1540# vdd 1.62fF **FLOATING
C15122 pll_full_0/divbuf_1/a_53790_n1540# vdd 1.62fF **FLOATING
C15123 pll_full_0/divbuf_1/a_53310_n1540# vdd 1.62fF **FLOATING
C15124 pll_full_0/divbuf_1/a_52830_n1540# vdd 1.62fF **FLOATING
C15125 pll_full_0/divbuf_1/a_52350_n1540# vdd 1.62fF **FLOATING
C15126 pll_full_0/divbuf_1/a_51870_n1540# vdd 1.62fF **FLOATING
C15127 pll_full_0/divbuf_1/a_51390_n1540# vdd 1.62fF **FLOATING
C15128 pll_full_0/divbuf_1/a_50910_n1540# vdd 1.62fF **FLOATING
C15129 pll_full_0/divbuf_1/a_50430_n1540# vdd 1.62fF **FLOATING
C15130 pll_full_0/divbuf_1/a_49950_n1540# vdd 1.62fF **FLOATING
C15131 pll_full_0/divbuf_1/a_49470_n1540# vdd 1.62fF **FLOATING
C15132 pll_full_0/divbuf_1/a_48990_n1540# vdd 1.62fF **FLOATING
C15133 pll_full_0/divbuf_1/a_48510_n1540# vdd 1.62fF **FLOATING
C15134 pll_full_0/divbuf_1/a_48030_n1540# vdd 1.62fF **FLOATING
C15135 pll_full_0/divbuf_1/a_47550_n1540# vdd 1.62fF **FLOATING
C15136 pll_full_0/divbuf_1/a_47070_n1540# vdd 1.62fF **FLOATING
C15137 pll_full_0/divbuf_1/a_46590_n1540# vdd 1.62fF **FLOATING
C15138 pll_full_0/divbuf_1/a_46110_n1540# vdd 1.62fF **FLOATING
C15139 pll_full_0/divbuf_1/a_45630_n1540# vdd 1.62fF **FLOATING
C15140 pll_full_0/divbuf_1/a_45150_n1540# vdd 1.62fF **FLOATING
C15141 pll_full_0/divbuf_1/a_44670_n1540# vdd 1.62fF **FLOATING
C15142 pll_full_0/divbuf_1/a_44190_n1540# vdd 1.62fF **FLOATING
C15143 pll_full_0/divbuf_1/a_43710_n1540# vdd 1.62fF **FLOATING
C15144 pll_full_0/divbuf_1/a_43230_n1540# vdd 1.62fF **FLOATING
C15145 pll_full_0/divbuf_1/a_42750_n1540# vdd 1.62fF **FLOATING
C15146 pll_full_0/divbuf_1/a_42270_n1540# vdd 1.62fF **FLOATING
C15147 pll_full_0/divbuf_1/a_41790_n1540# vdd 1.62fF **FLOATING
C15148 pll_full_0/divbuf_1/a_41310_n1540# vdd 1.62fF **FLOATING
C15149 pll_full_0/divbuf_1/a_40830_n1540# vdd 1.62fF **FLOATING
C15150 pll_full_0/divbuf_1/a_40350_n1540# vdd 1.62fF **FLOATING
C15151 pll_full_0/divbuf_1/a_39870_n1540# vdd 1.62fF **FLOATING
C15152 pll_full_0/divbuf_1/a_39390_n1540# vdd 1.62fF **FLOATING
C15153 pll_full_0/divbuf_1/a_38910_n1540# vdd 1.62fF **FLOATING
C15154 pll_full_0/divbuf_1/a_38430_n1540# vdd 1.62fF **FLOATING
C15155 pll_full_0/divbuf_1/a_37950_n1540# vdd 1.62fF **FLOATING
C15156 pll_full_0/divbuf_1/a_37470_n1540# vdd 1.62fF **FLOATING
C15157 pll_full_0/divbuf_1/a_36990_n1540# vdd 1.62fF **FLOATING
C15158 pll_full_0/divbuf_1/a_36510_n1540# vdd 1.62fF **FLOATING
C15159 pll_full_0/divbuf_1/a_36030_n1540# vdd 1.62fF **FLOATING
C15160 pll_full_0/divbuf_1/a_35550_n1540# vdd 1.62fF **FLOATING
C15161 pll_full_0/divbuf_1/a_35070_n1540# vdd 1.62fF **FLOATING
C15162 pll_full_0/divbuf_1/a_34590_n1540# vdd 1.62fF **FLOATING
C15163 pll_full_0/divbuf_1/a_34110_n1540# vdd 1.62fF **FLOATING
C15164 pll_full_0/divbuf_1/a_33630_n1540# vdd 1.62fF **FLOATING
C15165 pll_full_0/divbuf_1/a_33150_n1540# vdd 1.62fF **FLOATING
C15166 pll_full_0/divbuf_1/a_32670_n1540# vdd 1.62fF **FLOATING
C15167 pll_full_0/divbuf_1/a_32190_n1540# vdd 1.62fF **FLOATING
C15168 pll_full_0/divbuf_1/a_31710_n1540# vdd 1.62fF **FLOATING
C15169 pll_full_0/divbuf_1/a_31230_n1540# vdd 1.62fF **FLOATING
C15170 pll_full_0/divbuf_1/a_30750_n1540# vdd 1.62fF **FLOATING
C15171 pll_full_0/divbuf_1/a_30270_n1540# vdd 1.62fF **FLOATING
C15172 pll_full_0/divbuf_1/a_29790_n1540# vdd 1.62fF **FLOATING
C15173 pll_full_0/divbuf_1/a_29310_n1540# vdd 1.62fF **FLOATING
C15174 pll_full_0/divbuf_1/a_28830_n1540# vdd 1.62fF **FLOATING
C15175 pll_full_0/divbuf_1/a_28350_n1540# vdd 1.62fF **FLOATING
C15176 pll_full_0/divbuf_1/a_27870_n1540# vdd 1.62fF **FLOATING
C15177 pll_full_0/divbuf_1/a_27390_n1540# vdd 1.62fF **FLOATING
C15178 pll_full_0/divbuf_1/a_26910_n1540# vdd 1.62fF **FLOATING
C15179 pll_full_0/divbuf_1/a_26430_n1540# vdd 1.62fF **FLOATING
C15180 pll_full_0/divbuf_1/a_25950_n1540# vdd 1.62fF **FLOATING
C15181 pll_full_0/divbuf_1/a_25470_n1540# vdd 1.62fF **FLOATING
C15182 pll_full_0/divbuf_1/a_24990_n1540# vdd 1.62fF **FLOATING
C15183 pll_full_0/divbuf_1/a_24510_n1540# vdd 1.62fF **FLOATING
C15184 pll_full_0/divbuf_1/a_24030_n1540# vdd 1.62fF **FLOATING
C15185 pll_full_0/divbuf_1/a_23550_n1540# vdd 1.62fF **FLOATING
C15186 pll_full_0/divbuf_1/a_23070_n1540# vdd 1.62fF **FLOATING
C15187 pll_full_0/divbuf_1/a_22590_n1540# vdd 1.62fF **FLOATING
C15188 pll_full_0/divbuf_1/a_22110_n1540# vdd 1.62fF **FLOATING
C15189 pll_full_0/divbuf_1/a_21630_n1540# vdd 1.62fF **FLOATING
C15190 pll_full_0/divbuf_1/a_21150_n1540# vdd 1.62fF **FLOATING
C15191 pll_full_0/divbuf_1/a_20670_n1540# vdd 1.62fF **FLOATING
C15192 pll_full_0/divbuf_1/a_20190_n1540# vdd 1.62fF **FLOATING
C15193 pll_full_0/divbuf_1/a_19710_n1540# vdd 1.62fF **FLOATING
C15194 pll_full_0/divbuf_1/a_19230_n1540# vdd 1.62fF **FLOATING
C15195 pll_full_0/divbuf_1/a_18750_n1540# vdd 1.62fF **FLOATING
C15196 pll_full_0/divbuf_1/a_18270_n1540# vdd 1.62fF **FLOATING
C15197 pll_full_0/divbuf_1/a_17790_n1540# vdd 1.62fF **FLOATING
C15198 pll_full_0/divbuf_1/a_17310_n1540# vdd 1.62fF **FLOATING
C15199 pll_full_0/divbuf_1/a_16830_n1540# vdd 1.62fF **FLOATING
C15200 pll_full_0/divbuf_1/a_16350_n1540# vdd 1.62fF **FLOATING
C15201 pll_full_0/divbuf_1/a_15870_n1540# vdd 1.62fF **FLOATING
C15202 pll_full_0/divbuf_1/a_15390_n1540# vdd 1.62fF **FLOATING
C15203 pll_full_0/divbuf_1/a_14910_n1540# vdd 1.62fF **FLOATING
C15204 pll_full_0/divbuf_1/a_14430_n1540# vdd 1.62fF **FLOATING
C15205 pll_full_0/divbuf_1/a_13950_n1540# vdd 1.62fF **FLOATING
C15206 pll_full_0/divbuf_1/a_13470_n1540# vdd 1.62fF **FLOATING
C15207 pll_full_0/divbuf_1/a_12990_n1540# vdd 1.62fF **FLOATING
C15208 pll_full_0/divbuf_1/a_12510_n1540# vdd 1.62fF **FLOATING
C15209 pll_full_0/divbuf_1/a_12030_n1540# vdd 1.62fF **FLOATING
C15210 pll_full_0/divbuf_1/a_11550_n1540# vdd 1.62fF **FLOATING
C15211 pll_full_0/divbuf_1/a_11070_n1540# vdd 1.62fF **FLOATING
C15212 pll_full_0/divbuf_1/a_10590_n1540# vdd 1.62fF **FLOATING
C15213 pll_full_0/divbuf_1/a_10110_n1540# vdd 1.62fF **FLOATING
C15214 pll_full_0/divbuf_1/a_9630_n1540# vdd 1.62fF **FLOATING
C15215 pll_full_0/divbuf_1/a_9150_n1540# vdd 1.62fF **FLOATING
C15216 pll_full_0/divbuf_1/a_8670_n1540# vdd 1.62fF **FLOATING
C15217 pll_full_0/divbuf_1/a_8190_n1540# vdd 1.62fF **FLOATING
C15218 pll_full_0/divbuf_1/a_7710_n1540# vdd 1.62fF **FLOATING
C15219 pll_full_0/divbuf_1/a_7230_n1540# vdd 1.62fF **FLOATING
C15220 pll_full_0/divbuf_1/a_6750_n1540# vdd 1.62fF **FLOATING
C15221 pll_full_0/divbuf_1/a_6270_n1540# vdd 1.62fF **FLOATING
C15222 pll_full_0/divbuf_1/a_5790_n1540# vdd 1.62fF **FLOATING
C15223 pll_full_0/divbuf_1/a_5310_n1540# vdd 1.62fF **FLOATING
C15224 pll_full_0/divbuf_1/a_4830_n1540# vdd 1.62fF **FLOATING
C15225 pll_full_0/divbuf_1/a_4350_n1540# vdd 1.62fF **FLOATING
C15226 pll_full_0/divbuf_1/a_3870_n1540# vdd 1.62fF **FLOATING
C15227 pll_full_0/divbuf_1/a_3390_n1540# vdd 1.62fF **FLOATING
C15228 pll_full_0/divbuf_1/a_2910_n1540# vdd 1.62fF **FLOATING
C15229 pll_full_0/divbuf_1/a_2430_n1540# vdd 1.62fF **FLOATING
C15230 pll_full_0/divbuf_1/a_1950_n1540# vdd 1.62fF **FLOATING
C15231 pll_full_0/divbuf_1/a_1470_n1540# vdd 1.62fF **FLOATING
C15232 pll_full_0/divbuf_1/a_990_n1540# vdd 1.62fF **FLOATING
C15233 pll_full_0/divbuf_1/a_510_n1540# vdd 1.62fF **FLOATING
C15234 pll_full_0/divbuf_1/a_60990_n840# vdd 1.06fF **FLOATING
C15235 pll_full_0/divbuf_1/a_60510_n840# vdd 1.09fF **FLOATING
C15236 pll_full_0/divbuf_1/a_60030_n840# vdd 1.09fF **FLOATING
C15237 pll_full_0/divbuf_1/a_59550_n840# vdd 1.09fF **FLOATING
C15238 pll_full_0/divbuf_1/a_59070_n840# vdd 1.09fF **FLOATING
C15239 pll_full_0/divbuf_1/a_58590_n840# vdd 1.09fF **FLOATING
C15240 pll_full_0/divbuf_1/a_58110_n840# vdd 1.09fF **FLOATING
C15241 pll_full_0/divbuf_1/a_57630_n840# vdd 1.09fF **FLOATING
C15242 pll_full_0/divbuf_1/a_57150_n840# vdd 1.09fF **FLOATING
C15243 pll_full_0/divbuf_1/a_56670_n840# vdd 1.09fF **FLOATING
C15244 pll_full_0/divbuf_1/a_56190_n840# vdd 1.09fF **FLOATING
C15245 pll_full_0/divbuf_1/a_55710_n840# vdd 1.09fF **FLOATING
C15246 pll_full_0/divbuf_1/a_55230_n840# vdd 1.09fF **FLOATING
C15247 pll_full_0/divbuf_1/a_54750_n840# vdd 1.09fF **FLOATING
C15248 pll_full_0/divbuf_1/a_54270_n840# vdd 1.09fF **FLOATING
C15249 pll_full_0/divbuf_1/a_53790_n840# vdd 1.09fF **FLOATING
C15250 pll_full_0/divbuf_1/a_53310_n840# vdd 1.09fF **FLOATING
C15251 pll_full_0/divbuf_1/a_52830_n840# vdd 1.09fF **FLOATING
C15252 pll_full_0/divbuf_1/a_52350_n840# vdd 1.09fF **FLOATING
C15253 pll_full_0/divbuf_1/a_51870_n840# vdd 1.09fF **FLOATING
C15254 pll_full_0/divbuf_1/a_51390_n840# vdd 1.09fF **FLOATING
C15255 pll_full_0/divbuf_1/a_50910_n840# vdd 1.09fF **FLOATING
C15256 pll_full_0/divbuf_1/a_50430_n840# vdd 1.09fF **FLOATING
C15257 pll_full_0/divbuf_1/a_49950_n840# vdd 1.09fF **FLOATING
C15258 pll_full_0/divbuf_1/a_49470_n840# vdd 1.09fF **FLOATING
C15259 pll_full_0/divbuf_1/a_48990_n840# vdd 1.09fF **FLOATING
C15260 pll_full_0/divbuf_1/a_48510_n840# vdd 1.09fF **FLOATING
C15261 pll_full_0/divbuf_1/a_48030_n840# vdd 1.09fF **FLOATING
C15262 pll_full_0/divbuf_1/a_47550_n840# vdd 1.09fF **FLOATING
C15263 pll_full_0/divbuf_1/a_47070_n840# vdd 1.09fF **FLOATING
C15264 pll_full_0/divbuf_1/a_46590_n840# vdd 1.09fF **FLOATING
C15265 pll_full_0/divbuf_1/a_46110_n840# vdd 1.09fF **FLOATING
C15266 pll_full_0/divbuf_1/a_45630_n840# vdd 1.09fF **FLOATING
C15267 pll_full_0/divbuf_1/a_45150_n840# vdd 1.09fF **FLOATING
C15268 pll_full_0/divbuf_1/a_44670_n840# vdd 1.09fF **FLOATING
C15269 pll_full_0/divbuf_1/a_44190_n840# vdd 1.09fF **FLOATING
C15270 pll_full_0/divbuf_1/a_43710_n840# vdd 1.09fF **FLOATING
C15271 pll_full_0/divbuf_1/a_43230_n840# vdd 1.09fF **FLOATING
C15272 pll_full_0/divbuf_1/a_42750_n840# vdd 1.08fF **FLOATING
C15273 pll_full_0/divbuf_1/a_42270_n840# vdd 1.08fF **FLOATING
C15274 pll_full_0/divbuf_1/a_41790_n840# vdd 1.10fF **FLOATING
C15275 pll_full_0/divbuf_1/a_41310_n840# vdd 1.09fF **FLOATING
C15276 pll_full_0/divbuf_1/a_40830_n840# vdd 1.09fF **FLOATING
C15277 pll_full_0/divbuf_1/a_40350_n840# vdd 1.09fF **FLOATING
C15278 pll_full_0/divbuf_1/a_39870_n840# vdd 1.09fF **FLOATING
C15279 pll_full_0/divbuf_1/a_39390_n840# vdd 1.09fF **FLOATING
C15280 pll_full_0/divbuf_1/a_38910_n840# vdd 1.09fF **FLOATING
C15281 pll_full_0/divbuf_1/a_38430_n840# vdd 1.09fF **FLOATING
C15282 pll_full_0/divbuf_1/a_37950_n840# vdd 1.09fF **FLOATING
C15283 pll_full_0/divbuf_1/a_37470_n840# vdd 1.09fF **FLOATING
C15284 pll_full_0/divbuf_1/a_36990_n840# vdd 1.09fF **FLOATING
C15285 pll_full_0/divbuf_1/a_36510_n840# vdd 1.09fF **FLOATING
C15286 pll_full_0/divbuf_1/a_36030_n840# vdd 1.09fF **FLOATING
C15287 pll_full_0/divbuf_1/a_35550_n840# vdd 1.09fF **FLOATING
C15288 pll_full_0/divbuf_1/a_35070_n840# vdd 1.09fF **FLOATING
C15289 pll_full_0/divbuf_1/a_34590_n840# vdd 1.09fF **FLOATING
C15290 pll_full_0/divbuf_1/a_34110_n840# vdd 1.09fF **FLOATING
C15291 pll_full_0/divbuf_1/a_33630_n840# vdd 1.09fF **FLOATING
C15292 pll_full_0/divbuf_1/a_33150_n840# vdd 1.09fF **FLOATING
C15293 pll_full_0/divbuf_1/a_32670_n840# vdd 1.09fF **FLOATING
C15294 pll_full_0/divbuf_1/a_32190_n840# vdd 1.09fF **FLOATING
C15295 pll_full_0/divbuf_1/a_31710_n840# vdd 1.11fF **FLOATING
C15296 pll_full_0/divbuf_1/a_31230_n840# vdd 1.13fF **FLOATING
C15297 pll_full_0/divbuf_1/a_30750_n840# vdd 1.09fF **FLOATING
C15298 pll_full_0/divbuf_1/a_30270_n840# vdd 1.09fF **FLOATING
C15299 pll_full_0/divbuf_1/a_29790_n840# vdd 1.09fF **FLOATING
C15300 pll_full_0/divbuf_1/a_29310_n840# vdd 1.09fF **FLOATING
C15301 pll_full_0/divbuf_1/a_28830_n840# vdd 1.09fF **FLOATING
C15302 pll_full_0/divbuf_1/a_28350_n840# vdd 1.09fF **FLOATING
C15303 pll_full_0/divbuf_1/a_27870_n840# vdd 1.08fF **FLOATING
C15304 pll_full_0/divbuf_1/a_27390_n840# vdd 1.11fF **FLOATING
C15305 pll_full_0/divbuf_1/a_26910_n840# vdd 1.10fF **FLOATING
C15306 pll_full_0/divbuf_1/a_26430_n840# vdd 1.10fF **FLOATING
C15307 pll_full_0/divbuf_1/a_25950_n840# vdd 1.10fF **FLOATING
C15308 pll_full_0/divbuf_1/a_25470_n840# vdd 1.10fF **FLOATING
C15309 pll_full_0/divbuf_1/a_24990_n840# vdd 1.10fF **FLOATING
C15310 pll_full_0/divbuf_1/a_24510_n840# vdd 1.10fF **FLOATING
C15311 pll_full_0/divbuf_1/a_24030_n840# vdd 1.09fF **FLOATING
C15312 pll_full_0/divbuf_1/a_23550_n840# vdd 1.11fF **FLOATING
C15313 pll_full_0/divbuf_1/a_23070_n840# vdd 1.10fF **FLOATING
C15314 pll_full_0/divbuf_1/a_22590_n840# vdd 1.10fF **FLOATING
C15315 pll_full_0/divbuf_1/a_22110_n840# vdd 1.10fF **FLOATING
C15316 pll_full_0/divbuf_1/a_21630_n840# vdd 1.10fF **FLOATING
C15317 pll_full_0/divbuf_1/a_21150_n840# vdd 1.10fF **FLOATING
C15318 pll_full_0/divbuf_1/a_20670_n840# vdd 1.10fF **FLOATING
C15319 pll_full_0/divbuf_1/a_20190_n840# vdd 1.09fF **FLOATING
C15320 pll_full_0/divbuf_1/a_19710_n840# vdd 1.09fF **FLOATING
C15321 pll_full_0/divbuf_1/a_19230_n840# vdd 1.09fF **FLOATING
C15322 pll_full_0/divbuf_1/a_18750_n840# vdd 1.09fF **FLOATING
C15323 pll_full_0/divbuf_1/a_18270_n840# vdd 1.08fF **FLOATING
C15324 pll_full_0/divbuf_1/a_17790_n840# vdd 1.08fF **FLOATING
C15325 pll_full_0/divbuf_1/a_17310_n840# vdd 1.07fF **FLOATING
C15326 pll_full_0/divbuf_1/a_16830_n840# vdd 1.07fF **FLOATING
C15327 pll_full_0/divbuf_1/a_16350_n840# vdd 1.07fF **FLOATING
C15328 pll_full_0/divbuf_1/a_15870_n840# vdd 1.07fF **FLOATING
C15329 pll_full_0/divbuf_1/a_15390_n840# vdd 1.08fF **FLOATING
C15330 pll_full_0/divbuf_1/a_14910_n840# vdd 1.07fF **FLOATING
C15331 pll_full_0/divbuf_1/a_14430_n840# vdd 1.07fF **FLOATING
C15332 pll_full_0/divbuf_1/a_13950_n840# vdd 1.07fF **FLOATING
C15333 pll_full_0/divbuf_1/a_13470_n840# vdd 1.07fF **FLOATING
C15334 pll_full_0/divbuf_1/a_12990_n840# vdd 1.10fF **FLOATING
C15335 pll_full_0/divbuf_1/a_12510_n840# vdd 1.08fF **FLOATING
C15336 pll_full_0/divbuf_1/a_12030_n840# vdd 1.07fF **FLOATING
C15337 pll_full_0/divbuf_1/a_11550_n840# vdd 1.07fF **FLOATING
C15338 pll_full_0/divbuf_1/a_11070_n840# vdd 1.08fF **FLOATING
C15339 pll_full_0/divbuf_1/a_10590_n840# vdd 1.10fF **FLOATING
C15340 pll_full_0/divbuf_1/a_10110_n840# vdd 1.10fF **FLOATING
C15341 pll_full_0/divbuf_1/a_9630_n840# vdd 1.10fF **FLOATING
C15342 pll_full_0/divbuf_1/a_9150_n840# vdd 1.10fF **FLOATING
C15343 pll_full_0/divbuf_1/a_8670_n840# vdd 1.10fF **FLOATING
C15344 pll_full_0/divbuf_1/a_8190_n840# vdd 1.12fF **FLOATING
C15345 pll_full_0/divbuf_1/a_7710_n840# vdd 1.10fF **FLOATING
C15346 pll_full_0/divbuf_1/a_7230_n840# vdd 1.09fF **FLOATING
C15347 pll_full_0/divbuf_1/a_6750_n840# vdd 1.09fF **FLOATING
C15348 pll_full_0/divbuf_1/a_6270_n840# vdd 1.09fF **FLOATING
C15349 pll_full_0/divbuf_1/a_5790_n840# vdd 1.09fF **FLOATING
C15350 pll_full_0/divbuf_1/a_5310_n840# vdd 1.09fF **FLOATING
C15351 pll_full_0/divbuf_1/a_4830_n840# vdd 1.09fF **FLOATING
C15352 pll_full_0/divbuf_1/a_4350_n840# vdd 1.09fF **FLOATING
C15353 pll_full_0/divbuf_1/a_3870_n840# vdd 1.09fF **FLOATING
C15354 pll_full_0/divbuf_1/a_3390_n840# vdd 1.09fF **FLOATING
C15355 pll_full_0/divbuf_1/a_2910_n840# vdd 1.10fF **FLOATING
C15356 pll_full_0/divbuf_1/a_2430_n840# vdd 1.10fF **FLOATING
C15357 pll_full_0/divbuf_1/a_1950_n840# vdd 1.10fF **FLOATING
C15358 pll_full_0/divbuf_1/a_1470_n840# vdd 1.10fF **FLOATING
C15359 pll_full_0/divbuf_1/a_990_n840# vdd 1.08fF **FLOATING
C15360 pll_full_0/divbuf_1/a_510_n840# vdd 1.07fF **FLOATING
C15361 pll_full_0/divbuf_1/a_60480_n1600# vdd 1.48fF **FLOATING
C15362 pll_full_0/divbuf_1/a_60000_n1600# vdd 1.48fF **FLOATING
C15363 pll_full_0/divbuf_1/a_59520_n1600# vdd 1.48fF **FLOATING
C15364 pll_full_0/divbuf_1/a_59040_n1600# vdd 1.48fF **FLOATING
C15365 pll_full_0/divbuf_1/a_58560_n1600# vdd 1.48fF **FLOATING
C15366 pll_full_0/divbuf_1/a_58080_n1600# vdd 1.48fF **FLOATING
C15367 pll_full_0/divbuf_1/a_57600_n1600# vdd 1.48fF **FLOATING
C15368 pll_full_0/divbuf_1/a_57120_n1600# vdd 1.48fF **FLOATING
C15369 pll_full_0/divbuf_1/a_56640_n1600# vdd 1.48fF **FLOATING
C15370 pll_full_0/divbuf_1/a_56160_n1600# vdd 1.48fF **FLOATING
C15371 pll_full_0/divbuf_1/a_55680_n1600# vdd 1.48fF **FLOATING
C15372 pll_full_0/divbuf_1/a_55200_n1600# vdd 1.48fF **FLOATING
C15373 pll_full_0/divbuf_1/a_54720_n1600# vdd 1.48fF **FLOATING
C15374 pll_full_0/divbuf_1/a_54240_n1600# vdd 1.48fF **FLOATING
C15375 pll_full_0/divbuf_1/a_53760_n1600# vdd 1.48fF **FLOATING
C15376 pll_full_0/divbuf_1/a_53280_n1600# vdd 1.48fF **FLOATING
C15377 pll_full_0/divbuf_1/a_52800_n1600# vdd 1.48fF **FLOATING
C15378 pll_full_0/divbuf_1/a_52320_n1600# vdd 1.48fF **FLOATING
C15379 pll_full_0/divbuf_1/a_51840_n1600# vdd 1.48fF **FLOATING
C15380 pll_full_0/divbuf_1/a_51360_n1600# vdd 1.48fF **FLOATING
C15381 pll_full_0/divbuf_1/a_50880_n1600# vdd 1.48fF **FLOATING
C15382 pll_full_0/divbuf_1/a_50400_n1600# vdd 1.48fF **FLOATING
C15383 pll_full_0/divbuf_1/a_49920_n1600# vdd 1.48fF **FLOATING
C15384 pll_full_0/divbuf_1/a_49440_n1600# vdd 1.48fF **FLOATING
C15385 pll_full_0/divbuf_1/a_48960_n1600# vdd 1.48fF **FLOATING
C15386 pll_full_0/divbuf_1/a_48480_n1600# vdd 1.48fF **FLOATING
C15387 pll_full_0/divbuf_1/a_48000_n1600# vdd 1.48fF **FLOATING
C15388 pll_full_0/divbuf_1/a_47520_n1600# vdd 1.48fF **FLOATING
C15389 pll_full_0/divbuf_1/a_47040_n1600# vdd 1.48fF **FLOATING
C15390 pll_full_0/divbuf_1/a_46560_n1600# vdd 1.48fF **FLOATING
C15391 pll_full_0/divbuf_1/a_46080_n1600# vdd 1.48fF **FLOATING
C15392 pll_full_0/divbuf_1/a_45600_n1600# vdd 1.48fF **FLOATING
C15393 pll_full_0/divbuf_1/a_45120_n1600# vdd 1.48fF **FLOATING
C15394 pll_full_0/divbuf_1/a_44640_n1600# vdd 1.48fF **FLOATING
C15395 pll_full_0/divbuf_1/a_44160_n1600# vdd 1.48fF **FLOATING
C15396 pll_full_0/divbuf_1/a_43680_n1600# vdd 1.48fF **FLOATING
C15397 pll_full_0/divbuf_1/a_43200_n1600# vdd 1.48fF **FLOATING
C15398 pll_full_0/divbuf_1/a_42720_n1600# vdd 1.48fF **FLOATING
C15399 pll_full_0/divbuf_1/a_42240_n1600# vdd 1.48fF **FLOATING
C15400 pll_full_0/divbuf_1/a_41760_n1600# vdd 1.48fF **FLOATING
C15401 pll_full_0/divbuf_1/a_41280_n1600# vdd 1.48fF **FLOATING
C15402 pll_full_0/divbuf_1/a_40800_n1600# vdd 1.48fF **FLOATING
C15403 pll_full_0/divbuf_1/a_40320_n1600# vdd 1.48fF **FLOATING
C15404 pll_full_0/divbuf_1/a_39840_n1600# vdd 1.48fF **FLOATING
C15405 pll_full_0/divbuf_1/a_39360_n1600# vdd 1.48fF **FLOATING
C15406 pll_full_0/divbuf_1/a_38880_n1600# vdd 1.48fF **FLOATING
C15407 pll_full_0/divbuf_1/a_38400_n1600# vdd 1.48fF **FLOATING
C15408 pll_full_0/divbuf_1/a_37920_n1600# vdd 1.48fF **FLOATING
C15409 pll_full_0/divbuf_1/a_37440_n1600# vdd 1.48fF **FLOATING
C15410 pll_full_0/divbuf_1/a_36960_n1600# vdd 1.48fF **FLOATING
C15411 pll_full_0/divbuf_1/a_36480_n1600# vdd 1.48fF **FLOATING
C15412 pll_full_0/divbuf_1/a_36000_n1600# vdd 1.48fF **FLOATING
C15413 pll_full_0/divbuf_1/a_35520_n1600# vdd 1.48fF **FLOATING
C15414 pll_full_0/divbuf_1/a_35040_n1600# vdd 1.48fF **FLOATING
C15415 pll_full_0/divbuf_1/a_34560_n1600# vdd 1.48fF **FLOATING
C15416 pll_full_0/divbuf_1/a_34080_n1600# vdd 1.48fF **FLOATING
C15417 pll_full_0/divbuf_1/a_33600_n1600# vdd 1.48fF **FLOATING
C15418 pll_full_0/divbuf_1/a_33120_n1600# vdd 1.48fF **FLOATING
C15419 pll_full_0/divbuf_1/a_32640_n1600# vdd 1.48fF **FLOATING
C15420 pll_full_0/divbuf_1/a_32160_n1600# vdd 1.48fF **FLOATING
C15421 pll_full_0/divbuf_1/a_31680_n1600# vdd 1.48fF **FLOATING
C15422 pll_full_0/divbuf_1/a_31200_n1600# vdd 1.48fF **FLOATING
C15423 pll_full_0/divbuf_1/a_30720_n1600# vdd 1.48fF **FLOATING
C15424 pll_full_0/divbuf_1/a_30240_n1600# vdd 1.48fF **FLOATING
C15425 pll_full_0/divbuf_1/a_29760_n1600# vdd 1.48fF **FLOATING
C15426 pll_full_0/divbuf_1/a_29280_n1600# vdd 1.48fF **FLOATING
C15427 pll_full_0/divbuf_1/a_28800_n1600# vdd 1.48fF **FLOATING
C15428 pll_full_0/divbuf_1/a_28320_n1600# vdd 1.48fF **FLOATING
C15429 pll_full_0/divbuf_1/a_27840_n1600# vdd 1.48fF **FLOATING
C15430 pll_full_0/divbuf_1/a_27360_n1600# vdd 1.48fF **FLOATING
C15431 pll_full_0/divbuf_1/a_26880_n1600# vdd 1.48fF **FLOATING
C15432 pll_full_0/divbuf_1/a_26400_n1600# vdd 1.48fF **FLOATING
C15433 pll_full_0/divbuf_1/a_25920_n1600# vdd 1.48fF **FLOATING
C15434 pll_full_0/divbuf_1/a_25440_n1600# vdd 1.48fF **FLOATING
C15435 pll_full_0/divbuf_1/a_24960_n1600# vdd 1.48fF **FLOATING
C15436 pll_full_0/divbuf_1/a_24480_n1600# vdd 1.48fF **FLOATING
C15437 pll_full_0/divbuf_1/a_24000_n1600# vdd 1.48fF **FLOATING
C15438 pll_full_0/divbuf_1/a_23520_n1600# vdd 1.48fF **FLOATING
C15439 pll_full_0/divbuf_1/a_23040_n1600# vdd 1.48fF **FLOATING
C15440 pll_full_0/divbuf_1/a_22560_n1600# vdd 1.48fF **FLOATING
C15441 pll_full_0/divbuf_1/a_22080_n1600# vdd 1.48fF **FLOATING
C15442 pll_full_0/divbuf_1/a_21600_n1600# vdd 1.48fF **FLOATING
C15443 pll_full_0/divbuf_1/a_21120_n1600# vdd 1.48fF **FLOATING
C15444 pll_full_0/divbuf_1/a_20640_n1600# vdd 1.48fF **FLOATING
C15445 pll_full_0/divbuf_1/a_20160_n1600# vdd 1.48fF **FLOATING
C15446 pll_full_0/divbuf_1/a_19680_n1600# vdd 1.48fF **FLOATING
C15447 pll_full_0/divbuf_1/a_19200_n1600# vdd 1.48fF **FLOATING
C15448 pll_full_0/divbuf_1/a_18720_n1600# vdd 1.48fF **FLOATING
C15449 pll_full_0/divbuf_1/a_18240_n1600# vdd 1.48fF **FLOATING
C15450 pll_full_0/divbuf_1/a_17760_n1600# vdd 1.48fF **FLOATING
C15451 pll_full_0/divbuf_1/a_17280_n1600# vdd 1.48fF **FLOATING
C15452 pll_full_0/divbuf_1/a_16800_n1600# vdd 1.48fF **FLOATING
C15453 pll_full_0/divbuf_1/a_16320_n1600# vdd 1.48fF **FLOATING
C15454 pll_full_0/divbuf_1/a_15840_n1600# vdd 1.48fF **FLOATING
C15455 pll_full_0/divbuf_1/a_15360_n1600# vdd 1.48fF **FLOATING
C15456 pll_full_0/divbuf_1/a_14880_n1600# vdd 1.48fF **FLOATING
C15457 pll_full_0/divbuf_1/a_14400_n1600# vdd 1.48fF **FLOATING
C15458 pll_full_0/divbuf_1/a_13920_n1600# vdd 1.48fF **FLOATING
C15459 pll_full_0/divbuf_1/a_13440_n1600# vdd 1.48fF **FLOATING
C15460 pll_full_0/divbuf_1/a_12960_n1600# vdd 1.48fF **FLOATING
C15461 pll_full_0/divbuf_1/a_12480_n1600# vdd 1.48fF **FLOATING
C15462 pll_full_0/divbuf_1/a_12000_n1600# vdd 1.48fF **FLOATING
C15463 pll_full_0/divbuf_1/a_11520_n1600# vdd 1.48fF **FLOATING
C15464 pll_full_0/divbuf_1/a_11040_n1600# vdd 1.48fF **FLOATING
C15465 pll_full_0/divbuf_1/a_10560_n1600# vdd 1.48fF **FLOATING
C15466 pll_full_0/divbuf_1/a_10080_n1600# vdd 1.48fF **FLOATING
C15467 pll_full_0/divbuf_1/a_9600_n1600# vdd 1.48fF **FLOATING
C15468 pll_full_0/divbuf_1/a_9120_n1600# vdd 1.48fF **FLOATING
C15469 pll_full_0/divbuf_1/a_8640_n1600# vdd 1.48fF **FLOATING
C15470 pll_full_0/divbuf_1/a_8160_n1600# vdd 1.48fF **FLOATING
C15471 pll_full_0/divbuf_1/a_7680_n1600# vdd 1.48fF **FLOATING
C15472 pll_full_0/divbuf_1/a_7200_n1600# vdd 1.48fF **FLOATING
C15473 pll_full_0/divbuf_1/a_6720_n1600# vdd 1.48fF **FLOATING
C15474 pll_full_0/divbuf_1/a_6240_n1600# vdd 1.48fF **FLOATING
C15475 pll_full_0/divbuf_1/a_5760_n1600# vdd 1.48fF **FLOATING
C15476 pll_full_0/divbuf_1/a_5280_n1600# vdd 1.48fF **FLOATING
C15477 pll_full_0/divbuf_1/a_4800_n1600# vdd 1.48fF **FLOATING
C15478 pll_full_0/divbuf_1/a_4320_n1600# vdd 1.48fF **FLOATING
C15479 pll_full_0/divbuf_1/a_3840_n1600# vdd 1.48fF **FLOATING
C15480 pll_full_0/divbuf_1/a_3360_n1600# vdd 1.48fF **FLOATING
C15481 pll_full_0/divbuf_1/a_2880_n1600# vdd 1.48fF **FLOATING
C15482 pll_full_0/divbuf_1/a_2400_n1600# vdd 1.48fF **FLOATING
C15483 pll_full_0/divbuf_1/a_1920_n1600# vdd 1.48fF **FLOATING
C15484 pll_full_0/divbuf_1/a_1440_n1600# vdd 1.48fF **FLOATING
C15485 pll_full_0/divbuf_1/a_960_n1600# vdd 1.48fF **FLOATING
C15486 pll_full_0/divbuf_1/a_480_n1600# vdd 1.48fF **FLOATING
C15487 pll_full_0/divbuf_1/a_0_n1600# vdd 1.48fF **FLOATING
C15488 pll_full_0/divbuf_1/a_41382_n240# vdd 0.90fF **FLOATING
C15489 pll_full_0/divbuf_1/a_40902_n240# vdd 0.90fF **FLOATING
C15490 pll_full_0/divbuf_1/a_40412_n240# vdd 0.90fF **FLOATING
C15491 pll_full_0/divbuf_1/a_39932_n240# vdd 0.90fF **FLOATING
C15492 pll_full_0/divbuf_1/a_39442_n240# vdd 0.90fF **FLOATING
C15493 pll_full_0/divbuf_1/a_38962_n240# vdd 0.91fF **FLOATING
C15494 pll_full_0/divbuf_1/a_38472_n240# vdd 0.90fF **FLOATING
C15495 pll_full_0/divbuf_1/a_37992_n240# vdd 0.90fF **FLOATING
C15496 pll_full_0/divbuf_1/a_37502_n240# vdd 0.90fF **FLOATING
C15497 pll_full_0/divbuf_1/a_37022_n240# vdd 0.90fF **FLOATING
C15498 pll_full_0/divbuf_1/a_36532_n240# vdd 0.90fF **FLOATING
C15499 pll_full_0/divbuf_1/a_36052_n240# vdd 0.90fF **FLOATING
C15500 pll_full_0/divbuf_1/a_35562_n240# vdd 0.90fF **FLOATING
C15501 pll_full_0/divbuf_1/a_35082_n240# vdd 0.91fF **FLOATING
C15502 pll_full_0/divbuf_1/a_34592_n240# vdd 0.90fF **FLOATING
C15503 pll_full_0/divbuf_1/a_34112_n240# vdd 0.90fF **FLOATING
C15504 pll_full_0/divbuf_1/a_33622_n240# vdd 0.90fF **FLOATING
C15505 pll_full_0/divbuf_1/a_33142_n240# vdd 0.90fF **FLOATING
C15506 pll_full_0/divbuf_1/a_32652_n240# vdd 0.90fF **FLOATING
C15507 pll_full_0/divbuf_1/a_32172_n240# vdd 0.90fF **FLOATING
C15508 pll_full_0/divbuf_1/a_31682_n240# vdd 0.89fF **FLOATING
C15509 pll_full_0/divbuf_1/a_31202_n240# vdd 0.92fF **FLOATING
C15510 pll_full_0/divbuf_1/a_30712_n240# vdd 0.90fF **FLOATING
C15511 pll_full_0/divbuf_1/a_30232_n240# vdd 0.90fF **FLOATING
C15512 pll_full_0/divbuf_1/a_29742_n240# vdd 0.90fF **FLOATING
C15513 pll_full_0/divbuf_1/a_29262_n240# vdd 0.90fF **FLOATING
C15514 pll_full_0/divbuf_1/a_28772_n240# vdd 0.90fF **FLOATING
C15515 pll_full_0/divbuf_1/a_28292_n240# vdd 0.90fF **FLOATING
C15516 pll_full_0/divbuf_1/a_27802_n240# vdd 0.89fF **FLOATING
C15517 pll_full_0/divbuf_1/a_27322_n240# vdd 0.95fF **FLOATING
C15518 pll_full_0/divbuf_1/a_26832_n240# vdd 0.91fF **FLOATING
C15519 pll_full_0/divbuf_1/a_26352_n240# vdd 0.91fF **FLOATING
C15520 pll_full_0/divbuf_1/a_25862_n240# vdd 0.91fF **FLOATING
C15521 pll_full_0/divbuf_1/a_25382_n240# vdd 0.91fF **FLOATING
C15522 pll_full_0/divbuf_1/a_24892_n240# vdd 0.91fF **FLOATING
C15523 pll_full_0/divbuf_1/a_24412_n240# vdd 0.91fF **FLOATING
C15524 pll_full_0/divbuf_1/a_23922_n240# vdd 0.92fF **FLOATING
C15525 pll_full_0/divbuf_1/a_23442_n240# vdd 0.94fF **FLOATING
C15526 pll_full_0/divbuf_1/a_22952_n240# vdd 0.91fF **FLOATING
C15527 pll_full_0/divbuf_1/a_22472_n240# vdd 0.91fF **FLOATING
C15528 pll_full_0/divbuf_1/a_21982_n240# vdd 0.91fF **FLOATING
C15529 pll_full_0/divbuf_1/a_21502_n240# vdd 0.91fF **FLOATING
C15530 pll_full_0/divbuf_1/a_21012_n240# vdd 0.91fF **FLOATING
C15531 pll_full_0/divbuf_1/a_20532_n240# vdd 0.91fF **FLOATING
C15532 pll_full_0/divbuf_1/a_20042_n240# vdd 0.90fF **FLOATING
C15533 pll_full_0/divbuf_1/a_19562_n240# vdd 0.90fF **FLOATING
C15534 pll_full_0/divbuf_1/a_19072_n240# vdd 0.90fF **FLOATING
C15535 pll_full_0/divbuf_1/a_18582_n240# vdd 0.89fF **FLOATING
C15536 pll_full_0/divbuf_1/a_18092_n240# vdd 0.89fF **FLOATING
C15537 pll_full_0/divbuf_1/a_17612_n240# vdd 0.89fF **FLOATING
C15538 pll_full_0/divbuf_1/a_17122_n240# vdd 0.88fF **FLOATING
C15539 pll_full_0/divbuf_1/a_16642_n240# vdd 0.88fF **FLOATING
C15540 pll_full_0/divbuf_1/a_16152_n240# vdd 0.88fF **FLOATING
C15541 pll_full_0/divbuf_1/a_15672_n240# vdd 0.90fF **FLOATING
C15542 pll_full_0/divbuf_1/a_15182_n240# vdd 0.88fF **FLOATING
C15543 pll_full_0/divbuf_1/a_14702_n240# vdd 0.88fF **FLOATING
C15544 pll_full_0/divbuf_1/a_14222_n240# vdd 0.88fF **FLOATING
C15545 pll_full_0/divbuf_1/a_13742_n240# vdd 0.88fF **FLOATING
C15546 pll_full_0/divbuf_1/a_13252_n240# vdd 0.88fF **FLOATING
C15547 pll_full_0/divbuf_1/a_12772_n240# vdd 0.88fF **FLOATING
C15548 pll_full_0/divbuf_1/a_12282_n240# vdd 0.88fF **FLOATING
C15549 pll_full_0/divbuf_1/a_11802_n240# vdd 0.88fF **FLOATING
C15550 pll_full_0/divbuf_1/a_11312_n240# vdd 0.89fF **FLOATING
C15551 pll_full_0/divbuf_1/a_10212_n240# vdd 0.91fF **FLOATING
C15552 pll_full_0/divbuf_1/a_9732_n240# vdd 0.91fF **FLOATING
C15553 pll_full_0/divbuf_1/a_9242_n240# vdd 0.91fF **FLOATING
C15554 pll_full_0/divbuf_1/a_8762_n240# vdd 0.91fF **FLOATING
C15555 pll_full_0/divbuf_1/a_8272_n240# vdd 0.91fF **FLOATING
C15556 pll_full_0/divbuf_1/a_7792_n240# vdd 0.92fF **FLOATING
C15557 pll_full_0/divbuf_1/a_7302_n240# vdd 0.90fF **FLOATING
C15558 pll_full_0/divbuf_1/a_6822_n240# vdd 0.90fF **FLOATING
C15559 pll_full_0/divbuf_1/a_6332_n240# vdd 0.90fF **FLOATING
C15560 pll_full_0/divbuf_1/a_5852_n240# vdd 0.90fF **FLOATING
C15561 pll_full_0/divbuf_1/a_5362_n240# vdd 0.90fF **FLOATING
C15562 pll_full_0/divbuf_1/a_4882_n240# vdd 0.90fF **FLOATING
C15563 pll_full_0/divbuf_1/a_4392_n240# vdd 0.90fF **FLOATING
C15564 pll_full_0/divbuf_1/a_3912_n240# vdd 0.90fF **FLOATING
C15565 pll_full_0/divbuf_1/a_3422_n240# vdd 0.90fF **FLOATING
C15566 pll_full_0/divbuf_1/a_2322_n240# vdd 0.91fF **FLOATING
C15567 pll_full_0/divbuf_1/a_1842_n240# vdd 0.91fF **FLOATING
C15568 pll_full_0/divbuf_1/a_1352_n240# vdd 0.91fF **FLOATING
C15569 pll_full_0/divbuf_1/a_41382_170# vdd 1.07fF **FLOATING
C15570 pll_full_0/divbuf_1/a_40902_170# vdd 1.09fF **FLOATING
C15571 pll_full_0/divbuf_1/a_40412_170# vdd 1.09fF **FLOATING
C15572 pll_full_0/divbuf_1/a_39932_170# vdd 1.09fF **FLOATING
C15573 pll_full_0/divbuf_1/a_39442_170# vdd 1.09fF **FLOATING
C15574 pll_full_0/divbuf_1/a_38962_170# vdd 1.07fF **FLOATING
C15575 pll_full_0/divbuf_1/a_38472_170# vdd 1.09fF **FLOATING
C15576 pll_full_0/divbuf_1/a_37992_170# vdd 1.09fF **FLOATING
C15577 pll_full_0/divbuf_1/a_37502_170# vdd 1.09fF **FLOATING
C15578 pll_full_0/divbuf_1/a_37022_170# vdd 1.09fF **FLOATING
C15579 pll_full_0/divbuf_1/a_36532_170# vdd 1.09fF **FLOATING
C15580 pll_full_0/divbuf_1/a_36052_170# vdd 1.09fF **FLOATING
C15581 pll_full_0/divbuf_1/a_35562_170# vdd 1.09fF **FLOATING
C15582 pll_full_0/divbuf_1/a_35082_170# vdd 1.09fF **FLOATING
C15583 pll_full_0/divbuf_1/a_34592_170# vdd 1.07fF **FLOATING
C15584 pll_full_0/divbuf_1/a_34112_170# vdd 1.09fF **FLOATING
C15585 pll_full_0/divbuf_1/a_33622_170# vdd 1.09fF **FLOATING
C15586 pll_full_0/divbuf_1/a_33142_170# vdd 1.09fF **FLOATING
C15587 pll_full_0/divbuf_1/a_32652_170# vdd 1.09fF **FLOATING
C15588 pll_full_0/divbuf_1/a_32172_170# vdd 1.09fF **FLOATING
C15589 pll_full_0/divbuf_1/a_31682_170# vdd 1.09fF **FLOATING
C15590 pll_full_0/divbuf_1/a_31202_170# vdd 1.09fF **FLOATING
C15591 pll_full_0/divbuf_1/a_30712_170# vdd 1.09fF **FLOATING
C15592 pll_full_0/divbuf_1/a_30232_170# vdd 1.07fF **FLOATING
C15593 pll_full_0/divbuf_1/a_29742_170# vdd 1.09fF **FLOATING
C15594 pll_full_0/divbuf_1/a_29262_170# vdd 1.09fF **FLOATING
C15595 pll_full_0/divbuf_1/a_28772_170# vdd 1.09fF **FLOATING
C15596 pll_full_0/divbuf_1/a_28292_170# vdd 1.09fF **FLOATING
C15597 pll_full_0/divbuf_1/a_27802_170# vdd 1.09fF **FLOATING
C15598 pll_full_0/divbuf_1/a_27322_170# vdd 1.09fF **FLOATING
C15599 pll_full_0/divbuf_1/a_26832_170# vdd 1.09fF **FLOATING
C15600 pll_full_0/divbuf_1/a_26352_170# vdd 1.09fF **FLOATING
C15601 pll_full_0/divbuf_1/a_25862_170# vdd 1.07fF **FLOATING
C15602 pll_full_0/divbuf_1/a_25382_170# vdd 1.09fF **FLOATING
C15603 pll_full_0/divbuf_1/a_24892_170# vdd 1.09fF **FLOATING
C15604 pll_full_0/divbuf_1/a_24412_170# vdd 1.09fF **FLOATING
C15605 pll_full_0/divbuf_1/a_23922_170# vdd 1.09fF **FLOATING
C15606 pll_full_0/divbuf_1/a_23442_170# vdd 1.09fF **FLOATING
C15607 pll_full_0/divbuf_1/a_22952_170# vdd 1.09fF **FLOATING
C15608 pll_full_0/divbuf_1/a_22472_170# vdd 1.07fF **FLOATING
C15609 pll_full_0/divbuf_1/a_21982_170# vdd 1.09fF **FLOATING
C15610 pll_full_0/divbuf_1/a_21502_170# vdd 1.09fF **FLOATING
C15611 pll_full_0/divbuf_1/a_21012_170# vdd 1.09fF **FLOATING
C15612 pll_full_0/divbuf_1/a_20532_170# vdd 1.09fF **FLOATING
C15613 pll_full_0/divbuf_1/a_20042_170# vdd 1.09fF **FLOATING
C15614 pll_full_0/divbuf_1/a_19562_170# vdd 1.09fF **FLOATING
C15615 pll_full_0/divbuf_1/a_19072_170# vdd 1.09fF **FLOATING
C15616 pll_full_0/divbuf_1/a_18582_170# vdd 1.07fF **FLOATING
C15617 pll_full_0/divbuf_1/a_18092_170# vdd 1.09fF **FLOATING
C15618 pll_full_0/divbuf_1/a_17612_170# vdd 1.09fF **FLOATING
C15619 pll_full_0/divbuf_1/a_17122_170# vdd 1.09fF **FLOATING
C15620 pll_full_0/divbuf_1/a_16642_170# vdd 1.09fF **FLOATING
C15621 pll_full_0/divbuf_1/a_16152_170# vdd 1.09fF **FLOATING
C15622 pll_full_0/divbuf_1/a_15672_170# vdd 1.09fF **FLOATING
C15623 pll_full_0/divbuf_1/a_15182_170# vdd 1.09fF **FLOATING
C15624 pll_full_0/divbuf_1/a_14702_170# vdd 1.10fF **FLOATING
C15625 pll_full_0/divbuf_1/a_14222_170# vdd 1.10fF **FLOATING
C15626 pll_full_0/divbuf_1/a_13742_170# vdd 1.09fF **FLOATING
C15627 pll_full_0/divbuf_1/a_13252_170# vdd 1.09fF **FLOATING
C15628 pll_full_0/divbuf_1/a_12772_170# vdd 1.07fF **FLOATING
C15629 pll_full_0/divbuf_1/a_12282_170# vdd 1.09fF **FLOATING
C15630 pll_full_0/divbuf_1/a_11802_170# vdd 1.09fF **FLOATING
C15631 pll_full_0/divbuf_1/a_11312_170# vdd 1.10fF **FLOATING
C15632 pll_full_0/divbuf_1/a_10212_170# vdd 1.09fF **FLOATING
C15633 pll_full_0/divbuf_1/a_9732_170# vdd 1.09fF **FLOATING
C15634 pll_full_0/divbuf_1/a_9242_170# vdd 1.09fF **FLOATING
C15635 pll_full_0/divbuf_1/a_8762_170# vdd 1.09fF **FLOATING
C15636 pll_full_0/divbuf_1/a_8272_170# vdd 1.07fF **FLOATING
C15637 pll_full_0/divbuf_1/a_7792_170# vdd 1.09fF **FLOATING
C15638 pll_full_0/divbuf_1/a_7302_170# vdd 1.09fF **FLOATING
C15639 pll_full_0/divbuf_1/a_6822_170# vdd 1.09fF **FLOATING
C15640 pll_full_0/divbuf_1/a_6332_170# vdd 1.09fF **FLOATING
C15641 pll_full_0/divbuf_1/a_5852_170# vdd 1.09fF **FLOATING
C15642 pll_full_0/divbuf_1/a_5362_170# vdd 1.09fF **FLOATING
C15643 pll_full_0/divbuf_1/a_4882_170# vdd 1.09fF **FLOATING
C15644 pll_full_0/divbuf_1/a_4392_170# vdd 1.07fF **FLOATING
C15645 pll_full_0/divbuf_1/a_3912_170# vdd 1.09fF **FLOATING
C15646 pll_full_0/divbuf_1/a_3422_170# vdd 1.10fF **FLOATING
C15647 pll_full_0/divbuf_1/a_2322_170# vdd 1.09fF **FLOATING
C15648 pll_full_0/divbuf_1/a_1842_170# vdd 1.09fF **FLOATING
C15649 pll_full_0/divbuf_1/a_1352_170# vdd 1.10fF **FLOATING
C15650 pll_full_0/divbuf_1/a_492_n240# vdd 2.46fF **FLOATING
C15651 pll_full_0/divbuf_0/OUT5 vdd 16.40fF
C15652 pll_full_0/divbuf_0/OUT4 vdd 100.06fF
C15653 pll_full_0/divbuf_0/OUT3 vdd 27.01fF
C15654 pll_full_0/divbuf_0/OUT2 vdd 8.71fF
C15655 pll_full_0/divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C15656 pll_full_0/divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C15657 pll_full_0/divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C15658 pll_full_0/divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C15659 pll_full_0/divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C15660 pll_full_0/divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C15661 pll_full_0/divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C15662 pll_full_0/divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C15663 pll_full_0/divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C15664 pll_full_0/divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C15665 pll_full_0/divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C15666 pll_full_0/divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C15667 pll_full_0/divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C15668 pll_full_0/divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C15669 pll_full_0/divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C15670 pll_full_0/divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C15671 pll_full_0/divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C15672 pll_full_0/divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C15673 pll_full_0/divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C15674 pll_full_0/divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C15675 pll_full_0/divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C15676 pll_full_0/divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C15677 pll_full_0/divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C15678 pll_full_0/divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C15679 pll_full_0/divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C15680 pll_full_0/divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C15681 pll_full_0/divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C15682 pll_full_0/divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C15683 pll_full_0/divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C15684 pll_full_0/divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C15685 pll_full_0/divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C15686 pll_full_0/divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C15687 pll_full_0/divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C15688 pll_full_0/divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C15689 pll_full_0/divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C15690 pll_full_0/divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C15691 pll_full_0/divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C15692 pll_full_0/divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C15693 pll_full_0/divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C15694 pll_full_0/divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C15695 pll_full_0/divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C15696 pll_full_0/divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C15697 pll_full_0/divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C15698 pll_full_0/divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C15699 pll_full_0/divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C15700 pll_full_0/divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C15701 pll_full_0/divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C15702 pll_full_0/divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C15703 pll_full_0/divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C15704 pll_full_0/divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C15705 pll_full_0/divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C15706 pll_full_0/divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C15707 pll_full_0/divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C15708 pll_full_0/divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C15709 pll_full_0/divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C15710 pll_full_0/divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C15711 pll_full_0/divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C15712 pll_full_0/divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C15713 pll_full_0/divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C15714 pll_full_0/divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C15715 pll_full_0/divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C15716 pll_full_0/divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C15717 pll_full_0/divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C15718 pll_full_0/divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C15719 pll_full_0/divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C15720 pll_full_0/divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C15721 pll_full_0/divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C15722 pll_full_0/divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C15723 pll_full_0/divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C15724 pll_full_0/divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C15725 pll_full_0/divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C15726 pll_full_0/divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C15727 pll_full_0/divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C15728 pll_full_0/divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C15729 pll_full_0/divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C15730 pll_full_0/divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C15731 pll_full_0/divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C15732 pll_full_0/divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C15733 pll_full_0/divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C15734 pll_full_0/divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C15735 pll_full_0/divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C15736 pll_full_0/divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C15737 pll_full_0/divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C15738 pll_full_0/divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C15739 pll_full_0/divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C15740 pll_full_0/divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C15741 pll_full_0/divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C15742 pll_full_0/divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C15743 pll_full_0/divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C15744 pll_full_0/divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C15745 pll_full_0/divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C15746 pll_full_0/divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C15747 pll_full_0/divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C15748 pll_full_0/divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C15749 pll_full_0/divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C15750 pll_full_0/divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C15751 pll_full_0/divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C15752 pll_full_0/divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C15753 pll_full_0/divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C15754 pll_full_0/divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C15755 pll_full_0/divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C15756 pll_full_0/divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C15757 pll_full_0/divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C15758 pll_full_0/divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C15759 pll_full_0/divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C15760 pll_full_0/divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C15761 pll_full_0/divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C15762 pll_full_0/divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C15763 pll_full_0/divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C15764 pll_full_0/divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C15765 pll_full_0/divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C15766 pll_full_0/divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C15767 pll_full_0/divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C15768 pll_full_0/divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C15769 pll_full_0/divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C15770 pll_full_0/divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C15771 pll_full_0/divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C15772 pll_full_0/divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C15773 pll_full_0/divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C15774 pll_full_0/divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C15775 pll_full_0/divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C15776 pll_full_0/divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C15777 pll_full_0/divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C15778 pll_full_0/divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C15779 pll_full_0/divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C15780 pll_full_0/divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C15781 pll_full_0/divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C15782 pll_full_0/divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C15783 pll_full_0/divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C15784 pll_full_0/divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C15785 pll_full_0/divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C15786 pll_full_0/divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C15787 pll_full_0/divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C15788 pll_full_0/divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C15789 pll_full_0/divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C15790 pll_full_0/divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C15791 pll_full_0/divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C15792 pll_full_0/divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C15793 pll_full_0/divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C15794 pll_full_0/divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C15795 pll_full_0/divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C15796 pll_full_0/divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C15797 pll_full_0/divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C15798 pll_full_0/divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C15799 pll_full_0/divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C15800 pll_full_0/divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C15801 pll_full_0/divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C15802 pll_full_0/divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C15803 pll_full_0/divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C15804 pll_full_0/divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C15805 pll_full_0/divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C15806 pll_full_0/divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C15807 pll_full_0/divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C15808 pll_full_0/divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C15809 pll_full_0/divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C15810 pll_full_0/divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C15811 pll_full_0/divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C15812 pll_full_0/divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C15813 pll_full_0/divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C15814 pll_full_0/divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C15815 pll_full_0/divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C15816 pll_full_0/divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C15817 pll_full_0/divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C15818 pll_full_0/divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C15819 pll_full_0/divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C15820 pll_full_0/divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C15821 pll_full_0/divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C15822 pll_full_0/divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C15823 pll_full_0/divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C15824 pll_full_0/divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C15825 pll_full_0/divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C15826 pll_full_0/divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C15827 pll_full_0/divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C15828 pll_full_0/divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C15829 pll_full_0/divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C15830 pll_full_0/divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C15831 pll_full_0/divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C15832 pll_full_0/divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C15833 pll_full_0/divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C15834 pll_full_0/divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C15835 pll_full_0/divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C15836 pll_full_0/divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C15837 pll_full_0/divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C15838 pll_full_0/divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C15839 pll_full_0/divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C15840 pll_full_0/divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C15841 pll_full_0/divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C15842 pll_full_0/divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C15843 pll_full_0/divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C15844 pll_full_0/divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C15845 pll_full_0/divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C15846 pll_full_0/divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C15847 pll_full_0/divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C15848 pll_full_0/divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C15849 pll_full_0/divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C15850 pll_full_0/divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C15851 pll_full_0/divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C15852 pll_full_0/divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C15853 pll_full_0/divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C15854 pll_full_0/divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C15855 pll_full_0/divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C15856 pll_full_0/divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C15857 pll_full_0/divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C15858 pll_full_0/divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C15859 pll_full_0/divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C15860 pll_full_0/divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C15861 pll_full_0/divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C15862 pll_full_0/divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C15863 pll_full_0/divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C15864 pll_full_0/divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C15865 pll_full_0/divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C15866 pll_full_0/divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C15867 pll_full_0/divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C15868 pll_full_0/divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C15869 pll_full_0/divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C15870 pll_full_0/divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C15871 pll_full_0/divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C15872 pll_full_0/divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C15873 pll_full_0/divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C15874 pll_full_0/divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C15875 pll_full_0/divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C15876 pll_full_0/divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C15877 pll_full_0/divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C15878 pll_full_0/divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C15879 pll_full_0/divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C15880 pll_full_0/divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C15881 pll_full_0/divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C15882 pll_full_0/divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C15883 pll_full_0/divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C15884 pll_full_0/divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C15885 pll_full_0/divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C15886 pll_full_0/divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C15887 pll_full_0/divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C15888 pll_full_0/divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C15889 pll_full_0/divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C15890 pll_full_0/divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C15891 pll_full_0/divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C15892 pll_full_0/divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C15893 pll_full_0/divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C15894 pll_full_0/divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C15895 pll_full_0/divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C15896 pll_full_0/divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C15897 pll_full_0/divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C15898 pll_full_0/divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C15899 pll_full_0/divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C15900 pll_full_0/divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C15901 pll_full_0/divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C15902 pll_full_0/divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C15903 pll_full_0/divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C15904 pll_full_0/divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C15905 pll_full_0/divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C15906 pll_full_0/divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C15907 pll_full_0/divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C15908 pll_full_0/divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C15909 pll_full_0/divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C15910 pll_full_0/divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C15911 pll_full_0/divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C15912 pll_full_0/divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C15913 pll_full_0/divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C15914 pll_full_0/divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C15915 pll_full_0/divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C15916 pll_full_0/divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C15917 pll_full_0/divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C15918 pll_full_0/divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C15919 pll_full_0/divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C15920 pll_full_0/divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C15921 pll_full_0/divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C15922 pll_full_0/divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C15923 pll_full_0/divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C15924 pll_full_0/divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C15925 pll_full_0/divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C15926 pll_full_0/divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C15927 pll_full_0/divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C15928 pll_full_0/divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C15929 pll_full_0/divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C15930 pll_full_0/divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C15931 pll_full_0/divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C15932 pll_full_0/divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C15933 pll_full_0/divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C15934 pll_full_0/divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C15935 pll_full_0/divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C15936 pll_full_0/divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C15937 pll_full_0/divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C15938 pll_full_0/divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C15939 pll_full_0/divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C15940 pll_full_0/divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C15941 pll_full_0/divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C15942 pll_full_0/divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C15943 pll_full_0/divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C15944 pll_full_0/divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C15945 pll_full_0/divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C15946 pll_full_0/divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C15947 pll_full_0/divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C15948 pll_full_0/divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C15949 pll_full_0/divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C15950 pll_full_0/divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C15951 pll_full_0/divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C15952 pll_full_0/divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C15953 pll_full_0/divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C15954 pll_full_0/divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C15955 pll_full_0/divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C15956 pll_full_0/divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C15957 pll_full_0/divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C15958 pll_full_0/divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C15959 pll_full_0/divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C15960 pll_full_0/divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C15961 pll_full_0/divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C15962 pll_full_0/divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C15963 pll_full_0/divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C15964 pll_full_0/divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C15965 pll_full_0/divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C15966 pll_full_0/divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C15967 pll_full_0/divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C15968 pll_full_0/divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C15969 pll_full_0/divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C15970 pll_full_0/divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C15971 pll_full_0/divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C15972 pll_full_0/divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C15973 pll_full_0/divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C15974 pll_full_0/divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C15975 pll_full_0/divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C15976 pll_full_0/divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C15977 pll_full_0/divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C15978 pll_full_0/divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C15979 pll_full_0/divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C15980 pll_full_0/divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C15981 pll_full_0/divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C15982 pll_full_0/divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C15983 pll_full_0/divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C15984 pll_full_0/divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C15985 pll_full_0/divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C15986 pll_full_0/divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C15987 pll_full_0/divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C15988 pll_full_0/divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C15989 pll_full_0/divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C15990 pll_full_0/divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C15991 pll_full_0/divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C15992 pll_full_0/divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C15993 pll_full_0/divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C15994 pll_full_0/divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C15995 pll_full_0/divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C15996 pll_full_0/divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C15997 pll_full_0/divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C15998 pll_full_0/divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C15999 pll_full_0/divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C16000 pll_full_0/divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C16001 pll_full_0/divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C16002 pll_full_0/divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C16003 pll_full_0/divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C16004 pll_full_0/divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C16005 pll_full_0/divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C16006 pll_full_0/divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C16007 pll_full_0/divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C16008 pll_full_0/divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C16009 pll_full_0/divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C16010 pll_full_0/divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C16011 pll_full_0/divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C16012 pll_full_0/divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C16013 pll_full_0/divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C16014 pll_full_0/divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C16015 pll_full_0/divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C16016 pll_full_0/divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C16017 pll_full_0/divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C16018 pll_full_0/divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C16019 pll_full_0/divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C16020 pll_full_0/divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C16021 pll_full_0/divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C16022 pll_full_0/divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C16023 pll_full_0/divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C16024 pll_full_0/divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C16025 pll_full_0/divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C16026 pll_full_0/divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C16027 pll_full_0/divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C16028 pll_full_0/divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C16029 pll_full_0/divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C16030 pll_full_0/divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C16031 pll_full_0/divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C16032 pll_full_0/divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C16033 pll_full_0/divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C16034 pll_full_0/divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C16035 pll_full_0/divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C16036 pll_full_0/divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C16037 pll_full_0/divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C16038 pll_full_0/divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C16039 pll_full_0/divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C16040 pll_full_0/divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C16041 pll_full_0/divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C16042 pll_full_0/divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C16043 pll_full_0/divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C16044 pll_full_0/divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C16045 pll_full_0/divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C16046 pll_full_0/divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C16047 pll_full_0/divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C16048 pll_full_0/divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C16049 pll_full_0/divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C16050 pll_full_0/divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C16051 pll_full_0/divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C16052 pll_full_0/divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C16053 pll_full_0/divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C16054 pll_full_0/divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C16055 pll_full_0/divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C16056 pll_full_0/divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C16057 pll_full_0/divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C16058 pll_full_0/divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C16059 pll_full_0/divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C16060 pll_full_0/divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C16061 pll_full_0/divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C16062 pll_full_0/divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C16063 pll_full_0/divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C16064 pll_full_0/divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C16065 pll_full_0/divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C16066 pll_full_0/divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C16067 pll_full_0/divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C16068 pll_full_0/divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C16069 pll_full_0/divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C16070 pll_full_0/divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C16071 pll_full_0/divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C16072 pll_full_0/divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C16073 pll_full_0/divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C16074 pll_full_0/divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C16075 pll_full_0/divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C16076 pll_full_0/divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C16077 pll_full_0/divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C16078 pll_full_0/divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C16079 pll_full_0/divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C16080 pll_full_0/divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C16081 pll_full_0/divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C16082 pll_full_0/divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C16083 pll_full_0/divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C16084 pll_full_0/divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C16085 pll_full_0/divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C16086 pll_full_0/divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C16087 pll_full_0/divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C16088 pll_full_0/divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C16089 pll_full_0/divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C16090 pll_full_0/divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C16091 pll_full_0/divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C16092 pll_full_0/divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C16093 pll_full_0/divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C16094 pll_full_0/divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C16095 pll_full_0/divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C16096 pll_full_0/divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C16097 pll_full_0/divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C16098 pll_full_0/divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C16099 pll_full_0/divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C16100 pll_full_0/divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C16101 pll_full_0/divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C16102 pll_full_0/divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C16103 pll_full_0/divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C16104 pll_full_0/divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C16105 pll_full_0/divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C16106 pll_full_0/divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C16107 pll_full_0/divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C16108 pll_full_0/divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C16109 pll_full_0/divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C16110 pll_full_0/divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C16111 pll_full_0/divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C16112 pll_full_0/divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C16113 pll_full_0/divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C16114 pll_full_0/divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C16115 pll_full_0/divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C16116 pll_full_0/divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C16117 pll_full_0/divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C16118 pll_full_0/divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C16119 pll_full_0/divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C16120 pll_full_0/divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C16121 pll_full_0/divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C16122 pll_full_0/divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C16123 pll_full_0/divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C16124 pll_full_0/divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C16125 pll_full_0/divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C16126 pll_full_0/divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C16127 pll_full_0/divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C16128 pll_full_0/divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C16129 pll_full_0/divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C16130 pll_full_0/divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C16131 pll_full_0/divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C16132 pll_full_0/divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C16133 pll_full_0/divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C16134 pll_full_0/divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C16135 pll_full_0/divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C16136 pll_full_0/divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C16137 pll_full_0/divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C16138 pll_full_0/divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C16139 pll_full_0/divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C16140 pll_full_0/divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C16141 pll_full_0/divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C16142 pll_full_0/divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C16143 pll_full_0/divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C16144 pll_full_0/divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C16145 pll_full_0/divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C16146 pll_full_0/divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C16147 pll_full_0/divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C16148 pll_full_0/divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C16149 pll_full_0/divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C16150 pll_full_0/divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C16151 pll_full_0/divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C16152 pll_full_0/divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C16153 pll_full_0/divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C16154 pll_full_0/divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C16155 pll_full_0/divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C16156 pll_full_0/divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C16157 pll_full_0/divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C16158 pll_full_0/divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C16159 pll_full_0/divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C16160 pll_full_0/divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C16161 pll_full_0/divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C16162 pll_full_0/divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C16163 pll_full_0/divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C16164 pll_full_0/divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C16165 pll_full_0/divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C16166 pll_full_0/divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C16167 pll_full_0/divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C16168 pll_full_0/divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C16169 pll_full_0/divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C16170 pll_full_0/divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C16171 pll_full_0/divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C16172 pll_full_0/divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C16173 pll_full_0/divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C16174 pll_full_0/divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C16175 pll_full_0/divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C16176 pll_full_0/divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C16177 pll_full_0/divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C16178 pll_full_0/divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C16179 pll_full_0/divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C16180 pll_full_0/divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C16181 pll_full_0/divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C16182 pll_full_0/divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C16183 pll_full_0/divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C16184 pll_full_0/divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C16185 pll_full_0/divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C16186 pll_full_0/divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C16187 pll_full_0/divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C16188 pll_full_0/divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C16189 pll_full_0/divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C16190 pll_full_0/divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C16191 pll_full_0/divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C16192 pll_full_0/divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C16193 pll_full_0/divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C16194 pll_full_0/divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C16195 pll_full_0/divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C16196 pll_full_0/divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C16197 pll_full_0/divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C16198 pll_full_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C16199 pll_full_0/ro_complete_0/cbank_2/v vdd 17.88fF
C16200 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C16201 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C16202 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C16203 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C16204 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C16205 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C16206 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C16207 pll_full_0/ro_complete_0/a0 vdd 7.88fF
C16208 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C16209 pll_full_0/ro_complete_0/a1 vdd 5.39fF
C16210 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C16211 pll_full_0/ro_complete_0/a3 vdd 6.85fF
C16212 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C16213 pll_full_0/ro_complete_0/a2 vdd 5.48fF
C16214 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C16215 pll_full_0/ro_complete_0/a4 vdd 5.36fF
C16216 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C16217 pll_full_0/ro_complete_0/a5 vdd 5.19fF
C16218 pll_full_0/ro_complete_0/cbank_0/v vdd 15.02fF
C16219 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C16220 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C16221 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C16222 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C16223 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C16224 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C16225 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C16226 pll_full_0/filter_0/a_4216_n5230# vdd 419.25fF **FLOATING
C16227 pll_full_0/filter_0/a_4216_n2998# vdd 1.39fF **FLOATING
C16228 pll_full_0/cp_0/down vdd 1.54fF
C16229 pll_full_0/cp_0/upbar vdd 1.79fF
C16230 pll_full_0/cp_0/a_7110_n2840# vdd 0.17fF **FLOATING
C16231 pll_full_0/cp_0/a_3060_n2840# vdd 1.71fF **FLOATING
C16232 pll_full_0/cp_0/a_7110_0# vdd 0.17fF **FLOATING
C16233 pll_full_0/cp_0/a_6370_0# vdd 0.40fF **FLOATING
C16234 pll_full_0/cp_0/a_3060_0# vdd 2.49fF **FLOATING
C16235 pll_full_0/cp_0/a_1710_0# vdd 7.47fF **FLOATING
C16236 pll_full_0/pd_0/and_pd_0/Z1 vdd 0.39fF
C16237 pll_full_0/pd_0/and_pd_0/Out1 vdd 2.22fF
C16238 pll_full_0/pd_0/tspc_r_1/z5 vdd 1.10fF
C16239 pll_full_0/pd_0/tspc_r_1/Z4 vdd 1.07fF
C16240 pll_full_0/pd_0/tspc_r_1/Qbar vdd 0.88fF
C16241 pll_full_0/pd_0/tspc_r_1/Z2 vdd 1.22fF
C16242 pll_full_0/pd_0/tspc_r_1/Z1 vdd 0.67fF
C16243 pll_full_0/pd_0/UP vdd 6.61fF
C16244 pll_full_0/pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C16245 pll_full_0/pd_0/tspc_r_1/Z3 vdd 2.12fF
C16246 pll_full_0/pd_0/REF vdd 6.44fF
C16247 pll_full_0/pd_0/tspc_r_0/z5 vdd 1.10fF
C16248 pll_full_0/pd_0/tspc_r_0/Z4 vdd 1.07fF
C16249 pll_full_0/pd_0/R vdd 3.05fF
C16250 pll_full_0/pd_0/tspc_r_0/Qbar vdd 0.79fF
C16251 pll_full_0/pd_0/tspc_r_0/Z2 vdd 1.22fF
C16252 pll_full_0/pd_0/tspc_r_0/Z1 vdd 0.67fF
C16253 pll_full_0/pd_0/DOWN vdd 7.24fF
C16254 pll_full_0/pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C16255 pll_full_0/pd_0/tspc_r_0/Z3 vdd 2.12fF
C16256 pll_full_0/pd_0/DIV vdd 11.32fF
C16257 divbuf_5/OUT5 vdd 16.40fF
C16258 divbuf_5/OUT4 vdd 100.50fF
C16259 divbuf_5/OUT3 vdd 27.05fF
C16260 divbuf_5/OUT2 vdd 8.71fF
C16261 gpio_analog[7] vdd 131.17fF
C16262 divbuf_5/a_60990_n1540# vdd 1.57fF **FLOATING
C16263 divbuf_5/a_60510_n1540# vdd 1.62fF **FLOATING
C16264 divbuf_5/a_60030_n1540# vdd 1.62fF **FLOATING
C16265 divbuf_5/a_59550_n1540# vdd 1.62fF **FLOATING
C16266 divbuf_5/a_59070_n1540# vdd 1.62fF **FLOATING
C16267 divbuf_5/a_58590_n1540# vdd 1.62fF **FLOATING
C16268 divbuf_5/a_58110_n1540# vdd 1.62fF **FLOATING
C16269 divbuf_5/a_57630_n1540# vdd 1.62fF **FLOATING
C16270 divbuf_5/a_57150_n1540# vdd 1.62fF **FLOATING
C16271 divbuf_5/a_56670_n1540# vdd 1.62fF **FLOATING
C16272 divbuf_5/a_56190_n1540# vdd 1.62fF **FLOATING
C16273 divbuf_5/a_55710_n1540# vdd 1.62fF **FLOATING
C16274 divbuf_5/a_55230_n1540# vdd 1.62fF **FLOATING
C16275 divbuf_5/a_54750_n1540# vdd 1.62fF **FLOATING
C16276 divbuf_5/a_54270_n1540# vdd 1.62fF **FLOATING
C16277 divbuf_5/a_53790_n1540# vdd 1.62fF **FLOATING
C16278 divbuf_5/a_53310_n1540# vdd 1.62fF **FLOATING
C16279 divbuf_5/a_52830_n1540# vdd 1.62fF **FLOATING
C16280 divbuf_5/a_52350_n1540# vdd 1.62fF **FLOATING
C16281 divbuf_5/a_51870_n1540# vdd 1.62fF **FLOATING
C16282 divbuf_5/a_51390_n1540# vdd 1.62fF **FLOATING
C16283 divbuf_5/a_50910_n1540# vdd 1.62fF **FLOATING
C16284 divbuf_5/a_50430_n1540# vdd 1.62fF **FLOATING
C16285 divbuf_5/a_49950_n1540# vdd 1.62fF **FLOATING
C16286 divbuf_5/a_49470_n1540# vdd 1.62fF **FLOATING
C16287 divbuf_5/a_48990_n1540# vdd 1.62fF **FLOATING
C16288 divbuf_5/a_48510_n1540# vdd 1.62fF **FLOATING
C16289 divbuf_5/a_48030_n1540# vdd 1.62fF **FLOATING
C16290 divbuf_5/a_47550_n1540# vdd 1.62fF **FLOATING
C16291 divbuf_5/a_47070_n1540# vdd 1.62fF **FLOATING
C16292 divbuf_5/a_46590_n1540# vdd 1.62fF **FLOATING
C16293 divbuf_5/a_46110_n1540# vdd 1.62fF **FLOATING
C16294 divbuf_5/a_45630_n1540# vdd 1.62fF **FLOATING
C16295 divbuf_5/a_45150_n1540# vdd 1.62fF **FLOATING
C16296 divbuf_5/a_44670_n1540# vdd 1.62fF **FLOATING
C16297 divbuf_5/a_44190_n1540# vdd 1.62fF **FLOATING
C16298 divbuf_5/a_43710_n1540# vdd 1.62fF **FLOATING
C16299 divbuf_5/a_43230_n1540# vdd 1.62fF **FLOATING
C16300 divbuf_5/a_42750_n1540# vdd 1.62fF **FLOATING
C16301 divbuf_5/a_42270_n1540# vdd 1.62fF **FLOATING
C16302 divbuf_5/a_41790_n1540# vdd 1.62fF **FLOATING
C16303 divbuf_5/a_41310_n1540# vdd 1.62fF **FLOATING
C16304 divbuf_5/a_40830_n1540# vdd 1.62fF **FLOATING
C16305 divbuf_5/a_40350_n1540# vdd 1.62fF **FLOATING
C16306 divbuf_5/a_39870_n1540# vdd 1.62fF **FLOATING
C16307 divbuf_5/a_39390_n1540# vdd 1.62fF **FLOATING
C16308 divbuf_5/a_38910_n1540# vdd 1.62fF **FLOATING
C16309 divbuf_5/a_38430_n1540# vdd 1.62fF **FLOATING
C16310 divbuf_5/a_37950_n1540# vdd 1.62fF **FLOATING
C16311 divbuf_5/a_37470_n1540# vdd 1.62fF **FLOATING
C16312 divbuf_5/a_36990_n1540# vdd 1.62fF **FLOATING
C16313 divbuf_5/a_36510_n1540# vdd 1.62fF **FLOATING
C16314 divbuf_5/a_36030_n1540# vdd 1.62fF **FLOATING
C16315 divbuf_5/a_35550_n1540# vdd 1.62fF **FLOATING
C16316 divbuf_5/a_35070_n1540# vdd 1.62fF **FLOATING
C16317 divbuf_5/a_34590_n1540# vdd 1.62fF **FLOATING
C16318 divbuf_5/a_34110_n1540# vdd 1.62fF **FLOATING
C16319 divbuf_5/a_33630_n1540# vdd 1.62fF **FLOATING
C16320 divbuf_5/a_33150_n1540# vdd 1.62fF **FLOATING
C16321 divbuf_5/a_32670_n1540# vdd 1.62fF **FLOATING
C16322 divbuf_5/a_32190_n1540# vdd 1.62fF **FLOATING
C16323 divbuf_5/a_31710_n1540# vdd 1.62fF **FLOATING
C16324 divbuf_5/a_31230_n1540# vdd 1.62fF **FLOATING
C16325 divbuf_5/a_30750_n1540# vdd 1.62fF **FLOATING
C16326 divbuf_5/a_30270_n1540# vdd 1.62fF **FLOATING
C16327 divbuf_5/a_29790_n1540# vdd 1.62fF **FLOATING
C16328 divbuf_5/a_29310_n1540# vdd 1.62fF **FLOATING
C16329 divbuf_5/a_28830_n1540# vdd 1.62fF **FLOATING
C16330 divbuf_5/a_28350_n1540# vdd 1.62fF **FLOATING
C16331 divbuf_5/a_27870_n1540# vdd 1.62fF **FLOATING
C16332 divbuf_5/a_27390_n1540# vdd 1.62fF **FLOATING
C16333 divbuf_5/a_26910_n1540# vdd 1.62fF **FLOATING
C16334 divbuf_5/a_26430_n1540# vdd 1.62fF **FLOATING
C16335 divbuf_5/a_25950_n1540# vdd 1.62fF **FLOATING
C16336 divbuf_5/a_25470_n1540# vdd 1.62fF **FLOATING
C16337 divbuf_5/a_24990_n1540# vdd 1.62fF **FLOATING
C16338 divbuf_5/a_24510_n1540# vdd 1.62fF **FLOATING
C16339 divbuf_5/a_24030_n1540# vdd 1.62fF **FLOATING
C16340 divbuf_5/a_23550_n1540# vdd 1.62fF **FLOATING
C16341 divbuf_5/a_23070_n1540# vdd 1.62fF **FLOATING
C16342 divbuf_5/a_22590_n1540# vdd 1.62fF **FLOATING
C16343 divbuf_5/a_22110_n1540# vdd 1.62fF **FLOATING
C16344 divbuf_5/a_21630_n1540# vdd 1.62fF **FLOATING
C16345 divbuf_5/a_21150_n1540# vdd 1.62fF **FLOATING
C16346 divbuf_5/a_20670_n1540# vdd 1.62fF **FLOATING
C16347 divbuf_5/a_20190_n1540# vdd 1.62fF **FLOATING
C16348 divbuf_5/a_19710_n1540# vdd 1.62fF **FLOATING
C16349 divbuf_5/a_19230_n1540# vdd 1.62fF **FLOATING
C16350 divbuf_5/a_18750_n1540# vdd 1.62fF **FLOATING
C16351 divbuf_5/a_18270_n1540# vdd 1.62fF **FLOATING
C16352 divbuf_5/a_17790_n1540# vdd 1.62fF **FLOATING
C16353 divbuf_5/a_17310_n1540# vdd 1.62fF **FLOATING
C16354 divbuf_5/a_16830_n1540# vdd 1.62fF **FLOATING
C16355 divbuf_5/a_16350_n1540# vdd 1.62fF **FLOATING
C16356 divbuf_5/a_15870_n1540# vdd 1.62fF **FLOATING
C16357 divbuf_5/a_15390_n1540# vdd 1.62fF **FLOATING
C16358 divbuf_5/a_14910_n1540# vdd 1.62fF **FLOATING
C16359 divbuf_5/a_14430_n1540# vdd 1.62fF **FLOATING
C16360 divbuf_5/a_13950_n1540# vdd 1.62fF **FLOATING
C16361 divbuf_5/a_13470_n1540# vdd 1.62fF **FLOATING
C16362 divbuf_5/a_12990_n1540# vdd 1.62fF **FLOATING
C16363 divbuf_5/a_12510_n1540# vdd 1.62fF **FLOATING
C16364 divbuf_5/a_12030_n1540# vdd 1.70fF **FLOATING
C16365 divbuf_5/a_11550_n1540# vdd 1.59fF **FLOATING
C16366 divbuf_5/a_11070_n1540# vdd 1.78fF **FLOATING
C16367 divbuf_5/a_10590_n1540# vdd 1.62fF **FLOATING
C16368 divbuf_5/a_10110_n1540# vdd 1.62fF **FLOATING
C16369 divbuf_5/a_9630_n1540# vdd 1.62fF **FLOATING
C16370 divbuf_5/a_9150_n1540# vdd 1.62fF **FLOATING
C16371 divbuf_5/a_8670_n1540# vdd 1.62fF **FLOATING
C16372 divbuf_5/a_8190_n1540# vdd 1.62fF **FLOATING
C16373 divbuf_5/a_7710_n1540# vdd 1.62fF **FLOATING
C16374 divbuf_5/a_7230_n1540# vdd 1.62fF **FLOATING
C16375 divbuf_5/a_6750_n1540# vdd 1.62fF **FLOATING
C16376 divbuf_5/a_6270_n1540# vdd 1.62fF **FLOATING
C16377 divbuf_5/a_5790_n1540# vdd 1.62fF **FLOATING
C16378 divbuf_5/a_5310_n1540# vdd 1.62fF **FLOATING
C16379 divbuf_5/a_4830_n1540# vdd 1.62fF **FLOATING
C16380 divbuf_5/a_4350_n1540# vdd 1.62fF **FLOATING
C16381 divbuf_5/a_3870_n1540# vdd 1.62fF **FLOATING
C16382 divbuf_5/a_3390_n1540# vdd 1.62fF **FLOATING
C16383 divbuf_5/a_2910_n1540# vdd 1.62fF **FLOATING
C16384 divbuf_5/a_2430_n1540# vdd 1.62fF **FLOATING
C16385 divbuf_5/a_1950_n1540# vdd 1.62fF **FLOATING
C16386 divbuf_5/a_1470_n1540# vdd 1.62fF **FLOATING
C16387 divbuf_5/a_990_n1540# vdd 1.62fF **FLOATING
C16388 divbuf_5/a_510_n1540# vdd 1.62fF **FLOATING
C16389 divbuf_5/a_60990_n840# vdd 1.06fF **FLOATING
C16390 divbuf_5/a_60510_n840# vdd 1.09fF **FLOATING
C16391 divbuf_5/a_60030_n840# vdd 1.09fF **FLOATING
C16392 divbuf_5/a_59550_n840# vdd 1.09fF **FLOATING
C16393 divbuf_5/a_59070_n840# vdd 1.09fF **FLOATING
C16394 divbuf_5/a_58590_n840# vdd 1.09fF **FLOATING
C16395 divbuf_5/a_58110_n840# vdd 1.09fF **FLOATING
C16396 divbuf_5/a_57630_n840# vdd 1.09fF **FLOATING
C16397 divbuf_5/a_57150_n840# vdd 1.09fF **FLOATING
C16398 divbuf_5/a_56670_n840# vdd 1.09fF **FLOATING
C16399 divbuf_5/a_56190_n840# vdd 1.09fF **FLOATING
C16400 divbuf_5/a_55710_n840# vdd 1.09fF **FLOATING
C16401 divbuf_5/a_55230_n840# vdd 1.09fF **FLOATING
C16402 divbuf_5/a_54750_n840# vdd 1.09fF **FLOATING
C16403 divbuf_5/a_54270_n840# vdd 1.09fF **FLOATING
C16404 divbuf_5/a_53790_n840# vdd 1.09fF **FLOATING
C16405 divbuf_5/a_53310_n840# vdd 1.09fF **FLOATING
C16406 divbuf_5/a_52830_n840# vdd 1.09fF **FLOATING
C16407 divbuf_5/a_52350_n840# vdd 1.09fF **FLOATING
C16408 divbuf_5/a_51870_n840# vdd 1.09fF **FLOATING
C16409 divbuf_5/a_51390_n840# vdd 1.09fF **FLOATING
C16410 divbuf_5/a_50910_n840# vdd 1.09fF **FLOATING
C16411 divbuf_5/a_50430_n840# vdd 1.09fF **FLOATING
C16412 divbuf_5/a_49950_n840# vdd 1.09fF **FLOATING
C16413 divbuf_5/a_49470_n840# vdd 1.09fF **FLOATING
C16414 divbuf_5/a_48990_n840# vdd 1.09fF **FLOATING
C16415 divbuf_5/a_48510_n840# vdd 1.09fF **FLOATING
C16416 divbuf_5/a_48030_n840# vdd 1.09fF **FLOATING
C16417 divbuf_5/a_47550_n840# vdd 1.09fF **FLOATING
C16418 divbuf_5/a_47070_n840# vdd 1.09fF **FLOATING
C16419 divbuf_5/a_46590_n840# vdd 1.09fF **FLOATING
C16420 divbuf_5/a_46110_n840# vdd 1.09fF **FLOATING
C16421 divbuf_5/a_45630_n840# vdd 1.09fF **FLOATING
C16422 divbuf_5/a_45150_n840# vdd 1.09fF **FLOATING
C16423 divbuf_5/a_44670_n840# vdd 1.09fF **FLOATING
C16424 divbuf_5/a_44190_n840# vdd 1.09fF **FLOATING
C16425 divbuf_5/a_43710_n840# vdd 1.09fF **FLOATING
C16426 divbuf_5/a_43230_n840# vdd 1.09fF **FLOATING
C16427 divbuf_5/a_42750_n840# vdd 1.08fF **FLOATING
C16428 divbuf_5/a_42270_n840# vdd 1.08fF **FLOATING
C16429 divbuf_5/a_41790_n840# vdd 1.10fF **FLOATING
C16430 divbuf_5/a_41310_n840# vdd 1.09fF **FLOATING
C16431 divbuf_5/a_40830_n840# vdd 1.09fF **FLOATING
C16432 divbuf_5/a_40350_n840# vdd 1.09fF **FLOATING
C16433 divbuf_5/a_39870_n840# vdd 1.09fF **FLOATING
C16434 divbuf_5/a_39390_n840# vdd 1.09fF **FLOATING
C16435 divbuf_5/a_38910_n840# vdd 1.09fF **FLOATING
C16436 divbuf_5/a_38430_n840# vdd 1.09fF **FLOATING
C16437 divbuf_5/a_37950_n840# vdd 1.09fF **FLOATING
C16438 divbuf_5/a_37470_n840# vdd 1.09fF **FLOATING
C16439 divbuf_5/a_36990_n840# vdd 1.09fF **FLOATING
C16440 divbuf_5/a_36510_n840# vdd 1.09fF **FLOATING
C16441 divbuf_5/a_36030_n840# vdd 1.09fF **FLOATING
C16442 divbuf_5/a_35550_n840# vdd 1.09fF **FLOATING
C16443 divbuf_5/a_35070_n840# vdd 1.09fF **FLOATING
C16444 divbuf_5/a_34590_n840# vdd 1.09fF **FLOATING
C16445 divbuf_5/a_34110_n840# vdd 1.09fF **FLOATING
C16446 divbuf_5/a_33630_n840# vdd 1.09fF **FLOATING
C16447 divbuf_5/a_33150_n840# vdd 1.09fF **FLOATING
C16448 divbuf_5/a_32670_n840# vdd 1.09fF **FLOATING
C16449 divbuf_5/a_32190_n840# vdd 1.09fF **FLOATING
C16450 divbuf_5/a_31710_n840# vdd 1.11fF **FLOATING
C16451 divbuf_5/a_31230_n840# vdd 1.13fF **FLOATING
C16452 divbuf_5/a_30750_n840# vdd 1.09fF **FLOATING
C16453 divbuf_5/a_30270_n840# vdd 1.09fF **FLOATING
C16454 divbuf_5/a_29790_n840# vdd 1.09fF **FLOATING
C16455 divbuf_5/a_29310_n840# vdd 1.09fF **FLOATING
C16456 divbuf_5/a_28830_n840# vdd 1.09fF **FLOATING
C16457 divbuf_5/a_28350_n840# vdd 1.09fF **FLOATING
C16458 divbuf_5/a_27870_n840# vdd 1.08fF **FLOATING
C16459 divbuf_5/a_27390_n840# vdd 1.11fF **FLOATING
C16460 divbuf_5/a_26910_n840# vdd 1.10fF **FLOATING
C16461 divbuf_5/a_26430_n840# vdd 1.10fF **FLOATING
C16462 divbuf_5/a_25950_n840# vdd 1.10fF **FLOATING
C16463 divbuf_5/a_25470_n840# vdd 1.10fF **FLOATING
C16464 divbuf_5/a_24990_n840# vdd 1.10fF **FLOATING
C16465 divbuf_5/a_24510_n840# vdd 1.10fF **FLOATING
C16466 divbuf_5/a_24030_n840# vdd 1.09fF **FLOATING
C16467 divbuf_5/a_23550_n840# vdd 1.11fF **FLOATING
C16468 divbuf_5/a_23070_n840# vdd 1.10fF **FLOATING
C16469 divbuf_5/a_22590_n840# vdd 1.10fF **FLOATING
C16470 divbuf_5/a_22110_n840# vdd 1.10fF **FLOATING
C16471 divbuf_5/a_21630_n840# vdd 1.10fF **FLOATING
C16472 divbuf_5/a_21150_n840# vdd 1.10fF **FLOATING
C16473 divbuf_5/a_20670_n840# vdd 1.10fF **FLOATING
C16474 divbuf_5/a_20190_n840# vdd 1.09fF **FLOATING
C16475 divbuf_5/a_19710_n840# vdd 1.09fF **FLOATING
C16476 divbuf_5/a_19230_n840# vdd 1.09fF **FLOATING
C16477 divbuf_5/a_18750_n840# vdd 1.09fF **FLOATING
C16478 divbuf_5/a_18270_n840# vdd 1.08fF **FLOATING
C16479 divbuf_5/a_17790_n840# vdd 1.08fF **FLOATING
C16480 divbuf_5/a_17310_n840# vdd 1.07fF **FLOATING
C16481 divbuf_5/a_16830_n840# vdd 1.07fF **FLOATING
C16482 divbuf_5/a_16350_n840# vdd 1.07fF **FLOATING
C16483 divbuf_5/a_15870_n840# vdd 1.07fF **FLOATING
C16484 divbuf_5/a_15390_n840# vdd 1.08fF **FLOATING
C16485 divbuf_5/a_14910_n840# vdd 1.07fF **FLOATING
C16486 divbuf_5/a_14430_n840# vdd 1.07fF **FLOATING
C16487 divbuf_5/a_13950_n840# vdd 1.07fF **FLOATING
C16488 divbuf_5/a_13470_n840# vdd 1.07fF **FLOATING
C16489 divbuf_5/a_12990_n840# vdd 1.10fF **FLOATING
C16490 divbuf_5/a_12510_n840# vdd 1.08fF **FLOATING
C16491 divbuf_5/a_12030_n840# vdd 1.13fF **FLOATING
C16492 divbuf_5/a_11550_n840# vdd 1.00fF **FLOATING
C16493 divbuf_5/a_11070_n840# vdd 1.19fF **FLOATING
C16494 divbuf_5/a_10590_n840# vdd 1.10fF **FLOATING
C16495 divbuf_5/a_10110_n840# vdd 1.10fF **FLOATING
C16496 divbuf_5/a_9630_n840# vdd 1.10fF **FLOATING
C16497 divbuf_5/a_9150_n840# vdd 1.10fF **FLOATING
C16498 divbuf_5/a_8670_n840# vdd 1.10fF **FLOATING
C16499 divbuf_5/a_8190_n840# vdd 1.12fF **FLOATING
C16500 divbuf_5/a_7710_n840# vdd 1.10fF **FLOATING
C16501 divbuf_5/a_7230_n840# vdd 1.09fF **FLOATING
C16502 divbuf_5/a_6750_n840# vdd 1.09fF **FLOATING
C16503 divbuf_5/a_6270_n840# vdd 1.09fF **FLOATING
C16504 divbuf_5/a_5790_n840# vdd 1.09fF **FLOATING
C16505 divbuf_5/a_5310_n840# vdd 1.09fF **FLOATING
C16506 divbuf_5/a_4830_n840# vdd 1.09fF **FLOATING
C16507 divbuf_5/a_4350_n840# vdd 1.09fF **FLOATING
C16508 divbuf_5/a_3870_n840# vdd 1.09fF **FLOATING
C16509 divbuf_5/a_3390_n840# vdd 1.09fF **FLOATING
C16510 divbuf_5/a_2910_n840# vdd 1.10fF **FLOATING
C16511 divbuf_5/a_2430_n840# vdd 1.10fF **FLOATING
C16512 divbuf_5/a_1950_n840# vdd 1.10fF **FLOATING
C16513 divbuf_5/a_1470_n840# vdd 1.10fF **FLOATING
C16514 divbuf_5/a_990_n840# vdd 1.08fF **FLOATING
C16515 divbuf_5/a_510_n840# vdd 1.07fF **FLOATING
C16516 divbuf_5/a_60480_n1600# vdd 1.48fF **FLOATING
C16517 divbuf_5/a_60000_n1600# vdd 1.48fF **FLOATING
C16518 divbuf_5/a_59520_n1600# vdd 1.48fF **FLOATING
C16519 divbuf_5/a_59040_n1600# vdd 1.48fF **FLOATING
C16520 divbuf_5/a_58560_n1600# vdd 1.48fF **FLOATING
C16521 divbuf_5/a_58080_n1600# vdd 1.48fF **FLOATING
C16522 divbuf_5/a_57600_n1600# vdd 1.48fF **FLOATING
C16523 divbuf_5/a_57120_n1600# vdd 1.48fF **FLOATING
C16524 divbuf_5/a_56640_n1600# vdd 1.48fF **FLOATING
C16525 divbuf_5/a_56160_n1600# vdd 1.48fF **FLOATING
C16526 divbuf_5/a_55680_n1600# vdd 1.48fF **FLOATING
C16527 divbuf_5/a_55200_n1600# vdd 1.48fF **FLOATING
C16528 divbuf_5/a_54720_n1600# vdd 1.48fF **FLOATING
C16529 divbuf_5/a_54240_n1600# vdd 1.48fF **FLOATING
C16530 divbuf_5/a_53760_n1600# vdd 1.48fF **FLOATING
C16531 divbuf_5/a_53280_n1600# vdd 1.48fF **FLOATING
C16532 divbuf_5/a_52800_n1600# vdd 1.48fF **FLOATING
C16533 divbuf_5/a_52320_n1600# vdd 1.48fF **FLOATING
C16534 divbuf_5/a_51840_n1600# vdd 1.48fF **FLOATING
C16535 divbuf_5/a_51360_n1600# vdd 1.48fF **FLOATING
C16536 divbuf_5/a_50880_n1600# vdd 1.48fF **FLOATING
C16537 divbuf_5/a_50400_n1600# vdd 1.48fF **FLOATING
C16538 divbuf_5/a_49920_n1600# vdd 1.48fF **FLOATING
C16539 divbuf_5/a_49440_n1600# vdd 1.48fF **FLOATING
C16540 divbuf_5/a_48960_n1600# vdd 1.48fF **FLOATING
C16541 divbuf_5/a_48480_n1600# vdd 1.48fF **FLOATING
C16542 divbuf_5/a_48000_n1600# vdd 1.48fF **FLOATING
C16543 divbuf_5/a_47520_n1600# vdd 1.48fF **FLOATING
C16544 divbuf_5/a_47040_n1600# vdd 1.48fF **FLOATING
C16545 divbuf_5/a_46560_n1600# vdd 1.48fF **FLOATING
C16546 divbuf_5/a_46080_n1600# vdd 1.48fF **FLOATING
C16547 divbuf_5/a_45600_n1600# vdd 1.48fF **FLOATING
C16548 divbuf_5/a_45120_n1600# vdd 1.48fF **FLOATING
C16549 divbuf_5/a_44640_n1600# vdd 1.48fF **FLOATING
C16550 divbuf_5/a_44160_n1600# vdd 1.48fF **FLOATING
C16551 divbuf_5/a_43680_n1600# vdd 1.48fF **FLOATING
C16552 divbuf_5/a_43200_n1600# vdd 1.48fF **FLOATING
C16553 divbuf_5/a_42720_n1600# vdd 1.48fF **FLOATING
C16554 divbuf_5/a_42240_n1600# vdd 1.48fF **FLOATING
C16555 divbuf_5/a_41760_n1600# vdd 1.48fF **FLOATING
C16556 divbuf_5/a_41280_n1600# vdd 1.48fF **FLOATING
C16557 divbuf_5/a_40800_n1600# vdd 1.48fF **FLOATING
C16558 divbuf_5/a_40320_n1600# vdd 1.48fF **FLOATING
C16559 divbuf_5/a_39840_n1600# vdd 1.48fF **FLOATING
C16560 divbuf_5/a_39360_n1600# vdd 1.48fF **FLOATING
C16561 divbuf_5/a_38880_n1600# vdd 1.48fF **FLOATING
C16562 divbuf_5/a_38400_n1600# vdd 1.48fF **FLOATING
C16563 divbuf_5/a_37920_n1600# vdd 1.48fF **FLOATING
C16564 divbuf_5/a_37440_n1600# vdd 1.48fF **FLOATING
C16565 divbuf_5/a_36960_n1600# vdd 1.48fF **FLOATING
C16566 divbuf_5/a_36480_n1600# vdd 1.48fF **FLOATING
C16567 divbuf_5/a_36000_n1600# vdd 1.48fF **FLOATING
C16568 divbuf_5/a_35520_n1600# vdd 1.48fF **FLOATING
C16569 divbuf_5/a_35040_n1600# vdd 1.48fF **FLOATING
C16570 divbuf_5/a_34560_n1600# vdd 1.48fF **FLOATING
C16571 divbuf_5/a_34080_n1600# vdd 1.48fF **FLOATING
C16572 divbuf_5/a_33600_n1600# vdd 1.48fF **FLOATING
C16573 divbuf_5/a_33120_n1600# vdd 1.48fF **FLOATING
C16574 divbuf_5/a_32640_n1600# vdd 1.48fF **FLOATING
C16575 divbuf_5/a_32160_n1600# vdd 1.48fF **FLOATING
C16576 divbuf_5/a_31680_n1600# vdd 1.48fF **FLOATING
C16577 divbuf_5/a_31200_n1600# vdd 1.48fF **FLOATING
C16578 divbuf_5/a_30720_n1600# vdd 1.48fF **FLOATING
C16579 divbuf_5/a_30240_n1600# vdd 1.48fF **FLOATING
C16580 divbuf_5/a_29760_n1600# vdd 1.48fF **FLOATING
C16581 divbuf_5/a_29280_n1600# vdd 1.48fF **FLOATING
C16582 divbuf_5/a_28800_n1600# vdd 1.48fF **FLOATING
C16583 divbuf_5/a_28320_n1600# vdd 1.48fF **FLOATING
C16584 divbuf_5/a_27840_n1600# vdd 1.48fF **FLOATING
C16585 divbuf_5/a_27360_n1600# vdd 1.48fF **FLOATING
C16586 divbuf_5/a_26880_n1600# vdd 1.48fF **FLOATING
C16587 divbuf_5/a_26400_n1600# vdd 1.48fF **FLOATING
C16588 divbuf_5/a_25920_n1600# vdd 1.48fF **FLOATING
C16589 divbuf_5/a_25440_n1600# vdd 1.48fF **FLOATING
C16590 divbuf_5/a_24960_n1600# vdd 1.48fF **FLOATING
C16591 divbuf_5/a_24480_n1600# vdd 1.48fF **FLOATING
C16592 divbuf_5/a_24000_n1600# vdd 1.48fF **FLOATING
C16593 divbuf_5/a_23520_n1600# vdd 1.48fF **FLOATING
C16594 divbuf_5/a_23040_n1600# vdd 1.48fF **FLOATING
C16595 divbuf_5/a_22560_n1600# vdd 1.48fF **FLOATING
C16596 divbuf_5/a_22080_n1600# vdd 1.48fF **FLOATING
C16597 divbuf_5/a_21600_n1600# vdd 1.48fF **FLOATING
C16598 divbuf_5/a_21120_n1600# vdd 1.48fF **FLOATING
C16599 divbuf_5/a_20640_n1600# vdd 1.48fF **FLOATING
C16600 divbuf_5/a_20160_n1600# vdd 1.48fF **FLOATING
C16601 divbuf_5/a_19680_n1600# vdd 1.48fF **FLOATING
C16602 divbuf_5/a_19200_n1600# vdd 1.48fF **FLOATING
C16603 divbuf_5/a_18720_n1600# vdd 1.48fF **FLOATING
C16604 divbuf_5/a_18240_n1600# vdd 1.48fF **FLOATING
C16605 divbuf_5/a_17760_n1600# vdd 1.48fF **FLOATING
C16606 divbuf_5/a_17280_n1600# vdd 1.48fF **FLOATING
C16607 divbuf_5/a_16800_n1600# vdd 1.48fF **FLOATING
C16608 divbuf_5/a_16320_n1600# vdd 1.48fF **FLOATING
C16609 divbuf_5/a_15840_n1600# vdd 1.48fF **FLOATING
C16610 divbuf_5/a_15360_n1600# vdd 1.48fF **FLOATING
C16611 divbuf_5/a_14880_n1600# vdd 1.48fF **FLOATING
C16612 divbuf_5/a_14400_n1600# vdd 1.48fF **FLOATING
C16613 divbuf_5/a_13920_n1600# vdd 1.48fF **FLOATING
C16614 divbuf_5/a_13440_n1600# vdd 1.48fF **FLOATING
C16615 divbuf_5/a_12960_n1600# vdd 1.48fF **FLOATING
C16616 divbuf_5/a_12480_n1600# vdd 1.48fF **FLOATING
C16617 divbuf_5/a_12000_n1600# vdd 1.73fF **FLOATING
C16618 divbuf_5/a_11520_n1600# vdd 1.52fF **FLOATING
C16619 divbuf_5/a_11040_n1600# vdd 1.61fF **FLOATING
C16620 divbuf_5/a_10560_n1600# vdd 1.48fF **FLOATING
C16621 divbuf_5/a_10080_n1600# vdd 1.48fF **FLOATING
C16622 divbuf_5/a_9600_n1600# vdd 1.48fF **FLOATING
C16623 divbuf_5/a_9120_n1600# vdd 1.48fF **FLOATING
C16624 divbuf_5/a_8640_n1600# vdd 1.48fF **FLOATING
C16625 divbuf_5/a_8160_n1600# vdd 1.48fF **FLOATING
C16626 divbuf_5/a_7680_n1600# vdd 1.48fF **FLOATING
C16627 divbuf_5/a_7200_n1600# vdd 1.48fF **FLOATING
C16628 divbuf_5/a_6720_n1600# vdd 1.48fF **FLOATING
C16629 divbuf_5/a_6240_n1600# vdd 1.48fF **FLOATING
C16630 divbuf_5/a_5760_n1600# vdd 1.48fF **FLOATING
C16631 divbuf_5/a_5280_n1600# vdd 1.48fF **FLOATING
C16632 divbuf_5/a_4800_n1600# vdd 1.48fF **FLOATING
C16633 divbuf_5/a_4320_n1600# vdd 1.48fF **FLOATING
C16634 divbuf_5/a_3840_n1600# vdd 1.48fF **FLOATING
C16635 divbuf_5/a_3360_n1600# vdd 1.48fF **FLOATING
C16636 divbuf_5/a_2880_n1600# vdd 1.48fF **FLOATING
C16637 divbuf_5/a_2400_n1600# vdd 1.48fF **FLOATING
C16638 divbuf_5/a_1920_n1600# vdd 1.48fF **FLOATING
C16639 divbuf_5/a_1440_n1600# vdd 1.48fF **FLOATING
C16640 divbuf_5/a_960_n1600# vdd 1.48fF **FLOATING
C16641 divbuf_5/a_480_n1600# vdd 1.48fF **FLOATING
C16642 divbuf_5/a_0_n1600# vdd 1.48fF **FLOATING
C16643 divbuf_5/a_41382_n240# vdd 0.90fF **FLOATING
C16644 divbuf_5/a_40902_n240# vdd 0.90fF **FLOATING
C16645 divbuf_5/a_40412_n240# vdd 0.90fF **FLOATING
C16646 divbuf_5/a_39932_n240# vdd 0.90fF **FLOATING
C16647 divbuf_5/a_39442_n240# vdd 0.90fF **FLOATING
C16648 divbuf_5/a_38962_n240# vdd 0.91fF **FLOATING
C16649 divbuf_5/a_38472_n240# vdd 0.90fF **FLOATING
C16650 divbuf_5/a_37992_n240# vdd 0.90fF **FLOATING
C16651 divbuf_5/a_37502_n240# vdd 0.90fF **FLOATING
C16652 divbuf_5/a_37022_n240# vdd 0.90fF **FLOATING
C16653 divbuf_5/a_36532_n240# vdd 0.90fF **FLOATING
C16654 divbuf_5/a_36052_n240# vdd 0.90fF **FLOATING
C16655 divbuf_5/a_35562_n240# vdd 0.90fF **FLOATING
C16656 divbuf_5/a_35082_n240# vdd 0.91fF **FLOATING
C16657 divbuf_5/a_34592_n240# vdd 0.90fF **FLOATING
C16658 divbuf_5/a_34112_n240# vdd 0.90fF **FLOATING
C16659 divbuf_5/a_33622_n240# vdd 0.90fF **FLOATING
C16660 divbuf_5/a_33142_n240# vdd 0.90fF **FLOATING
C16661 divbuf_5/a_32652_n240# vdd 0.90fF **FLOATING
C16662 divbuf_5/a_32172_n240# vdd 0.90fF **FLOATING
C16663 divbuf_5/a_31682_n240# vdd 0.89fF **FLOATING
C16664 divbuf_5/a_31202_n240# vdd 0.92fF **FLOATING
C16665 divbuf_5/a_30712_n240# vdd 0.90fF **FLOATING
C16666 divbuf_5/a_30232_n240# vdd 0.90fF **FLOATING
C16667 divbuf_5/a_29742_n240# vdd 0.90fF **FLOATING
C16668 divbuf_5/a_29262_n240# vdd 0.90fF **FLOATING
C16669 divbuf_5/a_28772_n240# vdd 0.90fF **FLOATING
C16670 divbuf_5/a_28292_n240# vdd 0.90fF **FLOATING
C16671 divbuf_5/a_27802_n240# vdd 0.89fF **FLOATING
C16672 divbuf_5/a_27322_n240# vdd 0.95fF **FLOATING
C16673 divbuf_5/a_26832_n240# vdd 0.91fF **FLOATING
C16674 divbuf_5/a_26352_n240# vdd 0.91fF **FLOATING
C16675 divbuf_5/a_25862_n240# vdd 0.91fF **FLOATING
C16676 divbuf_5/a_25382_n240# vdd 0.91fF **FLOATING
C16677 divbuf_5/a_24892_n240# vdd 0.91fF **FLOATING
C16678 divbuf_5/a_24412_n240# vdd 0.91fF **FLOATING
C16679 divbuf_5/a_23922_n240# vdd 0.92fF **FLOATING
C16680 divbuf_5/a_23442_n240# vdd 0.94fF **FLOATING
C16681 divbuf_5/a_22952_n240# vdd 0.91fF **FLOATING
C16682 divbuf_5/a_22472_n240# vdd 0.91fF **FLOATING
C16683 divbuf_5/a_21982_n240# vdd 0.91fF **FLOATING
C16684 divbuf_5/a_21502_n240# vdd 0.91fF **FLOATING
C16685 divbuf_5/a_21012_n240# vdd 0.91fF **FLOATING
C16686 divbuf_5/a_20532_n240# vdd 0.91fF **FLOATING
C16687 divbuf_5/a_20042_n240# vdd 0.90fF **FLOATING
C16688 divbuf_5/a_19562_n240# vdd 0.90fF **FLOATING
C16689 divbuf_5/a_19072_n240# vdd 0.90fF **FLOATING
C16690 divbuf_5/a_18582_n240# vdd 0.89fF **FLOATING
C16691 divbuf_5/a_18092_n240# vdd 0.89fF **FLOATING
C16692 divbuf_5/a_17612_n240# vdd 0.89fF **FLOATING
C16693 divbuf_5/a_17122_n240# vdd 0.88fF **FLOATING
C16694 divbuf_5/a_16642_n240# vdd 0.88fF **FLOATING
C16695 divbuf_5/a_16152_n240# vdd 0.88fF **FLOATING
C16696 divbuf_5/a_15672_n240# vdd 0.90fF **FLOATING
C16697 divbuf_5/a_15182_n240# vdd 0.88fF **FLOATING
C16698 divbuf_5/a_14702_n240# vdd 0.88fF **FLOATING
C16699 divbuf_5/a_14222_n240# vdd 0.88fF **FLOATING
C16700 divbuf_5/a_13742_n240# vdd 0.88fF **FLOATING
C16701 divbuf_5/a_13252_n240# vdd 0.88fF **FLOATING
C16702 divbuf_5/a_12772_n240# vdd 0.88fF **FLOATING
C16703 divbuf_5/a_12282_n240# vdd 0.88fF **FLOATING
C16704 divbuf_5/a_11802_n240# vdd 0.98fF **FLOATING
C16705 divbuf_5/a_11312_n240# vdd 0.98fF **FLOATING
C16706 divbuf_5/a_10212_n240# vdd 0.91fF **FLOATING
C16707 divbuf_5/a_9732_n240# vdd 0.91fF **FLOATING
C16708 divbuf_5/a_9242_n240# vdd 0.91fF **FLOATING
C16709 divbuf_5/a_8762_n240# vdd 0.91fF **FLOATING
C16710 divbuf_5/a_8272_n240# vdd 0.91fF **FLOATING
C16711 divbuf_5/a_7792_n240# vdd 0.92fF **FLOATING
C16712 divbuf_5/a_7302_n240# vdd 0.90fF **FLOATING
C16713 divbuf_5/a_6822_n240# vdd 0.90fF **FLOATING
C16714 divbuf_5/a_6332_n240# vdd 0.90fF **FLOATING
C16715 divbuf_5/a_5852_n240# vdd 0.90fF **FLOATING
C16716 divbuf_5/a_5362_n240# vdd 0.90fF **FLOATING
C16717 divbuf_5/a_4882_n240# vdd 0.90fF **FLOATING
C16718 divbuf_5/a_4392_n240# vdd 0.90fF **FLOATING
C16719 divbuf_5/a_3912_n240# vdd 0.90fF **FLOATING
C16720 divbuf_5/a_3422_n240# vdd 0.90fF **FLOATING
C16721 divbuf_5/a_2322_n240# vdd 0.91fF **FLOATING
C16722 divbuf_5/a_1842_n240# vdd 0.91fF **FLOATING
C16723 divbuf_5/a_1352_n240# vdd 0.91fF **FLOATING
C16724 divbuf_5/a_41382_170# vdd 1.07fF **FLOATING
C16725 divbuf_5/a_40902_170# vdd 1.09fF **FLOATING
C16726 divbuf_5/a_40412_170# vdd 1.09fF **FLOATING
C16727 divbuf_5/a_39932_170# vdd 1.09fF **FLOATING
C16728 divbuf_5/a_39442_170# vdd 1.09fF **FLOATING
C16729 divbuf_5/a_38962_170# vdd 1.07fF **FLOATING
C16730 divbuf_5/a_38472_170# vdd 1.09fF **FLOATING
C16731 divbuf_5/a_37992_170# vdd 1.09fF **FLOATING
C16732 divbuf_5/a_37502_170# vdd 1.09fF **FLOATING
C16733 divbuf_5/a_37022_170# vdd 1.09fF **FLOATING
C16734 divbuf_5/a_36532_170# vdd 1.09fF **FLOATING
C16735 divbuf_5/a_36052_170# vdd 1.09fF **FLOATING
C16736 divbuf_5/a_35562_170# vdd 1.09fF **FLOATING
C16737 divbuf_5/a_35082_170# vdd 1.09fF **FLOATING
C16738 divbuf_5/a_34592_170# vdd 1.07fF **FLOATING
C16739 divbuf_5/a_34112_170# vdd 1.09fF **FLOATING
C16740 divbuf_5/a_33622_170# vdd 1.09fF **FLOATING
C16741 divbuf_5/a_33142_170# vdd 1.09fF **FLOATING
C16742 divbuf_5/a_32652_170# vdd 1.09fF **FLOATING
C16743 divbuf_5/a_32172_170# vdd 1.09fF **FLOATING
C16744 divbuf_5/a_31682_170# vdd 1.09fF **FLOATING
C16745 divbuf_5/a_31202_170# vdd 1.09fF **FLOATING
C16746 divbuf_5/a_30712_170# vdd 1.09fF **FLOATING
C16747 divbuf_5/a_30232_170# vdd 1.07fF **FLOATING
C16748 divbuf_5/a_29742_170# vdd 1.09fF **FLOATING
C16749 divbuf_5/a_29262_170# vdd 1.09fF **FLOATING
C16750 divbuf_5/a_28772_170# vdd 1.09fF **FLOATING
C16751 divbuf_5/a_28292_170# vdd 1.09fF **FLOATING
C16752 divbuf_5/a_27802_170# vdd 1.09fF **FLOATING
C16753 divbuf_5/a_27322_170# vdd 1.09fF **FLOATING
C16754 divbuf_5/a_26832_170# vdd 1.09fF **FLOATING
C16755 divbuf_5/a_26352_170# vdd 1.09fF **FLOATING
C16756 divbuf_5/a_25862_170# vdd 1.07fF **FLOATING
C16757 divbuf_5/a_25382_170# vdd 1.09fF **FLOATING
C16758 divbuf_5/a_24892_170# vdd 1.09fF **FLOATING
C16759 divbuf_5/a_24412_170# vdd 1.09fF **FLOATING
C16760 divbuf_5/a_23922_170# vdd 1.09fF **FLOATING
C16761 divbuf_5/a_23442_170# vdd 1.09fF **FLOATING
C16762 divbuf_5/a_22952_170# vdd 1.09fF **FLOATING
C16763 divbuf_5/a_22472_170# vdd 1.07fF **FLOATING
C16764 divbuf_5/a_21982_170# vdd 1.09fF **FLOATING
C16765 divbuf_5/a_21502_170# vdd 1.09fF **FLOATING
C16766 divbuf_5/a_21012_170# vdd 1.09fF **FLOATING
C16767 divbuf_5/a_20532_170# vdd 1.09fF **FLOATING
C16768 divbuf_5/a_20042_170# vdd 1.09fF **FLOATING
C16769 divbuf_5/a_19562_170# vdd 1.09fF **FLOATING
C16770 divbuf_5/a_19072_170# vdd 1.09fF **FLOATING
C16771 divbuf_5/a_18582_170# vdd 1.07fF **FLOATING
C16772 divbuf_5/a_18092_170# vdd 1.09fF **FLOATING
C16773 divbuf_5/a_17612_170# vdd 1.09fF **FLOATING
C16774 divbuf_5/a_17122_170# vdd 1.09fF **FLOATING
C16775 divbuf_5/a_16642_170# vdd 1.09fF **FLOATING
C16776 divbuf_5/a_16152_170# vdd 1.09fF **FLOATING
C16777 divbuf_5/a_15672_170# vdd 1.09fF **FLOATING
C16778 divbuf_5/a_15182_170# vdd 1.09fF **FLOATING
C16779 divbuf_5/a_14702_170# vdd 1.10fF **FLOATING
C16780 divbuf_5/a_14222_170# vdd 1.10fF **FLOATING
C16781 divbuf_5/a_13742_170# vdd 1.09fF **FLOATING
C16782 divbuf_5/a_13252_170# vdd 1.09fF **FLOATING
C16783 divbuf_5/a_12772_170# vdd 1.07fF **FLOATING
C16784 divbuf_5/a_12282_170# vdd 1.09fF **FLOATING
C16785 divbuf_5/a_11802_170# vdd 1.23fF **FLOATING
C16786 divbuf_5/a_11312_170# vdd 1.24fF **FLOATING
C16787 divbuf_5/a_10212_170# vdd 1.09fF **FLOATING
C16788 divbuf_5/a_9732_170# vdd 1.09fF **FLOATING
C16789 divbuf_5/a_9242_170# vdd 1.09fF **FLOATING
C16790 divbuf_5/a_8762_170# vdd 1.09fF **FLOATING
C16791 divbuf_5/a_8272_170# vdd 1.07fF **FLOATING
C16792 divbuf_5/a_7792_170# vdd 1.09fF **FLOATING
C16793 divbuf_5/a_7302_170# vdd 1.09fF **FLOATING
C16794 divbuf_5/a_6822_170# vdd 1.09fF **FLOATING
C16795 divbuf_5/a_6332_170# vdd 1.09fF **FLOATING
C16796 divbuf_5/a_5852_170# vdd 1.09fF **FLOATING
C16797 divbuf_5/a_5362_170# vdd 1.09fF **FLOATING
C16798 divbuf_5/a_4882_170# vdd 1.09fF **FLOATING
C16799 divbuf_5/a_4392_170# vdd 1.07fF **FLOATING
C16800 divbuf_5/a_3912_170# vdd 1.09fF **FLOATING
C16801 divbuf_5/a_3422_170# vdd 1.10fF **FLOATING
C16802 divbuf_5/a_2322_170# vdd 1.09fF **FLOATING
C16803 divbuf_5/a_1842_170# vdd 1.09fF **FLOATING
C16804 divbuf_5/a_1352_170# vdd 1.10fF **FLOATING
C16805 divbuf_5/a_492_n240# vdd 2.46fF **FLOATING
C16806 divbuf_4/OUT5 vdd 16.40fF
C16807 divbuf_4/OUT4 vdd 100.06fF
C16808 divbuf_4/OUT3 vdd 27.01fF
C16809 divbuf_4/OUT2 vdd 8.71fF
C16810 divbuf_4/a_60990_n1540# vdd 1.57fF **FLOATING
C16811 divbuf_4/a_60510_n1540# vdd 1.62fF **FLOATING
C16812 divbuf_4/a_60030_n1540# vdd 1.62fF **FLOATING
C16813 divbuf_4/a_59550_n1540# vdd 1.62fF **FLOATING
C16814 divbuf_4/a_59070_n1540# vdd 1.62fF **FLOATING
C16815 divbuf_4/a_58590_n1540# vdd 1.62fF **FLOATING
C16816 divbuf_4/a_58110_n1540# vdd 1.62fF **FLOATING
C16817 divbuf_4/a_57630_n1540# vdd 1.62fF **FLOATING
C16818 divbuf_4/a_57150_n1540# vdd 1.62fF **FLOATING
C16819 divbuf_4/a_56670_n1540# vdd 1.62fF **FLOATING
C16820 divbuf_4/a_56190_n1540# vdd 1.62fF **FLOATING
C16821 divbuf_4/a_55710_n1540# vdd 1.62fF **FLOATING
C16822 divbuf_4/a_55230_n1540# vdd 1.62fF **FLOATING
C16823 divbuf_4/a_54750_n1540# vdd 1.62fF **FLOATING
C16824 divbuf_4/a_54270_n1540# vdd 1.62fF **FLOATING
C16825 divbuf_4/a_53790_n1540# vdd 1.62fF **FLOATING
C16826 divbuf_4/a_53310_n1540# vdd 1.62fF **FLOATING
C16827 divbuf_4/a_52830_n1540# vdd 1.62fF **FLOATING
C16828 divbuf_4/a_52350_n1540# vdd 1.62fF **FLOATING
C16829 divbuf_4/a_51870_n1540# vdd 1.62fF **FLOATING
C16830 divbuf_4/a_51390_n1540# vdd 1.62fF **FLOATING
C16831 divbuf_4/a_50910_n1540# vdd 1.62fF **FLOATING
C16832 divbuf_4/a_50430_n1540# vdd 1.62fF **FLOATING
C16833 divbuf_4/a_49950_n1540# vdd 1.62fF **FLOATING
C16834 divbuf_4/a_49470_n1540# vdd 1.62fF **FLOATING
C16835 divbuf_4/a_48990_n1540# vdd 1.62fF **FLOATING
C16836 divbuf_4/a_48510_n1540# vdd 1.62fF **FLOATING
C16837 divbuf_4/a_48030_n1540# vdd 1.62fF **FLOATING
C16838 divbuf_4/a_47550_n1540# vdd 1.62fF **FLOATING
C16839 divbuf_4/a_47070_n1540# vdd 1.62fF **FLOATING
C16840 divbuf_4/a_46590_n1540# vdd 1.62fF **FLOATING
C16841 divbuf_4/a_46110_n1540# vdd 1.62fF **FLOATING
C16842 divbuf_4/a_45630_n1540# vdd 1.62fF **FLOATING
C16843 divbuf_4/a_45150_n1540# vdd 1.62fF **FLOATING
C16844 divbuf_4/a_44670_n1540# vdd 1.62fF **FLOATING
C16845 divbuf_4/a_44190_n1540# vdd 1.62fF **FLOATING
C16846 divbuf_4/a_43710_n1540# vdd 1.62fF **FLOATING
C16847 divbuf_4/a_43230_n1540# vdd 1.62fF **FLOATING
C16848 divbuf_4/a_42750_n1540# vdd 1.62fF **FLOATING
C16849 divbuf_4/a_42270_n1540# vdd 1.62fF **FLOATING
C16850 divbuf_4/a_41790_n1540# vdd 1.62fF **FLOATING
C16851 divbuf_4/a_41310_n1540# vdd 1.62fF **FLOATING
C16852 divbuf_4/a_40830_n1540# vdd 1.62fF **FLOATING
C16853 divbuf_4/a_40350_n1540# vdd 1.62fF **FLOATING
C16854 divbuf_4/a_39870_n1540# vdd 1.62fF **FLOATING
C16855 divbuf_4/a_39390_n1540# vdd 1.62fF **FLOATING
C16856 divbuf_4/a_38910_n1540# vdd 1.62fF **FLOATING
C16857 divbuf_4/a_38430_n1540# vdd 1.62fF **FLOATING
C16858 divbuf_4/a_37950_n1540# vdd 1.62fF **FLOATING
C16859 divbuf_4/a_37470_n1540# vdd 1.62fF **FLOATING
C16860 divbuf_4/a_36990_n1540# vdd 1.62fF **FLOATING
C16861 divbuf_4/a_36510_n1540# vdd 1.62fF **FLOATING
C16862 divbuf_4/a_36030_n1540# vdd 1.62fF **FLOATING
C16863 divbuf_4/a_35550_n1540# vdd 1.62fF **FLOATING
C16864 divbuf_4/a_35070_n1540# vdd 1.62fF **FLOATING
C16865 divbuf_4/a_34590_n1540# vdd 1.62fF **FLOATING
C16866 divbuf_4/a_34110_n1540# vdd 1.62fF **FLOATING
C16867 divbuf_4/a_33630_n1540# vdd 1.62fF **FLOATING
C16868 divbuf_4/a_33150_n1540# vdd 1.62fF **FLOATING
C16869 divbuf_4/a_32670_n1540# vdd 1.62fF **FLOATING
C16870 divbuf_4/a_32190_n1540# vdd 1.62fF **FLOATING
C16871 divbuf_4/a_31710_n1540# vdd 1.62fF **FLOATING
C16872 divbuf_4/a_31230_n1540# vdd 1.62fF **FLOATING
C16873 divbuf_4/a_30750_n1540# vdd 1.62fF **FLOATING
C16874 divbuf_4/a_30270_n1540# vdd 1.62fF **FLOATING
C16875 divbuf_4/a_29790_n1540# vdd 1.62fF **FLOATING
C16876 divbuf_4/a_29310_n1540# vdd 1.62fF **FLOATING
C16877 divbuf_4/a_28830_n1540# vdd 1.62fF **FLOATING
C16878 divbuf_4/a_28350_n1540# vdd 1.62fF **FLOATING
C16879 divbuf_4/a_27870_n1540# vdd 1.62fF **FLOATING
C16880 divbuf_4/a_27390_n1540# vdd 1.62fF **FLOATING
C16881 divbuf_4/a_26910_n1540# vdd 1.62fF **FLOATING
C16882 divbuf_4/a_26430_n1540# vdd 1.62fF **FLOATING
C16883 divbuf_4/a_25950_n1540# vdd 1.62fF **FLOATING
C16884 divbuf_4/a_25470_n1540# vdd 1.62fF **FLOATING
C16885 divbuf_4/a_24990_n1540# vdd 1.62fF **FLOATING
C16886 divbuf_4/a_24510_n1540# vdd 1.62fF **FLOATING
C16887 divbuf_4/a_24030_n1540# vdd 1.62fF **FLOATING
C16888 divbuf_4/a_23550_n1540# vdd 1.62fF **FLOATING
C16889 divbuf_4/a_23070_n1540# vdd 1.62fF **FLOATING
C16890 divbuf_4/a_22590_n1540# vdd 1.62fF **FLOATING
C16891 divbuf_4/a_22110_n1540# vdd 1.62fF **FLOATING
C16892 divbuf_4/a_21630_n1540# vdd 1.62fF **FLOATING
C16893 divbuf_4/a_21150_n1540# vdd 1.62fF **FLOATING
C16894 divbuf_4/a_20670_n1540# vdd 1.62fF **FLOATING
C16895 divbuf_4/a_20190_n1540# vdd 1.62fF **FLOATING
C16896 divbuf_4/a_19710_n1540# vdd 1.62fF **FLOATING
C16897 divbuf_4/a_19230_n1540# vdd 1.62fF **FLOATING
C16898 divbuf_4/a_18750_n1540# vdd 1.62fF **FLOATING
C16899 divbuf_4/a_18270_n1540# vdd 1.62fF **FLOATING
C16900 divbuf_4/a_17790_n1540# vdd 1.62fF **FLOATING
C16901 divbuf_4/a_17310_n1540# vdd 1.62fF **FLOATING
C16902 divbuf_4/a_16830_n1540# vdd 1.62fF **FLOATING
C16903 divbuf_4/a_16350_n1540# vdd 1.62fF **FLOATING
C16904 divbuf_4/a_15870_n1540# vdd 1.62fF **FLOATING
C16905 divbuf_4/a_15390_n1540# vdd 1.62fF **FLOATING
C16906 divbuf_4/a_14910_n1540# vdd 1.62fF **FLOATING
C16907 divbuf_4/a_14430_n1540# vdd 1.62fF **FLOATING
C16908 divbuf_4/a_13950_n1540# vdd 1.62fF **FLOATING
C16909 divbuf_4/a_13470_n1540# vdd 1.62fF **FLOATING
C16910 divbuf_4/a_12990_n1540# vdd 1.62fF **FLOATING
C16911 divbuf_4/a_12510_n1540# vdd 1.62fF **FLOATING
C16912 divbuf_4/a_12030_n1540# vdd 1.62fF **FLOATING
C16913 divbuf_4/a_11550_n1540# vdd 1.62fF **FLOATING
C16914 divbuf_4/a_11070_n1540# vdd 1.62fF **FLOATING
C16915 divbuf_4/a_10590_n1540# vdd 1.62fF **FLOATING
C16916 divbuf_4/a_10110_n1540# vdd 1.62fF **FLOATING
C16917 divbuf_4/a_9630_n1540# vdd 1.62fF **FLOATING
C16918 divbuf_4/a_9150_n1540# vdd 1.62fF **FLOATING
C16919 divbuf_4/a_8670_n1540# vdd 1.62fF **FLOATING
C16920 divbuf_4/a_8190_n1540# vdd 1.62fF **FLOATING
C16921 divbuf_4/a_7710_n1540# vdd 1.62fF **FLOATING
C16922 divbuf_4/a_7230_n1540# vdd 1.62fF **FLOATING
C16923 divbuf_4/a_6750_n1540# vdd 1.62fF **FLOATING
C16924 divbuf_4/a_6270_n1540# vdd 1.62fF **FLOATING
C16925 divbuf_4/a_5790_n1540# vdd 1.62fF **FLOATING
C16926 divbuf_4/a_5310_n1540# vdd 1.62fF **FLOATING
C16927 divbuf_4/a_4830_n1540# vdd 1.62fF **FLOATING
C16928 divbuf_4/a_4350_n1540# vdd 1.62fF **FLOATING
C16929 divbuf_4/a_3870_n1540# vdd 1.62fF **FLOATING
C16930 divbuf_4/a_3390_n1540# vdd 1.62fF **FLOATING
C16931 divbuf_4/a_2910_n1540# vdd 1.62fF **FLOATING
C16932 divbuf_4/a_2430_n1540# vdd 1.62fF **FLOATING
C16933 divbuf_4/a_1950_n1540# vdd 1.62fF **FLOATING
C16934 divbuf_4/a_1470_n1540# vdd 1.62fF **FLOATING
C16935 divbuf_4/a_990_n1540# vdd 1.62fF **FLOATING
C16936 divbuf_4/a_510_n1540# vdd 1.62fF **FLOATING
C16937 divbuf_4/a_60990_n840# vdd 1.06fF **FLOATING
C16938 divbuf_4/a_60510_n840# vdd 1.09fF **FLOATING
C16939 divbuf_4/a_60030_n840# vdd 1.09fF **FLOATING
C16940 divbuf_4/a_59550_n840# vdd 1.09fF **FLOATING
C16941 divbuf_4/a_59070_n840# vdd 1.09fF **FLOATING
C16942 divbuf_4/a_58590_n840# vdd 1.09fF **FLOATING
C16943 divbuf_4/a_58110_n840# vdd 1.09fF **FLOATING
C16944 divbuf_4/a_57630_n840# vdd 1.09fF **FLOATING
C16945 divbuf_4/a_57150_n840# vdd 1.09fF **FLOATING
C16946 divbuf_4/a_56670_n840# vdd 1.09fF **FLOATING
C16947 divbuf_4/a_56190_n840# vdd 1.09fF **FLOATING
C16948 divbuf_4/a_55710_n840# vdd 1.09fF **FLOATING
C16949 divbuf_4/a_55230_n840# vdd 1.09fF **FLOATING
C16950 divbuf_4/a_54750_n840# vdd 1.09fF **FLOATING
C16951 divbuf_4/a_54270_n840# vdd 1.09fF **FLOATING
C16952 divbuf_4/a_53790_n840# vdd 1.09fF **FLOATING
C16953 divbuf_4/a_53310_n840# vdd 1.09fF **FLOATING
C16954 divbuf_4/a_52830_n840# vdd 1.09fF **FLOATING
C16955 divbuf_4/a_52350_n840# vdd 1.09fF **FLOATING
C16956 divbuf_4/a_51870_n840# vdd 1.09fF **FLOATING
C16957 divbuf_4/a_51390_n840# vdd 1.09fF **FLOATING
C16958 divbuf_4/a_50910_n840# vdd 1.09fF **FLOATING
C16959 divbuf_4/a_50430_n840# vdd 1.09fF **FLOATING
C16960 divbuf_4/a_49950_n840# vdd 1.09fF **FLOATING
C16961 divbuf_4/a_49470_n840# vdd 1.09fF **FLOATING
C16962 divbuf_4/a_48990_n840# vdd 1.09fF **FLOATING
C16963 divbuf_4/a_48510_n840# vdd 1.09fF **FLOATING
C16964 divbuf_4/a_48030_n840# vdd 1.09fF **FLOATING
C16965 divbuf_4/a_47550_n840# vdd 1.09fF **FLOATING
C16966 divbuf_4/a_47070_n840# vdd 1.09fF **FLOATING
C16967 divbuf_4/a_46590_n840# vdd 1.09fF **FLOATING
C16968 divbuf_4/a_46110_n840# vdd 1.09fF **FLOATING
C16969 divbuf_4/a_45630_n840# vdd 1.09fF **FLOATING
C16970 divbuf_4/a_45150_n840# vdd 1.09fF **FLOATING
C16971 divbuf_4/a_44670_n840# vdd 1.09fF **FLOATING
C16972 divbuf_4/a_44190_n840# vdd 1.09fF **FLOATING
C16973 divbuf_4/a_43710_n840# vdd 1.09fF **FLOATING
C16974 divbuf_4/a_43230_n840# vdd 1.09fF **FLOATING
C16975 divbuf_4/a_42750_n840# vdd 1.08fF **FLOATING
C16976 divbuf_4/a_42270_n840# vdd 1.08fF **FLOATING
C16977 divbuf_4/a_41790_n840# vdd 1.10fF **FLOATING
C16978 divbuf_4/a_41310_n840# vdd 1.09fF **FLOATING
C16979 divbuf_4/a_40830_n840# vdd 1.09fF **FLOATING
C16980 divbuf_4/a_40350_n840# vdd 1.09fF **FLOATING
C16981 divbuf_4/a_39870_n840# vdd 1.09fF **FLOATING
C16982 divbuf_4/a_39390_n840# vdd 1.09fF **FLOATING
C16983 divbuf_4/a_38910_n840# vdd 1.09fF **FLOATING
C16984 divbuf_4/a_38430_n840# vdd 1.09fF **FLOATING
C16985 divbuf_4/a_37950_n840# vdd 1.09fF **FLOATING
C16986 divbuf_4/a_37470_n840# vdd 1.09fF **FLOATING
C16987 divbuf_4/a_36990_n840# vdd 1.09fF **FLOATING
C16988 divbuf_4/a_36510_n840# vdd 1.09fF **FLOATING
C16989 divbuf_4/a_36030_n840# vdd 1.09fF **FLOATING
C16990 divbuf_4/a_35550_n840# vdd 1.09fF **FLOATING
C16991 divbuf_4/a_35070_n840# vdd 1.09fF **FLOATING
C16992 divbuf_4/a_34590_n840# vdd 1.09fF **FLOATING
C16993 divbuf_4/a_34110_n840# vdd 1.09fF **FLOATING
C16994 divbuf_4/a_33630_n840# vdd 1.09fF **FLOATING
C16995 divbuf_4/a_33150_n840# vdd 1.09fF **FLOATING
C16996 divbuf_4/a_32670_n840# vdd 1.09fF **FLOATING
C16997 divbuf_4/a_32190_n840# vdd 1.09fF **FLOATING
C16998 divbuf_4/a_31710_n840# vdd 1.11fF **FLOATING
C16999 divbuf_4/a_31230_n840# vdd 1.13fF **FLOATING
C17000 divbuf_4/a_30750_n840# vdd 1.09fF **FLOATING
C17001 divbuf_4/a_30270_n840# vdd 1.09fF **FLOATING
C17002 divbuf_4/a_29790_n840# vdd 1.09fF **FLOATING
C17003 divbuf_4/a_29310_n840# vdd 1.09fF **FLOATING
C17004 divbuf_4/a_28830_n840# vdd 1.09fF **FLOATING
C17005 divbuf_4/a_28350_n840# vdd 1.09fF **FLOATING
C17006 divbuf_4/a_27870_n840# vdd 1.08fF **FLOATING
C17007 divbuf_4/a_27390_n840# vdd 1.11fF **FLOATING
C17008 divbuf_4/a_26910_n840# vdd 1.10fF **FLOATING
C17009 divbuf_4/a_26430_n840# vdd 1.10fF **FLOATING
C17010 divbuf_4/a_25950_n840# vdd 1.10fF **FLOATING
C17011 divbuf_4/a_25470_n840# vdd 1.10fF **FLOATING
C17012 divbuf_4/a_24990_n840# vdd 1.10fF **FLOATING
C17013 divbuf_4/a_24510_n840# vdd 1.10fF **FLOATING
C17014 divbuf_4/a_24030_n840# vdd 1.09fF **FLOATING
C17015 divbuf_4/a_23550_n840# vdd 1.11fF **FLOATING
C17016 divbuf_4/a_23070_n840# vdd 1.10fF **FLOATING
C17017 divbuf_4/a_22590_n840# vdd 1.10fF **FLOATING
C17018 divbuf_4/a_22110_n840# vdd 1.10fF **FLOATING
C17019 divbuf_4/a_21630_n840# vdd 1.10fF **FLOATING
C17020 divbuf_4/a_21150_n840# vdd 1.10fF **FLOATING
C17021 divbuf_4/a_20670_n840# vdd 1.10fF **FLOATING
C17022 divbuf_4/a_20190_n840# vdd 1.09fF **FLOATING
C17023 divbuf_4/a_19710_n840# vdd 1.09fF **FLOATING
C17024 divbuf_4/a_19230_n840# vdd 1.09fF **FLOATING
C17025 divbuf_4/a_18750_n840# vdd 1.09fF **FLOATING
C17026 divbuf_4/a_18270_n840# vdd 1.08fF **FLOATING
C17027 divbuf_4/a_17790_n840# vdd 1.08fF **FLOATING
C17028 divbuf_4/a_17310_n840# vdd 1.07fF **FLOATING
C17029 divbuf_4/a_16830_n840# vdd 1.07fF **FLOATING
C17030 divbuf_4/a_16350_n840# vdd 1.07fF **FLOATING
C17031 divbuf_4/a_15870_n840# vdd 1.07fF **FLOATING
C17032 divbuf_4/a_15390_n840# vdd 1.08fF **FLOATING
C17033 divbuf_4/a_14910_n840# vdd 1.07fF **FLOATING
C17034 divbuf_4/a_14430_n840# vdd 1.07fF **FLOATING
C17035 divbuf_4/a_13950_n840# vdd 1.07fF **FLOATING
C17036 divbuf_4/a_13470_n840# vdd 1.07fF **FLOATING
C17037 divbuf_4/a_12990_n840# vdd 1.10fF **FLOATING
C17038 divbuf_4/a_12510_n840# vdd 1.08fF **FLOATING
C17039 divbuf_4/a_12030_n840# vdd 1.07fF **FLOATING
C17040 divbuf_4/a_11550_n840# vdd 1.07fF **FLOATING
C17041 divbuf_4/a_11070_n840# vdd 1.08fF **FLOATING
C17042 divbuf_4/a_10590_n840# vdd 1.10fF **FLOATING
C17043 divbuf_4/a_10110_n840# vdd 1.10fF **FLOATING
C17044 divbuf_4/a_9630_n840# vdd 1.10fF **FLOATING
C17045 divbuf_4/a_9150_n840# vdd 1.10fF **FLOATING
C17046 divbuf_4/a_8670_n840# vdd 1.10fF **FLOATING
C17047 divbuf_4/a_8190_n840# vdd 1.12fF **FLOATING
C17048 divbuf_4/a_7710_n840# vdd 1.10fF **FLOATING
C17049 divbuf_4/a_7230_n840# vdd 1.09fF **FLOATING
C17050 divbuf_4/a_6750_n840# vdd 1.09fF **FLOATING
C17051 divbuf_4/a_6270_n840# vdd 1.09fF **FLOATING
C17052 divbuf_4/a_5790_n840# vdd 1.09fF **FLOATING
C17053 divbuf_4/a_5310_n840# vdd 1.09fF **FLOATING
C17054 divbuf_4/a_4830_n840# vdd 1.09fF **FLOATING
C17055 divbuf_4/a_4350_n840# vdd 1.09fF **FLOATING
C17056 divbuf_4/a_3870_n840# vdd 1.09fF **FLOATING
C17057 divbuf_4/a_3390_n840# vdd 1.09fF **FLOATING
C17058 divbuf_4/a_2910_n840# vdd 1.10fF **FLOATING
C17059 divbuf_4/a_2430_n840# vdd 1.10fF **FLOATING
C17060 divbuf_4/a_1950_n840# vdd 1.10fF **FLOATING
C17061 divbuf_4/a_1470_n840# vdd 1.10fF **FLOATING
C17062 divbuf_4/a_990_n840# vdd 1.08fF **FLOATING
C17063 divbuf_4/a_510_n840# vdd 1.07fF **FLOATING
C17064 divbuf_4/a_60480_n1600# vdd 1.48fF **FLOATING
C17065 divbuf_4/a_60000_n1600# vdd 1.48fF **FLOATING
C17066 divbuf_4/a_59520_n1600# vdd 1.48fF **FLOATING
C17067 divbuf_4/a_59040_n1600# vdd 1.48fF **FLOATING
C17068 divbuf_4/a_58560_n1600# vdd 1.48fF **FLOATING
C17069 divbuf_4/a_58080_n1600# vdd 1.48fF **FLOATING
C17070 divbuf_4/a_57600_n1600# vdd 1.48fF **FLOATING
C17071 divbuf_4/a_57120_n1600# vdd 1.48fF **FLOATING
C17072 divbuf_4/a_56640_n1600# vdd 1.48fF **FLOATING
C17073 divbuf_4/a_56160_n1600# vdd 1.48fF **FLOATING
C17074 divbuf_4/a_55680_n1600# vdd 1.48fF **FLOATING
C17075 divbuf_4/a_55200_n1600# vdd 1.48fF **FLOATING
C17076 divbuf_4/a_54720_n1600# vdd 1.48fF **FLOATING
C17077 divbuf_4/a_54240_n1600# vdd 1.48fF **FLOATING
C17078 divbuf_4/a_53760_n1600# vdd 1.48fF **FLOATING
C17079 divbuf_4/a_53280_n1600# vdd 1.48fF **FLOATING
C17080 divbuf_4/a_52800_n1600# vdd 1.48fF **FLOATING
C17081 divbuf_4/a_52320_n1600# vdd 1.48fF **FLOATING
C17082 divbuf_4/a_51840_n1600# vdd 1.48fF **FLOATING
C17083 divbuf_4/a_51360_n1600# vdd 1.48fF **FLOATING
C17084 divbuf_4/a_50880_n1600# vdd 1.48fF **FLOATING
C17085 divbuf_4/a_50400_n1600# vdd 1.48fF **FLOATING
C17086 divbuf_4/a_49920_n1600# vdd 1.48fF **FLOATING
C17087 divbuf_4/a_49440_n1600# vdd 1.48fF **FLOATING
C17088 divbuf_4/a_48960_n1600# vdd 1.48fF **FLOATING
C17089 divbuf_4/a_48480_n1600# vdd 1.48fF **FLOATING
C17090 divbuf_4/a_48000_n1600# vdd 1.48fF **FLOATING
C17091 divbuf_4/a_47520_n1600# vdd 1.48fF **FLOATING
C17092 divbuf_4/a_47040_n1600# vdd 1.48fF **FLOATING
C17093 divbuf_4/a_46560_n1600# vdd 1.48fF **FLOATING
C17094 divbuf_4/a_46080_n1600# vdd 1.48fF **FLOATING
C17095 divbuf_4/a_45600_n1600# vdd 1.48fF **FLOATING
C17096 divbuf_4/a_45120_n1600# vdd 1.48fF **FLOATING
C17097 divbuf_4/a_44640_n1600# vdd 1.48fF **FLOATING
C17098 divbuf_4/a_44160_n1600# vdd 1.48fF **FLOATING
C17099 divbuf_4/a_43680_n1600# vdd 1.48fF **FLOATING
C17100 divbuf_4/a_43200_n1600# vdd 1.48fF **FLOATING
C17101 divbuf_4/a_42720_n1600# vdd 1.48fF **FLOATING
C17102 divbuf_4/a_42240_n1600# vdd 1.48fF **FLOATING
C17103 divbuf_4/a_41760_n1600# vdd 1.48fF **FLOATING
C17104 divbuf_4/a_41280_n1600# vdd 1.48fF **FLOATING
C17105 divbuf_4/a_40800_n1600# vdd 1.48fF **FLOATING
C17106 divbuf_4/a_40320_n1600# vdd 1.48fF **FLOATING
C17107 divbuf_4/a_39840_n1600# vdd 1.48fF **FLOATING
C17108 divbuf_4/a_39360_n1600# vdd 1.48fF **FLOATING
C17109 divbuf_4/a_38880_n1600# vdd 1.48fF **FLOATING
C17110 divbuf_4/a_38400_n1600# vdd 1.48fF **FLOATING
C17111 divbuf_4/a_37920_n1600# vdd 1.48fF **FLOATING
C17112 divbuf_4/a_37440_n1600# vdd 1.48fF **FLOATING
C17113 divbuf_4/a_36960_n1600# vdd 1.48fF **FLOATING
C17114 divbuf_4/a_36480_n1600# vdd 1.48fF **FLOATING
C17115 divbuf_4/a_36000_n1600# vdd 1.48fF **FLOATING
C17116 divbuf_4/a_35520_n1600# vdd 1.48fF **FLOATING
C17117 divbuf_4/a_35040_n1600# vdd 1.48fF **FLOATING
C17118 divbuf_4/a_34560_n1600# vdd 1.48fF **FLOATING
C17119 divbuf_4/a_34080_n1600# vdd 1.48fF **FLOATING
C17120 divbuf_4/a_33600_n1600# vdd 1.48fF **FLOATING
C17121 divbuf_4/a_33120_n1600# vdd 1.48fF **FLOATING
C17122 divbuf_4/a_32640_n1600# vdd 1.48fF **FLOATING
C17123 divbuf_4/a_32160_n1600# vdd 1.48fF **FLOATING
C17124 divbuf_4/a_31680_n1600# vdd 1.48fF **FLOATING
C17125 divbuf_4/a_31200_n1600# vdd 1.48fF **FLOATING
C17126 divbuf_4/a_30720_n1600# vdd 1.48fF **FLOATING
C17127 divbuf_4/a_30240_n1600# vdd 1.48fF **FLOATING
C17128 divbuf_4/a_29760_n1600# vdd 1.48fF **FLOATING
C17129 divbuf_4/a_29280_n1600# vdd 1.48fF **FLOATING
C17130 divbuf_4/a_28800_n1600# vdd 1.48fF **FLOATING
C17131 divbuf_4/a_28320_n1600# vdd 1.48fF **FLOATING
C17132 divbuf_4/a_27840_n1600# vdd 1.48fF **FLOATING
C17133 divbuf_4/a_27360_n1600# vdd 1.48fF **FLOATING
C17134 divbuf_4/a_26880_n1600# vdd 1.48fF **FLOATING
C17135 divbuf_4/a_26400_n1600# vdd 1.48fF **FLOATING
C17136 divbuf_4/a_25920_n1600# vdd 1.48fF **FLOATING
C17137 divbuf_4/a_25440_n1600# vdd 1.48fF **FLOATING
C17138 divbuf_4/a_24960_n1600# vdd 1.48fF **FLOATING
C17139 divbuf_4/a_24480_n1600# vdd 1.48fF **FLOATING
C17140 divbuf_4/a_24000_n1600# vdd 1.48fF **FLOATING
C17141 divbuf_4/a_23520_n1600# vdd 1.48fF **FLOATING
C17142 divbuf_4/a_23040_n1600# vdd 1.48fF **FLOATING
C17143 divbuf_4/a_22560_n1600# vdd 1.48fF **FLOATING
C17144 divbuf_4/a_22080_n1600# vdd 1.48fF **FLOATING
C17145 divbuf_4/a_21600_n1600# vdd 1.48fF **FLOATING
C17146 divbuf_4/a_21120_n1600# vdd 1.48fF **FLOATING
C17147 divbuf_4/a_20640_n1600# vdd 1.48fF **FLOATING
C17148 divbuf_4/a_20160_n1600# vdd 1.48fF **FLOATING
C17149 divbuf_4/a_19680_n1600# vdd 1.48fF **FLOATING
C17150 divbuf_4/a_19200_n1600# vdd 1.48fF **FLOATING
C17151 divbuf_4/a_18720_n1600# vdd 1.48fF **FLOATING
C17152 divbuf_4/a_18240_n1600# vdd 1.48fF **FLOATING
C17153 divbuf_4/a_17760_n1600# vdd 1.48fF **FLOATING
C17154 divbuf_4/a_17280_n1600# vdd 1.48fF **FLOATING
C17155 divbuf_4/a_16800_n1600# vdd 1.48fF **FLOATING
C17156 divbuf_4/a_16320_n1600# vdd 1.48fF **FLOATING
C17157 divbuf_4/a_15840_n1600# vdd 1.48fF **FLOATING
C17158 divbuf_4/a_15360_n1600# vdd 1.48fF **FLOATING
C17159 divbuf_4/a_14880_n1600# vdd 1.48fF **FLOATING
C17160 divbuf_4/a_14400_n1600# vdd 1.48fF **FLOATING
C17161 divbuf_4/a_13920_n1600# vdd 1.48fF **FLOATING
C17162 divbuf_4/a_13440_n1600# vdd 1.48fF **FLOATING
C17163 divbuf_4/a_12960_n1600# vdd 1.48fF **FLOATING
C17164 divbuf_4/a_12480_n1600# vdd 1.48fF **FLOATING
C17165 divbuf_4/a_12000_n1600# vdd 1.48fF **FLOATING
C17166 divbuf_4/a_11520_n1600# vdd 1.48fF **FLOATING
C17167 divbuf_4/a_11040_n1600# vdd 1.48fF **FLOATING
C17168 divbuf_4/a_10560_n1600# vdd 1.48fF **FLOATING
C17169 divbuf_4/a_10080_n1600# vdd 1.48fF **FLOATING
C17170 divbuf_4/a_9600_n1600# vdd 1.48fF **FLOATING
C17171 divbuf_4/a_9120_n1600# vdd 1.48fF **FLOATING
C17172 divbuf_4/a_8640_n1600# vdd 1.48fF **FLOATING
C17173 divbuf_4/a_8160_n1600# vdd 1.48fF **FLOATING
C17174 divbuf_4/a_7680_n1600# vdd 1.48fF **FLOATING
C17175 divbuf_4/a_7200_n1600# vdd 1.48fF **FLOATING
C17176 divbuf_4/a_6720_n1600# vdd 1.48fF **FLOATING
C17177 divbuf_4/a_6240_n1600# vdd 1.48fF **FLOATING
C17178 divbuf_4/a_5760_n1600# vdd 1.48fF **FLOATING
C17179 divbuf_4/a_5280_n1600# vdd 1.48fF **FLOATING
C17180 divbuf_4/a_4800_n1600# vdd 1.48fF **FLOATING
C17181 divbuf_4/a_4320_n1600# vdd 1.48fF **FLOATING
C17182 divbuf_4/a_3840_n1600# vdd 1.48fF **FLOATING
C17183 divbuf_4/a_3360_n1600# vdd 1.48fF **FLOATING
C17184 divbuf_4/a_2880_n1600# vdd 1.48fF **FLOATING
C17185 divbuf_4/a_2400_n1600# vdd 1.48fF **FLOATING
C17186 divbuf_4/a_1920_n1600# vdd 1.48fF **FLOATING
C17187 divbuf_4/a_1440_n1600# vdd 1.48fF **FLOATING
C17188 divbuf_4/a_960_n1600# vdd 1.48fF **FLOATING
C17189 divbuf_4/a_480_n1600# vdd 1.48fF **FLOATING
C17190 divbuf_4/a_0_n1600# vdd 1.48fF **FLOATING
C17191 divbuf_4/a_41382_n240# vdd 0.90fF **FLOATING
C17192 divbuf_4/a_40902_n240# vdd 0.90fF **FLOATING
C17193 divbuf_4/a_40412_n240# vdd 0.90fF **FLOATING
C17194 divbuf_4/a_39932_n240# vdd 0.90fF **FLOATING
C17195 divbuf_4/a_39442_n240# vdd 0.90fF **FLOATING
C17196 divbuf_4/a_38962_n240# vdd 0.91fF **FLOATING
C17197 divbuf_4/a_38472_n240# vdd 0.90fF **FLOATING
C17198 divbuf_4/a_37992_n240# vdd 0.90fF **FLOATING
C17199 divbuf_4/a_37502_n240# vdd 0.90fF **FLOATING
C17200 divbuf_4/a_37022_n240# vdd 0.90fF **FLOATING
C17201 divbuf_4/a_36532_n240# vdd 0.90fF **FLOATING
C17202 divbuf_4/a_36052_n240# vdd 0.90fF **FLOATING
C17203 divbuf_4/a_35562_n240# vdd 0.90fF **FLOATING
C17204 divbuf_4/a_35082_n240# vdd 0.91fF **FLOATING
C17205 divbuf_4/a_34592_n240# vdd 0.90fF **FLOATING
C17206 divbuf_4/a_34112_n240# vdd 0.90fF **FLOATING
C17207 divbuf_4/a_33622_n240# vdd 0.90fF **FLOATING
C17208 divbuf_4/a_33142_n240# vdd 0.90fF **FLOATING
C17209 divbuf_4/a_32652_n240# vdd 0.90fF **FLOATING
C17210 divbuf_4/a_32172_n240# vdd 0.90fF **FLOATING
C17211 divbuf_4/a_31682_n240# vdd 0.89fF **FLOATING
C17212 divbuf_4/a_31202_n240# vdd 0.92fF **FLOATING
C17213 divbuf_4/a_30712_n240# vdd 0.90fF **FLOATING
C17214 divbuf_4/a_30232_n240# vdd 0.90fF **FLOATING
C17215 divbuf_4/a_29742_n240# vdd 0.90fF **FLOATING
C17216 divbuf_4/a_29262_n240# vdd 0.90fF **FLOATING
C17217 divbuf_4/a_28772_n240# vdd 0.90fF **FLOATING
C17218 divbuf_4/a_28292_n240# vdd 0.90fF **FLOATING
C17219 divbuf_4/a_27802_n240# vdd 0.89fF **FLOATING
C17220 divbuf_4/a_27322_n240# vdd 0.95fF **FLOATING
C17221 divbuf_4/a_26832_n240# vdd 0.91fF **FLOATING
C17222 divbuf_4/a_26352_n240# vdd 0.91fF **FLOATING
C17223 divbuf_4/a_25862_n240# vdd 0.91fF **FLOATING
C17224 divbuf_4/a_25382_n240# vdd 0.91fF **FLOATING
C17225 divbuf_4/a_24892_n240# vdd 0.91fF **FLOATING
C17226 divbuf_4/a_24412_n240# vdd 0.91fF **FLOATING
C17227 divbuf_4/a_23922_n240# vdd 0.92fF **FLOATING
C17228 divbuf_4/a_23442_n240# vdd 0.94fF **FLOATING
C17229 divbuf_4/a_22952_n240# vdd 0.91fF **FLOATING
C17230 divbuf_4/a_22472_n240# vdd 0.91fF **FLOATING
C17231 divbuf_4/a_21982_n240# vdd 0.91fF **FLOATING
C17232 divbuf_4/a_21502_n240# vdd 0.91fF **FLOATING
C17233 divbuf_4/a_21012_n240# vdd 0.91fF **FLOATING
C17234 divbuf_4/a_20532_n240# vdd 0.91fF **FLOATING
C17235 divbuf_4/a_20042_n240# vdd 0.90fF **FLOATING
C17236 divbuf_4/a_19562_n240# vdd 0.90fF **FLOATING
C17237 divbuf_4/a_19072_n240# vdd 0.90fF **FLOATING
C17238 divbuf_4/a_18582_n240# vdd 0.89fF **FLOATING
C17239 divbuf_4/a_18092_n240# vdd 0.89fF **FLOATING
C17240 divbuf_4/a_17612_n240# vdd 0.89fF **FLOATING
C17241 divbuf_4/a_17122_n240# vdd 0.88fF **FLOATING
C17242 divbuf_4/a_16642_n240# vdd 0.88fF **FLOATING
C17243 divbuf_4/a_16152_n240# vdd 0.88fF **FLOATING
C17244 divbuf_4/a_15672_n240# vdd 0.90fF **FLOATING
C17245 divbuf_4/a_15182_n240# vdd 0.88fF **FLOATING
C17246 divbuf_4/a_14702_n240# vdd 0.88fF **FLOATING
C17247 divbuf_4/a_14222_n240# vdd 0.88fF **FLOATING
C17248 divbuf_4/a_13742_n240# vdd 0.88fF **FLOATING
C17249 divbuf_4/a_13252_n240# vdd 0.88fF **FLOATING
C17250 divbuf_4/a_12772_n240# vdd 0.88fF **FLOATING
C17251 divbuf_4/a_12282_n240# vdd 0.88fF **FLOATING
C17252 divbuf_4/a_11802_n240# vdd 0.88fF **FLOATING
C17253 divbuf_4/a_11312_n240# vdd 0.89fF **FLOATING
C17254 divbuf_4/a_10212_n240# vdd 0.91fF **FLOATING
C17255 divbuf_4/a_9732_n240# vdd 0.91fF **FLOATING
C17256 divbuf_4/a_9242_n240# vdd 0.91fF **FLOATING
C17257 divbuf_4/a_8762_n240# vdd 0.91fF **FLOATING
C17258 divbuf_4/a_8272_n240# vdd 0.91fF **FLOATING
C17259 divbuf_4/a_7792_n240# vdd 0.92fF **FLOATING
C17260 divbuf_4/a_7302_n240# vdd 0.90fF **FLOATING
C17261 divbuf_4/a_6822_n240# vdd 0.90fF **FLOATING
C17262 divbuf_4/a_6332_n240# vdd 0.90fF **FLOATING
C17263 divbuf_4/a_5852_n240# vdd 0.90fF **FLOATING
C17264 divbuf_4/a_5362_n240# vdd 0.90fF **FLOATING
C17265 divbuf_4/a_4882_n240# vdd 0.90fF **FLOATING
C17266 divbuf_4/a_4392_n240# vdd 0.90fF **FLOATING
C17267 divbuf_4/a_3912_n240# vdd 0.90fF **FLOATING
C17268 divbuf_4/a_3422_n240# vdd 0.90fF **FLOATING
C17269 divbuf_4/a_2322_n240# vdd 0.91fF **FLOATING
C17270 divbuf_4/a_1842_n240# vdd 0.91fF **FLOATING
C17271 divbuf_4/a_1352_n240# vdd 0.91fF **FLOATING
C17272 divbuf_4/a_41382_170# vdd 1.07fF **FLOATING
C17273 divbuf_4/a_40902_170# vdd 1.09fF **FLOATING
C17274 divbuf_4/a_40412_170# vdd 1.09fF **FLOATING
C17275 divbuf_4/a_39932_170# vdd 1.09fF **FLOATING
C17276 divbuf_4/a_39442_170# vdd 1.09fF **FLOATING
C17277 divbuf_4/a_38962_170# vdd 1.07fF **FLOATING
C17278 divbuf_4/a_38472_170# vdd 1.09fF **FLOATING
C17279 divbuf_4/a_37992_170# vdd 1.09fF **FLOATING
C17280 divbuf_4/a_37502_170# vdd 1.09fF **FLOATING
C17281 divbuf_4/a_37022_170# vdd 1.09fF **FLOATING
C17282 divbuf_4/a_36532_170# vdd 1.09fF **FLOATING
C17283 divbuf_4/a_36052_170# vdd 1.09fF **FLOATING
C17284 divbuf_4/a_35562_170# vdd 1.09fF **FLOATING
C17285 divbuf_4/a_35082_170# vdd 1.09fF **FLOATING
C17286 divbuf_4/a_34592_170# vdd 1.07fF **FLOATING
C17287 divbuf_4/a_34112_170# vdd 1.09fF **FLOATING
C17288 divbuf_4/a_33622_170# vdd 1.09fF **FLOATING
C17289 divbuf_4/a_33142_170# vdd 1.09fF **FLOATING
C17290 divbuf_4/a_32652_170# vdd 1.09fF **FLOATING
C17291 divbuf_4/a_32172_170# vdd 1.09fF **FLOATING
C17292 divbuf_4/a_31682_170# vdd 1.09fF **FLOATING
C17293 divbuf_4/a_31202_170# vdd 1.09fF **FLOATING
C17294 divbuf_4/a_30712_170# vdd 1.09fF **FLOATING
C17295 divbuf_4/a_30232_170# vdd 1.07fF **FLOATING
C17296 divbuf_4/a_29742_170# vdd 1.09fF **FLOATING
C17297 divbuf_4/a_29262_170# vdd 1.09fF **FLOATING
C17298 divbuf_4/a_28772_170# vdd 1.09fF **FLOATING
C17299 divbuf_4/a_28292_170# vdd 1.09fF **FLOATING
C17300 divbuf_4/a_27802_170# vdd 1.09fF **FLOATING
C17301 divbuf_4/a_27322_170# vdd 1.09fF **FLOATING
C17302 divbuf_4/a_26832_170# vdd 1.09fF **FLOATING
C17303 divbuf_4/a_26352_170# vdd 1.09fF **FLOATING
C17304 divbuf_4/a_25862_170# vdd 1.07fF **FLOATING
C17305 divbuf_4/a_25382_170# vdd 1.09fF **FLOATING
C17306 divbuf_4/a_24892_170# vdd 1.09fF **FLOATING
C17307 divbuf_4/a_24412_170# vdd 1.09fF **FLOATING
C17308 divbuf_4/a_23922_170# vdd 1.09fF **FLOATING
C17309 divbuf_4/a_23442_170# vdd 1.09fF **FLOATING
C17310 divbuf_4/a_22952_170# vdd 1.09fF **FLOATING
C17311 divbuf_4/a_22472_170# vdd 1.07fF **FLOATING
C17312 divbuf_4/a_21982_170# vdd 1.09fF **FLOATING
C17313 divbuf_4/a_21502_170# vdd 1.09fF **FLOATING
C17314 divbuf_4/a_21012_170# vdd 1.09fF **FLOATING
C17315 divbuf_4/a_20532_170# vdd 1.09fF **FLOATING
C17316 divbuf_4/a_20042_170# vdd 1.09fF **FLOATING
C17317 divbuf_4/a_19562_170# vdd 1.09fF **FLOATING
C17318 divbuf_4/a_19072_170# vdd 1.09fF **FLOATING
C17319 divbuf_4/a_18582_170# vdd 1.07fF **FLOATING
C17320 divbuf_4/a_18092_170# vdd 1.09fF **FLOATING
C17321 divbuf_4/a_17612_170# vdd 1.09fF **FLOATING
C17322 divbuf_4/a_17122_170# vdd 1.09fF **FLOATING
C17323 divbuf_4/a_16642_170# vdd 1.09fF **FLOATING
C17324 divbuf_4/a_16152_170# vdd 1.09fF **FLOATING
C17325 divbuf_4/a_15672_170# vdd 1.09fF **FLOATING
C17326 divbuf_4/a_15182_170# vdd 1.09fF **FLOATING
C17327 divbuf_4/a_14702_170# vdd 1.10fF **FLOATING
C17328 divbuf_4/a_14222_170# vdd 1.10fF **FLOATING
C17329 divbuf_4/a_13742_170# vdd 1.09fF **FLOATING
C17330 divbuf_4/a_13252_170# vdd 1.09fF **FLOATING
C17331 divbuf_4/a_12772_170# vdd 1.07fF **FLOATING
C17332 divbuf_4/a_12282_170# vdd 1.09fF **FLOATING
C17333 divbuf_4/a_11802_170# vdd 1.09fF **FLOATING
C17334 divbuf_4/a_11312_170# vdd 1.10fF **FLOATING
C17335 divbuf_4/a_10212_170# vdd 1.09fF **FLOATING
C17336 divbuf_4/a_9732_170# vdd 1.09fF **FLOATING
C17337 divbuf_4/a_9242_170# vdd 1.09fF **FLOATING
C17338 divbuf_4/a_8762_170# vdd 1.09fF **FLOATING
C17339 divbuf_4/a_8272_170# vdd 1.07fF **FLOATING
C17340 divbuf_4/a_7792_170# vdd 1.09fF **FLOATING
C17341 divbuf_4/a_7302_170# vdd 1.09fF **FLOATING
C17342 divbuf_4/a_6822_170# vdd 1.09fF **FLOATING
C17343 divbuf_4/a_6332_170# vdd 1.09fF **FLOATING
C17344 divbuf_4/a_5852_170# vdd 1.09fF **FLOATING
C17345 divbuf_4/a_5362_170# vdd 1.09fF **FLOATING
C17346 divbuf_4/a_4882_170# vdd 1.09fF **FLOATING
C17347 divbuf_4/a_4392_170# vdd 1.07fF **FLOATING
C17348 divbuf_4/a_3912_170# vdd 1.09fF **FLOATING
C17349 divbuf_4/a_3422_170# vdd 1.10fF **FLOATING
C17350 divbuf_4/a_2322_170# vdd 1.09fF **FLOATING
C17351 divbuf_4/a_1842_170# vdd 1.09fF **FLOATING
C17352 divbuf_4/a_1352_170# vdd 1.10fF **FLOATING
C17353 divbuf_4/a_492_n240# vdd 2.59fF **FLOATING
C17354 io_analog[9] vdd 64.84fF
C17355 divbuf_3/OUT5 vdd 16.40fF
C17356 divbuf_3/OUT4 vdd 100.06fF
C17357 divbuf_3/OUT3 vdd 27.01fF
C17358 divbuf_3/OUT2 vdd 8.71fF
C17359 divbuf_3/a_60990_n1540# vdd 1.57fF **FLOATING
C17360 divbuf_3/a_60510_n1540# vdd 1.62fF **FLOATING
C17361 divbuf_3/a_60030_n1540# vdd 1.62fF **FLOATING
C17362 divbuf_3/a_59550_n1540# vdd 1.62fF **FLOATING
C17363 divbuf_3/a_59070_n1540# vdd 1.62fF **FLOATING
C17364 divbuf_3/a_58590_n1540# vdd 1.62fF **FLOATING
C17365 divbuf_3/a_58110_n1540# vdd 1.62fF **FLOATING
C17366 divbuf_3/a_57630_n1540# vdd 1.62fF **FLOATING
C17367 divbuf_3/a_57150_n1540# vdd 1.62fF **FLOATING
C17368 divbuf_3/a_56670_n1540# vdd 1.62fF **FLOATING
C17369 divbuf_3/a_56190_n1540# vdd 1.62fF **FLOATING
C17370 divbuf_3/a_55710_n1540# vdd 1.62fF **FLOATING
C17371 divbuf_3/a_55230_n1540# vdd 1.62fF **FLOATING
C17372 divbuf_3/a_54750_n1540# vdd 1.62fF **FLOATING
C17373 divbuf_3/a_54270_n1540# vdd 1.62fF **FLOATING
C17374 divbuf_3/a_53790_n1540# vdd 1.62fF **FLOATING
C17375 divbuf_3/a_53310_n1540# vdd 1.62fF **FLOATING
C17376 divbuf_3/a_52830_n1540# vdd 1.62fF **FLOATING
C17377 divbuf_3/a_52350_n1540# vdd 1.62fF **FLOATING
C17378 divbuf_3/a_51870_n1540# vdd 1.62fF **FLOATING
C17379 divbuf_3/a_51390_n1540# vdd 1.62fF **FLOATING
C17380 divbuf_3/a_50910_n1540# vdd 1.62fF **FLOATING
C17381 divbuf_3/a_50430_n1540# vdd 1.62fF **FLOATING
C17382 divbuf_3/a_49950_n1540# vdd 1.62fF **FLOATING
C17383 divbuf_3/a_49470_n1540# vdd 1.62fF **FLOATING
C17384 divbuf_3/a_48990_n1540# vdd 1.62fF **FLOATING
C17385 divbuf_3/a_48510_n1540# vdd 1.62fF **FLOATING
C17386 divbuf_3/a_48030_n1540# vdd 1.62fF **FLOATING
C17387 divbuf_3/a_47550_n1540# vdd 1.62fF **FLOATING
C17388 divbuf_3/a_47070_n1540# vdd 1.62fF **FLOATING
C17389 divbuf_3/a_46590_n1540# vdd 1.62fF **FLOATING
C17390 divbuf_3/a_46110_n1540# vdd 1.62fF **FLOATING
C17391 divbuf_3/a_45630_n1540# vdd 1.62fF **FLOATING
C17392 divbuf_3/a_45150_n1540# vdd 1.62fF **FLOATING
C17393 divbuf_3/a_44670_n1540# vdd 1.62fF **FLOATING
C17394 divbuf_3/a_44190_n1540# vdd 1.62fF **FLOATING
C17395 divbuf_3/a_43710_n1540# vdd 1.62fF **FLOATING
C17396 divbuf_3/a_43230_n1540# vdd 1.62fF **FLOATING
C17397 divbuf_3/a_42750_n1540# vdd 1.62fF **FLOATING
C17398 divbuf_3/a_42270_n1540# vdd 1.62fF **FLOATING
C17399 divbuf_3/a_41790_n1540# vdd 1.62fF **FLOATING
C17400 divbuf_3/a_41310_n1540# vdd 1.62fF **FLOATING
C17401 divbuf_3/a_40830_n1540# vdd 1.62fF **FLOATING
C17402 divbuf_3/a_40350_n1540# vdd 1.62fF **FLOATING
C17403 divbuf_3/a_39870_n1540# vdd 1.62fF **FLOATING
C17404 divbuf_3/a_39390_n1540# vdd 1.62fF **FLOATING
C17405 divbuf_3/a_38910_n1540# vdd 1.62fF **FLOATING
C17406 divbuf_3/a_38430_n1540# vdd 1.62fF **FLOATING
C17407 divbuf_3/a_37950_n1540# vdd 1.62fF **FLOATING
C17408 divbuf_3/a_37470_n1540# vdd 1.62fF **FLOATING
C17409 divbuf_3/a_36990_n1540# vdd 1.62fF **FLOATING
C17410 divbuf_3/a_36510_n1540# vdd 1.62fF **FLOATING
C17411 divbuf_3/a_36030_n1540# vdd 1.62fF **FLOATING
C17412 divbuf_3/a_35550_n1540# vdd 1.62fF **FLOATING
C17413 divbuf_3/a_35070_n1540# vdd 1.62fF **FLOATING
C17414 divbuf_3/a_34590_n1540# vdd 1.62fF **FLOATING
C17415 divbuf_3/a_34110_n1540# vdd 1.62fF **FLOATING
C17416 divbuf_3/a_33630_n1540# vdd 1.62fF **FLOATING
C17417 divbuf_3/a_33150_n1540# vdd 1.62fF **FLOATING
C17418 divbuf_3/a_32670_n1540# vdd 1.62fF **FLOATING
C17419 divbuf_3/a_32190_n1540# vdd 1.62fF **FLOATING
C17420 divbuf_3/a_31710_n1540# vdd 1.62fF **FLOATING
C17421 divbuf_3/a_31230_n1540# vdd 1.62fF **FLOATING
C17422 divbuf_3/a_30750_n1540# vdd 1.62fF **FLOATING
C17423 divbuf_3/a_30270_n1540# vdd 1.62fF **FLOATING
C17424 divbuf_3/a_29790_n1540# vdd 1.62fF **FLOATING
C17425 divbuf_3/a_29310_n1540# vdd 1.62fF **FLOATING
C17426 divbuf_3/a_28830_n1540# vdd 1.62fF **FLOATING
C17427 divbuf_3/a_28350_n1540# vdd 1.62fF **FLOATING
C17428 divbuf_3/a_27870_n1540# vdd 1.62fF **FLOATING
C17429 divbuf_3/a_27390_n1540# vdd 1.62fF **FLOATING
C17430 divbuf_3/a_26910_n1540# vdd 1.62fF **FLOATING
C17431 divbuf_3/a_26430_n1540# vdd 1.62fF **FLOATING
C17432 divbuf_3/a_25950_n1540# vdd 1.62fF **FLOATING
C17433 divbuf_3/a_25470_n1540# vdd 1.62fF **FLOATING
C17434 divbuf_3/a_24990_n1540# vdd 1.62fF **FLOATING
C17435 divbuf_3/a_24510_n1540# vdd 1.62fF **FLOATING
C17436 divbuf_3/a_24030_n1540# vdd 1.62fF **FLOATING
C17437 divbuf_3/a_23550_n1540# vdd 1.62fF **FLOATING
C17438 divbuf_3/a_23070_n1540# vdd 1.62fF **FLOATING
C17439 divbuf_3/a_22590_n1540# vdd 1.62fF **FLOATING
C17440 divbuf_3/a_22110_n1540# vdd 1.62fF **FLOATING
C17441 divbuf_3/a_21630_n1540# vdd 1.62fF **FLOATING
C17442 divbuf_3/a_21150_n1540# vdd 1.62fF **FLOATING
C17443 divbuf_3/a_20670_n1540# vdd 1.62fF **FLOATING
C17444 divbuf_3/a_20190_n1540# vdd 1.62fF **FLOATING
C17445 divbuf_3/a_19710_n1540# vdd 1.62fF **FLOATING
C17446 divbuf_3/a_19230_n1540# vdd 1.62fF **FLOATING
C17447 divbuf_3/a_18750_n1540# vdd 1.62fF **FLOATING
C17448 divbuf_3/a_18270_n1540# vdd 1.62fF **FLOATING
C17449 divbuf_3/a_17790_n1540# vdd 1.62fF **FLOATING
C17450 divbuf_3/a_17310_n1540# vdd 1.62fF **FLOATING
C17451 divbuf_3/a_16830_n1540# vdd 1.62fF **FLOATING
C17452 divbuf_3/a_16350_n1540# vdd 1.62fF **FLOATING
C17453 divbuf_3/a_15870_n1540# vdd 1.62fF **FLOATING
C17454 divbuf_3/a_15390_n1540# vdd 1.62fF **FLOATING
C17455 divbuf_3/a_14910_n1540# vdd 1.62fF **FLOATING
C17456 divbuf_3/a_14430_n1540# vdd 1.62fF **FLOATING
C17457 divbuf_3/a_13950_n1540# vdd 1.62fF **FLOATING
C17458 divbuf_3/a_13470_n1540# vdd 1.62fF **FLOATING
C17459 divbuf_3/a_12990_n1540# vdd 1.62fF **FLOATING
C17460 divbuf_3/a_12510_n1540# vdd 1.62fF **FLOATING
C17461 divbuf_3/a_12030_n1540# vdd 1.62fF **FLOATING
C17462 divbuf_3/a_11550_n1540# vdd 1.62fF **FLOATING
C17463 divbuf_3/a_11070_n1540# vdd 1.62fF **FLOATING
C17464 divbuf_3/a_10590_n1540# vdd 1.62fF **FLOATING
C17465 divbuf_3/a_10110_n1540# vdd 1.62fF **FLOATING
C17466 divbuf_3/a_9630_n1540# vdd 1.62fF **FLOATING
C17467 divbuf_3/a_9150_n1540# vdd 1.62fF **FLOATING
C17468 divbuf_3/a_8670_n1540# vdd 1.62fF **FLOATING
C17469 divbuf_3/a_8190_n1540# vdd 1.62fF **FLOATING
C17470 divbuf_3/a_7710_n1540# vdd 1.62fF **FLOATING
C17471 divbuf_3/a_7230_n1540# vdd 1.62fF **FLOATING
C17472 divbuf_3/a_6750_n1540# vdd 1.62fF **FLOATING
C17473 divbuf_3/a_6270_n1540# vdd 1.62fF **FLOATING
C17474 divbuf_3/a_5790_n1540# vdd 1.62fF **FLOATING
C17475 divbuf_3/a_5310_n1540# vdd 1.62fF **FLOATING
C17476 divbuf_3/a_4830_n1540# vdd 1.62fF **FLOATING
C17477 divbuf_3/a_4350_n1540# vdd 1.62fF **FLOATING
C17478 divbuf_3/a_3870_n1540# vdd 1.62fF **FLOATING
C17479 divbuf_3/a_3390_n1540# vdd 1.62fF **FLOATING
C17480 divbuf_3/a_2910_n1540# vdd 1.62fF **FLOATING
C17481 divbuf_3/a_2430_n1540# vdd 1.62fF **FLOATING
C17482 divbuf_3/a_1950_n1540# vdd 1.62fF **FLOATING
C17483 divbuf_3/a_1470_n1540# vdd 1.62fF **FLOATING
C17484 divbuf_3/a_990_n1540# vdd 1.62fF **FLOATING
C17485 divbuf_3/a_510_n1540# vdd 1.62fF **FLOATING
C17486 divbuf_3/a_60990_n840# vdd 1.06fF **FLOATING
C17487 divbuf_3/a_60510_n840# vdd 1.09fF **FLOATING
C17488 divbuf_3/a_60030_n840# vdd 1.09fF **FLOATING
C17489 divbuf_3/a_59550_n840# vdd 1.09fF **FLOATING
C17490 divbuf_3/a_59070_n840# vdd 1.09fF **FLOATING
C17491 divbuf_3/a_58590_n840# vdd 1.09fF **FLOATING
C17492 divbuf_3/a_58110_n840# vdd 1.09fF **FLOATING
C17493 divbuf_3/a_57630_n840# vdd 1.09fF **FLOATING
C17494 divbuf_3/a_57150_n840# vdd 1.09fF **FLOATING
C17495 divbuf_3/a_56670_n840# vdd 1.09fF **FLOATING
C17496 divbuf_3/a_56190_n840# vdd 1.09fF **FLOATING
C17497 divbuf_3/a_55710_n840# vdd 1.09fF **FLOATING
C17498 divbuf_3/a_55230_n840# vdd 1.09fF **FLOATING
C17499 divbuf_3/a_54750_n840# vdd 1.09fF **FLOATING
C17500 divbuf_3/a_54270_n840# vdd 1.09fF **FLOATING
C17501 divbuf_3/a_53790_n840# vdd 1.09fF **FLOATING
C17502 divbuf_3/a_53310_n840# vdd 1.09fF **FLOATING
C17503 divbuf_3/a_52830_n840# vdd 1.09fF **FLOATING
C17504 divbuf_3/a_52350_n840# vdd 1.09fF **FLOATING
C17505 divbuf_3/a_51870_n840# vdd 1.09fF **FLOATING
C17506 divbuf_3/a_51390_n840# vdd 1.09fF **FLOATING
C17507 divbuf_3/a_50910_n840# vdd 1.09fF **FLOATING
C17508 divbuf_3/a_50430_n840# vdd 1.09fF **FLOATING
C17509 divbuf_3/a_49950_n840# vdd 1.09fF **FLOATING
C17510 divbuf_3/a_49470_n840# vdd 1.09fF **FLOATING
C17511 divbuf_3/a_48990_n840# vdd 1.09fF **FLOATING
C17512 divbuf_3/a_48510_n840# vdd 1.09fF **FLOATING
C17513 divbuf_3/a_48030_n840# vdd 1.09fF **FLOATING
C17514 divbuf_3/a_47550_n840# vdd 1.09fF **FLOATING
C17515 divbuf_3/a_47070_n840# vdd 1.09fF **FLOATING
C17516 divbuf_3/a_46590_n840# vdd 1.09fF **FLOATING
C17517 divbuf_3/a_46110_n840# vdd 1.09fF **FLOATING
C17518 divbuf_3/a_45630_n840# vdd 1.09fF **FLOATING
C17519 divbuf_3/a_45150_n840# vdd 1.09fF **FLOATING
C17520 divbuf_3/a_44670_n840# vdd 1.09fF **FLOATING
C17521 divbuf_3/a_44190_n840# vdd 1.09fF **FLOATING
C17522 divbuf_3/a_43710_n840# vdd 1.09fF **FLOATING
C17523 divbuf_3/a_43230_n840# vdd 1.09fF **FLOATING
C17524 divbuf_3/a_42750_n840# vdd 1.08fF **FLOATING
C17525 divbuf_3/a_42270_n840# vdd 1.08fF **FLOATING
C17526 divbuf_3/a_41790_n840# vdd 1.10fF **FLOATING
C17527 divbuf_3/a_41310_n840# vdd 1.09fF **FLOATING
C17528 divbuf_3/a_40830_n840# vdd 1.09fF **FLOATING
C17529 divbuf_3/a_40350_n840# vdd 1.09fF **FLOATING
C17530 divbuf_3/a_39870_n840# vdd 1.09fF **FLOATING
C17531 divbuf_3/a_39390_n840# vdd 1.09fF **FLOATING
C17532 divbuf_3/a_38910_n840# vdd 1.09fF **FLOATING
C17533 divbuf_3/a_38430_n840# vdd 1.09fF **FLOATING
C17534 divbuf_3/a_37950_n840# vdd 1.09fF **FLOATING
C17535 divbuf_3/a_37470_n840# vdd 1.09fF **FLOATING
C17536 divbuf_3/a_36990_n840# vdd 1.09fF **FLOATING
C17537 divbuf_3/a_36510_n840# vdd 1.09fF **FLOATING
C17538 divbuf_3/a_36030_n840# vdd 1.09fF **FLOATING
C17539 divbuf_3/a_35550_n840# vdd 1.09fF **FLOATING
C17540 divbuf_3/a_35070_n840# vdd 1.09fF **FLOATING
C17541 divbuf_3/a_34590_n840# vdd 1.09fF **FLOATING
C17542 divbuf_3/a_34110_n840# vdd 1.09fF **FLOATING
C17543 divbuf_3/a_33630_n840# vdd 1.09fF **FLOATING
C17544 divbuf_3/a_33150_n840# vdd 1.09fF **FLOATING
C17545 divbuf_3/a_32670_n840# vdd 1.09fF **FLOATING
C17546 divbuf_3/a_32190_n840# vdd 1.09fF **FLOATING
C17547 divbuf_3/a_31710_n840# vdd 1.11fF **FLOATING
C17548 divbuf_3/a_31230_n840# vdd 1.13fF **FLOATING
C17549 divbuf_3/a_30750_n840# vdd 1.09fF **FLOATING
C17550 divbuf_3/a_30270_n840# vdd 1.09fF **FLOATING
C17551 divbuf_3/a_29790_n840# vdd 1.09fF **FLOATING
C17552 divbuf_3/a_29310_n840# vdd 1.09fF **FLOATING
C17553 divbuf_3/a_28830_n840# vdd 1.09fF **FLOATING
C17554 divbuf_3/a_28350_n840# vdd 1.09fF **FLOATING
C17555 divbuf_3/a_27870_n840# vdd 1.08fF **FLOATING
C17556 divbuf_3/a_27390_n840# vdd 1.11fF **FLOATING
C17557 divbuf_3/a_26910_n840# vdd 1.10fF **FLOATING
C17558 divbuf_3/a_26430_n840# vdd 1.10fF **FLOATING
C17559 divbuf_3/a_25950_n840# vdd 1.10fF **FLOATING
C17560 divbuf_3/a_25470_n840# vdd 1.10fF **FLOATING
C17561 divbuf_3/a_24990_n840# vdd 1.10fF **FLOATING
C17562 divbuf_3/a_24510_n840# vdd 1.10fF **FLOATING
C17563 divbuf_3/a_24030_n840# vdd 1.09fF **FLOATING
C17564 divbuf_3/a_23550_n840# vdd 1.11fF **FLOATING
C17565 divbuf_3/a_23070_n840# vdd 1.10fF **FLOATING
C17566 divbuf_3/a_22590_n840# vdd 1.10fF **FLOATING
C17567 divbuf_3/a_22110_n840# vdd 1.10fF **FLOATING
C17568 divbuf_3/a_21630_n840# vdd 1.10fF **FLOATING
C17569 divbuf_3/a_21150_n840# vdd 1.10fF **FLOATING
C17570 divbuf_3/a_20670_n840# vdd 1.10fF **FLOATING
C17571 divbuf_3/a_20190_n840# vdd 1.09fF **FLOATING
C17572 divbuf_3/a_19710_n840# vdd 1.09fF **FLOATING
C17573 divbuf_3/a_19230_n840# vdd 1.09fF **FLOATING
C17574 divbuf_3/a_18750_n840# vdd 1.09fF **FLOATING
C17575 divbuf_3/a_18270_n840# vdd 1.08fF **FLOATING
C17576 divbuf_3/a_17790_n840# vdd 1.08fF **FLOATING
C17577 divbuf_3/a_17310_n840# vdd 1.07fF **FLOATING
C17578 divbuf_3/a_16830_n840# vdd 1.07fF **FLOATING
C17579 divbuf_3/a_16350_n840# vdd 1.07fF **FLOATING
C17580 divbuf_3/a_15870_n840# vdd 1.07fF **FLOATING
C17581 divbuf_3/a_15390_n840# vdd 1.08fF **FLOATING
C17582 divbuf_3/a_14910_n840# vdd 1.07fF **FLOATING
C17583 divbuf_3/a_14430_n840# vdd 1.07fF **FLOATING
C17584 divbuf_3/a_13950_n840# vdd 1.07fF **FLOATING
C17585 divbuf_3/a_13470_n840# vdd 1.07fF **FLOATING
C17586 divbuf_3/a_12990_n840# vdd 1.10fF **FLOATING
C17587 divbuf_3/a_12510_n840# vdd 1.08fF **FLOATING
C17588 divbuf_3/a_12030_n840# vdd 1.07fF **FLOATING
C17589 divbuf_3/a_11550_n840# vdd 1.07fF **FLOATING
C17590 divbuf_3/a_11070_n840# vdd 1.08fF **FLOATING
C17591 divbuf_3/a_10590_n840# vdd 1.10fF **FLOATING
C17592 divbuf_3/a_10110_n840# vdd 1.10fF **FLOATING
C17593 divbuf_3/a_9630_n840# vdd 1.10fF **FLOATING
C17594 divbuf_3/a_9150_n840# vdd 1.10fF **FLOATING
C17595 divbuf_3/a_8670_n840# vdd 1.10fF **FLOATING
C17596 divbuf_3/a_8190_n840# vdd 1.12fF **FLOATING
C17597 divbuf_3/a_7710_n840# vdd 1.10fF **FLOATING
C17598 divbuf_3/a_7230_n840# vdd 1.09fF **FLOATING
C17599 divbuf_3/a_6750_n840# vdd 1.09fF **FLOATING
C17600 divbuf_3/a_6270_n840# vdd 1.09fF **FLOATING
C17601 divbuf_3/a_5790_n840# vdd 1.09fF **FLOATING
C17602 divbuf_3/a_5310_n840# vdd 1.09fF **FLOATING
C17603 divbuf_3/a_4830_n840# vdd 1.09fF **FLOATING
C17604 divbuf_3/a_4350_n840# vdd 1.09fF **FLOATING
C17605 divbuf_3/a_3870_n840# vdd 1.09fF **FLOATING
C17606 divbuf_3/a_3390_n840# vdd 1.09fF **FLOATING
C17607 divbuf_3/a_2910_n840# vdd 1.10fF **FLOATING
C17608 divbuf_3/a_2430_n840# vdd 1.10fF **FLOATING
C17609 divbuf_3/a_1950_n840# vdd 1.10fF **FLOATING
C17610 divbuf_3/a_1470_n840# vdd 1.10fF **FLOATING
C17611 divbuf_3/a_990_n840# vdd 1.08fF **FLOATING
C17612 divbuf_3/a_510_n840# vdd 1.07fF **FLOATING
C17613 divbuf_3/a_60480_n1600# vdd 1.48fF **FLOATING
C17614 divbuf_3/a_60000_n1600# vdd 1.48fF **FLOATING
C17615 divbuf_3/a_59520_n1600# vdd 1.48fF **FLOATING
C17616 divbuf_3/a_59040_n1600# vdd 1.48fF **FLOATING
C17617 divbuf_3/a_58560_n1600# vdd 1.48fF **FLOATING
C17618 divbuf_3/a_58080_n1600# vdd 1.48fF **FLOATING
C17619 divbuf_3/a_57600_n1600# vdd 1.48fF **FLOATING
C17620 divbuf_3/a_57120_n1600# vdd 1.48fF **FLOATING
C17621 divbuf_3/a_56640_n1600# vdd 1.48fF **FLOATING
C17622 divbuf_3/a_56160_n1600# vdd 1.48fF **FLOATING
C17623 divbuf_3/a_55680_n1600# vdd 1.48fF **FLOATING
C17624 divbuf_3/a_55200_n1600# vdd 1.48fF **FLOATING
C17625 divbuf_3/a_54720_n1600# vdd 1.48fF **FLOATING
C17626 divbuf_3/a_54240_n1600# vdd 1.48fF **FLOATING
C17627 divbuf_3/a_53760_n1600# vdd 1.48fF **FLOATING
C17628 divbuf_3/a_53280_n1600# vdd 1.48fF **FLOATING
C17629 divbuf_3/a_52800_n1600# vdd 1.48fF **FLOATING
C17630 divbuf_3/a_52320_n1600# vdd 1.48fF **FLOATING
C17631 divbuf_3/a_51840_n1600# vdd 1.48fF **FLOATING
C17632 divbuf_3/a_51360_n1600# vdd 1.48fF **FLOATING
C17633 divbuf_3/a_50880_n1600# vdd 1.48fF **FLOATING
C17634 divbuf_3/a_50400_n1600# vdd 1.48fF **FLOATING
C17635 divbuf_3/a_49920_n1600# vdd 1.48fF **FLOATING
C17636 divbuf_3/a_49440_n1600# vdd 1.48fF **FLOATING
C17637 divbuf_3/a_48960_n1600# vdd 1.48fF **FLOATING
C17638 divbuf_3/a_48480_n1600# vdd 1.48fF **FLOATING
C17639 divbuf_3/a_48000_n1600# vdd 1.48fF **FLOATING
C17640 divbuf_3/a_47520_n1600# vdd 1.48fF **FLOATING
C17641 divbuf_3/a_47040_n1600# vdd 1.48fF **FLOATING
C17642 divbuf_3/a_46560_n1600# vdd 1.48fF **FLOATING
C17643 divbuf_3/a_46080_n1600# vdd 1.48fF **FLOATING
C17644 divbuf_3/a_45600_n1600# vdd 1.48fF **FLOATING
C17645 divbuf_3/a_45120_n1600# vdd 1.48fF **FLOATING
C17646 divbuf_3/a_44640_n1600# vdd 1.48fF **FLOATING
C17647 divbuf_3/a_44160_n1600# vdd 1.48fF **FLOATING
C17648 divbuf_3/a_43680_n1600# vdd 1.48fF **FLOATING
C17649 divbuf_3/a_43200_n1600# vdd 1.48fF **FLOATING
C17650 divbuf_3/a_42720_n1600# vdd 1.48fF **FLOATING
C17651 divbuf_3/a_42240_n1600# vdd 1.48fF **FLOATING
C17652 divbuf_3/a_41760_n1600# vdd 1.48fF **FLOATING
C17653 divbuf_3/a_41280_n1600# vdd 1.48fF **FLOATING
C17654 divbuf_3/a_40800_n1600# vdd 1.48fF **FLOATING
C17655 divbuf_3/a_40320_n1600# vdd 1.48fF **FLOATING
C17656 divbuf_3/a_39840_n1600# vdd 1.48fF **FLOATING
C17657 divbuf_3/a_39360_n1600# vdd 1.48fF **FLOATING
C17658 divbuf_3/a_38880_n1600# vdd 1.48fF **FLOATING
C17659 divbuf_3/a_38400_n1600# vdd 1.48fF **FLOATING
C17660 divbuf_3/a_37920_n1600# vdd 1.48fF **FLOATING
C17661 divbuf_3/a_37440_n1600# vdd 1.48fF **FLOATING
C17662 divbuf_3/a_36960_n1600# vdd 1.48fF **FLOATING
C17663 divbuf_3/a_36480_n1600# vdd 1.48fF **FLOATING
C17664 divbuf_3/a_36000_n1600# vdd 1.48fF **FLOATING
C17665 divbuf_3/a_35520_n1600# vdd 1.48fF **FLOATING
C17666 divbuf_3/a_35040_n1600# vdd 1.48fF **FLOATING
C17667 divbuf_3/a_34560_n1600# vdd 1.48fF **FLOATING
C17668 divbuf_3/a_34080_n1600# vdd 1.48fF **FLOATING
C17669 divbuf_3/a_33600_n1600# vdd 1.48fF **FLOATING
C17670 divbuf_3/a_33120_n1600# vdd 1.48fF **FLOATING
C17671 divbuf_3/a_32640_n1600# vdd 1.48fF **FLOATING
C17672 divbuf_3/a_32160_n1600# vdd 1.48fF **FLOATING
C17673 divbuf_3/a_31680_n1600# vdd 1.48fF **FLOATING
C17674 divbuf_3/a_31200_n1600# vdd 1.48fF **FLOATING
C17675 divbuf_3/a_30720_n1600# vdd 1.48fF **FLOATING
C17676 divbuf_3/a_30240_n1600# vdd 1.48fF **FLOATING
C17677 divbuf_3/a_29760_n1600# vdd 1.48fF **FLOATING
C17678 divbuf_3/a_29280_n1600# vdd 1.48fF **FLOATING
C17679 divbuf_3/a_28800_n1600# vdd 1.48fF **FLOATING
C17680 divbuf_3/a_28320_n1600# vdd 1.48fF **FLOATING
C17681 divbuf_3/a_27840_n1600# vdd 1.48fF **FLOATING
C17682 divbuf_3/a_27360_n1600# vdd 1.48fF **FLOATING
C17683 divbuf_3/a_26880_n1600# vdd 1.48fF **FLOATING
C17684 divbuf_3/a_26400_n1600# vdd 1.48fF **FLOATING
C17685 divbuf_3/a_25920_n1600# vdd 1.48fF **FLOATING
C17686 divbuf_3/a_25440_n1600# vdd 1.48fF **FLOATING
C17687 divbuf_3/a_24960_n1600# vdd 1.48fF **FLOATING
C17688 divbuf_3/a_24480_n1600# vdd 1.48fF **FLOATING
C17689 divbuf_3/a_24000_n1600# vdd 1.48fF **FLOATING
C17690 divbuf_3/a_23520_n1600# vdd 1.48fF **FLOATING
C17691 divbuf_3/a_23040_n1600# vdd 1.48fF **FLOATING
C17692 divbuf_3/a_22560_n1600# vdd 1.48fF **FLOATING
C17693 divbuf_3/a_22080_n1600# vdd 1.48fF **FLOATING
C17694 divbuf_3/a_21600_n1600# vdd 1.48fF **FLOATING
C17695 divbuf_3/a_21120_n1600# vdd 1.48fF **FLOATING
C17696 divbuf_3/a_20640_n1600# vdd 1.48fF **FLOATING
C17697 divbuf_3/a_20160_n1600# vdd 1.48fF **FLOATING
C17698 divbuf_3/a_19680_n1600# vdd 1.48fF **FLOATING
C17699 divbuf_3/a_19200_n1600# vdd 1.48fF **FLOATING
C17700 divbuf_3/a_18720_n1600# vdd 1.48fF **FLOATING
C17701 divbuf_3/a_18240_n1600# vdd 1.48fF **FLOATING
C17702 divbuf_3/a_17760_n1600# vdd 1.48fF **FLOATING
C17703 divbuf_3/a_17280_n1600# vdd 1.48fF **FLOATING
C17704 divbuf_3/a_16800_n1600# vdd 1.48fF **FLOATING
C17705 divbuf_3/a_16320_n1600# vdd 1.48fF **FLOATING
C17706 divbuf_3/a_15840_n1600# vdd 1.48fF **FLOATING
C17707 divbuf_3/a_15360_n1600# vdd 1.48fF **FLOATING
C17708 divbuf_3/a_14880_n1600# vdd 1.48fF **FLOATING
C17709 divbuf_3/a_14400_n1600# vdd 1.48fF **FLOATING
C17710 divbuf_3/a_13920_n1600# vdd 1.48fF **FLOATING
C17711 divbuf_3/a_13440_n1600# vdd 1.48fF **FLOATING
C17712 divbuf_3/a_12960_n1600# vdd 1.48fF **FLOATING
C17713 divbuf_3/a_12480_n1600# vdd 1.48fF **FLOATING
C17714 divbuf_3/a_12000_n1600# vdd 1.48fF **FLOATING
C17715 divbuf_3/a_11520_n1600# vdd 1.48fF **FLOATING
C17716 divbuf_3/a_11040_n1600# vdd 1.48fF **FLOATING
C17717 divbuf_3/a_10560_n1600# vdd 1.48fF **FLOATING
C17718 divbuf_3/a_10080_n1600# vdd 1.48fF **FLOATING
C17719 divbuf_3/a_9600_n1600# vdd 1.48fF **FLOATING
C17720 divbuf_3/a_9120_n1600# vdd 1.48fF **FLOATING
C17721 divbuf_3/a_8640_n1600# vdd 1.48fF **FLOATING
C17722 divbuf_3/a_8160_n1600# vdd 1.48fF **FLOATING
C17723 divbuf_3/a_7680_n1600# vdd 1.48fF **FLOATING
C17724 divbuf_3/a_7200_n1600# vdd 1.48fF **FLOATING
C17725 divbuf_3/a_6720_n1600# vdd 1.48fF **FLOATING
C17726 divbuf_3/a_6240_n1600# vdd 1.48fF **FLOATING
C17727 divbuf_3/a_5760_n1600# vdd 1.48fF **FLOATING
C17728 divbuf_3/a_5280_n1600# vdd 1.48fF **FLOATING
C17729 divbuf_3/a_4800_n1600# vdd 1.48fF **FLOATING
C17730 divbuf_3/a_4320_n1600# vdd 1.48fF **FLOATING
C17731 divbuf_3/a_3840_n1600# vdd 1.48fF **FLOATING
C17732 divbuf_3/a_3360_n1600# vdd 1.48fF **FLOATING
C17733 divbuf_3/a_2880_n1600# vdd 1.48fF **FLOATING
C17734 divbuf_3/a_2400_n1600# vdd 1.48fF **FLOATING
C17735 divbuf_3/a_1920_n1600# vdd 1.48fF **FLOATING
C17736 divbuf_3/a_1440_n1600# vdd 1.48fF **FLOATING
C17737 divbuf_3/a_960_n1600# vdd 1.48fF **FLOATING
C17738 divbuf_3/a_480_n1600# vdd 1.48fF **FLOATING
C17739 divbuf_3/a_0_n1600# vdd 1.48fF **FLOATING
C17740 divbuf_3/a_41382_n240# vdd 0.90fF **FLOATING
C17741 divbuf_3/a_40902_n240# vdd 0.90fF **FLOATING
C17742 divbuf_3/a_40412_n240# vdd 0.90fF **FLOATING
C17743 divbuf_3/a_39932_n240# vdd 0.90fF **FLOATING
C17744 divbuf_3/a_39442_n240# vdd 0.90fF **FLOATING
C17745 divbuf_3/a_38962_n240# vdd 0.91fF **FLOATING
C17746 divbuf_3/a_38472_n240# vdd 0.90fF **FLOATING
C17747 divbuf_3/a_37992_n240# vdd 0.90fF **FLOATING
C17748 divbuf_3/a_37502_n240# vdd 0.90fF **FLOATING
C17749 divbuf_3/a_37022_n240# vdd 0.90fF **FLOATING
C17750 divbuf_3/a_36532_n240# vdd 0.90fF **FLOATING
C17751 divbuf_3/a_36052_n240# vdd 0.90fF **FLOATING
C17752 divbuf_3/a_35562_n240# vdd 0.90fF **FLOATING
C17753 divbuf_3/a_35082_n240# vdd 0.91fF **FLOATING
C17754 divbuf_3/a_34592_n240# vdd 0.90fF **FLOATING
C17755 divbuf_3/a_34112_n240# vdd 0.90fF **FLOATING
C17756 divbuf_3/a_33622_n240# vdd 0.90fF **FLOATING
C17757 divbuf_3/a_33142_n240# vdd 0.90fF **FLOATING
C17758 divbuf_3/a_32652_n240# vdd 0.90fF **FLOATING
C17759 divbuf_3/a_32172_n240# vdd 0.90fF **FLOATING
C17760 divbuf_3/a_31682_n240# vdd 0.89fF **FLOATING
C17761 divbuf_3/a_31202_n240# vdd 0.92fF **FLOATING
C17762 divbuf_3/a_30712_n240# vdd 0.90fF **FLOATING
C17763 divbuf_3/a_30232_n240# vdd 0.90fF **FLOATING
C17764 divbuf_3/a_29742_n240# vdd 0.90fF **FLOATING
C17765 divbuf_3/a_29262_n240# vdd 0.90fF **FLOATING
C17766 divbuf_3/a_28772_n240# vdd 0.90fF **FLOATING
C17767 divbuf_3/a_28292_n240# vdd 0.90fF **FLOATING
C17768 divbuf_3/a_27802_n240# vdd 0.89fF **FLOATING
C17769 divbuf_3/a_27322_n240# vdd 0.95fF **FLOATING
C17770 divbuf_3/a_26832_n240# vdd 0.91fF **FLOATING
C17771 divbuf_3/a_26352_n240# vdd 0.91fF **FLOATING
C17772 divbuf_3/a_25862_n240# vdd 0.91fF **FLOATING
C17773 divbuf_3/a_25382_n240# vdd 0.91fF **FLOATING
C17774 divbuf_3/a_24892_n240# vdd 0.91fF **FLOATING
C17775 divbuf_3/a_24412_n240# vdd 0.91fF **FLOATING
C17776 divbuf_3/a_23922_n240# vdd 0.92fF **FLOATING
C17777 divbuf_3/a_23442_n240# vdd 0.94fF **FLOATING
C17778 divbuf_3/a_22952_n240# vdd 0.91fF **FLOATING
C17779 divbuf_3/a_22472_n240# vdd 0.91fF **FLOATING
C17780 divbuf_3/a_21982_n240# vdd 0.91fF **FLOATING
C17781 divbuf_3/a_21502_n240# vdd 0.91fF **FLOATING
C17782 divbuf_3/a_21012_n240# vdd 0.91fF **FLOATING
C17783 divbuf_3/a_20532_n240# vdd 0.91fF **FLOATING
C17784 divbuf_3/a_20042_n240# vdd 0.90fF **FLOATING
C17785 divbuf_3/a_19562_n240# vdd 0.90fF **FLOATING
C17786 divbuf_3/a_19072_n240# vdd 0.90fF **FLOATING
C17787 divbuf_3/a_18582_n240# vdd 0.89fF **FLOATING
C17788 divbuf_3/a_18092_n240# vdd 0.89fF **FLOATING
C17789 divbuf_3/a_17612_n240# vdd 0.89fF **FLOATING
C17790 divbuf_3/a_17122_n240# vdd 0.88fF **FLOATING
C17791 divbuf_3/a_16642_n240# vdd 0.88fF **FLOATING
C17792 divbuf_3/a_16152_n240# vdd 0.88fF **FLOATING
C17793 divbuf_3/a_15672_n240# vdd 0.90fF **FLOATING
C17794 divbuf_3/a_15182_n240# vdd 0.88fF **FLOATING
C17795 divbuf_3/a_14702_n240# vdd 0.88fF **FLOATING
C17796 divbuf_3/a_14222_n240# vdd 0.88fF **FLOATING
C17797 divbuf_3/a_13742_n240# vdd 0.88fF **FLOATING
C17798 divbuf_3/a_13252_n240# vdd 0.88fF **FLOATING
C17799 divbuf_3/a_12772_n240# vdd 0.88fF **FLOATING
C17800 divbuf_3/a_12282_n240# vdd 0.88fF **FLOATING
C17801 divbuf_3/a_11802_n240# vdd 0.88fF **FLOATING
C17802 divbuf_3/a_11312_n240# vdd 0.89fF **FLOATING
C17803 divbuf_3/a_10212_n240# vdd 0.91fF **FLOATING
C17804 divbuf_3/a_9732_n240# vdd 0.91fF **FLOATING
C17805 divbuf_3/a_9242_n240# vdd 0.91fF **FLOATING
C17806 divbuf_3/a_8762_n240# vdd 0.91fF **FLOATING
C17807 divbuf_3/a_8272_n240# vdd 0.91fF **FLOATING
C17808 divbuf_3/a_7792_n240# vdd 0.92fF **FLOATING
C17809 divbuf_3/a_7302_n240# vdd 0.90fF **FLOATING
C17810 divbuf_3/a_6822_n240# vdd 0.90fF **FLOATING
C17811 divbuf_3/a_6332_n240# vdd 0.90fF **FLOATING
C17812 divbuf_3/a_5852_n240# vdd 0.90fF **FLOATING
C17813 divbuf_3/a_5362_n240# vdd 0.90fF **FLOATING
C17814 divbuf_3/a_4882_n240# vdd 0.90fF **FLOATING
C17815 divbuf_3/a_4392_n240# vdd 0.90fF **FLOATING
C17816 divbuf_3/a_3912_n240# vdd 0.90fF **FLOATING
C17817 divbuf_3/a_3422_n240# vdd 0.90fF **FLOATING
C17818 divbuf_3/a_2322_n240# vdd 0.91fF **FLOATING
C17819 divbuf_3/a_1842_n240# vdd 0.91fF **FLOATING
C17820 divbuf_3/a_1352_n240# vdd 0.91fF **FLOATING
C17821 divbuf_3/a_41382_170# vdd 1.07fF **FLOATING
C17822 divbuf_3/a_40902_170# vdd 1.09fF **FLOATING
C17823 divbuf_3/a_40412_170# vdd 1.09fF **FLOATING
C17824 divbuf_3/a_39932_170# vdd 1.09fF **FLOATING
C17825 divbuf_3/a_39442_170# vdd 1.09fF **FLOATING
C17826 divbuf_3/a_38962_170# vdd 1.07fF **FLOATING
C17827 divbuf_3/a_38472_170# vdd 1.09fF **FLOATING
C17828 divbuf_3/a_37992_170# vdd 1.09fF **FLOATING
C17829 divbuf_3/a_37502_170# vdd 1.09fF **FLOATING
C17830 divbuf_3/a_37022_170# vdd 1.09fF **FLOATING
C17831 divbuf_3/a_36532_170# vdd 1.09fF **FLOATING
C17832 divbuf_3/a_36052_170# vdd 1.09fF **FLOATING
C17833 divbuf_3/a_35562_170# vdd 1.09fF **FLOATING
C17834 divbuf_3/a_35082_170# vdd 1.09fF **FLOATING
C17835 divbuf_3/a_34592_170# vdd 1.07fF **FLOATING
C17836 divbuf_3/a_34112_170# vdd 1.09fF **FLOATING
C17837 divbuf_3/a_33622_170# vdd 1.09fF **FLOATING
C17838 divbuf_3/a_33142_170# vdd 1.09fF **FLOATING
C17839 divbuf_3/a_32652_170# vdd 1.09fF **FLOATING
C17840 divbuf_3/a_32172_170# vdd 1.09fF **FLOATING
C17841 divbuf_3/a_31682_170# vdd 1.09fF **FLOATING
C17842 divbuf_3/a_31202_170# vdd 1.09fF **FLOATING
C17843 divbuf_3/a_30712_170# vdd 1.09fF **FLOATING
C17844 divbuf_3/a_30232_170# vdd 1.07fF **FLOATING
C17845 divbuf_3/a_29742_170# vdd 1.09fF **FLOATING
C17846 divbuf_3/a_29262_170# vdd 1.09fF **FLOATING
C17847 divbuf_3/a_28772_170# vdd 1.09fF **FLOATING
C17848 divbuf_3/a_28292_170# vdd 1.09fF **FLOATING
C17849 divbuf_3/a_27802_170# vdd 1.09fF **FLOATING
C17850 divbuf_3/a_27322_170# vdd 1.09fF **FLOATING
C17851 divbuf_3/a_26832_170# vdd 1.09fF **FLOATING
C17852 divbuf_3/a_26352_170# vdd 1.09fF **FLOATING
C17853 divbuf_3/a_25862_170# vdd 1.07fF **FLOATING
C17854 divbuf_3/a_25382_170# vdd 1.09fF **FLOATING
C17855 divbuf_3/a_24892_170# vdd 1.09fF **FLOATING
C17856 divbuf_3/a_24412_170# vdd 1.09fF **FLOATING
C17857 divbuf_3/a_23922_170# vdd 1.09fF **FLOATING
C17858 divbuf_3/a_23442_170# vdd 1.09fF **FLOATING
C17859 divbuf_3/a_22952_170# vdd 1.09fF **FLOATING
C17860 divbuf_3/a_22472_170# vdd 1.07fF **FLOATING
C17861 divbuf_3/a_21982_170# vdd 1.09fF **FLOATING
C17862 divbuf_3/a_21502_170# vdd 1.09fF **FLOATING
C17863 divbuf_3/a_21012_170# vdd 1.09fF **FLOATING
C17864 divbuf_3/a_20532_170# vdd 1.09fF **FLOATING
C17865 divbuf_3/a_20042_170# vdd 1.09fF **FLOATING
C17866 divbuf_3/a_19562_170# vdd 1.09fF **FLOATING
C17867 divbuf_3/a_19072_170# vdd 1.09fF **FLOATING
C17868 divbuf_3/a_18582_170# vdd 1.07fF **FLOATING
C17869 divbuf_3/a_18092_170# vdd 1.09fF **FLOATING
C17870 divbuf_3/a_17612_170# vdd 1.09fF **FLOATING
C17871 divbuf_3/a_17122_170# vdd 1.09fF **FLOATING
C17872 divbuf_3/a_16642_170# vdd 1.09fF **FLOATING
C17873 divbuf_3/a_16152_170# vdd 1.09fF **FLOATING
C17874 divbuf_3/a_15672_170# vdd 1.09fF **FLOATING
C17875 divbuf_3/a_15182_170# vdd 1.09fF **FLOATING
C17876 divbuf_3/a_14702_170# vdd 1.10fF **FLOATING
C17877 divbuf_3/a_14222_170# vdd 1.10fF **FLOATING
C17878 divbuf_3/a_13742_170# vdd 1.09fF **FLOATING
C17879 divbuf_3/a_13252_170# vdd 1.09fF **FLOATING
C17880 divbuf_3/a_12772_170# vdd 1.07fF **FLOATING
C17881 divbuf_3/a_12282_170# vdd 1.09fF **FLOATING
C17882 divbuf_3/a_11802_170# vdd 1.09fF **FLOATING
C17883 divbuf_3/a_11312_170# vdd 1.10fF **FLOATING
C17884 divbuf_3/a_10212_170# vdd 1.09fF **FLOATING
C17885 divbuf_3/a_9732_170# vdd 1.09fF **FLOATING
C17886 divbuf_3/a_9242_170# vdd 1.09fF **FLOATING
C17887 divbuf_3/a_8762_170# vdd 1.09fF **FLOATING
C17888 divbuf_3/a_8272_170# vdd 1.07fF **FLOATING
C17889 divbuf_3/a_7792_170# vdd 1.09fF **FLOATING
C17890 divbuf_3/a_7302_170# vdd 1.09fF **FLOATING
C17891 divbuf_3/a_6822_170# vdd 1.09fF **FLOATING
C17892 divbuf_3/a_6332_170# vdd 1.09fF **FLOATING
C17893 divbuf_3/a_5852_170# vdd 1.09fF **FLOATING
C17894 divbuf_3/a_5362_170# vdd 1.09fF **FLOATING
C17895 divbuf_3/a_4882_170# vdd 1.09fF **FLOATING
C17896 divbuf_3/a_4392_170# vdd 1.07fF **FLOATING
C17897 divbuf_3/a_3912_170# vdd 1.09fF **FLOATING
C17898 divbuf_3/a_3422_170# vdd 1.10fF **FLOATING
C17899 divbuf_3/a_2322_170# vdd 1.09fF **FLOATING
C17900 divbuf_3/a_1842_170# vdd 1.09fF **FLOATING
C17901 divbuf_3/a_1352_170# vdd 1.10fF **FLOATING
C17902 divbuf_3/a_492_n240# vdd 2.46fF **FLOATING
C17903 io_analog[10] vdd 56.84fF
C17904 divbuf_2/OUT5 vdd 16.40fF
C17905 divbuf_2/OUT4 vdd 100.06fF
C17906 divbuf_2/OUT3 vdd 27.01fF
C17907 divbuf_2/OUT2 vdd 8.71fF
C17908 divbuf_2/a_60990_n1540# vdd 1.57fF **FLOATING
C17909 divbuf_2/a_60510_n1540# vdd 1.62fF **FLOATING
C17910 divbuf_2/a_60030_n1540# vdd 1.62fF **FLOATING
C17911 divbuf_2/a_59550_n1540# vdd 1.62fF **FLOATING
C17912 divbuf_2/a_59070_n1540# vdd 1.62fF **FLOATING
C17913 divbuf_2/a_58590_n1540# vdd 1.62fF **FLOATING
C17914 divbuf_2/a_58110_n1540# vdd 1.62fF **FLOATING
C17915 divbuf_2/a_57630_n1540# vdd 1.62fF **FLOATING
C17916 divbuf_2/a_57150_n1540# vdd 1.62fF **FLOATING
C17917 divbuf_2/a_56670_n1540# vdd 1.62fF **FLOATING
C17918 divbuf_2/a_56190_n1540# vdd 1.62fF **FLOATING
C17919 divbuf_2/a_55710_n1540# vdd 1.62fF **FLOATING
C17920 divbuf_2/a_55230_n1540# vdd 1.62fF **FLOATING
C17921 divbuf_2/a_54750_n1540# vdd 1.62fF **FLOATING
C17922 divbuf_2/a_54270_n1540# vdd 1.62fF **FLOATING
C17923 divbuf_2/a_53790_n1540# vdd 1.62fF **FLOATING
C17924 divbuf_2/a_53310_n1540# vdd 1.62fF **FLOATING
C17925 divbuf_2/a_52830_n1540# vdd 1.62fF **FLOATING
C17926 divbuf_2/a_52350_n1540# vdd 1.62fF **FLOATING
C17927 divbuf_2/a_51870_n1540# vdd 1.62fF **FLOATING
C17928 divbuf_2/a_51390_n1540# vdd 1.62fF **FLOATING
C17929 divbuf_2/a_50910_n1540# vdd 1.62fF **FLOATING
C17930 divbuf_2/a_50430_n1540# vdd 1.62fF **FLOATING
C17931 divbuf_2/a_49950_n1540# vdd 1.62fF **FLOATING
C17932 divbuf_2/a_49470_n1540# vdd 1.62fF **FLOATING
C17933 divbuf_2/a_48990_n1540# vdd 1.62fF **FLOATING
C17934 divbuf_2/a_48510_n1540# vdd 1.62fF **FLOATING
C17935 divbuf_2/a_48030_n1540# vdd 1.62fF **FLOATING
C17936 divbuf_2/a_47550_n1540# vdd 1.62fF **FLOATING
C17937 divbuf_2/a_47070_n1540# vdd 1.62fF **FLOATING
C17938 divbuf_2/a_46590_n1540# vdd 1.62fF **FLOATING
C17939 divbuf_2/a_46110_n1540# vdd 1.62fF **FLOATING
C17940 divbuf_2/a_45630_n1540# vdd 1.62fF **FLOATING
C17941 divbuf_2/a_45150_n1540# vdd 1.62fF **FLOATING
C17942 divbuf_2/a_44670_n1540# vdd 1.62fF **FLOATING
C17943 divbuf_2/a_44190_n1540# vdd 1.62fF **FLOATING
C17944 divbuf_2/a_43710_n1540# vdd 1.62fF **FLOATING
C17945 divbuf_2/a_43230_n1540# vdd 1.62fF **FLOATING
C17946 divbuf_2/a_42750_n1540# vdd 1.62fF **FLOATING
C17947 divbuf_2/a_42270_n1540# vdd 1.62fF **FLOATING
C17948 divbuf_2/a_41790_n1540# vdd 1.62fF **FLOATING
C17949 divbuf_2/a_41310_n1540# vdd 1.62fF **FLOATING
C17950 divbuf_2/a_40830_n1540# vdd 1.62fF **FLOATING
C17951 divbuf_2/a_40350_n1540# vdd 1.62fF **FLOATING
C17952 divbuf_2/a_39870_n1540# vdd 1.62fF **FLOATING
C17953 divbuf_2/a_39390_n1540# vdd 1.62fF **FLOATING
C17954 divbuf_2/a_38910_n1540# vdd 1.62fF **FLOATING
C17955 divbuf_2/a_38430_n1540# vdd 1.62fF **FLOATING
C17956 divbuf_2/a_37950_n1540# vdd 1.62fF **FLOATING
C17957 divbuf_2/a_37470_n1540# vdd 1.62fF **FLOATING
C17958 divbuf_2/a_36990_n1540# vdd 1.62fF **FLOATING
C17959 divbuf_2/a_36510_n1540# vdd 1.62fF **FLOATING
C17960 divbuf_2/a_36030_n1540# vdd 1.62fF **FLOATING
C17961 divbuf_2/a_35550_n1540# vdd 1.62fF **FLOATING
C17962 divbuf_2/a_35070_n1540# vdd 1.62fF **FLOATING
C17963 divbuf_2/a_34590_n1540# vdd 1.62fF **FLOATING
C17964 divbuf_2/a_34110_n1540# vdd 1.62fF **FLOATING
C17965 divbuf_2/a_33630_n1540# vdd 1.62fF **FLOATING
C17966 divbuf_2/a_33150_n1540# vdd 1.62fF **FLOATING
C17967 divbuf_2/a_32670_n1540# vdd 1.62fF **FLOATING
C17968 divbuf_2/a_32190_n1540# vdd 1.62fF **FLOATING
C17969 divbuf_2/a_31710_n1540# vdd 1.62fF **FLOATING
C17970 divbuf_2/a_31230_n1540# vdd 1.62fF **FLOATING
C17971 divbuf_2/a_30750_n1540# vdd 1.62fF **FLOATING
C17972 divbuf_2/a_30270_n1540# vdd 1.62fF **FLOATING
C17973 divbuf_2/a_29790_n1540# vdd 1.62fF **FLOATING
C17974 divbuf_2/a_29310_n1540# vdd 1.62fF **FLOATING
C17975 divbuf_2/a_28830_n1540# vdd 1.62fF **FLOATING
C17976 divbuf_2/a_28350_n1540# vdd 1.62fF **FLOATING
C17977 divbuf_2/a_27870_n1540# vdd 1.62fF **FLOATING
C17978 divbuf_2/a_27390_n1540# vdd 1.62fF **FLOATING
C17979 divbuf_2/a_26910_n1540# vdd 1.62fF **FLOATING
C17980 divbuf_2/a_26430_n1540# vdd 1.62fF **FLOATING
C17981 divbuf_2/a_25950_n1540# vdd 1.62fF **FLOATING
C17982 divbuf_2/a_25470_n1540# vdd 1.62fF **FLOATING
C17983 divbuf_2/a_24990_n1540# vdd 1.62fF **FLOATING
C17984 divbuf_2/a_24510_n1540# vdd 1.62fF **FLOATING
C17985 divbuf_2/a_24030_n1540# vdd 1.62fF **FLOATING
C17986 divbuf_2/a_23550_n1540# vdd 1.62fF **FLOATING
C17987 divbuf_2/a_23070_n1540# vdd 1.62fF **FLOATING
C17988 divbuf_2/a_22590_n1540# vdd 1.62fF **FLOATING
C17989 divbuf_2/a_22110_n1540# vdd 1.62fF **FLOATING
C17990 divbuf_2/a_21630_n1540# vdd 1.62fF **FLOATING
C17991 divbuf_2/a_21150_n1540# vdd 1.62fF **FLOATING
C17992 divbuf_2/a_20670_n1540# vdd 1.62fF **FLOATING
C17993 divbuf_2/a_20190_n1540# vdd 1.62fF **FLOATING
C17994 divbuf_2/a_19710_n1540# vdd 1.62fF **FLOATING
C17995 divbuf_2/a_19230_n1540# vdd 1.62fF **FLOATING
C17996 divbuf_2/a_18750_n1540# vdd 1.62fF **FLOATING
C17997 divbuf_2/a_18270_n1540# vdd 1.62fF **FLOATING
C17998 divbuf_2/a_17790_n1540# vdd 1.62fF **FLOATING
C17999 divbuf_2/a_17310_n1540# vdd 1.62fF **FLOATING
C18000 divbuf_2/a_16830_n1540# vdd 1.62fF **FLOATING
C18001 divbuf_2/a_16350_n1540# vdd 1.62fF **FLOATING
C18002 divbuf_2/a_15870_n1540# vdd 1.62fF **FLOATING
C18003 divbuf_2/a_15390_n1540# vdd 1.62fF **FLOATING
C18004 divbuf_2/a_14910_n1540# vdd 1.62fF **FLOATING
C18005 divbuf_2/a_14430_n1540# vdd 1.62fF **FLOATING
C18006 divbuf_2/a_13950_n1540# vdd 1.62fF **FLOATING
C18007 divbuf_2/a_13470_n1540# vdd 1.62fF **FLOATING
C18008 divbuf_2/a_12990_n1540# vdd 1.62fF **FLOATING
C18009 divbuf_2/a_12510_n1540# vdd 1.62fF **FLOATING
C18010 divbuf_2/a_12030_n1540# vdd 1.62fF **FLOATING
C18011 divbuf_2/a_11550_n1540# vdd 1.62fF **FLOATING
C18012 divbuf_2/a_11070_n1540# vdd 1.62fF **FLOATING
C18013 divbuf_2/a_10590_n1540# vdd 1.62fF **FLOATING
C18014 divbuf_2/a_10110_n1540# vdd 1.62fF **FLOATING
C18015 divbuf_2/a_9630_n1540# vdd 1.62fF **FLOATING
C18016 divbuf_2/a_9150_n1540# vdd 1.62fF **FLOATING
C18017 divbuf_2/a_8670_n1540# vdd 1.62fF **FLOATING
C18018 divbuf_2/a_8190_n1540# vdd 1.62fF **FLOATING
C18019 divbuf_2/a_7710_n1540# vdd 1.62fF **FLOATING
C18020 divbuf_2/a_7230_n1540# vdd 1.62fF **FLOATING
C18021 divbuf_2/a_6750_n1540# vdd 1.62fF **FLOATING
C18022 divbuf_2/a_6270_n1540# vdd 1.62fF **FLOATING
C18023 divbuf_2/a_5790_n1540# vdd 1.62fF **FLOATING
C18024 divbuf_2/a_5310_n1540# vdd 1.62fF **FLOATING
C18025 divbuf_2/a_4830_n1540# vdd 1.62fF **FLOATING
C18026 divbuf_2/a_4350_n1540# vdd 1.62fF **FLOATING
C18027 divbuf_2/a_3870_n1540# vdd 1.62fF **FLOATING
C18028 divbuf_2/a_3390_n1540# vdd 1.62fF **FLOATING
C18029 divbuf_2/a_2910_n1540# vdd 1.62fF **FLOATING
C18030 divbuf_2/a_2430_n1540# vdd 1.62fF **FLOATING
C18031 divbuf_2/a_1950_n1540# vdd 1.62fF **FLOATING
C18032 divbuf_2/a_1470_n1540# vdd 1.62fF **FLOATING
C18033 divbuf_2/a_990_n1540# vdd 1.62fF **FLOATING
C18034 divbuf_2/a_510_n1540# vdd 1.62fF **FLOATING
C18035 divbuf_2/a_60990_n840# vdd 1.06fF **FLOATING
C18036 divbuf_2/a_60510_n840# vdd 1.09fF **FLOATING
C18037 divbuf_2/a_60030_n840# vdd 1.09fF **FLOATING
C18038 divbuf_2/a_59550_n840# vdd 1.09fF **FLOATING
C18039 divbuf_2/a_59070_n840# vdd 1.09fF **FLOATING
C18040 divbuf_2/a_58590_n840# vdd 1.09fF **FLOATING
C18041 divbuf_2/a_58110_n840# vdd 1.09fF **FLOATING
C18042 divbuf_2/a_57630_n840# vdd 1.09fF **FLOATING
C18043 divbuf_2/a_57150_n840# vdd 1.09fF **FLOATING
C18044 divbuf_2/a_56670_n840# vdd 1.09fF **FLOATING
C18045 divbuf_2/a_56190_n840# vdd 1.09fF **FLOATING
C18046 divbuf_2/a_55710_n840# vdd 1.09fF **FLOATING
C18047 divbuf_2/a_55230_n840# vdd 1.09fF **FLOATING
C18048 divbuf_2/a_54750_n840# vdd 1.09fF **FLOATING
C18049 divbuf_2/a_54270_n840# vdd 1.09fF **FLOATING
C18050 divbuf_2/a_53790_n840# vdd 1.09fF **FLOATING
C18051 divbuf_2/a_53310_n840# vdd 1.09fF **FLOATING
C18052 divbuf_2/a_52830_n840# vdd 1.09fF **FLOATING
C18053 divbuf_2/a_52350_n840# vdd 1.09fF **FLOATING
C18054 divbuf_2/a_51870_n840# vdd 1.09fF **FLOATING
C18055 divbuf_2/a_51390_n840# vdd 1.09fF **FLOATING
C18056 divbuf_2/a_50910_n840# vdd 1.09fF **FLOATING
C18057 divbuf_2/a_50430_n840# vdd 1.09fF **FLOATING
C18058 divbuf_2/a_49950_n840# vdd 1.09fF **FLOATING
C18059 divbuf_2/a_49470_n840# vdd 1.09fF **FLOATING
C18060 divbuf_2/a_48990_n840# vdd 1.09fF **FLOATING
C18061 divbuf_2/a_48510_n840# vdd 1.09fF **FLOATING
C18062 divbuf_2/a_48030_n840# vdd 1.09fF **FLOATING
C18063 divbuf_2/a_47550_n840# vdd 1.09fF **FLOATING
C18064 divbuf_2/a_47070_n840# vdd 1.09fF **FLOATING
C18065 divbuf_2/a_46590_n840# vdd 1.09fF **FLOATING
C18066 divbuf_2/a_46110_n840# vdd 1.09fF **FLOATING
C18067 divbuf_2/a_45630_n840# vdd 1.09fF **FLOATING
C18068 divbuf_2/a_45150_n840# vdd 1.09fF **FLOATING
C18069 divbuf_2/a_44670_n840# vdd 1.09fF **FLOATING
C18070 divbuf_2/a_44190_n840# vdd 1.09fF **FLOATING
C18071 divbuf_2/a_43710_n840# vdd 1.09fF **FLOATING
C18072 divbuf_2/a_43230_n840# vdd 1.09fF **FLOATING
C18073 divbuf_2/a_42750_n840# vdd 1.08fF **FLOATING
C18074 divbuf_2/a_42270_n840# vdd 1.08fF **FLOATING
C18075 divbuf_2/a_41790_n840# vdd 1.10fF **FLOATING
C18076 divbuf_2/a_41310_n840# vdd 1.09fF **FLOATING
C18077 divbuf_2/a_40830_n840# vdd 1.09fF **FLOATING
C18078 divbuf_2/a_40350_n840# vdd 1.09fF **FLOATING
C18079 divbuf_2/a_39870_n840# vdd 1.09fF **FLOATING
C18080 divbuf_2/a_39390_n840# vdd 1.09fF **FLOATING
C18081 divbuf_2/a_38910_n840# vdd 1.09fF **FLOATING
C18082 divbuf_2/a_38430_n840# vdd 1.09fF **FLOATING
C18083 divbuf_2/a_37950_n840# vdd 1.09fF **FLOATING
C18084 divbuf_2/a_37470_n840# vdd 1.09fF **FLOATING
C18085 divbuf_2/a_36990_n840# vdd 1.09fF **FLOATING
C18086 divbuf_2/a_36510_n840# vdd 1.09fF **FLOATING
C18087 divbuf_2/a_36030_n840# vdd 1.09fF **FLOATING
C18088 divbuf_2/a_35550_n840# vdd 1.09fF **FLOATING
C18089 divbuf_2/a_35070_n840# vdd 1.09fF **FLOATING
C18090 divbuf_2/a_34590_n840# vdd 1.09fF **FLOATING
C18091 divbuf_2/a_34110_n840# vdd 1.09fF **FLOATING
C18092 divbuf_2/a_33630_n840# vdd 1.09fF **FLOATING
C18093 divbuf_2/a_33150_n840# vdd 1.09fF **FLOATING
C18094 divbuf_2/a_32670_n840# vdd 1.09fF **FLOATING
C18095 divbuf_2/a_32190_n840# vdd 1.09fF **FLOATING
C18096 divbuf_2/a_31710_n840# vdd 1.11fF **FLOATING
C18097 divbuf_2/a_31230_n840# vdd 1.13fF **FLOATING
C18098 divbuf_2/a_30750_n840# vdd 1.09fF **FLOATING
C18099 divbuf_2/a_30270_n840# vdd 1.09fF **FLOATING
C18100 divbuf_2/a_29790_n840# vdd 1.09fF **FLOATING
C18101 divbuf_2/a_29310_n840# vdd 1.09fF **FLOATING
C18102 divbuf_2/a_28830_n840# vdd 1.09fF **FLOATING
C18103 divbuf_2/a_28350_n840# vdd 1.09fF **FLOATING
C18104 divbuf_2/a_27870_n840# vdd 1.08fF **FLOATING
C18105 divbuf_2/a_27390_n840# vdd 1.11fF **FLOATING
C18106 divbuf_2/a_26910_n840# vdd 1.10fF **FLOATING
C18107 divbuf_2/a_26430_n840# vdd 1.10fF **FLOATING
C18108 divbuf_2/a_25950_n840# vdd 1.10fF **FLOATING
C18109 divbuf_2/a_25470_n840# vdd 1.10fF **FLOATING
C18110 divbuf_2/a_24990_n840# vdd 1.10fF **FLOATING
C18111 divbuf_2/a_24510_n840# vdd 1.10fF **FLOATING
C18112 divbuf_2/a_24030_n840# vdd 1.09fF **FLOATING
C18113 divbuf_2/a_23550_n840# vdd 1.11fF **FLOATING
C18114 divbuf_2/a_23070_n840# vdd 1.10fF **FLOATING
C18115 divbuf_2/a_22590_n840# vdd 1.10fF **FLOATING
C18116 divbuf_2/a_22110_n840# vdd 1.10fF **FLOATING
C18117 divbuf_2/a_21630_n840# vdd 1.10fF **FLOATING
C18118 divbuf_2/a_21150_n840# vdd 1.10fF **FLOATING
C18119 divbuf_2/a_20670_n840# vdd 1.10fF **FLOATING
C18120 divbuf_2/a_20190_n840# vdd 1.09fF **FLOATING
C18121 divbuf_2/a_19710_n840# vdd 1.09fF **FLOATING
C18122 divbuf_2/a_19230_n840# vdd 1.09fF **FLOATING
C18123 divbuf_2/a_18750_n840# vdd 1.09fF **FLOATING
C18124 divbuf_2/a_18270_n840# vdd 1.08fF **FLOATING
C18125 divbuf_2/a_17790_n840# vdd 1.08fF **FLOATING
C18126 divbuf_2/a_17310_n840# vdd 1.07fF **FLOATING
C18127 divbuf_2/a_16830_n840# vdd 1.07fF **FLOATING
C18128 divbuf_2/a_16350_n840# vdd 1.07fF **FLOATING
C18129 divbuf_2/a_15870_n840# vdd 1.07fF **FLOATING
C18130 divbuf_2/a_15390_n840# vdd 1.08fF **FLOATING
C18131 divbuf_2/a_14910_n840# vdd 1.07fF **FLOATING
C18132 divbuf_2/a_14430_n840# vdd 1.07fF **FLOATING
C18133 divbuf_2/a_13950_n840# vdd 1.07fF **FLOATING
C18134 divbuf_2/a_13470_n840# vdd 1.07fF **FLOATING
C18135 divbuf_2/a_12990_n840# vdd 1.10fF **FLOATING
C18136 divbuf_2/a_12510_n840# vdd 1.08fF **FLOATING
C18137 divbuf_2/a_12030_n840# vdd 1.07fF **FLOATING
C18138 divbuf_2/a_11550_n840# vdd 1.07fF **FLOATING
C18139 divbuf_2/a_11070_n840# vdd 1.08fF **FLOATING
C18140 divbuf_2/a_10590_n840# vdd 1.10fF **FLOATING
C18141 divbuf_2/a_10110_n840# vdd 1.10fF **FLOATING
C18142 divbuf_2/a_9630_n840# vdd 1.10fF **FLOATING
C18143 divbuf_2/a_9150_n840# vdd 1.10fF **FLOATING
C18144 divbuf_2/a_8670_n840# vdd 1.10fF **FLOATING
C18145 divbuf_2/a_8190_n840# vdd 1.12fF **FLOATING
C18146 divbuf_2/a_7710_n840# vdd 1.10fF **FLOATING
C18147 divbuf_2/a_7230_n840# vdd 1.09fF **FLOATING
C18148 divbuf_2/a_6750_n840# vdd 1.09fF **FLOATING
C18149 divbuf_2/a_6270_n840# vdd 1.09fF **FLOATING
C18150 divbuf_2/a_5790_n840# vdd 1.09fF **FLOATING
C18151 divbuf_2/a_5310_n840# vdd 1.09fF **FLOATING
C18152 divbuf_2/a_4830_n840# vdd 1.09fF **FLOATING
C18153 divbuf_2/a_4350_n840# vdd 1.09fF **FLOATING
C18154 divbuf_2/a_3870_n840# vdd 1.09fF **FLOATING
C18155 divbuf_2/a_3390_n840# vdd 1.09fF **FLOATING
C18156 divbuf_2/a_2910_n840# vdd 1.10fF **FLOATING
C18157 divbuf_2/a_2430_n840# vdd 1.10fF **FLOATING
C18158 divbuf_2/a_1950_n840# vdd 1.10fF **FLOATING
C18159 divbuf_2/a_1470_n840# vdd 1.10fF **FLOATING
C18160 divbuf_2/a_990_n840# vdd 1.08fF **FLOATING
C18161 divbuf_2/a_510_n840# vdd 1.07fF **FLOATING
C18162 divbuf_2/a_60480_n1600# vdd 1.48fF **FLOATING
C18163 divbuf_2/a_60000_n1600# vdd 1.48fF **FLOATING
C18164 divbuf_2/a_59520_n1600# vdd 1.48fF **FLOATING
C18165 divbuf_2/a_59040_n1600# vdd 1.48fF **FLOATING
C18166 divbuf_2/a_58560_n1600# vdd 1.48fF **FLOATING
C18167 divbuf_2/a_58080_n1600# vdd 1.48fF **FLOATING
C18168 divbuf_2/a_57600_n1600# vdd 1.48fF **FLOATING
C18169 divbuf_2/a_57120_n1600# vdd 1.48fF **FLOATING
C18170 divbuf_2/a_56640_n1600# vdd 1.48fF **FLOATING
C18171 divbuf_2/a_56160_n1600# vdd 1.48fF **FLOATING
C18172 divbuf_2/a_55680_n1600# vdd 1.48fF **FLOATING
C18173 divbuf_2/a_55200_n1600# vdd 1.48fF **FLOATING
C18174 divbuf_2/a_54720_n1600# vdd 1.48fF **FLOATING
C18175 divbuf_2/a_54240_n1600# vdd 1.48fF **FLOATING
C18176 divbuf_2/a_53760_n1600# vdd 1.48fF **FLOATING
C18177 divbuf_2/a_53280_n1600# vdd 1.48fF **FLOATING
C18178 divbuf_2/a_52800_n1600# vdd 1.48fF **FLOATING
C18179 divbuf_2/a_52320_n1600# vdd 1.48fF **FLOATING
C18180 divbuf_2/a_51840_n1600# vdd 1.48fF **FLOATING
C18181 divbuf_2/a_51360_n1600# vdd 1.48fF **FLOATING
C18182 divbuf_2/a_50880_n1600# vdd 1.48fF **FLOATING
C18183 divbuf_2/a_50400_n1600# vdd 1.48fF **FLOATING
C18184 divbuf_2/a_49920_n1600# vdd 1.48fF **FLOATING
C18185 divbuf_2/a_49440_n1600# vdd 1.48fF **FLOATING
C18186 divbuf_2/a_48960_n1600# vdd 1.48fF **FLOATING
C18187 divbuf_2/a_48480_n1600# vdd 1.48fF **FLOATING
C18188 divbuf_2/a_48000_n1600# vdd 1.48fF **FLOATING
C18189 divbuf_2/a_47520_n1600# vdd 1.48fF **FLOATING
C18190 divbuf_2/a_47040_n1600# vdd 1.48fF **FLOATING
C18191 divbuf_2/a_46560_n1600# vdd 1.48fF **FLOATING
C18192 divbuf_2/a_46080_n1600# vdd 1.48fF **FLOATING
C18193 divbuf_2/a_45600_n1600# vdd 1.48fF **FLOATING
C18194 divbuf_2/a_45120_n1600# vdd 1.48fF **FLOATING
C18195 divbuf_2/a_44640_n1600# vdd 1.48fF **FLOATING
C18196 divbuf_2/a_44160_n1600# vdd 1.48fF **FLOATING
C18197 divbuf_2/a_43680_n1600# vdd 1.48fF **FLOATING
C18198 divbuf_2/a_43200_n1600# vdd 1.48fF **FLOATING
C18199 divbuf_2/a_42720_n1600# vdd 1.48fF **FLOATING
C18200 divbuf_2/a_42240_n1600# vdd 1.48fF **FLOATING
C18201 divbuf_2/a_41760_n1600# vdd 1.48fF **FLOATING
C18202 divbuf_2/a_41280_n1600# vdd 1.48fF **FLOATING
C18203 divbuf_2/a_40800_n1600# vdd 1.48fF **FLOATING
C18204 divbuf_2/a_40320_n1600# vdd 1.48fF **FLOATING
C18205 divbuf_2/a_39840_n1600# vdd 1.48fF **FLOATING
C18206 divbuf_2/a_39360_n1600# vdd 1.48fF **FLOATING
C18207 divbuf_2/a_38880_n1600# vdd 1.48fF **FLOATING
C18208 divbuf_2/a_38400_n1600# vdd 1.48fF **FLOATING
C18209 divbuf_2/a_37920_n1600# vdd 1.48fF **FLOATING
C18210 divbuf_2/a_37440_n1600# vdd 1.48fF **FLOATING
C18211 divbuf_2/a_36960_n1600# vdd 1.48fF **FLOATING
C18212 divbuf_2/a_36480_n1600# vdd 1.48fF **FLOATING
C18213 divbuf_2/a_36000_n1600# vdd 1.48fF **FLOATING
C18214 divbuf_2/a_35520_n1600# vdd 1.48fF **FLOATING
C18215 divbuf_2/a_35040_n1600# vdd 1.48fF **FLOATING
C18216 divbuf_2/a_34560_n1600# vdd 1.48fF **FLOATING
C18217 divbuf_2/a_34080_n1600# vdd 1.48fF **FLOATING
C18218 divbuf_2/a_33600_n1600# vdd 1.48fF **FLOATING
C18219 divbuf_2/a_33120_n1600# vdd 1.48fF **FLOATING
C18220 divbuf_2/a_32640_n1600# vdd 1.48fF **FLOATING
C18221 divbuf_2/a_32160_n1600# vdd 1.48fF **FLOATING
C18222 divbuf_2/a_31680_n1600# vdd 1.48fF **FLOATING
C18223 divbuf_2/a_31200_n1600# vdd 1.48fF **FLOATING
C18224 divbuf_2/a_30720_n1600# vdd 1.48fF **FLOATING
C18225 divbuf_2/a_30240_n1600# vdd 1.48fF **FLOATING
C18226 divbuf_2/a_29760_n1600# vdd 1.48fF **FLOATING
C18227 divbuf_2/a_29280_n1600# vdd 1.48fF **FLOATING
C18228 divbuf_2/a_28800_n1600# vdd 1.48fF **FLOATING
C18229 divbuf_2/a_28320_n1600# vdd 1.48fF **FLOATING
C18230 divbuf_2/a_27840_n1600# vdd 1.48fF **FLOATING
C18231 divbuf_2/a_27360_n1600# vdd 1.48fF **FLOATING
C18232 divbuf_2/a_26880_n1600# vdd 1.48fF **FLOATING
C18233 divbuf_2/a_26400_n1600# vdd 1.48fF **FLOATING
C18234 divbuf_2/a_25920_n1600# vdd 1.48fF **FLOATING
C18235 divbuf_2/a_25440_n1600# vdd 1.48fF **FLOATING
C18236 divbuf_2/a_24960_n1600# vdd 1.48fF **FLOATING
C18237 divbuf_2/a_24480_n1600# vdd 1.48fF **FLOATING
C18238 divbuf_2/a_24000_n1600# vdd 1.48fF **FLOATING
C18239 divbuf_2/a_23520_n1600# vdd 1.48fF **FLOATING
C18240 divbuf_2/a_23040_n1600# vdd 1.48fF **FLOATING
C18241 divbuf_2/a_22560_n1600# vdd 1.48fF **FLOATING
C18242 divbuf_2/a_22080_n1600# vdd 1.48fF **FLOATING
C18243 divbuf_2/a_21600_n1600# vdd 1.48fF **FLOATING
C18244 divbuf_2/a_21120_n1600# vdd 1.48fF **FLOATING
C18245 divbuf_2/a_20640_n1600# vdd 1.48fF **FLOATING
C18246 divbuf_2/a_20160_n1600# vdd 1.48fF **FLOATING
C18247 divbuf_2/a_19680_n1600# vdd 1.48fF **FLOATING
C18248 divbuf_2/a_19200_n1600# vdd 1.48fF **FLOATING
C18249 divbuf_2/a_18720_n1600# vdd 1.48fF **FLOATING
C18250 divbuf_2/a_18240_n1600# vdd 1.48fF **FLOATING
C18251 divbuf_2/a_17760_n1600# vdd 1.48fF **FLOATING
C18252 divbuf_2/a_17280_n1600# vdd 1.48fF **FLOATING
C18253 divbuf_2/a_16800_n1600# vdd 1.48fF **FLOATING
C18254 divbuf_2/a_16320_n1600# vdd 1.48fF **FLOATING
C18255 divbuf_2/a_15840_n1600# vdd 1.48fF **FLOATING
C18256 divbuf_2/a_15360_n1600# vdd 1.48fF **FLOATING
C18257 divbuf_2/a_14880_n1600# vdd 1.48fF **FLOATING
C18258 divbuf_2/a_14400_n1600# vdd 1.48fF **FLOATING
C18259 divbuf_2/a_13920_n1600# vdd 1.48fF **FLOATING
C18260 divbuf_2/a_13440_n1600# vdd 1.48fF **FLOATING
C18261 divbuf_2/a_12960_n1600# vdd 1.48fF **FLOATING
C18262 divbuf_2/a_12480_n1600# vdd 1.48fF **FLOATING
C18263 divbuf_2/a_12000_n1600# vdd 1.48fF **FLOATING
C18264 divbuf_2/a_11520_n1600# vdd 1.48fF **FLOATING
C18265 divbuf_2/a_11040_n1600# vdd 1.48fF **FLOATING
C18266 divbuf_2/a_10560_n1600# vdd 1.48fF **FLOATING
C18267 divbuf_2/a_10080_n1600# vdd 1.48fF **FLOATING
C18268 divbuf_2/a_9600_n1600# vdd 1.48fF **FLOATING
C18269 divbuf_2/a_9120_n1600# vdd 1.48fF **FLOATING
C18270 divbuf_2/a_8640_n1600# vdd 1.48fF **FLOATING
C18271 divbuf_2/a_8160_n1600# vdd 1.48fF **FLOATING
C18272 divbuf_2/a_7680_n1600# vdd 1.48fF **FLOATING
C18273 divbuf_2/a_7200_n1600# vdd 1.48fF **FLOATING
C18274 divbuf_2/a_6720_n1600# vdd 1.48fF **FLOATING
C18275 divbuf_2/a_6240_n1600# vdd 1.48fF **FLOATING
C18276 divbuf_2/a_5760_n1600# vdd 1.48fF **FLOATING
C18277 divbuf_2/a_5280_n1600# vdd 1.48fF **FLOATING
C18278 divbuf_2/a_4800_n1600# vdd 1.48fF **FLOATING
C18279 divbuf_2/a_4320_n1600# vdd 1.48fF **FLOATING
C18280 divbuf_2/a_3840_n1600# vdd 1.48fF **FLOATING
C18281 divbuf_2/a_3360_n1600# vdd 1.48fF **FLOATING
C18282 divbuf_2/a_2880_n1600# vdd 1.48fF **FLOATING
C18283 divbuf_2/a_2400_n1600# vdd 1.48fF **FLOATING
C18284 divbuf_2/a_1920_n1600# vdd 1.48fF **FLOATING
C18285 divbuf_2/a_1440_n1600# vdd 1.48fF **FLOATING
C18286 divbuf_2/a_960_n1600# vdd 1.48fF **FLOATING
C18287 divbuf_2/a_480_n1600# vdd 1.48fF **FLOATING
C18288 divbuf_2/a_0_n1600# vdd 1.48fF **FLOATING
C18289 divbuf_2/a_41382_n240# vdd 0.90fF **FLOATING
C18290 divbuf_2/a_40902_n240# vdd 0.90fF **FLOATING
C18291 divbuf_2/a_40412_n240# vdd 0.90fF **FLOATING
C18292 divbuf_2/a_39932_n240# vdd 0.90fF **FLOATING
C18293 divbuf_2/a_39442_n240# vdd 0.90fF **FLOATING
C18294 divbuf_2/a_38962_n240# vdd 0.91fF **FLOATING
C18295 divbuf_2/a_38472_n240# vdd 0.90fF **FLOATING
C18296 divbuf_2/a_37992_n240# vdd 0.90fF **FLOATING
C18297 divbuf_2/a_37502_n240# vdd 0.90fF **FLOATING
C18298 divbuf_2/a_37022_n240# vdd 0.90fF **FLOATING
C18299 divbuf_2/a_36532_n240# vdd 0.90fF **FLOATING
C18300 divbuf_2/a_36052_n240# vdd 0.90fF **FLOATING
C18301 divbuf_2/a_35562_n240# vdd 0.90fF **FLOATING
C18302 divbuf_2/a_35082_n240# vdd 0.91fF **FLOATING
C18303 divbuf_2/a_34592_n240# vdd 0.90fF **FLOATING
C18304 divbuf_2/a_34112_n240# vdd 0.90fF **FLOATING
C18305 divbuf_2/a_33622_n240# vdd 0.90fF **FLOATING
C18306 divbuf_2/a_33142_n240# vdd 0.90fF **FLOATING
C18307 divbuf_2/a_32652_n240# vdd 0.90fF **FLOATING
C18308 divbuf_2/a_32172_n240# vdd 0.90fF **FLOATING
C18309 divbuf_2/a_31682_n240# vdd 0.89fF **FLOATING
C18310 divbuf_2/a_31202_n240# vdd 0.92fF **FLOATING
C18311 divbuf_2/a_30712_n240# vdd 0.90fF **FLOATING
C18312 divbuf_2/a_30232_n240# vdd 0.90fF **FLOATING
C18313 divbuf_2/a_29742_n240# vdd 0.90fF **FLOATING
C18314 divbuf_2/a_29262_n240# vdd 0.90fF **FLOATING
C18315 divbuf_2/a_28772_n240# vdd 0.90fF **FLOATING
C18316 divbuf_2/a_28292_n240# vdd 0.90fF **FLOATING
C18317 divbuf_2/a_27802_n240# vdd 0.89fF **FLOATING
C18318 divbuf_2/a_27322_n240# vdd 0.95fF **FLOATING
C18319 divbuf_2/a_26832_n240# vdd 0.91fF **FLOATING
C18320 divbuf_2/a_26352_n240# vdd 0.91fF **FLOATING
C18321 divbuf_2/a_25862_n240# vdd 0.91fF **FLOATING
C18322 divbuf_2/a_25382_n240# vdd 0.91fF **FLOATING
C18323 divbuf_2/a_24892_n240# vdd 0.91fF **FLOATING
C18324 divbuf_2/a_24412_n240# vdd 0.91fF **FLOATING
C18325 divbuf_2/a_23922_n240# vdd 0.92fF **FLOATING
C18326 divbuf_2/a_23442_n240# vdd 0.94fF **FLOATING
C18327 divbuf_2/a_22952_n240# vdd 0.91fF **FLOATING
C18328 divbuf_2/a_22472_n240# vdd 0.91fF **FLOATING
C18329 divbuf_2/a_21982_n240# vdd 0.91fF **FLOATING
C18330 divbuf_2/a_21502_n240# vdd 0.91fF **FLOATING
C18331 divbuf_2/a_21012_n240# vdd 0.91fF **FLOATING
C18332 divbuf_2/a_20532_n240# vdd 0.91fF **FLOATING
C18333 divbuf_2/a_20042_n240# vdd 0.90fF **FLOATING
C18334 divbuf_2/a_19562_n240# vdd 0.90fF **FLOATING
C18335 divbuf_2/a_19072_n240# vdd 0.90fF **FLOATING
C18336 divbuf_2/a_18582_n240# vdd 0.89fF **FLOATING
C18337 divbuf_2/a_18092_n240# vdd 0.89fF **FLOATING
C18338 divbuf_2/a_17612_n240# vdd 0.89fF **FLOATING
C18339 divbuf_2/a_17122_n240# vdd 0.88fF **FLOATING
C18340 divbuf_2/a_16642_n240# vdd 0.88fF **FLOATING
C18341 divbuf_2/a_16152_n240# vdd 0.88fF **FLOATING
C18342 divbuf_2/a_15672_n240# vdd 0.90fF **FLOATING
C18343 divbuf_2/a_15182_n240# vdd 0.88fF **FLOATING
C18344 divbuf_2/a_14702_n240# vdd 0.88fF **FLOATING
C18345 divbuf_2/a_14222_n240# vdd 0.88fF **FLOATING
C18346 divbuf_2/a_13742_n240# vdd 0.88fF **FLOATING
C18347 divbuf_2/a_13252_n240# vdd 0.88fF **FLOATING
C18348 divbuf_2/a_12772_n240# vdd 0.88fF **FLOATING
C18349 divbuf_2/a_12282_n240# vdd 0.88fF **FLOATING
C18350 divbuf_2/a_11802_n240# vdd 0.88fF **FLOATING
C18351 divbuf_2/a_11312_n240# vdd 0.89fF **FLOATING
C18352 divbuf_2/a_10212_n240# vdd 0.91fF **FLOATING
C18353 divbuf_2/a_9732_n240# vdd 0.91fF **FLOATING
C18354 divbuf_2/a_9242_n240# vdd 0.91fF **FLOATING
C18355 divbuf_2/a_8762_n240# vdd 0.91fF **FLOATING
C18356 divbuf_2/a_8272_n240# vdd 0.91fF **FLOATING
C18357 divbuf_2/a_7792_n240# vdd 0.92fF **FLOATING
C18358 divbuf_2/a_7302_n240# vdd 0.90fF **FLOATING
C18359 divbuf_2/a_6822_n240# vdd 0.90fF **FLOATING
C18360 divbuf_2/a_6332_n240# vdd 0.90fF **FLOATING
C18361 divbuf_2/a_5852_n240# vdd 0.90fF **FLOATING
C18362 divbuf_2/a_5362_n240# vdd 0.90fF **FLOATING
C18363 divbuf_2/a_4882_n240# vdd 0.90fF **FLOATING
C18364 divbuf_2/a_4392_n240# vdd 0.90fF **FLOATING
C18365 divbuf_2/a_3912_n240# vdd 0.90fF **FLOATING
C18366 divbuf_2/a_3422_n240# vdd 0.90fF **FLOATING
C18367 divbuf_2/a_2322_n240# vdd 0.91fF **FLOATING
C18368 divbuf_2/a_1842_n240# vdd 0.91fF **FLOATING
C18369 divbuf_2/a_1352_n240# vdd 0.91fF **FLOATING
C18370 divbuf_2/a_41382_170# vdd 1.07fF **FLOATING
C18371 divbuf_2/a_40902_170# vdd 1.09fF **FLOATING
C18372 divbuf_2/a_40412_170# vdd 1.09fF **FLOATING
C18373 divbuf_2/a_39932_170# vdd 1.09fF **FLOATING
C18374 divbuf_2/a_39442_170# vdd 1.09fF **FLOATING
C18375 divbuf_2/a_38962_170# vdd 1.07fF **FLOATING
C18376 divbuf_2/a_38472_170# vdd 1.09fF **FLOATING
C18377 divbuf_2/a_37992_170# vdd 1.09fF **FLOATING
C18378 divbuf_2/a_37502_170# vdd 1.09fF **FLOATING
C18379 divbuf_2/a_37022_170# vdd 1.09fF **FLOATING
C18380 divbuf_2/a_36532_170# vdd 1.09fF **FLOATING
C18381 divbuf_2/a_36052_170# vdd 1.09fF **FLOATING
C18382 divbuf_2/a_35562_170# vdd 1.09fF **FLOATING
C18383 divbuf_2/a_35082_170# vdd 1.09fF **FLOATING
C18384 divbuf_2/a_34592_170# vdd 1.07fF **FLOATING
C18385 divbuf_2/a_34112_170# vdd 1.09fF **FLOATING
C18386 divbuf_2/a_33622_170# vdd 1.09fF **FLOATING
C18387 divbuf_2/a_33142_170# vdd 1.09fF **FLOATING
C18388 divbuf_2/a_32652_170# vdd 1.09fF **FLOATING
C18389 divbuf_2/a_32172_170# vdd 1.09fF **FLOATING
C18390 divbuf_2/a_31682_170# vdd 1.09fF **FLOATING
C18391 divbuf_2/a_31202_170# vdd 1.09fF **FLOATING
C18392 divbuf_2/a_30712_170# vdd 1.09fF **FLOATING
C18393 divbuf_2/a_30232_170# vdd 1.07fF **FLOATING
C18394 divbuf_2/a_29742_170# vdd 1.09fF **FLOATING
C18395 divbuf_2/a_29262_170# vdd 1.09fF **FLOATING
C18396 divbuf_2/a_28772_170# vdd 1.09fF **FLOATING
C18397 divbuf_2/a_28292_170# vdd 1.09fF **FLOATING
C18398 divbuf_2/a_27802_170# vdd 1.09fF **FLOATING
C18399 divbuf_2/a_27322_170# vdd 1.09fF **FLOATING
C18400 divbuf_2/a_26832_170# vdd 1.09fF **FLOATING
C18401 divbuf_2/a_26352_170# vdd 1.09fF **FLOATING
C18402 divbuf_2/a_25862_170# vdd 1.07fF **FLOATING
C18403 divbuf_2/a_25382_170# vdd 1.09fF **FLOATING
C18404 divbuf_2/a_24892_170# vdd 1.09fF **FLOATING
C18405 divbuf_2/a_24412_170# vdd 1.09fF **FLOATING
C18406 divbuf_2/a_23922_170# vdd 1.09fF **FLOATING
C18407 divbuf_2/a_23442_170# vdd 1.09fF **FLOATING
C18408 divbuf_2/a_22952_170# vdd 1.09fF **FLOATING
C18409 divbuf_2/a_22472_170# vdd 1.07fF **FLOATING
C18410 divbuf_2/a_21982_170# vdd 1.09fF **FLOATING
C18411 divbuf_2/a_21502_170# vdd 1.09fF **FLOATING
C18412 divbuf_2/a_21012_170# vdd 1.09fF **FLOATING
C18413 divbuf_2/a_20532_170# vdd 1.09fF **FLOATING
C18414 divbuf_2/a_20042_170# vdd 1.09fF **FLOATING
C18415 divbuf_2/a_19562_170# vdd 1.09fF **FLOATING
C18416 divbuf_2/a_19072_170# vdd 1.09fF **FLOATING
C18417 divbuf_2/a_18582_170# vdd 1.07fF **FLOATING
C18418 divbuf_2/a_18092_170# vdd 1.09fF **FLOATING
C18419 divbuf_2/a_17612_170# vdd 1.09fF **FLOATING
C18420 divbuf_2/a_17122_170# vdd 1.09fF **FLOATING
C18421 divbuf_2/a_16642_170# vdd 1.09fF **FLOATING
C18422 divbuf_2/a_16152_170# vdd 1.09fF **FLOATING
C18423 divbuf_2/a_15672_170# vdd 1.09fF **FLOATING
C18424 divbuf_2/a_15182_170# vdd 1.09fF **FLOATING
C18425 divbuf_2/a_14702_170# vdd 1.10fF **FLOATING
C18426 divbuf_2/a_14222_170# vdd 1.10fF **FLOATING
C18427 divbuf_2/a_13742_170# vdd 1.09fF **FLOATING
C18428 divbuf_2/a_13252_170# vdd 1.09fF **FLOATING
C18429 divbuf_2/a_12772_170# vdd 1.07fF **FLOATING
C18430 divbuf_2/a_12282_170# vdd 1.09fF **FLOATING
C18431 divbuf_2/a_11802_170# vdd 1.09fF **FLOATING
C18432 divbuf_2/a_11312_170# vdd 1.10fF **FLOATING
C18433 divbuf_2/a_10212_170# vdd 1.09fF **FLOATING
C18434 divbuf_2/a_9732_170# vdd 1.09fF **FLOATING
C18435 divbuf_2/a_9242_170# vdd 1.09fF **FLOATING
C18436 divbuf_2/a_8762_170# vdd 1.09fF **FLOATING
C18437 divbuf_2/a_8272_170# vdd 1.07fF **FLOATING
C18438 divbuf_2/a_7792_170# vdd 1.09fF **FLOATING
C18439 divbuf_2/a_7302_170# vdd 1.09fF **FLOATING
C18440 divbuf_2/a_6822_170# vdd 1.09fF **FLOATING
C18441 divbuf_2/a_6332_170# vdd 1.09fF **FLOATING
C18442 divbuf_2/a_5852_170# vdd 1.09fF **FLOATING
C18443 divbuf_2/a_5362_170# vdd 1.09fF **FLOATING
C18444 divbuf_2/a_4882_170# vdd 1.09fF **FLOATING
C18445 divbuf_2/a_4392_170# vdd 1.07fF **FLOATING
C18446 divbuf_2/a_3912_170# vdd 1.09fF **FLOATING
C18447 divbuf_2/a_3422_170# vdd 1.10fF **FLOATING
C18448 divbuf_2/a_2322_170# vdd 1.09fF **FLOATING
C18449 divbuf_2/a_1842_170# vdd 1.09fF **FLOATING
C18450 divbuf_2/a_1352_170# vdd 1.10fF **FLOATING
C18451 divbuf_2/a_492_n240# vdd 2.46fF **FLOATING
C18452 divbuf_1/OUT vdd 3.28fF
C18453 divbuf_1/OUT5 vdd 16.40fF
C18454 divbuf_1/OUT4 vdd 100.06fF
C18455 divbuf_1/OUT3 vdd 27.01fF
C18456 divbuf_1/OUT2 vdd 8.71fF
C18457 divbuf_1/IN vdd 0.89fF
C18458 divbuf_1/a_60990_n1540# vdd 1.57fF **FLOATING
C18459 divbuf_1/a_60510_n1540# vdd 1.62fF **FLOATING
C18460 divbuf_1/a_60030_n1540# vdd 1.62fF **FLOATING
C18461 divbuf_1/a_59550_n1540# vdd 1.62fF **FLOATING
C18462 divbuf_1/a_59070_n1540# vdd 1.62fF **FLOATING
C18463 divbuf_1/a_58590_n1540# vdd 1.62fF **FLOATING
C18464 divbuf_1/a_58110_n1540# vdd 1.62fF **FLOATING
C18465 divbuf_1/a_57630_n1540# vdd 1.62fF **FLOATING
C18466 divbuf_1/a_57150_n1540# vdd 1.62fF **FLOATING
C18467 divbuf_1/a_56670_n1540# vdd 1.62fF **FLOATING
C18468 divbuf_1/a_56190_n1540# vdd 1.62fF **FLOATING
C18469 divbuf_1/a_55710_n1540# vdd 1.62fF **FLOATING
C18470 divbuf_1/a_55230_n1540# vdd 1.62fF **FLOATING
C18471 divbuf_1/a_54750_n1540# vdd 1.62fF **FLOATING
C18472 divbuf_1/a_54270_n1540# vdd 1.62fF **FLOATING
C18473 divbuf_1/a_53790_n1540# vdd 1.62fF **FLOATING
C18474 divbuf_1/a_53310_n1540# vdd 1.62fF **FLOATING
C18475 divbuf_1/a_52830_n1540# vdd 1.62fF **FLOATING
C18476 divbuf_1/a_52350_n1540# vdd 1.62fF **FLOATING
C18477 divbuf_1/a_51870_n1540# vdd 1.62fF **FLOATING
C18478 divbuf_1/a_51390_n1540# vdd 1.62fF **FLOATING
C18479 divbuf_1/a_50910_n1540# vdd 1.62fF **FLOATING
C18480 divbuf_1/a_50430_n1540# vdd 1.62fF **FLOATING
C18481 divbuf_1/a_49950_n1540# vdd 1.62fF **FLOATING
C18482 divbuf_1/a_49470_n1540# vdd 1.62fF **FLOATING
C18483 divbuf_1/a_48990_n1540# vdd 1.62fF **FLOATING
C18484 divbuf_1/a_48510_n1540# vdd 1.62fF **FLOATING
C18485 divbuf_1/a_48030_n1540# vdd 1.62fF **FLOATING
C18486 divbuf_1/a_47550_n1540# vdd 1.62fF **FLOATING
C18487 divbuf_1/a_47070_n1540# vdd 1.62fF **FLOATING
C18488 divbuf_1/a_46590_n1540# vdd 1.62fF **FLOATING
C18489 divbuf_1/a_46110_n1540# vdd 1.62fF **FLOATING
C18490 divbuf_1/a_45630_n1540# vdd 1.62fF **FLOATING
C18491 divbuf_1/a_45150_n1540# vdd 1.62fF **FLOATING
C18492 divbuf_1/a_44670_n1540# vdd 1.62fF **FLOATING
C18493 divbuf_1/a_44190_n1540# vdd 1.62fF **FLOATING
C18494 divbuf_1/a_43710_n1540# vdd 1.62fF **FLOATING
C18495 divbuf_1/a_43230_n1540# vdd 1.62fF **FLOATING
C18496 divbuf_1/a_42750_n1540# vdd 1.62fF **FLOATING
C18497 divbuf_1/a_42270_n1540# vdd 1.62fF **FLOATING
C18498 divbuf_1/a_41790_n1540# vdd 1.62fF **FLOATING
C18499 divbuf_1/a_41310_n1540# vdd 1.62fF **FLOATING
C18500 divbuf_1/a_40830_n1540# vdd 1.62fF **FLOATING
C18501 divbuf_1/a_40350_n1540# vdd 1.62fF **FLOATING
C18502 divbuf_1/a_39870_n1540# vdd 1.62fF **FLOATING
C18503 divbuf_1/a_39390_n1540# vdd 1.62fF **FLOATING
C18504 divbuf_1/a_38910_n1540# vdd 1.62fF **FLOATING
C18505 divbuf_1/a_38430_n1540# vdd 1.62fF **FLOATING
C18506 divbuf_1/a_37950_n1540# vdd 1.62fF **FLOATING
C18507 divbuf_1/a_37470_n1540# vdd 1.62fF **FLOATING
C18508 divbuf_1/a_36990_n1540# vdd 1.62fF **FLOATING
C18509 divbuf_1/a_36510_n1540# vdd 1.62fF **FLOATING
C18510 divbuf_1/a_36030_n1540# vdd 1.62fF **FLOATING
C18511 divbuf_1/a_35550_n1540# vdd 1.62fF **FLOATING
C18512 divbuf_1/a_35070_n1540# vdd 1.62fF **FLOATING
C18513 divbuf_1/a_34590_n1540# vdd 1.62fF **FLOATING
C18514 divbuf_1/a_34110_n1540# vdd 1.62fF **FLOATING
C18515 divbuf_1/a_33630_n1540# vdd 1.62fF **FLOATING
C18516 divbuf_1/a_33150_n1540# vdd 1.62fF **FLOATING
C18517 divbuf_1/a_32670_n1540# vdd 1.62fF **FLOATING
C18518 divbuf_1/a_32190_n1540# vdd 1.62fF **FLOATING
C18519 divbuf_1/a_31710_n1540# vdd 1.62fF **FLOATING
C18520 divbuf_1/a_31230_n1540# vdd 1.62fF **FLOATING
C18521 divbuf_1/a_30750_n1540# vdd 1.62fF **FLOATING
C18522 divbuf_1/a_30270_n1540# vdd 1.62fF **FLOATING
C18523 divbuf_1/a_29790_n1540# vdd 1.62fF **FLOATING
C18524 divbuf_1/a_29310_n1540# vdd 1.62fF **FLOATING
C18525 divbuf_1/a_28830_n1540# vdd 1.62fF **FLOATING
C18526 divbuf_1/a_28350_n1540# vdd 1.62fF **FLOATING
C18527 divbuf_1/a_27870_n1540# vdd 1.62fF **FLOATING
C18528 divbuf_1/a_27390_n1540# vdd 1.62fF **FLOATING
C18529 divbuf_1/a_26910_n1540# vdd 1.62fF **FLOATING
C18530 divbuf_1/a_26430_n1540# vdd 1.62fF **FLOATING
C18531 divbuf_1/a_25950_n1540# vdd 1.62fF **FLOATING
C18532 divbuf_1/a_25470_n1540# vdd 1.62fF **FLOATING
C18533 divbuf_1/a_24990_n1540# vdd 1.62fF **FLOATING
C18534 divbuf_1/a_24510_n1540# vdd 1.62fF **FLOATING
C18535 divbuf_1/a_24030_n1540# vdd 1.62fF **FLOATING
C18536 divbuf_1/a_23550_n1540# vdd 1.62fF **FLOATING
C18537 divbuf_1/a_23070_n1540# vdd 1.62fF **FLOATING
C18538 divbuf_1/a_22590_n1540# vdd 1.62fF **FLOATING
C18539 divbuf_1/a_22110_n1540# vdd 1.62fF **FLOATING
C18540 divbuf_1/a_21630_n1540# vdd 1.62fF **FLOATING
C18541 divbuf_1/a_21150_n1540# vdd 1.62fF **FLOATING
C18542 divbuf_1/a_20670_n1540# vdd 1.62fF **FLOATING
C18543 divbuf_1/a_20190_n1540# vdd 1.62fF **FLOATING
C18544 divbuf_1/a_19710_n1540# vdd 1.62fF **FLOATING
C18545 divbuf_1/a_19230_n1540# vdd 1.62fF **FLOATING
C18546 divbuf_1/a_18750_n1540# vdd 1.62fF **FLOATING
C18547 divbuf_1/a_18270_n1540# vdd 1.62fF **FLOATING
C18548 divbuf_1/a_17790_n1540# vdd 1.62fF **FLOATING
C18549 divbuf_1/a_17310_n1540# vdd 1.62fF **FLOATING
C18550 divbuf_1/a_16830_n1540# vdd 1.62fF **FLOATING
C18551 divbuf_1/a_16350_n1540# vdd 1.62fF **FLOATING
C18552 divbuf_1/a_15870_n1540# vdd 1.62fF **FLOATING
C18553 divbuf_1/a_15390_n1540# vdd 1.62fF **FLOATING
C18554 divbuf_1/a_14910_n1540# vdd 1.62fF **FLOATING
C18555 divbuf_1/a_14430_n1540# vdd 1.62fF **FLOATING
C18556 divbuf_1/a_13950_n1540# vdd 1.62fF **FLOATING
C18557 divbuf_1/a_13470_n1540# vdd 1.62fF **FLOATING
C18558 divbuf_1/a_12990_n1540# vdd 1.62fF **FLOATING
C18559 divbuf_1/a_12510_n1540# vdd 1.62fF **FLOATING
C18560 divbuf_1/a_12030_n1540# vdd 1.62fF **FLOATING
C18561 divbuf_1/a_11550_n1540# vdd 1.62fF **FLOATING
C18562 divbuf_1/a_11070_n1540# vdd 1.62fF **FLOATING
C18563 divbuf_1/a_10590_n1540# vdd 1.62fF **FLOATING
C18564 divbuf_1/a_10110_n1540# vdd 1.62fF **FLOATING
C18565 divbuf_1/a_9630_n1540# vdd 1.62fF **FLOATING
C18566 divbuf_1/a_9150_n1540# vdd 1.62fF **FLOATING
C18567 divbuf_1/a_8670_n1540# vdd 1.62fF **FLOATING
C18568 divbuf_1/a_8190_n1540# vdd 1.62fF **FLOATING
C18569 divbuf_1/a_7710_n1540# vdd 1.62fF **FLOATING
C18570 divbuf_1/a_7230_n1540# vdd 1.62fF **FLOATING
C18571 divbuf_1/a_6750_n1540# vdd 1.62fF **FLOATING
C18572 divbuf_1/a_6270_n1540# vdd 1.62fF **FLOATING
C18573 divbuf_1/a_5790_n1540# vdd 1.62fF **FLOATING
C18574 divbuf_1/a_5310_n1540# vdd 1.62fF **FLOATING
C18575 divbuf_1/a_4830_n1540# vdd 1.62fF **FLOATING
C18576 divbuf_1/a_4350_n1540# vdd 1.62fF **FLOATING
C18577 divbuf_1/a_3870_n1540# vdd 1.62fF **FLOATING
C18578 divbuf_1/a_3390_n1540# vdd 1.62fF **FLOATING
C18579 divbuf_1/a_2910_n1540# vdd 1.62fF **FLOATING
C18580 divbuf_1/a_2430_n1540# vdd 1.62fF **FLOATING
C18581 divbuf_1/a_1950_n1540# vdd 1.62fF **FLOATING
C18582 divbuf_1/a_1470_n1540# vdd 1.62fF **FLOATING
C18583 divbuf_1/a_990_n1540# vdd 1.62fF **FLOATING
C18584 divbuf_1/a_510_n1540# vdd 1.62fF **FLOATING
C18585 divbuf_1/a_60990_n840# vdd 1.06fF **FLOATING
C18586 divbuf_1/a_60510_n840# vdd 1.09fF **FLOATING
C18587 divbuf_1/a_60030_n840# vdd 1.09fF **FLOATING
C18588 divbuf_1/a_59550_n840# vdd 1.09fF **FLOATING
C18589 divbuf_1/a_59070_n840# vdd 1.09fF **FLOATING
C18590 divbuf_1/a_58590_n840# vdd 1.09fF **FLOATING
C18591 divbuf_1/a_58110_n840# vdd 1.09fF **FLOATING
C18592 divbuf_1/a_57630_n840# vdd 1.09fF **FLOATING
C18593 divbuf_1/a_57150_n840# vdd 1.09fF **FLOATING
C18594 divbuf_1/a_56670_n840# vdd 1.09fF **FLOATING
C18595 divbuf_1/a_56190_n840# vdd 1.09fF **FLOATING
C18596 divbuf_1/a_55710_n840# vdd 1.09fF **FLOATING
C18597 divbuf_1/a_55230_n840# vdd 1.09fF **FLOATING
C18598 divbuf_1/a_54750_n840# vdd 1.09fF **FLOATING
C18599 divbuf_1/a_54270_n840# vdd 1.09fF **FLOATING
C18600 divbuf_1/a_53790_n840# vdd 1.09fF **FLOATING
C18601 divbuf_1/a_53310_n840# vdd 1.09fF **FLOATING
C18602 divbuf_1/a_52830_n840# vdd 1.09fF **FLOATING
C18603 divbuf_1/a_52350_n840# vdd 1.09fF **FLOATING
C18604 divbuf_1/a_51870_n840# vdd 1.09fF **FLOATING
C18605 divbuf_1/a_51390_n840# vdd 1.09fF **FLOATING
C18606 divbuf_1/a_50910_n840# vdd 1.09fF **FLOATING
C18607 divbuf_1/a_50430_n840# vdd 1.09fF **FLOATING
C18608 divbuf_1/a_49950_n840# vdd 1.09fF **FLOATING
C18609 divbuf_1/a_49470_n840# vdd 1.09fF **FLOATING
C18610 divbuf_1/a_48990_n840# vdd 1.09fF **FLOATING
C18611 divbuf_1/a_48510_n840# vdd 1.09fF **FLOATING
C18612 divbuf_1/a_48030_n840# vdd 1.09fF **FLOATING
C18613 divbuf_1/a_47550_n840# vdd 1.09fF **FLOATING
C18614 divbuf_1/a_47070_n840# vdd 1.09fF **FLOATING
C18615 divbuf_1/a_46590_n840# vdd 1.09fF **FLOATING
C18616 divbuf_1/a_46110_n840# vdd 1.09fF **FLOATING
C18617 divbuf_1/a_45630_n840# vdd 1.09fF **FLOATING
C18618 divbuf_1/a_45150_n840# vdd 1.09fF **FLOATING
C18619 divbuf_1/a_44670_n840# vdd 1.09fF **FLOATING
C18620 divbuf_1/a_44190_n840# vdd 1.09fF **FLOATING
C18621 divbuf_1/a_43710_n840# vdd 1.09fF **FLOATING
C18622 divbuf_1/a_43230_n840# vdd 1.09fF **FLOATING
C18623 divbuf_1/a_42750_n840# vdd 1.08fF **FLOATING
C18624 divbuf_1/a_42270_n840# vdd 1.08fF **FLOATING
C18625 divbuf_1/a_41790_n840# vdd 1.10fF **FLOATING
C18626 divbuf_1/a_41310_n840# vdd 1.09fF **FLOATING
C18627 divbuf_1/a_40830_n840# vdd 1.09fF **FLOATING
C18628 divbuf_1/a_40350_n840# vdd 1.09fF **FLOATING
C18629 divbuf_1/a_39870_n840# vdd 1.09fF **FLOATING
C18630 divbuf_1/a_39390_n840# vdd 1.09fF **FLOATING
C18631 divbuf_1/a_38910_n840# vdd 1.09fF **FLOATING
C18632 divbuf_1/a_38430_n840# vdd 1.09fF **FLOATING
C18633 divbuf_1/a_37950_n840# vdd 1.09fF **FLOATING
C18634 divbuf_1/a_37470_n840# vdd 1.09fF **FLOATING
C18635 divbuf_1/a_36990_n840# vdd 1.09fF **FLOATING
C18636 divbuf_1/a_36510_n840# vdd 1.09fF **FLOATING
C18637 divbuf_1/a_36030_n840# vdd 1.09fF **FLOATING
C18638 divbuf_1/a_35550_n840# vdd 1.09fF **FLOATING
C18639 divbuf_1/a_35070_n840# vdd 1.09fF **FLOATING
C18640 divbuf_1/a_34590_n840# vdd 1.09fF **FLOATING
C18641 divbuf_1/a_34110_n840# vdd 1.09fF **FLOATING
C18642 divbuf_1/a_33630_n840# vdd 1.09fF **FLOATING
C18643 divbuf_1/a_33150_n840# vdd 1.09fF **FLOATING
C18644 divbuf_1/a_32670_n840# vdd 1.09fF **FLOATING
C18645 divbuf_1/a_32190_n840# vdd 1.09fF **FLOATING
C18646 divbuf_1/a_31710_n840# vdd 1.11fF **FLOATING
C18647 divbuf_1/a_31230_n840# vdd 1.13fF **FLOATING
C18648 divbuf_1/a_30750_n840# vdd 1.09fF **FLOATING
C18649 divbuf_1/a_30270_n840# vdd 1.09fF **FLOATING
C18650 divbuf_1/a_29790_n840# vdd 1.09fF **FLOATING
C18651 divbuf_1/a_29310_n840# vdd 1.09fF **FLOATING
C18652 divbuf_1/a_28830_n840# vdd 1.09fF **FLOATING
C18653 divbuf_1/a_28350_n840# vdd 1.09fF **FLOATING
C18654 divbuf_1/a_27870_n840# vdd 1.08fF **FLOATING
C18655 divbuf_1/a_27390_n840# vdd 1.11fF **FLOATING
C18656 divbuf_1/a_26910_n840# vdd 1.10fF **FLOATING
C18657 divbuf_1/a_26430_n840# vdd 1.10fF **FLOATING
C18658 divbuf_1/a_25950_n840# vdd 1.10fF **FLOATING
C18659 divbuf_1/a_25470_n840# vdd 1.10fF **FLOATING
C18660 divbuf_1/a_24990_n840# vdd 1.10fF **FLOATING
C18661 divbuf_1/a_24510_n840# vdd 1.10fF **FLOATING
C18662 divbuf_1/a_24030_n840# vdd 1.09fF **FLOATING
C18663 divbuf_1/a_23550_n840# vdd 1.11fF **FLOATING
C18664 divbuf_1/a_23070_n840# vdd 1.10fF **FLOATING
C18665 divbuf_1/a_22590_n840# vdd 1.10fF **FLOATING
C18666 divbuf_1/a_22110_n840# vdd 1.10fF **FLOATING
C18667 divbuf_1/a_21630_n840# vdd 1.10fF **FLOATING
C18668 divbuf_1/a_21150_n840# vdd 1.10fF **FLOATING
C18669 divbuf_1/a_20670_n840# vdd 1.10fF **FLOATING
C18670 divbuf_1/a_20190_n840# vdd 1.09fF **FLOATING
C18671 divbuf_1/a_19710_n840# vdd 1.09fF **FLOATING
C18672 divbuf_1/a_19230_n840# vdd 1.09fF **FLOATING
C18673 divbuf_1/a_18750_n840# vdd 1.09fF **FLOATING
C18674 divbuf_1/a_18270_n840# vdd 1.08fF **FLOATING
C18675 divbuf_1/a_17790_n840# vdd 1.08fF **FLOATING
C18676 divbuf_1/a_17310_n840# vdd 1.07fF **FLOATING
C18677 divbuf_1/a_16830_n840# vdd 1.07fF **FLOATING
C18678 divbuf_1/a_16350_n840# vdd 1.07fF **FLOATING
C18679 divbuf_1/a_15870_n840# vdd 1.07fF **FLOATING
C18680 divbuf_1/a_15390_n840# vdd 1.08fF **FLOATING
C18681 divbuf_1/a_14910_n840# vdd 1.07fF **FLOATING
C18682 divbuf_1/a_14430_n840# vdd 1.07fF **FLOATING
C18683 divbuf_1/a_13950_n840# vdd 1.07fF **FLOATING
C18684 divbuf_1/a_13470_n840# vdd 1.07fF **FLOATING
C18685 divbuf_1/a_12990_n840# vdd 1.10fF **FLOATING
C18686 divbuf_1/a_12510_n840# vdd 1.08fF **FLOATING
C18687 divbuf_1/a_12030_n840# vdd 1.07fF **FLOATING
C18688 divbuf_1/a_11550_n840# vdd 1.07fF **FLOATING
C18689 divbuf_1/a_11070_n840# vdd 1.08fF **FLOATING
C18690 divbuf_1/a_10590_n840# vdd 1.10fF **FLOATING
C18691 divbuf_1/a_10110_n840# vdd 1.10fF **FLOATING
C18692 divbuf_1/a_9630_n840# vdd 1.10fF **FLOATING
C18693 divbuf_1/a_9150_n840# vdd 1.10fF **FLOATING
C18694 divbuf_1/a_8670_n840# vdd 1.10fF **FLOATING
C18695 divbuf_1/a_8190_n840# vdd 1.12fF **FLOATING
C18696 divbuf_1/a_7710_n840# vdd 1.10fF **FLOATING
C18697 divbuf_1/a_7230_n840# vdd 1.09fF **FLOATING
C18698 divbuf_1/a_6750_n840# vdd 1.09fF **FLOATING
C18699 divbuf_1/a_6270_n840# vdd 1.09fF **FLOATING
C18700 divbuf_1/a_5790_n840# vdd 1.09fF **FLOATING
C18701 divbuf_1/a_5310_n840# vdd 1.09fF **FLOATING
C18702 divbuf_1/a_4830_n840# vdd 1.09fF **FLOATING
C18703 divbuf_1/a_4350_n840# vdd 1.09fF **FLOATING
C18704 divbuf_1/a_3870_n840# vdd 1.09fF **FLOATING
C18705 divbuf_1/a_3390_n840# vdd 1.09fF **FLOATING
C18706 divbuf_1/a_2910_n840# vdd 1.10fF **FLOATING
C18707 divbuf_1/a_2430_n840# vdd 1.10fF **FLOATING
C18708 divbuf_1/a_1950_n840# vdd 1.10fF **FLOATING
C18709 divbuf_1/a_1470_n840# vdd 1.10fF **FLOATING
C18710 divbuf_1/a_990_n840# vdd 1.08fF **FLOATING
C18711 divbuf_1/a_510_n840# vdd 1.07fF **FLOATING
C18712 divbuf_1/a_60480_n1600# vdd 1.48fF **FLOATING
C18713 divbuf_1/a_60000_n1600# vdd 1.48fF **FLOATING
C18714 divbuf_1/a_59520_n1600# vdd 1.48fF **FLOATING
C18715 divbuf_1/a_59040_n1600# vdd 1.48fF **FLOATING
C18716 divbuf_1/a_58560_n1600# vdd 1.48fF **FLOATING
C18717 divbuf_1/a_58080_n1600# vdd 1.48fF **FLOATING
C18718 divbuf_1/a_57600_n1600# vdd 1.48fF **FLOATING
C18719 divbuf_1/a_57120_n1600# vdd 1.48fF **FLOATING
C18720 divbuf_1/a_56640_n1600# vdd 1.48fF **FLOATING
C18721 divbuf_1/a_56160_n1600# vdd 1.48fF **FLOATING
C18722 divbuf_1/a_55680_n1600# vdd 1.48fF **FLOATING
C18723 divbuf_1/a_55200_n1600# vdd 1.48fF **FLOATING
C18724 divbuf_1/a_54720_n1600# vdd 1.48fF **FLOATING
C18725 divbuf_1/a_54240_n1600# vdd 1.48fF **FLOATING
C18726 divbuf_1/a_53760_n1600# vdd 1.48fF **FLOATING
C18727 divbuf_1/a_53280_n1600# vdd 1.48fF **FLOATING
C18728 divbuf_1/a_52800_n1600# vdd 1.48fF **FLOATING
C18729 divbuf_1/a_52320_n1600# vdd 1.48fF **FLOATING
C18730 divbuf_1/a_51840_n1600# vdd 1.48fF **FLOATING
C18731 divbuf_1/a_51360_n1600# vdd 1.48fF **FLOATING
C18732 divbuf_1/a_50880_n1600# vdd 1.48fF **FLOATING
C18733 divbuf_1/a_50400_n1600# vdd 1.48fF **FLOATING
C18734 divbuf_1/a_49920_n1600# vdd 1.48fF **FLOATING
C18735 divbuf_1/a_49440_n1600# vdd 1.48fF **FLOATING
C18736 divbuf_1/a_48960_n1600# vdd 1.48fF **FLOATING
C18737 divbuf_1/a_48480_n1600# vdd 1.48fF **FLOATING
C18738 divbuf_1/a_48000_n1600# vdd 1.48fF **FLOATING
C18739 divbuf_1/a_47520_n1600# vdd 1.48fF **FLOATING
C18740 divbuf_1/a_47040_n1600# vdd 1.48fF **FLOATING
C18741 divbuf_1/a_46560_n1600# vdd 1.48fF **FLOATING
C18742 divbuf_1/a_46080_n1600# vdd 1.48fF **FLOATING
C18743 divbuf_1/a_45600_n1600# vdd 1.48fF **FLOATING
C18744 divbuf_1/a_45120_n1600# vdd 1.48fF **FLOATING
C18745 divbuf_1/a_44640_n1600# vdd 1.48fF **FLOATING
C18746 divbuf_1/a_44160_n1600# vdd 1.48fF **FLOATING
C18747 divbuf_1/a_43680_n1600# vdd 1.48fF **FLOATING
C18748 divbuf_1/a_43200_n1600# vdd 1.48fF **FLOATING
C18749 divbuf_1/a_42720_n1600# vdd 1.48fF **FLOATING
C18750 divbuf_1/a_42240_n1600# vdd 1.48fF **FLOATING
C18751 divbuf_1/a_41760_n1600# vdd 1.48fF **FLOATING
C18752 divbuf_1/a_41280_n1600# vdd 1.48fF **FLOATING
C18753 divbuf_1/a_40800_n1600# vdd 1.48fF **FLOATING
C18754 divbuf_1/a_40320_n1600# vdd 1.48fF **FLOATING
C18755 divbuf_1/a_39840_n1600# vdd 1.48fF **FLOATING
C18756 divbuf_1/a_39360_n1600# vdd 1.48fF **FLOATING
C18757 divbuf_1/a_38880_n1600# vdd 1.48fF **FLOATING
C18758 divbuf_1/a_38400_n1600# vdd 1.48fF **FLOATING
C18759 divbuf_1/a_37920_n1600# vdd 1.48fF **FLOATING
C18760 divbuf_1/a_37440_n1600# vdd 1.48fF **FLOATING
C18761 divbuf_1/a_36960_n1600# vdd 1.48fF **FLOATING
C18762 divbuf_1/a_36480_n1600# vdd 1.48fF **FLOATING
C18763 divbuf_1/a_36000_n1600# vdd 1.48fF **FLOATING
C18764 divbuf_1/a_35520_n1600# vdd 1.48fF **FLOATING
C18765 divbuf_1/a_35040_n1600# vdd 1.48fF **FLOATING
C18766 divbuf_1/a_34560_n1600# vdd 1.48fF **FLOATING
C18767 divbuf_1/a_34080_n1600# vdd 1.48fF **FLOATING
C18768 divbuf_1/a_33600_n1600# vdd 1.48fF **FLOATING
C18769 divbuf_1/a_33120_n1600# vdd 1.48fF **FLOATING
C18770 divbuf_1/a_32640_n1600# vdd 1.48fF **FLOATING
C18771 divbuf_1/a_32160_n1600# vdd 1.48fF **FLOATING
C18772 divbuf_1/a_31680_n1600# vdd 1.48fF **FLOATING
C18773 divbuf_1/a_31200_n1600# vdd 1.48fF **FLOATING
C18774 divbuf_1/a_30720_n1600# vdd 1.48fF **FLOATING
C18775 divbuf_1/a_30240_n1600# vdd 1.48fF **FLOATING
C18776 divbuf_1/a_29760_n1600# vdd 1.48fF **FLOATING
C18777 divbuf_1/a_29280_n1600# vdd 1.48fF **FLOATING
C18778 divbuf_1/a_28800_n1600# vdd 1.48fF **FLOATING
C18779 divbuf_1/a_28320_n1600# vdd 1.48fF **FLOATING
C18780 divbuf_1/a_27840_n1600# vdd 1.48fF **FLOATING
C18781 divbuf_1/a_27360_n1600# vdd 1.48fF **FLOATING
C18782 divbuf_1/a_26880_n1600# vdd 1.48fF **FLOATING
C18783 divbuf_1/a_26400_n1600# vdd 1.48fF **FLOATING
C18784 divbuf_1/a_25920_n1600# vdd 1.48fF **FLOATING
C18785 divbuf_1/a_25440_n1600# vdd 1.48fF **FLOATING
C18786 divbuf_1/a_24960_n1600# vdd 1.48fF **FLOATING
C18787 divbuf_1/a_24480_n1600# vdd 1.48fF **FLOATING
C18788 divbuf_1/a_24000_n1600# vdd 1.48fF **FLOATING
C18789 divbuf_1/a_23520_n1600# vdd 1.48fF **FLOATING
C18790 divbuf_1/a_23040_n1600# vdd 1.48fF **FLOATING
C18791 divbuf_1/a_22560_n1600# vdd 1.48fF **FLOATING
C18792 divbuf_1/a_22080_n1600# vdd 1.48fF **FLOATING
C18793 divbuf_1/a_21600_n1600# vdd 1.48fF **FLOATING
C18794 divbuf_1/a_21120_n1600# vdd 1.48fF **FLOATING
C18795 divbuf_1/a_20640_n1600# vdd 1.48fF **FLOATING
C18796 divbuf_1/a_20160_n1600# vdd 1.48fF **FLOATING
C18797 divbuf_1/a_19680_n1600# vdd 1.48fF **FLOATING
C18798 divbuf_1/a_19200_n1600# vdd 1.48fF **FLOATING
C18799 divbuf_1/a_18720_n1600# vdd 1.48fF **FLOATING
C18800 divbuf_1/a_18240_n1600# vdd 1.48fF **FLOATING
C18801 divbuf_1/a_17760_n1600# vdd 1.48fF **FLOATING
C18802 divbuf_1/a_17280_n1600# vdd 1.48fF **FLOATING
C18803 divbuf_1/a_16800_n1600# vdd 1.48fF **FLOATING
C18804 divbuf_1/a_16320_n1600# vdd 1.48fF **FLOATING
C18805 divbuf_1/a_15840_n1600# vdd 1.48fF **FLOATING
C18806 divbuf_1/a_15360_n1600# vdd 1.48fF **FLOATING
C18807 divbuf_1/a_14880_n1600# vdd 1.48fF **FLOATING
C18808 divbuf_1/a_14400_n1600# vdd 1.48fF **FLOATING
C18809 divbuf_1/a_13920_n1600# vdd 1.48fF **FLOATING
C18810 divbuf_1/a_13440_n1600# vdd 1.48fF **FLOATING
C18811 divbuf_1/a_12960_n1600# vdd 1.48fF **FLOATING
C18812 divbuf_1/a_12480_n1600# vdd 1.48fF **FLOATING
C18813 divbuf_1/a_12000_n1600# vdd 1.48fF **FLOATING
C18814 divbuf_1/a_11520_n1600# vdd 1.48fF **FLOATING
C18815 divbuf_1/a_11040_n1600# vdd 1.48fF **FLOATING
C18816 divbuf_1/a_10560_n1600# vdd 1.48fF **FLOATING
C18817 divbuf_1/a_10080_n1600# vdd 1.48fF **FLOATING
C18818 divbuf_1/a_9600_n1600# vdd 1.48fF **FLOATING
C18819 divbuf_1/a_9120_n1600# vdd 1.48fF **FLOATING
C18820 divbuf_1/a_8640_n1600# vdd 1.48fF **FLOATING
C18821 divbuf_1/a_8160_n1600# vdd 1.48fF **FLOATING
C18822 divbuf_1/a_7680_n1600# vdd 1.48fF **FLOATING
C18823 divbuf_1/a_7200_n1600# vdd 1.48fF **FLOATING
C18824 divbuf_1/a_6720_n1600# vdd 1.48fF **FLOATING
C18825 divbuf_1/a_6240_n1600# vdd 1.48fF **FLOATING
C18826 divbuf_1/a_5760_n1600# vdd 1.48fF **FLOATING
C18827 divbuf_1/a_5280_n1600# vdd 1.48fF **FLOATING
C18828 divbuf_1/a_4800_n1600# vdd 1.48fF **FLOATING
C18829 divbuf_1/a_4320_n1600# vdd 1.48fF **FLOATING
C18830 divbuf_1/a_3840_n1600# vdd 1.48fF **FLOATING
C18831 divbuf_1/a_3360_n1600# vdd 1.48fF **FLOATING
C18832 divbuf_1/a_2880_n1600# vdd 1.48fF **FLOATING
C18833 divbuf_1/a_2400_n1600# vdd 1.48fF **FLOATING
C18834 divbuf_1/a_1920_n1600# vdd 1.48fF **FLOATING
C18835 divbuf_1/a_1440_n1600# vdd 1.48fF **FLOATING
C18836 divbuf_1/a_960_n1600# vdd 1.48fF **FLOATING
C18837 divbuf_1/a_480_n1600# vdd 1.48fF **FLOATING
C18838 divbuf_1/a_0_n1600# vdd 1.48fF **FLOATING
C18839 divbuf_1/a_41382_n240# vdd 0.90fF **FLOATING
C18840 divbuf_1/a_40902_n240# vdd 0.90fF **FLOATING
C18841 divbuf_1/a_40412_n240# vdd 0.90fF **FLOATING
C18842 divbuf_1/a_39932_n240# vdd 0.90fF **FLOATING
C18843 divbuf_1/a_39442_n240# vdd 0.90fF **FLOATING
C18844 divbuf_1/a_38962_n240# vdd 0.91fF **FLOATING
C18845 divbuf_1/a_38472_n240# vdd 0.90fF **FLOATING
C18846 divbuf_1/a_37992_n240# vdd 0.90fF **FLOATING
C18847 divbuf_1/a_37502_n240# vdd 0.90fF **FLOATING
C18848 divbuf_1/a_37022_n240# vdd 0.90fF **FLOATING
C18849 divbuf_1/a_36532_n240# vdd 0.90fF **FLOATING
C18850 divbuf_1/a_36052_n240# vdd 0.90fF **FLOATING
C18851 divbuf_1/a_35562_n240# vdd 0.90fF **FLOATING
C18852 divbuf_1/a_35082_n240# vdd 0.91fF **FLOATING
C18853 divbuf_1/a_34592_n240# vdd 0.90fF **FLOATING
C18854 divbuf_1/a_34112_n240# vdd 0.90fF **FLOATING
C18855 divbuf_1/a_33622_n240# vdd 0.90fF **FLOATING
C18856 divbuf_1/a_33142_n240# vdd 0.90fF **FLOATING
C18857 divbuf_1/a_32652_n240# vdd 0.90fF **FLOATING
C18858 divbuf_1/a_32172_n240# vdd 0.90fF **FLOATING
C18859 divbuf_1/a_31682_n240# vdd 0.89fF **FLOATING
C18860 divbuf_1/a_31202_n240# vdd 0.92fF **FLOATING
C18861 divbuf_1/a_30712_n240# vdd 0.90fF **FLOATING
C18862 divbuf_1/a_30232_n240# vdd 0.90fF **FLOATING
C18863 divbuf_1/a_29742_n240# vdd 0.90fF **FLOATING
C18864 divbuf_1/a_29262_n240# vdd 0.90fF **FLOATING
C18865 divbuf_1/a_28772_n240# vdd 0.90fF **FLOATING
C18866 divbuf_1/a_28292_n240# vdd 0.90fF **FLOATING
C18867 divbuf_1/a_27802_n240# vdd 0.89fF **FLOATING
C18868 divbuf_1/a_27322_n240# vdd 0.95fF **FLOATING
C18869 divbuf_1/a_26832_n240# vdd 0.91fF **FLOATING
C18870 divbuf_1/a_26352_n240# vdd 0.91fF **FLOATING
C18871 divbuf_1/a_25862_n240# vdd 0.91fF **FLOATING
C18872 divbuf_1/a_25382_n240# vdd 0.91fF **FLOATING
C18873 divbuf_1/a_24892_n240# vdd 0.91fF **FLOATING
C18874 divbuf_1/a_24412_n240# vdd 0.91fF **FLOATING
C18875 divbuf_1/a_23922_n240# vdd 0.92fF **FLOATING
C18876 divbuf_1/a_23442_n240# vdd 0.94fF **FLOATING
C18877 divbuf_1/a_22952_n240# vdd 0.91fF **FLOATING
C18878 divbuf_1/a_22472_n240# vdd 0.91fF **FLOATING
C18879 divbuf_1/a_21982_n240# vdd 0.91fF **FLOATING
C18880 divbuf_1/a_21502_n240# vdd 0.91fF **FLOATING
C18881 divbuf_1/a_21012_n240# vdd 0.91fF **FLOATING
C18882 divbuf_1/a_20532_n240# vdd 0.91fF **FLOATING
C18883 divbuf_1/a_20042_n240# vdd 0.90fF **FLOATING
C18884 divbuf_1/a_19562_n240# vdd 0.90fF **FLOATING
C18885 divbuf_1/a_19072_n240# vdd 0.90fF **FLOATING
C18886 divbuf_1/a_18582_n240# vdd 0.89fF **FLOATING
C18887 divbuf_1/a_18092_n240# vdd 0.89fF **FLOATING
C18888 divbuf_1/a_17612_n240# vdd 0.89fF **FLOATING
C18889 divbuf_1/a_17122_n240# vdd 0.88fF **FLOATING
C18890 divbuf_1/a_16642_n240# vdd 0.88fF **FLOATING
C18891 divbuf_1/a_16152_n240# vdd 0.88fF **FLOATING
C18892 divbuf_1/a_15672_n240# vdd 0.90fF **FLOATING
C18893 divbuf_1/a_15182_n240# vdd 0.88fF **FLOATING
C18894 divbuf_1/a_14702_n240# vdd 0.88fF **FLOATING
C18895 divbuf_1/a_14222_n240# vdd 0.88fF **FLOATING
C18896 divbuf_1/a_13742_n240# vdd 0.88fF **FLOATING
C18897 divbuf_1/a_13252_n240# vdd 0.88fF **FLOATING
C18898 divbuf_1/a_12772_n240# vdd 0.88fF **FLOATING
C18899 divbuf_1/a_12282_n240# vdd 0.88fF **FLOATING
C18900 divbuf_1/a_11802_n240# vdd 0.88fF **FLOATING
C18901 divbuf_1/a_11312_n240# vdd 0.89fF **FLOATING
C18902 divbuf_1/a_10212_n240# vdd 0.91fF **FLOATING
C18903 divbuf_1/a_9732_n240# vdd 0.91fF **FLOATING
C18904 divbuf_1/a_9242_n240# vdd 0.91fF **FLOATING
C18905 divbuf_1/a_8762_n240# vdd 0.91fF **FLOATING
C18906 divbuf_1/a_8272_n240# vdd 0.91fF **FLOATING
C18907 divbuf_1/a_7792_n240# vdd 0.92fF **FLOATING
C18908 divbuf_1/a_7302_n240# vdd 0.90fF **FLOATING
C18909 divbuf_1/a_6822_n240# vdd 0.90fF **FLOATING
C18910 divbuf_1/a_6332_n240# vdd 0.90fF **FLOATING
C18911 divbuf_1/a_5852_n240# vdd 0.90fF **FLOATING
C18912 divbuf_1/a_5362_n240# vdd 0.90fF **FLOATING
C18913 divbuf_1/a_4882_n240# vdd 0.90fF **FLOATING
C18914 divbuf_1/a_4392_n240# vdd 0.90fF **FLOATING
C18915 divbuf_1/a_3912_n240# vdd 0.90fF **FLOATING
C18916 divbuf_1/a_3422_n240# vdd 0.90fF **FLOATING
C18917 divbuf_1/a_2322_n240# vdd 0.91fF **FLOATING
C18918 divbuf_1/a_1842_n240# vdd 0.91fF **FLOATING
C18919 divbuf_1/a_1352_n240# vdd 0.91fF **FLOATING
C18920 divbuf_1/a_41382_170# vdd 1.07fF **FLOATING
C18921 divbuf_1/a_40902_170# vdd 1.09fF **FLOATING
C18922 divbuf_1/a_40412_170# vdd 1.09fF **FLOATING
C18923 divbuf_1/a_39932_170# vdd 1.09fF **FLOATING
C18924 divbuf_1/a_39442_170# vdd 1.09fF **FLOATING
C18925 divbuf_1/a_38962_170# vdd 1.07fF **FLOATING
C18926 divbuf_1/a_38472_170# vdd 1.09fF **FLOATING
C18927 divbuf_1/a_37992_170# vdd 1.09fF **FLOATING
C18928 divbuf_1/a_37502_170# vdd 1.09fF **FLOATING
C18929 divbuf_1/a_37022_170# vdd 1.09fF **FLOATING
C18930 divbuf_1/a_36532_170# vdd 1.09fF **FLOATING
C18931 divbuf_1/a_36052_170# vdd 1.09fF **FLOATING
C18932 divbuf_1/a_35562_170# vdd 1.09fF **FLOATING
C18933 divbuf_1/a_35082_170# vdd 1.09fF **FLOATING
C18934 divbuf_1/a_34592_170# vdd 1.07fF **FLOATING
C18935 divbuf_1/a_34112_170# vdd 1.09fF **FLOATING
C18936 divbuf_1/a_33622_170# vdd 1.09fF **FLOATING
C18937 divbuf_1/a_33142_170# vdd 1.09fF **FLOATING
C18938 divbuf_1/a_32652_170# vdd 1.09fF **FLOATING
C18939 divbuf_1/a_32172_170# vdd 1.09fF **FLOATING
C18940 divbuf_1/a_31682_170# vdd 1.09fF **FLOATING
C18941 divbuf_1/a_31202_170# vdd 1.09fF **FLOATING
C18942 divbuf_1/a_30712_170# vdd 1.09fF **FLOATING
C18943 divbuf_1/a_30232_170# vdd 1.07fF **FLOATING
C18944 divbuf_1/a_29742_170# vdd 1.09fF **FLOATING
C18945 divbuf_1/a_29262_170# vdd 1.09fF **FLOATING
C18946 divbuf_1/a_28772_170# vdd 1.09fF **FLOATING
C18947 divbuf_1/a_28292_170# vdd 1.09fF **FLOATING
C18948 divbuf_1/a_27802_170# vdd 1.09fF **FLOATING
C18949 divbuf_1/a_27322_170# vdd 1.09fF **FLOATING
C18950 divbuf_1/a_26832_170# vdd 1.09fF **FLOATING
C18951 divbuf_1/a_26352_170# vdd 1.09fF **FLOATING
C18952 divbuf_1/a_25862_170# vdd 1.07fF **FLOATING
C18953 divbuf_1/a_25382_170# vdd 1.09fF **FLOATING
C18954 divbuf_1/a_24892_170# vdd 1.09fF **FLOATING
C18955 divbuf_1/a_24412_170# vdd 1.09fF **FLOATING
C18956 divbuf_1/a_23922_170# vdd 1.09fF **FLOATING
C18957 divbuf_1/a_23442_170# vdd 1.09fF **FLOATING
C18958 divbuf_1/a_22952_170# vdd 1.09fF **FLOATING
C18959 divbuf_1/a_22472_170# vdd 1.07fF **FLOATING
C18960 divbuf_1/a_21982_170# vdd 1.09fF **FLOATING
C18961 divbuf_1/a_21502_170# vdd 1.09fF **FLOATING
C18962 divbuf_1/a_21012_170# vdd 1.09fF **FLOATING
C18963 divbuf_1/a_20532_170# vdd 1.09fF **FLOATING
C18964 divbuf_1/a_20042_170# vdd 1.09fF **FLOATING
C18965 divbuf_1/a_19562_170# vdd 1.09fF **FLOATING
C18966 divbuf_1/a_19072_170# vdd 1.09fF **FLOATING
C18967 divbuf_1/a_18582_170# vdd 1.07fF **FLOATING
C18968 divbuf_1/a_18092_170# vdd 1.09fF **FLOATING
C18969 divbuf_1/a_17612_170# vdd 1.09fF **FLOATING
C18970 divbuf_1/a_17122_170# vdd 1.09fF **FLOATING
C18971 divbuf_1/a_16642_170# vdd 1.09fF **FLOATING
C18972 divbuf_1/a_16152_170# vdd 1.09fF **FLOATING
C18973 divbuf_1/a_15672_170# vdd 1.09fF **FLOATING
C18974 divbuf_1/a_15182_170# vdd 1.09fF **FLOATING
C18975 divbuf_1/a_14702_170# vdd 1.10fF **FLOATING
C18976 divbuf_1/a_14222_170# vdd 1.10fF **FLOATING
C18977 divbuf_1/a_13742_170# vdd 1.09fF **FLOATING
C18978 divbuf_1/a_13252_170# vdd 1.09fF **FLOATING
C18979 divbuf_1/a_12772_170# vdd 1.07fF **FLOATING
C18980 divbuf_1/a_12282_170# vdd 1.09fF **FLOATING
C18981 divbuf_1/a_11802_170# vdd 1.09fF **FLOATING
C18982 divbuf_1/a_11312_170# vdd 1.10fF **FLOATING
C18983 divbuf_1/a_10212_170# vdd 1.09fF **FLOATING
C18984 divbuf_1/a_9732_170# vdd 1.09fF **FLOATING
C18985 divbuf_1/a_9242_170# vdd 1.09fF **FLOATING
C18986 divbuf_1/a_8762_170# vdd 1.09fF **FLOATING
C18987 divbuf_1/a_8272_170# vdd 1.07fF **FLOATING
C18988 divbuf_1/a_7792_170# vdd 1.09fF **FLOATING
C18989 divbuf_1/a_7302_170# vdd 1.09fF **FLOATING
C18990 divbuf_1/a_6822_170# vdd 1.09fF **FLOATING
C18991 divbuf_1/a_6332_170# vdd 1.09fF **FLOATING
C18992 divbuf_1/a_5852_170# vdd 1.09fF **FLOATING
C18993 divbuf_1/a_5362_170# vdd 1.09fF **FLOATING
C18994 divbuf_1/a_4882_170# vdd 1.09fF **FLOATING
C18995 divbuf_1/a_4392_170# vdd 1.07fF **FLOATING
C18996 divbuf_1/a_3912_170# vdd 1.09fF **FLOATING
C18997 divbuf_1/a_3422_170# vdd 1.10fF **FLOATING
C18998 divbuf_1/a_2322_170# vdd 1.09fF **FLOATING
C18999 divbuf_1/a_1842_170# vdd 1.09fF **FLOATING
C19000 divbuf_1/a_1352_170# vdd 1.10fF **FLOATING
C19001 divbuf_1/a_492_n240# vdd 2.46fF **FLOATING
C19002 pd_div_0/divider_0/and_0/Z1 vdd 0.33fF
C19003 pd_div_0/divider_0/and_0/B vdd 1.79fF
C19004 pd_div_0/divider_0/and_0/A vdd 1.66fF
C19005 pd_div_0/divider_0/and_0/out1 vdd 2.71fF
C19006 pd_div_0/divider_0/tspc_2/Z4 vdd 0.42fF
C19007 pd_div_0/bufin vdd 9.07fF
C19008 pd_div_0/divider_0/tspc_2/Z3 vdd 2.00fF
C19009 pd_div_0/divider_0/tspc_2/Z2 vdd 1.29fF
C19010 pd_div_0/divider_0/tspc_2/Z1 vdd 0.99fF
C19011 pd_div_0/divider_0/nor_0/B vdd 5.25fF
C19012 pd_div_0/divider_0/tspc_2/a_630_n680# vdd 0.53fF **FLOATING
C19013 pd_div_0/divider_0/tspc_1/Z4 vdd 0.42fF
C19014 pd_div_0/divider_0/tspc_1/Q vdd 2.79fF
C19015 pd_div_0/divider_0/tspc_1/Z3 vdd 2.00fF
C19016 pd_div_0/divider_0/tspc_1/Z2 vdd 1.29fF
C19017 pd_div_0/divider_0/tspc_1/Z1 vdd 0.99fF
C19018 pd_div_0/divider_0/nor_1/B vdd 5.95fF
C19019 pd_div_0/divider_0/tspc_1/a_630_n680# vdd 0.53fF **FLOATING
C19020 pd_div_0/divider_0/tspc_0/Z4 vdd 0.42fF
C19021 pd_div_0/divider_0/tspc_0/Q vdd 2.81fF
C19022 pd_div_0/divider_0/tspc_0/Z3 vdd 2.00fF
C19023 pd_div_0/divider_0/tspc_0/Z2 vdd 1.30fF
C19024 pd_div_0/divider_0/tspc_0/Z1 vdd 0.99fF
C19025 pd_div_0/divider_0/nor_1/A vdd 6.02fF
C19026 pd_div_0/divider_0/tspc_0/a_630_n680# vdd 0.53fF **FLOATING
C19027 pd_div_0/divider_0/clk vdd 5.63fF
C19028 pd_div_0/divider_0/prescaler_0/Out vdd 4.13fF
C19029 pd_div_0/divider_0/prescaler_0/nand_1/z1 vdd 0.20fF
C19030 gnd vdd 78.43fF
C19031 pd_div_0/divider_0/prescaler_0/tspc_2/D vdd 2.59fF
C19032 pd_div_0/divider_0/prescaler_0/tspc_0/Q vdd 3.30fF
C19033 pd_div_0/divider_0/prescaler_0/tspc_1/Q vdd 2.78fF
C19034 pd_div_0/divider_0/prescaler_0/nand_0/z1 vdd 0.20fF
C19035 pd_div_0/divider_0/prescaler_0/tspc_0/D vdd 3.07fF
C19036 pd_div_0/divider_0/and_0/OUT vdd 5.35fF
C19037 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.42fF
C19038 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.00fF
C19039 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.30fF
C19040 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C19041 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 0.53fF **FLOATING
C19042 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 1.89fF **FLOATING
C19043 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.42fF
C19044 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.00fF
C19045 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.31fF
C19046 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C19047 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 0.53fF **FLOATING
C19048 pd_div_0/divider_0/prescaler_0/m1_2700_2190# vdd 3.99fF **FLOATING
C19049 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.42fF
C19050 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.00fF
C19051 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.30fF
C19052 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C19053 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 0.53fF **FLOATING
C19054 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 1.89fF **FLOATING
C19055 pd_div_0/divider_0/nor_1/Z1 vdd 1.33fF
C19056 pd_div_0/divider_0/nor_0/Z1 vdd 1.33fF
C19057 pd_div_0/divbuf_0/OUT5 vdd 16.40fF
C19058 pd_div_0/divbuf_0/OUT4 vdd 100.06fF
C19059 pd_div_0/divbuf_0/OUT3 vdd 27.01fF
C19060 pd_div_0/divbuf_0/OUT2 vdd 8.71fF
C19061 pd_div_0/divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C19062 pd_div_0/divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C19063 pd_div_0/divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C19064 pd_div_0/divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C19065 pd_div_0/divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C19066 pd_div_0/divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C19067 pd_div_0/divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C19068 pd_div_0/divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C19069 pd_div_0/divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C19070 pd_div_0/divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C19071 pd_div_0/divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C19072 pd_div_0/divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C19073 pd_div_0/divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C19074 pd_div_0/divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C19075 pd_div_0/divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C19076 pd_div_0/divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C19077 pd_div_0/divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C19078 pd_div_0/divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C19079 pd_div_0/divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C19080 pd_div_0/divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C19081 pd_div_0/divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C19082 pd_div_0/divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C19083 pd_div_0/divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C19084 pd_div_0/divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C19085 pd_div_0/divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C19086 pd_div_0/divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C19087 pd_div_0/divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C19088 pd_div_0/divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C19089 pd_div_0/divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C19090 pd_div_0/divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C19091 pd_div_0/divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C19092 pd_div_0/divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C19093 pd_div_0/divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C19094 pd_div_0/divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C19095 pd_div_0/divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C19096 pd_div_0/divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C19097 pd_div_0/divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C19098 pd_div_0/divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C19099 pd_div_0/divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C19100 pd_div_0/divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C19101 pd_div_0/divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C19102 pd_div_0/divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C19103 pd_div_0/divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C19104 pd_div_0/divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C19105 pd_div_0/divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C19106 pd_div_0/divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C19107 pd_div_0/divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C19108 pd_div_0/divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C19109 pd_div_0/divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C19110 pd_div_0/divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C19111 pd_div_0/divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C19112 pd_div_0/divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C19113 pd_div_0/divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C19114 pd_div_0/divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C19115 pd_div_0/divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C19116 pd_div_0/divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C19117 pd_div_0/divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C19118 pd_div_0/divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C19119 pd_div_0/divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C19120 pd_div_0/divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C19121 pd_div_0/divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C19122 pd_div_0/divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C19123 pd_div_0/divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C19124 pd_div_0/divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C19125 pd_div_0/divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C19126 pd_div_0/divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C19127 pd_div_0/divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C19128 pd_div_0/divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C19129 pd_div_0/divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C19130 pd_div_0/divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C19131 pd_div_0/divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C19132 pd_div_0/divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C19133 pd_div_0/divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C19134 pd_div_0/divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C19135 pd_div_0/divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C19136 pd_div_0/divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C19137 pd_div_0/divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C19138 pd_div_0/divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C19139 pd_div_0/divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C19140 pd_div_0/divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C19141 pd_div_0/divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C19142 pd_div_0/divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C19143 pd_div_0/divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C19144 pd_div_0/divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C19145 pd_div_0/divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C19146 pd_div_0/divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C19147 pd_div_0/divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C19148 pd_div_0/divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C19149 pd_div_0/divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C19150 pd_div_0/divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C19151 pd_div_0/divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C19152 pd_div_0/divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C19153 pd_div_0/divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C19154 pd_div_0/divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C19155 pd_div_0/divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C19156 pd_div_0/divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C19157 pd_div_0/divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C19158 pd_div_0/divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C19159 pd_div_0/divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C19160 pd_div_0/divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C19161 pd_div_0/divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C19162 pd_div_0/divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C19163 pd_div_0/divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C19164 pd_div_0/divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C19165 pd_div_0/divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C19166 pd_div_0/divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C19167 pd_div_0/divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C19168 pd_div_0/divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C19169 pd_div_0/divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C19170 pd_div_0/divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C19171 pd_div_0/divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C19172 pd_div_0/divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C19173 pd_div_0/divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C19174 pd_div_0/divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C19175 pd_div_0/divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C19176 pd_div_0/divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C19177 pd_div_0/divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C19178 pd_div_0/divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C19179 pd_div_0/divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C19180 pd_div_0/divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C19181 pd_div_0/divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C19182 pd_div_0/divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C19183 pd_div_0/divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C19184 pd_div_0/divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C19185 pd_div_0/divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C19186 pd_div_0/divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C19187 pd_div_0/divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C19188 pd_div_0/divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C19189 pd_div_0/divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C19190 pd_div_0/divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C19191 pd_div_0/divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C19192 pd_div_0/divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C19193 pd_div_0/divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C19194 pd_div_0/divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C19195 pd_div_0/divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C19196 pd_div_0/divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C19197 pd_div_0/divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C19198 pd_div_0/divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C19199 pd_div_0/divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C19200 pd_div_0/divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C19201 pd_div_0/divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C19202 pd_div_0/divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C19203 pd_div_0/divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C19204 pd_div_0/divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C19205 pd_div_0/divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C19206 pd_div_0/divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C19207 pd_div_0/divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C19208 pd_div_0/divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C19209 pd_div_0/divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C19210 pd_div_0/divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C19211 pd_div_0/divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C19212 pd_div_0/divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C19213 pd_div_0/divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C19214 pd_div_0/divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C19215 pd_div_0/divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C19216 pd_div_0/divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C19217 pd_div_0/divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C19218 pd_div_0/divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C19219 pd_div_0/divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C19220 pd_div_0/divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C19221 pd_div_0/divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C19222 pd_div_0/divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C19223 pd_div_0/divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C19224 pd_div_0/divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C19225 pd_div_0/divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C19226 pd_div_0/divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C19227 pd_div_0/divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C19228 pd_div_0/divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C19229 pd_div_0/divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C19230 pd_div_0/divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C19231 pd_div_0/divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C19232 pd_div_0/divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C19233 pd_div_0/divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C19234 pd_div_0/divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C19235 pd_div_0/divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C19236 pd_div_0/divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C19237 pd_div_0/divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C19238 pd_div_0/divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C19239 pd_div_0/divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C19240 pd_div_0/divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C19241 pd_div_0/divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C19242 pd_div_0/divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C19243 pd_div_0/divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C19244 pd_div_0/divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C19245 pd_div_0/divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C19246 pd_div_0/divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C19247 pd_div_0/divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C19248 pd_div_0/divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C19249 pd_div_0/divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C19250 pd_div_0/divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C19251 pd_div_0/divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C19252 pd_div_0/divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C19253 pd_div_0/divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C19254 pd_div_0/divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C19255 pd_div_0/divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C19256 pd_div_0/divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C19257 pd_div_0/divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C19258 pd_div_0/divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C19259 pd_div_0/divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C19260 pd_div_0/divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C19261 pd_div_0/divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C19262 pd_div_0/divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C19263 pd_div_0/divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C19264 pd_div_0/divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C19265 pd_div_0/divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C19266 pd_div_0/divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C19267 pd_div_0/divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C19268 pd_div_0/divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C19269 pd_div_0/divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C19270 pd_div_0/divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C19271 pd_div_0/divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C19272 pd_div_0/divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C19273 pd_div_0/divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C19274 pd_div_0/divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C19275 pd_div_0/divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C19276 pd_div_0/divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C19277 pd_div_0/divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C19278 pd_div_0/divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C19279 pd_div_0/divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C19280 pd_div_0/divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C19281 pd_div_0/divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C19282 pd_div_0/divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C19283 pd_div_0/divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C19284 pd_div_0/divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C19285 pd_div_0/divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C19286 pd_div_0/divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C19287 pd_div_0/divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C19288 pd_div_0/divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C19289 pd_div_0/divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C19290 pd_div_0/divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C19291 pd_div_0/divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C19292 pd_div_0/divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C19293 pd_div_0/divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C19294 pd_div_0/divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C19295 pd_div_0/divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C19296 pd_div_0/divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C19297 pd_div_0/divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C19298 pd_div_0/divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C19299 pd_div_0/divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C19300 pd_div_0/divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C19301 pd_div_0/divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C19302 pd_div_0/divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C19303 pd_div_0/divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C19304 pd_div_0/divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C19305 pd_div_0/divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C19306 pd_div_0/divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C19307 pd_div_0/divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C19308 pd_div_0/divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C19309 pd_div_0/divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C19310 pd_div_0/divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C19311 pd_div_0/divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C19312 pd_div_0/divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C19313 pd_div_0/divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C19314 pd_div_0/divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C19315 pd_div_0/divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C19316 pd_div_0/divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C19317 pd_div_0/divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C19318 pd_div_0/divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C19319 pd_div_0/divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C19320 pd_div_0/divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C19321 pd_div_0/divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C19322 pd_div_0/divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C19323 pd_div_0/divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C19324 pd_div_0/divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C19325 pd_div_0/divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C19326 pd_div_0/divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C19327 pd_div_0/divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C19328 pd_div_0/divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C19329 pd_div_0/divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C19330 pd_div_0/divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C19331 pd_div_0/divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C19332 pd_div_0/divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C19333 pd_div_0/divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C19334 pd_div_0/divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C19335 pd_div_0/divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C19336 pd_div_0/divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C19337 pd_div_0/divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C19338 pd_div_0/divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C19339 pd_div_0/divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C19340 pd_div_0/divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C19341 pd_div_0/divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C19342 pd_div_0/divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C19343 pd_div_0/divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C19344 pd_div_0/divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C19345 pd_div_0/divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C19346 pd_div_0/divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C19347 pd_div_0/divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C19348 pd_div_0/divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C19349 pd_div_0/divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C19350 pd_div_0/divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C19351 pd_div_0/divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C19352 pd_div_0/divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C19353 pd_div_0/divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C19354 pd_div_0/divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C19355 pd_div_0/divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C19356 pd_div_0/divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C19357 pd_div_0/divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C19358 pd_div_0/divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C19359 pd_div_0/divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C19360 pd_div_0/divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C19361 pd_div_0/divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C19362 pd_div_0/divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C19363 pd_div_0/divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C19364 pd_div_0/divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C19365 pd_div_0/divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C19366 pd_div_0/divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C19367 pd_div_0/divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C19368 pd_div_0/divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C19369 pd_div_0/divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C19370 pd_div_0/divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C19371 pd_div_0/divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C19372 pd_div_0/divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C19373 pd_div_0/divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C19374 pd_div_0/divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C19375 pd_div_0/divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C19376 pd_div_0/divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C19377 pd_div_0/divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C19378 pd_div_0/divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C19379 pd_div_0/divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C19380 pd_div_0/divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C19381 pd_div_0/divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C19382 pd_div_0/divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C19383 pd_div_0/divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C19384 pd_div_0/divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C19385 pd_div_0/divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C19386 pd_div_0/divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C19387 pd_div_0/divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C19388 pd_div_0/divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C19389 pd_div_0/divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C19390 pd_div_0/divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C19391 pd_div_0/divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C19392 pd_div_0/divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C19393 pd_div_0/divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C19394 pd_div_0/divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C19395 pd_div_0/divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C19396 pd_div_0/divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C19397 pd_div_0/divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C19398 pd_div_0/divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C19399 pd_div_0/divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C19400 pd_div_0/divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C19401 pd_div_0/divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C19402 pd_div_0/divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C19403 pd_div_0/divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C19404 pd_div_0/divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C19405 pd_div_0/divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C19406 pd_div_0/divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C19407 pd_div_0/divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C19408 pd_div_0/divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C19409 pd_div_0/divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C19410 pd_div_0/divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C19411 pd_div_0/divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C19412 pd_div_0/divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C19413 pd_div_0/divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C19414 pd_div_0/divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C19415 pd_div_0/divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C19416 pd_div_0/divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C19417 pd_div_0/divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C19418 pd_div_0/divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C19419 pd_div_0/divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C19420 pd_div_0/divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C19421 pd_div_0/divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C19422 pd_div_0/divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C19423 pd_div_0/divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C19424 pd_div_0/divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C19425 pd_div_0/divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C19426 pd_div_0/divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C19427 pd_div_0/divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C19428 pd_div_0/divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C19429 pd_div_0/divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C19430 pd_div_0/divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C19431 pd_div_0/divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C19432 pd_div_0/divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C19433 pd_div_0/divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C19434 pd_div_0/divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C19435 pd_div_0/divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C19436 pd_div_0/divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C19437 pd_div_0/divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C19438 pd_div_0/divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C19439 pd_div_0/divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C19440 pd_div_0/divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C19441 pd_div_0/divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C19442 pd_div_0/divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C19443 pd_div_0/divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C19444 pd_div_0/divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C19445 pd_div_0/divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C19446 pd_div_0/divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C19447 pd_div_0/divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C19448 pd_div_0/divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C19449 pd_div_0/divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C19450 pd_div_0/divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C19451 pd_div_0/divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C19452 pd_div_0/divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C19453 pd_div_0/divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C19454 pd_div_0/divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C19455 pd_div_0/divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C19456 pd_div_0/divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C19457 pd_div_0/divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C19458 pd_div_0/divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C19459 pd_div_0/divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C19460 pd_div_0/divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C19461 pd_div_0/divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C19462 pd_div_0/divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C19463 pd_div_0/divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C19464 pd_div_0/divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C19465 pd_div_0/divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C19466 pd_div_0/divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C19467 pd_div_0/divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C19468 pd_div_0/divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C19469 pd_div_0/divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C19470 pd_div_0/divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C19471 pd_div_0/divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C19472 pd_div_0/divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C19473 pd_div_0/divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C19474 pd_div_0/divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C19475 pd_div_0/divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C19476 pd_div_0/divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C19477 pd_div_0/divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C19478 pd_div_0/divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C19479 pd_div_0/divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C19480 pd_div_0/divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C19481 pd_div_0/divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C19482 pd_div_0/divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C19483 pd_div_0/divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C19484 pd_div_0/divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C19485 pd_div_0/divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C19486 pd_div_0/divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C19487 pd_div_0/divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C19488 pd_div_0/divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C19489 pd_div_0/divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C19490 pd_div_0/divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C19491 pd_div_0/divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C19492 pd_div_0/divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C19493 pd_div_0/divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C19494 pd_div_0/divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C19495 pd_div_0/divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C19496 pd_div_0/divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C19497 pd_div_0/divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C19498 pd_div_0/divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C19499 pd_div_0/divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C19500 pd_div_0/divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C19501 pd_div_0/divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C19502 pd_div_0/divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C19503 pd_div_0/divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C19504 pd_div_0/divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C19505 pd_div_0/divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C19506 pd_div_0/divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C19507 pd_div_0/divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C19508 pd_div_0/divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C19509 pd_div_0/divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C19510 pd_div_0/divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C19511 pd_div_0/divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C19512 pd_div_0/divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C19513 pd_div_0/divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C19514 pd_div_0/divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C19515 pd_div_0/divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C19516 pd_div_0/divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C19517 pd_div_0/divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C19518 pd_div_0/divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C19519 pd_div_0/divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C19520 pd_div_0/divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C19521 pd_div_0/divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C19522 pd_div_0/divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C19523 pd_div_0/divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C19524 pd_div_0/divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C19525 pd_div_0/divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C19526 pd_div_0/divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C19527 pd_div_0/divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C19528 pd_div_0/divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C19529 pd_div_0/divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C19530 pd_div_0/divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C19531 pd_div_0/divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C19532 pd_div_0/divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C19533 pd_div_0/divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C19534 pd_div_0/divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C19535 pd_div_0/divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C19536 pd_div_0/divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C19537 pd_div_0/divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C19538 pd_div_0/divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C19539 pd_div_0/divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C19540 pd_div_0/divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C19541 pd_div_0/divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C19542 pd_div_0/divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C19543 pd_div_0/divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C19544 pd_div_0/divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C19545 pd_div_0/divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C19546 pd_div_0/divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C19547 pd_div_0/divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C19548 pd_div_0/divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C19549 pd_div_0/divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C19550 pd_div_0/divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C19551 pd_div_0/divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C19552 pd_div_0/divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C19553 pd_div_0/divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C19554 pd_div_0/divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C19555 pd_div_0/divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C19556 pd_div_0/divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C19557 pd_div_0/divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C19558 pd_div_0/divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C19559 pd_div_0/divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C19560 pd_div_0/divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C19561 pd_div_0/divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C19562 pd_div_0/divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C19563 pd_div_0/divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C19564 pd_div_0/divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C19565 pd_div_0/divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C19566 pd_div_0/divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C19567 pd_div_0/divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C19568 pd_div_0/divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C19569 pd_div_0/divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C19570 pd_div_0/divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C19571 pd_div_0/divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C19572 pd_div_0/divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C19573 pd_div_0/divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C19574 pd_div_0/divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C19575 pd_div_0/divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C19576 pd_div_0/divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C19577 pd_div_0/divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C19578 pd_div_0/divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C19579 pd_div_0/divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C19580 pd_div_0/divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C19581 pd_div_0/divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C19582 pd_div_0/divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C19583 pd_div_0/divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C19584 pd_div_0/divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C19585 pd_div_0/divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C19586 pd_div_0/divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C19587 pd_div_0/divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C19588 pd_div_0/divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C19589 pd_div_0/divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C19590 pd_div_0/divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C19591 pd_div_0/divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C19592 pd_div_0/divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C19593 pd_div_0/divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C19594 pd_div_0/divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C19595 pd_div_0/divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C19596 pd_div_0/divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C19597 pd_div_0/divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C19598 pd_div_0/divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C19599 pd_div_0/divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C19600 pd_div_0/divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C19601 pd_div_0/divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C19602 pd_div_0/divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C19603 pd_div_0/divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C19604 pd_div_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C19605 pd_div_0/pd_0/and_pd_0/Z1 vdd 0.39fF
C19606 pd_div_0/pd_0/and_pd_0/Out1 vdd 2.22fF
C19607 pd_div_0/pd_0/tspc_r_1/z5 vdd 1.10fF
C19608 pd_div_0/pd_0/tspc_r_1/Z4 vdd 1.07fF
C19609 pd_div_0/pd_0/tspc_r_1/Qbar vdd 0.88fF
C19610 pd_div_0/pd_0/tspc_r_1/Z2 vdd 1.22fF
C19611 pd_div_0/pd_0/tspc_r_1/Z1 vdd 0.67fF
C19612 pd_div_0/pd_0/UP vdd 2.30fF
C19613 pd_div_0/pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C19614 pd_div_0/pd_0/tspc_r_1/Z3 vdd 2.12fF
C19615 pd_div_0/pd_0/REF vdd 1.86fF
C19616 pd_div_0/pd_0/tspc_r_0/z5 vdd 1.10fF
C19617 pd_div_0/pd_0/tspc_r_0/Z4 vdd 1.07fF
C19618 pd_div_0/pd_0/R vdd 3.05fF
C19619 pd_div_0/pd_0/tspc_r_0/Qbar vdd 0.79fF
C19620 pd_div_0/pd_0/tspc_r_0/Z2 vdd 1.22fF
C19621 pd_div_0/pd_0/tspc_r_0/Z1 vdd 0.67fF
C19622 pd_div_0/pd_0/DOWN vdd 3.17fF
C19623 pd_div_0/pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C19624 pd_div_0/pd_0/tspc_r_0/Z3 vdd 2.12fF
C19625 pd_div_0/div vdd 8.07fF
C19626 divbuf_0/OUT vdd 3.28fF
C19627 divbuf_0/OUT5 vdd 16.40fF
C19628 divbuf_0/OUT4 vdd 100.06fF
C19629 divbuf_0/OUT3 vdd 27.01fF
C19630 divbuf_0/OUT2 vdd 8.71fF
C19631 divbuf_0/IN vdd 0.89fF
C19632 divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C19633 divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C19634 divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C19635 divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C19636 divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C19637 divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C19638 divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C19639 divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C19640 divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C19641 divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C19642 divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C19643 divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C19644 divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C19645 divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C19646 divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C19647 divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C19648 divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C19649 divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C19650 divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C19651 divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C19652 divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C19653 divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C19654 divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C19655 divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C19656 divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C19657 divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C19658 divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C19659 divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C19660 divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C19661 divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C19662 divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C19663 divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C19664 divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C19665 divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C19666 divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C19667 divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C19668 divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C19669 divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C19670 divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C19671 divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C19672 divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C19673 divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C19674 divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C19675 divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C19676 divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C19677 divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C19678 divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C19679 divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C19680 divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C19681 divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C19682 divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C19683 divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C19684 divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C19685 divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C19686 divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C19687 divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C19688 divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C19689 divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C19690 divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C19691 divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C19692 divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C19693 divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C19694 divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C19695 divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C19696 divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C19697 divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C19698 divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C19699 divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C19700 divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C19701 divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C19702 divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C19703 divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C19704 divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C19705 divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C19706 divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C19707 divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C19708 divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C19709 divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C19710 divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C19711 divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C19712 divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C19713 divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C19714 divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C19715 divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C19716 divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C19717 divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C19718 divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C19719 divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C19720 divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C19721 divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C19722 divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C19723 divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C19724 divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C19725 divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C19726 divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C19727 divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C19728 divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C19729 divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C19730 divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C19731 divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C19732 divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C19733 divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C19734 divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C19735 divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C19736 divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C19737 divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C19738 divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C19739 divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C19740 divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C19741 divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C19742 divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C19743 divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C19744 divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C19745 divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C19746 divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C19747 divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C19748 divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C19749 divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C19750 divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C19751 divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C19752 divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C19753 divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C19754 divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C19755 divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C19756 divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C19757 divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C19758 divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C19759 divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C19760 divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C19761 divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C19762 divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C19763 divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C19764 divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C19765 divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C19766 divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C19767 divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C19768 divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C19769 divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C19770 divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C19771 divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C19772 divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C19773 divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C19774 divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C19775 divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C19776 divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C19777 divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C19778 divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C19779 divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C19780 divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C19781 divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C19782 divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C19783 divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C19784 divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C19785 divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C19786 divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C19787 divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C19788 divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C19789 divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C19790 divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C19791 divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C19792 divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C19793 divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C19794 divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C19795 divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C19796 divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C19797 divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C19798 divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C19799 divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C19800 divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C19801 divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C19802 divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C19803 divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C19804 divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C19805 divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C19806 divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C19807 divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C19808 divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C19809 divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C19810 divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C19811 divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C19812 divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C19813 divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C19814 divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C19815 divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C19816 divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C19817 divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C19818 divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C19819 divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C19820 divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C19821 divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C19822 divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C19823 divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C19824 divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C19825 divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C19826 divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C19827 divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C19828 divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C19829 divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C19830 divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C19831 divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C19832 divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C19833 divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C19834 divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C19835 divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C19836 divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C19837 divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C19838 divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C19839 divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C19840 divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C19841 divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C19842 divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C19843 divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C19844 divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C19845 divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C19846 divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C19847 divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C19848 divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C19849 divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C19850 divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C19851 divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C19852 divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C19853 divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C19854 divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C19855 divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C19856 divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C19857 divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C19858 divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C19859 divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C19860 divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C19861 divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C19862 divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C19863 divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C19864 divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C19865 divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C19866 divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C19867 divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C19868 divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C19869 divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C19870 divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C19871 divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C19872 divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C19873 divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C19874 divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C19875 divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C19876 divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C19877 divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C19878 divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C19879 divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C19880 divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C19881 divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C19882 divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C19883 divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C19884 divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C19885 divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C19886 divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C19887 divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C19888 divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C19889 divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C19890 divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C19891 divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C19892 divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C19893 divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C19894 divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C19895 divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C19896 divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C19897 divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C19898 divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C19899 divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C19900 divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C19901 divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C19902 divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C19903 divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C19904 divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C19905 divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C19906 divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C19907 divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C19908 divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C19909 divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C19910 divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C19911 divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C19912 divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C19913 divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C19914 divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C19915 divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C19916 divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C19917 divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C19918 divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C19919 divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C19920 divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C19921 divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C19922 divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C19923 divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C19924 divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C19925 divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C19926 divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C19927 divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C19928 divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C19929 divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C19930 divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C19931 divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C19932 divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C19933 divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C19934 divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C19935 divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C19936 divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C19937 divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C19938 divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C19939 divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C19940 divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C19941 divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C19942 divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C19943 divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C19944 divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C19945 divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C19946 divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C19947 divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C19948 divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C19949 divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C19950 divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C19951 divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C19952 divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C19953 divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C19954 divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C19955 divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C19956 divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C19957 divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C19958 divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C19959 divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C19960 divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C19961 divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C19962 divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C19963 divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C19964 divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C19965 divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C19966 divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C19967 divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C19968 divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C19969 divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C19970 divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C19971 divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C19972 divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C19973 divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C19974 divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C19975 divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C19976 divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C19977 divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C19978 divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C19979 divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C19980 divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C19981 divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C19982 divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C19983 divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C19984 divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C19985 divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C19986 divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C19987 divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C19988 divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C19989 divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C19990 divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C19991 divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C19992 divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C19993 divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C19994 divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C19995 divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C19996 divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C19997 divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C19998 divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C19999 divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C20000 divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C20001 divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C20002 divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C20003 divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C20004 divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C20005 divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C20006 divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C20007 divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C20008 divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C20009 divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C20010 divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C20011 divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C20012 divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C20013 divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C20014 divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C20015 divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C20016 divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C20017 divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C20018 divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C20019 divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C20020 divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C20021 divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C20022 divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C20023 divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C20024 divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C20025 divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C20026 divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C20027 divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C20028 divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C20029 divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C20030 divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C20031 divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C20032 divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C20033 divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C20034 divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C20035 divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C20036 divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C20037 divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C20038 divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C20039 divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C20040 divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C20041 divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C20042 divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C20043 divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C20044 divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C20045 divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C20046 divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C20047 divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C20048 divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C20049 divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C20050 divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C20051 divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C20052 divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C20053 divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C20054 divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C20055 divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C20056 divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C20057 divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C20058 divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C20059 divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C20060 divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C20061 divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C20062 divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C20063 divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C20064 divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C20065 divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C20066 divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C20067 divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C20068 divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C20069 divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C20070 divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C20071 divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C20072 divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C20073 divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C20074 divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C20075 divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C20076 divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C20077 divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C20078 divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C20079 divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C20080 divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C20081 divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C20082 divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C20083 divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C20084 divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C20085 divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C20086 divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C20087 divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C20088 divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C20089 divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C20090 divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C20091 divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C20092 divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C20093 divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C20094 divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C20095 divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C20096 divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C20097 divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C20098 divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C20099 divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C20100 divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C20101 divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C20102 divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C20103 divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C20104 divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C20105 divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C20106 divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C20107 divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C20108 divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C20109 divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C20110 divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C20111 divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C20112 divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C20113 divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C20114 divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C20115 divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C20116 divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C20117 divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C20118 divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C20119 divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C20120 divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C20121 divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C20122 divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C20123 divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C20124 divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C20125 divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C20126 divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C20127 divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C20128 divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C20129 divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C20130 divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C20131 divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C20132 divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C20133 divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C20134 divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C20135 divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C20136 divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C20137 divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C20138 divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C20139 divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C20140 divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C20141 divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C20142 divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C20143 divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C20144 divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C20145 divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C20146 divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C20147 divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C20148 divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C20149 divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C20150 divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C20151 divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C20152 divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C20153 divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C20154 divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C20155 divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C20156 divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C20157 divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C20158 divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C20159 divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C20160 divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C20161 divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C20162 divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C20163 divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C20164 divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C20165 divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C20166 divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C20167 divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C20168 divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C20169 divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C20170 divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C20171 divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C20172 divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C20173 divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C20174 divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C20175 divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C20176 ro_complete_0/cbank_2/v vdd 17.84fF
C20177 ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C20178 ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C20179 ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C20180 ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C20181 ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C20182 ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C20183 ro_complete_0/cbank_1/v vdd 16.34fF
C20184 ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C20185 ro_complete_0/a0 vdd 7.88fF
C20186 ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C20187 ro_complete_0/a1 vdd 5.39fF
C20188 ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C20189 ro_complete_0/a3 vdd 6.85fF
C20190 ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C20191 ro_complete_0/a2 vdd 5.48fF
C20192 ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C20193 ro_complete_0/a4 vdd 5.36fF
C20194 ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C20195 ro_complete_0/a5 vdd 5.19fF
C20196 ro_complete_0/cbank_0/v vdd 14.98fF
C20197 ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C20198 ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C20199 ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C20200 ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C20201 ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C20202 ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C20203 ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C20204 ro_div_0/divider_0/and_0/Z1 vdd 0.33fF
C20205 ro_div_0/divider_0/and_0/B vdd 1.79fF
C20206 ro_div_0/divider_0/and_0/A vdd 1.66fF
C20207 ro_div_0/divider_0/and_0/out1 vdd 2.71fF
C20208 ro_div_0/divider_0/tspc_2/Z4 vdd 0.42fF
C20209 ro_div_0/divbuf_0/IN vdd 9.25fF
C20210 ro_div_0/divider_0/tspc_2/Z3 vdd 2.00fF
C20211 ro_div_0/divider_0/tspc_2/Z2 vdd 1.29fF
C20212 ro_div_0/divider_0/tspc_2/Z1 vdd 0.99fF
C20213 ro_div_0/divider_0/nor_0/B vdd 5.25fF
C20214 ro_div_0/divider_0/tspc_2/a_630_n680# vdd 0.53fF **FLOATING
C20215 ro_div_0/divider_0/tspc_1/Z4 vdd 0.42fF
C20216 ro_div_0/divider_0/tspc_1/Q vdd 2.79fF
C20217 ro_div_0/divider_0/tspc_1/Z3 vdd 2.00fF
C20218 ro_div_0/divider_0/tspc_1/Z2 vdd 1.29fF
C20219 ro_div_0/divider_0/tspc_1/Z1 vdd 0.99fF
C20220 ro_div_0/divider_0/nor_1/B vdd 5.95fF
C20221 ro_div_0/divider_0/tspc_1/a_630_n680# vdd 0.53fF **FLOATING
C20222 ro_div_0/divider_0/tspc_0/Z4 vdd 0.42fF
C20223 ro_div_0/divider_0/tspc_0/Q vdd 2.81fF
C20224 ro_div_0/divider_0/tspc_0/Z3 vdd 2.00fF
C20225 ro_div_0/divider_0/tspc_0/Z2 vdd 1.30fF
C20226 ro_div_0/divider_0/tspc_0/Z1 vdd 0.99fF
C20227 ro_div_0/divider_0/nor_1/A vdd 6.02fF
C20228 ro_div_0/divider_0/tspc_0/a_630_n680# vdd 0.53fF **FLOATING
C20229 ro_div_0/divider_0/clk vdd 23.35fF
C20230 ro_div_0/divider_0/prescaler_0/Out vdd 4.13fF
C20231 ro_div_0/divider_0/prescaler_0/nand_1/z1 vdd 0.20fF
C20232 ro_div_0/divider_0/prescaler_0/tspc_2/D vdd 2.59fF
C20233 ro_div_0/divider_0/prescaler_0/tspc_0/Q vdd 3.30fF
C20234 ro_div_0/divider_0/prescaler_0/tspc_1/Q vdd 2.78fF
C20235 ro_div_0/divider_0/prescaler_0/nand_0/z1 vdd 0.20fF
C20236 ro_div_0/divider_0/prescaler_0/tspc_0/D vdd 3.07fF
C20237 ro_div_0/divider_0/and_0/OUT vdd 5.35fF
C20238 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.42fF
C20239 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.00fF
C20240 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.30fF
C20241 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C20242 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 0.53fF **FLOATING
C20243 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 1.89fF **FLOATING
C20244 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.42fF
C20245 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.00fF
C20246 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.31fF
C20247 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C20248 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 0.53fF **FLOATING
C20249 ro_div_0/divider_0/prescaler_0/m1_2700_2190# vdd 3.99fF **FLOATING
C20250 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.42fF
C20251 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.00fF
C20252 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.30fF
C20253 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C20254 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 0.53fF **FLOATING
C20255 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 1.89fF **FLOATING
C20256 ro_div_0/divider_0/nor_1/Z1 vdd 1.33fF
C20257 ro_div_0/divider_0/nor_0/Z1 vdd 1.33fF
C20258 ro_div_0/divbuf_0/OUT vdd 3.35fF
C20259 ro_div_0/divbuf_0/OUT5 vdd 16.40fF
C20260 ro_div_0/divbuf_0/OUT4 vdd 100.06fF
C20261 ro_div_0/divbuf_0/OUT3 vdd 27.01fF
C20262 ro_div_0/divbuf_0/OUT2 vdd 8.71fF
C20263 ro_div_0/divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C20264 ro_div_0/divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C20265 ro_div_0/divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C20266 ro_div_0/divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C20267 ro_div_0/divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C20268 ro_div_0/divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C20269 ro_div_0/divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C20270 ro_div_0/divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C20271 ro_div_0/divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C20272 ro_div_0/divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C20273 ro_div_0/divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C20274 ro_div_0/divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C20275 ro_div_0/divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C20276 ro_div_0/divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C20277 ro_div_0/divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C20278 ro_div_0/divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C20279 ro_div_0/divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C20280 ro_div_0/divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C20281 ro_div_0/divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C20282 ro_div_0/divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C20283 ro_div_0/divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C20284 ro_div_0/divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C20285 ro_div_0/divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C20286 ro_div_0/divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C20287 ro_div_0/divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C20288 ro_div_0/divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C20289 ro_div_0/divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C20290 ro_div_0/divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C20291 ro_div_0/divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C20292 ro_div_0/divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C20293 ro_div_0/divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C20294 ro_div_0/divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C20295 ro_div_0/divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C20296 ro_div_0/divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C20297 ro_div_0/divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C20298 ro_div_0/divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C20299 ro_div_0/divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C20300 ro_div_0/divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C20301 ro_div_0/divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C20302 ro_div_0/divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C20303 ro_div_0/divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C20304 ro_div_0/divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C20305 ro_div_0/divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C20306 ro_div_0/divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C20307 ro_div_0/divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C20308 ro_div_0/divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C20309 ro_div_0/divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C20310 ro_div_0/divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C20311 ro_div_0/divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C20312 ro_div_0/divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C20313 ro_div_0/divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C20314 ro_div_0/divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C20315 ro_div_0/divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C20316 ro_div_0/divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C20317 ro_div_0/divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C20318 ro_div_0/divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C20319 ro_div_0/divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C20320 ro_div_0/divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C20321 ro_div_0/divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C20322 ro_div_0/divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C20323 ro_div_0/divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C20324 ro_div_0/divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C20325 ro_div_0/divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C20326 ro_div_0/divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C20327 ro_div_0/divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C20328 ro_div_0/divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C20329 ro_div_0/divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C20330 ro_div_0/divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C20331 ro_div_0/divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C20332 ro_div_0/divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C20333 ro_div_0/divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C20334 ro_div_0/divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C20335 ro_div_0/divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C20336 ro_div_0/divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C20337 ro_div_0/divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C20338 ro_div_0/divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C20339 ro_div_0/divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C20340 ro_div_0/divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C20341 ro_div_0/divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C20342 ro_div_0/divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C20343 ro_div_0/divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C20344 ro_div_0/divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C20345 ro_div_0/divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C20346 ro_div_0/divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C20347 ro_div_0/divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C20348 ro_div_0/divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C20349 ro_div_0/divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C20350 ro_div_0/divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C20351 ro_div_0/divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C20352 ro_div_0/divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C20353 ro_div_0/divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C20354 ro_div_0/divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C20355 ro_div_0/divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C20356 ro_div_0/divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C20357 ro_div_0/divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C20358 ro_div_0/divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C20359 ro_div_0/divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C20360 ro_div_0/divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C20361 ro_div_0/divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C20362 ro_div_0/divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C20363 ro_div_0/divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C20364 ro_div_0/divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C20365 ro_div_0/divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C20366 ro_div_0/divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C20367 ro_div_0/divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C20368 ro_div_0/divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C20369 ro_div_0/divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C20370 ro_div_0/divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C20371 ro_div_0/divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C20372 ro_div_0/divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C20373 ro_div_0/divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C20374 ro_div_0/divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C20375 ro_div_0/divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C20376 ro_div_0/divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C20377 ro_div_0/divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C20378 ro_div_0/divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C20379 ro_div_0/divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C20380 ro_div_0/divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C20381 ro_div_0/divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C20382 ro_div_0/divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C20383 ro_div_0/divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C20384 ro_div_0/divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C20385 ro_div_0/divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C20386 ro_div_0/divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C20387 ro_div_0/divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C20388 ro_div_0/divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C20389 ro_div_0/divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C20390 ro_div_0/divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C20391 ro_div_0/divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C20392 ro_div_0/divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C20393 ro_div_0/divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C20394 ro_div_0/divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C20395 ro_div_0/divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C20396 ro_div_0/divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C20397 ro_div_0/divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C20398 ro_div_0/divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C20399 ro_div_0/divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C20400 ro_div_0/divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C20401 ro_div_0/divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C20402 ro_div_0/divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C20403 ro_div_0/divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C20404 ro_div_0/divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C20405 ro_div_0/divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C20406 ro_div_0/divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C20407 ro_div_0/divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C20408 ro_div_0/divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C20409 ro_div_0/divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C20410 ro_div_0/divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C20411 ro_div_0/divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C20412 ro_div_0/divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C20413 ro_div_0/divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C20414 ro_div_0/divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C20415 ro_div_0/divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C20416 ro_div_0/divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C20417 ro_div_0/divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C20418 ro_div_0/divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C20419 ro_div_0/divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C20420 ro_div_0/divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C20421 ro_div_0/divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C20422 ro_div_0/divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C20423 ro_div_0/divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C20424 ro_div_0/divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C20425 ro_div_0/divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C20426 ro_div_0/divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C20427 ro_div_0/divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C20428 ro_div_0/divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C20429 ro_div_0/divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C20430 ro_div_0/divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C20431 ro_div_0/divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C20432 ro_div_0/divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C20433 ro_div_0/divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C20434 ro_div_0/divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C20435 ro_div_0/divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C20436 ro_div_0/divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C20437 ro_div_0/divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C20438 ro_div_0/divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C20439 ro_div_0/divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C20440 ro_div_0/divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C20441 ro_div_0/divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C20442 ro_div_0/divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C20443 ro_div_0/divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C20444 ro_div_0/divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C20445 ro_div_0/divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C20446 ro_div_0/divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C20447 ro_div_0/divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C20448 ro_div_0/divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C20449 ro_div_0/divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C20450 ro_div_0/divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C20451 ro_div_0/divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C20452 ro_div_0/divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C20453 ro_div_0/divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C20454 ro_div_0/divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C20455 ro_div_0/divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C20456 ro_div_0/divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C20457 ro_div_0/divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C20458 ro_div_0/divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C20459 ro_div_0/divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C20460 ro_div_0/divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C20461 ro_div_0/divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C20462 ro_div_0/divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C20463 ro_div_0/divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C20464 ro_div_0/divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C20465 ro_div_0/divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C20466 ro_div_0/divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C20467 ro_div_0/divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C20468 ro_div_0/divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C20469 ro_div_0/divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C20470 ro_div_0/divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C20471 ro_div_0/divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C20472 ro_div_0/divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C20473 ro_div_0/divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C20474 ro_div_0/divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C20475 ro_div_0/divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C20476 ro_div_0/divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C20477 ro_div_0/divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C20478 ro_div_0/divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C20479 ro_div_0/divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C20480 ro_div_0/divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C20481 ro_div_0/divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C20482 ro_div_0/divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C20483 ro_div_0/divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C20484 ro_div_0/divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C20485 ro_div_0/divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C20486 ro_div_0/divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C20487 ro_div_0/divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C20488 ro_div_0/divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C20489 ro_div_0/divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C20490 ro_div_0/divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C20491 ro_div_0/divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C20492 ro_div_0/divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C20493 ro_div_0/divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C20494 ro_div_0/divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C20495 ro_div_0/divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C20496 ro_div_0/divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C20497 ro_div_0/divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C20498 ro_div_0/divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C20499 ro_div_0/divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C20500 ro_div_0/divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C20501 ro_div_0/divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C20502 ro_div_0/divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C20503 ro_div_0/divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C20504 ro_div_0/divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C20505 ro_div_0/divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C20506 ro_div_0/divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C20507 ro_div_0/divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C20508 ro_div_0/divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C20509 ro_div_0/divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C20510 ro_div_0/divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C20511 ro_div_0/divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C20512 ro_div_0/divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C20513 ro_div_0/divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C20514 ro_div_0/divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C20515 ro_div_0/divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C20516 ro_div_0/divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C20517 ro_div_0/divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C20518 ro_div_0/divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C20519 ro_div_0/divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C20520 ro_div_0/divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C20521 ro_div_0/divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C20522 ro_div_0/divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C20523 ro_div_0/divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C20524 ro_div_0/divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C20525 ro_div_0/divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C20526 ro_div_0/divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C20527 ro_div_0/divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C20528 ro_div_0/divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C20529 ro_div_0/divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C20530 ro_div_0/divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C20531 ro_div_0/divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C20532 ro_div_0/divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C20533 ro_div_0/divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C20534 ro_div_0/divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C20535 ro_div_0/divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C20536 ro_div_0/divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C20537 ro_div_0/divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C20538 ro_div_0/divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C20539 ro_div_0/divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C20540 ro_div_0/divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C20541 ro_div_0/divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C20542 ro_div_0/divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C20543 ro_div_0/divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C20544 ro_div_0/divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C20545 ro_div_0/divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C20546 ro_div_0/divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C20547 ro_div_0/divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C20548 ro_div_0/divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C20549 ro_div_0/divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C20550 ro_div_0/divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C20551 ro_div_0/divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C20552 ro_div_0/divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C20553 ro_div_0/divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C20554 ro_div_0/divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C20555 ro_div_0/divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C20556 ro_div_0/divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C20557 ro_div_0/divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C20558 ro_div_0/divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C20559 ro_div_0/divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C20560 ro_div_0/divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C20561 ro_div_0/divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C20562 ro_div_0/divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C20563 ro_div_0/divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C20564 ro_div_0/divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C20565 ro_div_0/divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C20566 ro_div_0/divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C20567 ro_div_0/divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C20568 ro_div_0/divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C20569 ro_div_0/divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C20570 ro_div_0/divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C20571 ro_div_0/divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C20572 ro_div_0/divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C20573 ro_div_0/divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C20574 ro_div_0/divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C20575 ro_div_0/divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C20576 ro_div_0/divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C20577 ro_div_0/divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C20578 ro_div_0/divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C20579 ro_div_0/divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C20580 ro_div_0/divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C20581 ro_div_0/divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C20582 ro_div_0/divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C20583 ro_div_0/divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C20584 ro_div_0/divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C20585 ro_div_0/divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C20586 ro_div_0/divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C20587 ro_div_0/divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C20588 ro_div_0/divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C20589 ro_div_0/divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C20590 ro_div_0/divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C20591 ro_div_0/divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C20592 ro_div_0/divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C20593 ro_div_0/divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C20594 ro_div_0/divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C20595 ro_div_0/divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C20596 ro_div_0/divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C20597 ro_div_0/divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C20598 ro_div_0/divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C20599 ro_div_0/divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C20600 ro_div_0/divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C20601 ro_div_0/divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C20602 ro_div_0/divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C20603 ro_div_0/divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C20604 ro_div_0/divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C20605 ro_div_0/divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C20606 ro_div_0/divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C20607 ro_div_0/divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C20608 ro_div_0/divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C20609 ro_div_0/divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C20610 ro_div_0/divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C20611 ro_div_0/divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C20612 ro_div_0/divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C20613 ro_div_0/divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C20614 ro_div_0/divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C20615 ro_div_0/divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C20616 ro_div_0/divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C20617 ro_div_0/divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C20618 ro_div_0/divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C20619 ro_div_0/divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C20620 ro_div_0/divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C20621 ro_div_0/divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C20622 ro_div_0/divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C20623 ro_div_0/divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C20624 ro_div_0/divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C20625 ro_div_0/divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C20626 ro_div_0/divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C20627 ro_div_0/divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C20628 ro_div_0/divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C20629 ro_div_0/divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C20630 ro_div_0/divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C20631 ro_div_0/divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C20632 ro_div_0/divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C20633 ro_div_0/divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C20634 ro_div_0/divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C20635 ro_div_0/divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C20636 ro_div_0/divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C20637 ro_div_0/divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C20638 ro_div_0/divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C20639 ro_div_0/divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C20640 ro_div_0/divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C20641 ro_div_0/divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C20642 ro_div_0/divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C20643 ro_div_0/divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C20644 ro_div_0/divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C20645 ro_div_0/divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C20646 ro_div_0/divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C20647 ro_div_0/divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C20648 ro_div_0/divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C20649 ro_div_0/divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C20650 ro_div_0/divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C20651 ro_div_0/divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C20652 ro_div_0/divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C20653 ro_div_0/divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C20654 ro_div_0/divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C20655 ro_div_0/divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C20656 ro_div_0/divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C20657 ro_div_0/divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C20658 ro_div_0/divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C20659 ro_div_0/divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C20660 ro_div_0/divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C20661 ro_div_0/divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C20662 ro_div_0/divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C20663 ro_div_0/divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C20664 ro_div_0/divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C20665 ro_div_0/divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C20666 ro_div_0/divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C20667 ro_div_0/divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C20668 ro_div_0/divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C20669 ro_div_0/divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C20670 ro_div_0/divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C20671 ro_div_0/divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C20672 ro_div_0/divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C20673 ro_div_0/divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C20674 ro_div_0/divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C20675 ro_div_0/divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C20676 ro_div_0/divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C20677 ro_div_0/divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C20678 ro_div_0/divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C20679 ro_div_0/divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C20680 ro_div_0/divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C20681 ro_div_0/divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C20682 ro_div_0/divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C20683 ro_div_0/divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C20684 ro_div_0/divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C20685 ro_div_0/divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C20686 ro_div_0/divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C20687 ro_div_0/divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C20688 ro_div_0/divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C20689 ro_div_0/divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C20690 ro_div_0/divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C20691 ro_div_0/divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C20692 ro_div_0/divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C20693 ro_div_0/divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C20694 ro_div_0/divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C20695 ro_div_0/divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C20696 ro_div_0/divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C20697 ro_div_0/divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C20698 ro_div_0/divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C20699 ro_div_0/divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C20700 ro_div_0/divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C20701 ro_div_0/divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C20702 ro_div_0/divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C20703 ro_div_0/divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C20704 ro_div_0/divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C20705 ro_div_0/divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C20706 ro_div_0/divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C20707 ro_div_0/divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C20708 ro_div_0/divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C20709 ro_div_0/divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C20710 ro_div_0/divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C20711 ro_div_0/divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C20712 ro_div_0/divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C20713 ro_div_0/divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C20714 ro_div_0/divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C20715 ro_div_0/divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C20716 ro_div_0/divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C20717 ro_div_0/divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C20718 ro_div_0/divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C20719 ro_div_0/divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C20720 ro_div_0/divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C20721 ro_div_0/divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C20722 ro_div_0/divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C20723 ro_div_0/divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C20724 ro_div_0/divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C20725 ro_div_0/divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C20726 ro_div_0/divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C20727 ro_div_0/divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C20728 ro_div_0/divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C20729 ro_div_0/divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C20730 ro_div_0/divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C20731 ro_div_0/divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C20732 ro_div_0/divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C20733 ro_div_0/divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C20734 ro_div_0/divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C20735 ro_div_0/divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C20736 ro_div_0/divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C20737 ro_div_0/divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C20738 ro_div_0/divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C20739 ro_div_0/divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C20740 ro_div_0/divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C20741 ro_div_0/divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C20742 ro_div_0/divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C20743 ro_div_0/divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C20744 ro_div_0/divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C20745 ro_div_0/divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C20746 ro_div_0/divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C20747 ro_div_0/divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C20748 ro_div_0/divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C20749 ro_div_0/divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C20750 ro_div_0/divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C20751 ro_div_0/divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C20752 ro_div_0/divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C20753 ro_div_0/divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C20754 ro_div_0/divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C20755 ro_div_0/divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C20756 ro_div_0/divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C20757 ro_div_0/divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C20758 ro_div_0/divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C20759 ro_div_0/divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C20760 ro_div_0/divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C20761 ro_div_0/divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C20762 ro_div_0/divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C20763 ro_div_0/divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C20764 ro_div_0/divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C20765 ro_div_0/divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C20766 ro_div_0/divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C20767 ro_div_0/divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C20768 ro_div_0/divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C20769 ro_div_0/divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C20770 ro_div_0/divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C20771 ro_div_0/divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C20772 ro_div_0/divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C20773 ro_div_0/divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C20774 ro_div_0/divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C20775 ro_div_0/divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C20776 ro_div_0/divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C20777 ro_div_0/divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C20778 ro_div_0/divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C20779 ro_div_0/divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C20780 ro_div_0/divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C20781 ro_div_0/divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C20782 ro_div_0/divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C20783 ro_div_0/divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C20784 ro_div_0/divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C20785 ro_div_0/divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C20786 ro_div_0/divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C20787 ro_div_0/divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C20788 ro_div_0/divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C20789 ro_div_0/divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C20790 ro_div_0/divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C20791 ro_div_0/divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C20792 ro_div_0/divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C20793 ro_div_0/divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C20794 ro_div_0/divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C20795 ro_div_0/divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C20796 ro_div_0/divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C20797 ro_div_0/divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C20798 ro_div_0/divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C20799 ro_div_0/divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C20800 ro_div_0/divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C20801 ro_div_0/divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C20802 ro_div_0/divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C20803 ro_div_0/divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C20804 ro_div_0/divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C20805 ro_div_0/divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C20806 ro_div_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C20807 ro_div_0/ro_complete_0/cbank_2/v vdd 17.84fF
C20808 ro_div_0/ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C20809 ro_div_0/ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C20810 ro_div_0/ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C20811 ro_div_0/ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C20812 ro_div_0/ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C20813 ro_div_0/ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C20814 ro_div_0/ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C20815 ro_div_0/ro_complete_0/a0 vdd 7.88fF
C20816 ro_div_0/ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C20817 ro_div_0/ro_complete_0/a1 vdd 5.39fF
C20818 ro_div_0/ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C20819 ro_div_0/ro_complete_0/a3 vdd 6.85fF
C20820 ro_div_0/ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C20821 ro_div_0/ro_complete_0/a2 vdd 5.48fF
C20822 ro_div_0/ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C20823 ro_div_0/ro_complete_0/a4 vdd 5.36fF
C20824 ro_div_0/ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C20825 ro_div_0/ro_complete_0/a5 vdd 5.19fF
C20826 ro_div_0/ro_complete_0/cbank_0/v vdd 14.98fF
C20827 ro_div_0/ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C20828 ro_div_0/ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C20829 ro_div_0/ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C20830 ro_div_0/ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C20831 ro_div_0/ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C20832 ro_div_0/ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C20833 ro_div_0/ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C20834 filter_0/v vdd 85.69fF
C20835 filter_0/a_4216_n5230# vdd 418.47fF **FLOATING
C20836 filter_0/a_4216_n2998# vdd 1.03fF **FLOATING
C20837 io_analog[1] vdd 61.29fF
C20838 io_analog[0] vdd 37.70fF
C20839 cp_0/upbar vdd 1.79fF
C20840 cp_0/a_7110_n2840# vdd 0.17fF **FLOATING
C20841 cp_0/a_3060_n2840# vdd 1.71fF **FLOATING
C20842 cp_0/a_7110_0# vdd 0.17fF **FLOATING
C20843 cp_0/a_6370_0# vdd 0.40fF **FLOATING
C20844 cp_0/a_3060_0# vdd 4.16fF **FLOATING
C20845 cp_0/a_1710_0# vdd 6.63fF **FLOATING
C20846 cp_0/a_10_n50# vdd 3.15fF **FLOATING
C20847 pd_0/and_pd_0/Z1 vdd 0.39fF
C20848 pd_0/and_pd_0/Out1 vdd 2.22fF
C20849 pd_0/tspc_r_1/z5 vdd 1.10fF
C20850 pd_0/tspc_r_1/Z4 vdd 1.07fF
C20851 pd_0/tspc_r_1/Qbar vdd 0.88fF
C20852 pd_0/tspc_r_1/Z2 vdd 1.22fF
C20853 pd_0/tspc_r_1/Z1 vdd 0.67fF
C20854 pd_0/UP vdd 7.57fF
C20855 pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C20856 pd_0/tspc_r_1/Z3 vdd 2.12fF
C20857 pd_0/REF vdd 28.01fF
C20858 pd_0/tspc_r_0/z5 vdd 1.10fF
C20859 pd_0/tspc_r_0/Z4 vdd 1.07fF
C20860 pd_0/R vdd 3.05fF
C20861 pd_0/tspc_r_0/Qbar vdd 0.79fF
C20862 pd_0/tspc_r_0/Z2 vdd 1.22fF
C20863 pd_0/tspc_r_0/Z1 vdd 0.67fF
C20864 pd_0/DOWN vdd 9.93fF
C20865 pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C20866 pd_0/tspc_r_0/Z3 vdd 2.12fF
C20867 pd_0/DIV vdd 17.90fF
C20868 ashish_0/Gnd vdd 0.54fF
C20869 ashish_0/vop vdd 16.42fF
C20870 ashish_0/von vdd 16.41fF
C20871 ashish_0/a_150_n710# vdd 1.54fF **FLOATING
.ends
