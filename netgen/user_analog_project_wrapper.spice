* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C2 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C3 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14430_n840# 0.04fF
C4 divbuf_2/a_53310_n1540# divbuf_2/a_53790_n1540# 0.11fF
C5 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_17790_n840# 0.00fF
C6 divbuf_0/a_18582_170# divbuf_0/OUT4 0.19fF
C7 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n840# 0.04fF
C8 divbuf_3/a_14222_n240# divbuf_3/a_14430_n840# 0.02fF
C9 divbuf_3/a_23520_n1600# divbuf_3/a_24000_n1600# 0.26fF
C10 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/a_9630_n840# 0.03fF
C11 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19680_n1600# 0.26fF
C12 divbuf_3/a_15870_n1540# divbuf_3/a_16350_n1540# 0.11fF
C13 divbuf_3/a_46590_n840# divbuf_3/a_46590_n1540# 0.01fF
C14 pd_div_0/divbuf_0/a_26910_n840# pd_div_0/divbuf_0/a_27390_n840# 0.07fF
C15 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C16 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_26910_n1540# 0.19fF
C17 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_0/a_630_n680# 0.04fF
C18 ro_div_0/divbuf_0/a_42270_n840# ro_div_0/divbuf_0/a_42270_n1540# 0.01fF
C19 ro_div_0/divbuf_0/a_11550_n1540# ro_div_0/divbuf_0/a_12030_n1540# 0.11fF
C20 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/a_31682_170# 0.07fF
C21 divbuf_2/a_50880_n1600# divbuf_2/a_50910_n840# 0.04fF
C22 divbuf_2/a_18582_n240# divbuf_2/OUT4 0.04fF
C23 divbuf_0/a_2322_170# divbuf_0/a_2322_n240# 0.01fF
C24 divbuf_0/a_21982_170# divbuf_0/a_22472_170# 0.07fF
C25 pll_full_0/divbuf_0/a_3870_n840# pll_full_0/divbuf_0/a_4350_n840# 0.07fF
C26 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/OUT4 0.19fF
C27 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_3870_n1540# 0.19fF
C28 divbuf_1/a_24480_n1600# divbuf_1/a_24960_n1600# 0.26fF
C29 divbuf_1/a_15182_n240# divbuf_1/a_15390_n840# 0.02fF
C30 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C31 divbuf_0/a_55200_n1600# divbuf_0/a_55680_n1600# 0.26fF
C32 pll_full_0/divbuf_0/a_56670_n1540# pll_full_0/divbuf_0/a_57150_n1540# 0.11fF
C33 divbuf_3/a_13440_n1600# divbuf_3/a_13470_n840# 0.04fF
C34 divbuf_1/a_16830_n1540# divbuf_1/a_17310_n1540# 0.11fF
C35 divbuf_1/a_47550_n840# divbuf_1/a_47550_n1540# 0.01fF
C36 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9150_n840# 0.04fF
C37 divbuf_0/a_47550_n1540# divbuf_0/a_48030_n1540# 0.11fF
C38 divbuf_2/a_28772_n240# divbuf_2/a_29262_n240# 0.04fF
C39 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_27360_n1600# 0.26fF
C40 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_17790_n840# 0.02fF
C41 pll_full_0/divbuf_1/a_19230_n1540# pll_full_0/divbuf_1/a_19710_n1540# 0.11fF
C42 pll_full_0/divbuf_1/a_49950_n840# pll_full_0/divbuf_1/a_49950_n1540# 0.01fF
C43 divbuf_2/a_10110_n840# divbuf_2/a_10110_n1540# 0.01fF
C44 divbuf_2/a_40350_n840# divbuf_2/a_40830_n840# 0.07fF
C45 divbuf_2/a_40320_n1600# divbuf_2/a_40350_n1540# 0.19fF
C46 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/clk 0.04fF
C47 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C48 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54270_n840# 0.04fF
C49 divbuf_3/a_10212_170# divbuf_3/a_10212_n240# 0.01fF
C50 divbuf_3/a_30232_170# divbuf_3/a_30712_170# 0.07fF
C51 divbuf_1/a_14400_n1600# divbuf_1/a_14430_n840# 0.04fF
C52 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/OUT4 0.19fF
C53 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_12772_n240# 0.01fF
C54 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/a_26352_170# 0.07fF
C55 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n840# 0.04fF
C56 divbuf_0/a_6822_n240# divbuf_0/OUT3 0.04fF
C57 divbuf_3/a_2910_n840# divbuf_3/a_3390_n840# 0.07fF
C58 divbuf_3/a_22472_170# divbuf_3/OUT4 0.19fF
C59 divbuf_3/a_2880_n1600# divbuf_3/a_2910_n1540# 0.19fF
C60 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13920_n1600# 0.26fF
C61 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/DOWN 0.03fF
C62 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/OUT4 0.19fF
C63 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59520_n1600# 0.26fF
C64 pd_div_0/divbuf_0/a_5790_n1540# pd_div_0/divbuf_0/a_6270_n1540# 0.11fF
C65 pd_div_0/divbuf_0/a_36510_n840# pd_div_0/divbuf_0/a_36510_n1540# 0.01fF
C66 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_16830_n840# 0.04fF
C67 divbuf_3/a_55710_n1540# divbuf_3/a_56190_n1540# 0.11fF
C68 ro_div_0/divbuf_0/a_51390_n1540# ro_div_0/divbuf_0/a_51870_n1540# 0.11fF
C69 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/a_32652_n240# 0.05fF
C70 divbuf_1/a_27802_170# divbuf_1/a_28292_170# 0.07fF
C71 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/a_34592_n240# 0.01fF
C72 divbuf_0/a_22952_n240# divbuf_0/a_23442_n240# 0.04fF
C73 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C74 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_43710_n1540# 0.19fF
C75 pll_full_0/divbuf_0/a_13470_n840# pll_full_0/divbuf_0/a_13470_n1540# 0.01fF
C76 pll_full_0/divbuf_0/a_43710_n840# pll_full_0/divbuf_0/a_44190_n840# 0.07fF
C77 divbuf_1/a_3870_n840# divbuf_1/a_4350_n840# 0.07fF
C78 divbuf_1/a_21012_170# divbuf_1/OUT4 0.19fF
C79 divbuf_1/a_3840_n1600# divbuf_1/a_3870_n1540# 0.19fF
C80 divbuf_0/a_34590_n840# divbuf_0/a_35070_n840# 0.07fF
C81 divbuf_0/a_4350_n840# divbuf_0/a_4350_n1540# 0.01fF
C82 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n1540# 0.19fF
C83 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/a_14222_n240# 0.01fF
C84 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/a_34112_170# 0.07fF
C85 divbuf_3/a_53280_n1600# divbuf_3/a_53310_n840# 0.04fF
C86 divbuf_3/a_23442_n240# divbuf_3/OUT4 0.04fF
C87 divbuf_1/a_56670_n1540# divbuf_1/a_57150_n1540# 0.11fF
C88 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3390_n840# 0.04fF
C89 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_48990_n840# 0.04fF
C90 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C91 divbuf_2/a_26880_n1600# divbuf_2/a_27360_n1600# 0.26fF
C92 divbuf_2/a_17612_n240# divbuf_2/a_17790_n840# 0.02fF
C93 pll_full_0/divbuf_1/a_6270_n840# pll_full_0/divbuf_1/a_6750_n840# 0.07fF
C94 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/OUT4 0.19fF
C95 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6270_n1540# 0.19fF
C96 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C97 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C98 pll_full_0/divbuf_1/a_59070_n1540# pll_full_0/divbuf_1/a_59550_n1540# 0.11fF
C99 divbuf_2/a_19230_n1540# divbuf_2/a_19710_n1540# 0.11fF
C100 divbuf_2/a_49950_n840# divbuf_2/a_49950_n1540# 0.01fF
C101 divbuf_1/a_30232_170# divbuf_1/a_30232_n240# 0.01fF
C102 divbuf_3/a_31202_n240# divbuf_3/a_31682_n240# 0.05fF
C103 divbuf_1/a_25382_n240# divbuf_1/OUT4 0.04fF
C104 divbuf_1/a_54240_n1600# divbuf_1/a_54270_n840# 0.04fF
C105 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/a_27322_n240# 0.04fF
C106 divbuf_3/a_21600_n1600# divbuf_3/OUT4 0.01fF
C107 divbuf_3/a_42720_n1600# divbuf_3/a_42750_n1540# 0.19fF
C108 divbuf_3/a_12510_n840# divbuf_3/a_12510_n1540# 0.01fF
C109 divbuf_3/a_42750_n840# divbuf_3/a_43230_n840# 0.07fF
C110 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53760_n1600# 0.26fF
C111 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38430_n1540# 0.19fF
C112 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C113 ro_div_0/divbuf_0/a_38430_n840# ro_div_0/divbuf_0/a_38910_n840# 0.07fF
C114 ro_div_0/divbuf_0/a_8190_n840# ro_div_0/divbuf_0/a_8190_n1540# 0.01fF
C115 divbuf_2/a_16800_n1600# divbuf_2/a_16830_n840# 0.04fF
C116 pd_div_0/divbuf_0/a_45630_n1540# pd_div_0/divbuf_0/a_46110_n1540# 0.11fF
C117 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C118 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_56670_n840# 0.04fF
C119 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_2/Z4 0.02fF
C120 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C121 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30720_n1600# 0.26fF
C122 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/a_21150_n840# 0.03fF
C123 divbuf_1/a_32172_n240# divbuf_1/a_32652_n240# 0.05fF
C124 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/a_3390_n840# 0.05fF
C125 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C126 divbuf_0/a_21120_n1600# divbuf_0/a_21600_n1600# 0.26fF
C127 divbuf_0/a_11802_n240# divbuf_0/a_12030_n840# 0.02fF
C128 pll_full_0/divbuf_0/a_22590_n1540# pll_full_0/divbuf_0/a_23070_n1540# 0.11fF
C129 pll_full_0/divbuf_0/a_53310_n840# pll_full_0/divbuf_0/a_53310_n1540# 0.01fF
C130 divbuf_1/a_23520_n1600# divbuf_1/OUT4 0.00fF
C131 divbuf_1/a_43680_n1600# divbuf_1/a_43710_n1540# 0.19fF
C132 divbuf_1/a_13470_n840# divbuf_1/a_13470_n1540# 0.01fF
C133 divbuf_1/a_43710_n840# divbuf_1/a_44190_n840# 0.07fF
C134 divbuf_0/a_44190_n840# divbuf_0/a_44190_n1540# 0.01fF
C135 divbuf_0/a_13470_n1540# divbuf_0/a_13950_n1540# 0.11fF
C136 divbuf_2/a_14222_170# divbuf_2/a_14222_n240# 0.01fF
C137 divbuf_2/a_33622_170# divbuf_2/a_34112_170# 0.07fF
C138 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43230_n840# 0.04fF
C139 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/a_35082_n240# 0.04fF
C140 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_14702_n240# 0.05fF
C141 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46110_n1540# 0.19fF
C142 pll_full_0/divbuf_1/a_15870_n840# pll_full_0/divbuf_1/a_15870_n1540# 0.01fF
C143 pll_full_0/divbuf_1/a_46110_n840# pll_full_0/divbuf_1/a_46590_n840# 0.07fF
C144 divbuf_2/a_6270_n840# divbuf_2/a_6750_n840# 0.07fF
C145 divbuf_2/a_29262_170# divbuf_2/OUT4 0.19fF
C146 divbuf_2/a_6240_n1600# divbuf_2/a_6270_n1540# 0.19fF
C147 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C148 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20190_n840# 0.04fF
C149 divbuf_2/a_59070_n1540# divbuf_2/a_59550_n1540# 0.11fF
C150 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n840# 0.04fF
C151 divbuf_3/a_29280_n1600# divbuf_3/a_29760_n1600# 0.26fF
C152 divbuf_3/a_20042_n240# divbuf_3/a_20190_n840# 0.03fF
C153 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_15870_n840# 0.02fF
C154 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_25440_n1600# 0.26fF
C155 divbuf_3/a_21630_n1540# divbuf_3/a_22110_n1540# 0.11fF
C156 divbuf_3/a_52350_n840# divbuf_3/a_52350_n1540# 0.01fF
C157 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C158 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_32670_n1540# 0.19fF
C159 pd_div_0/divbuf_0/a_2430_n840# pd_div_0/divbuf_0/a_2430_n1540# 0.01fF
C160 pd_div_0/divbuf_0/a_32670_n840# pd_div_0/divbuf_0/a_33150_n840# 0.07fF
C161 ro_div_0/divbuf_0/a_48030_n840# ro_div_0/divbuf_0/a_48030_n1540# 0.01fF
C162 ro_div_0/divbuf_0/a_17310_n1540# ro_div_0/divbuf_0/a_17790_n1540# 0.11fF
C163 pd_div_0/divider_0/tspc_1/Z3 pd_div_0/divider_0/tspc_1/Q 0.05fF
C164 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C165 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/a_37502_170# 0.07fF
C166 divbuf_2/a_30232_n240# divbuf_2/OUT4 0.04fF
C167 divbuf_2/a_56640_n1600# divbuf_2/a_56670_n840# 0.04fF
C168 divbuf_0/a_27802_170# divbuf_0/a_28292_170# 0.07fF
C169 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_9630_n1540# 0.19fF
C170 pll_full_0/divbuf_0/a_9630_n840# pll_full_0/divbuf_0/a_10110_n840# 0.07fF
C171 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/OUT4 0.19fF
C172 divbuf_1/a_30240_n1600# divbuf_1/a_30720_n1600# 0.26fF
C173 divbuf_1/a_21012_n240# divbuf_1/a_21150_n840# 0.03fF
C174 ro_div_0/ro_complete_0/a1 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C175 divbuf_0/a_15182_170# divbuf_0/OUT4 0.19fF
C176 divbuf_0/a_480_n1600# divbuf_0/a_510_n1540# 0.19fF
C177 divbuf_0/a_510_n840# divbuf_0/a_990_n840# 0.07fF
C178 pll_full_0/divbuf_0/a_60990_n1540# pll_full_0/divbuf_0/OUT5 0.19fF
C179 divbuf_3/a_19200_n1600# divbuf_3/a_19230_n840# 0.04fF
C180 divbuf_1/a_22590_n1540# divbuf_1/a_23070_n1540# 0.11fF
C181 divbuf_1/a_53310_n840# divbuf_1/a_53310_n1540# 0.01fF
C182 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_14910_n840# 0.04fF
C183 divbuf_0/a_53310_n1540# divbuf_0/a_53790_n1540# 0.11fF
C184 divbuf_2/a_34592_n240# divbuf_2/a_35082_n240# 0.04fF
C185 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/a_23550_n840# 0.03fF
C186 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_33120_n1600# 0.26fF
C187 divbuf_1/a_17612_170# divbuf_1/a_17612_n240# 0.01fF
C188 pll_full_0/divbuf_1/a_24990_n1540# pll_full_0/divbuf_1/a_25470_n1540# 0.11fF
C189 pll_full_0/divbuf_1/a_55710_n840# pll_full_0/divbuf_1/a_55710_n1540# 0.01fF
C190 divbuf_2/a_46080_n1600# divbuf_2/a_46110_n1540# 0.19fF
C191 divbuf_2/a_15870_n840# divbuf_2/a_15870_n1540# 0.01fF
C192 divbuf_2/a_46110_n840# divbuf_2/a_46590_n840# 0.07fF
C193 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C194 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60030_n840# 0.04fF
C195 divbuf_3/a_16642_170# divbuf_3/a_16642_n240# 0.01fF
C196 divbuf_3/a_36052_170# divbuf_3/a_36532_170# 0.07fF
C197 divbuf_1/a_20160_n1600# divbuf_1/a_20190_n840# 0.04fF
C198 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/OUT2 0.04fF
C199 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/OUT4 0.19fF
C200 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/a_32172_170# 0.07fF
C201 divbuf_0/a_18582_n240# divbuf_0/OUT4 0.04fF
C202 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n840# 0.04fF
C203 divbuf_3/a_8640_n1600# divbuf_3/a_8670_n1540# 0.19fF
C204 divbuf_3/a_8670_n840# divbuf_3/a_9150_n840# 0.07fF
C205 divbuf_3/a_34112_170# divbuf_3/OUT4 0.19fF
C206 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19680_n1600# 0.26fF
C207 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4350_n1540# 0.19fF
C208 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/OUT4 0.19fF
C209 ro_div_0/divbuf_0/a_4350_n840# ro_div_0/divbuf_0/a_4830_n840# 0.07fF
C210 pd_div_0/divbuf_0/a_11550_n1540# pd_div_0/divbuf_0/a_12030_n1540# 0.11fF
C211 pd_div_0/divbuf_0/a_42270_n840# pd_div_0/divbuf_0/a_42270_n1540# 0.01fF
C212 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_22590_n840# 0.04fF
C213 ro_div_0/divbuf_0/a_57150_n1540# ro_div_0/divbuf_0/a_57630_n1540# 0.11fF
C214 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/a_38472_n240# 0.05fF
C215 divbuf_1/a_37022_170# divbuf_1/a_37502_170# 0.07fF
C216 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/a_40412_n240# 0.01fF
C217 divbuf_0/a_28772_n240# divbuf_0/a_29262_n240# 0.04fF
C218 pll_full_0/divbuf_0/a_19230_n840# pll_full_0/divbuf_0/a_19230_n1540# 0.01fF
C219 pll_full_0/divbuf_0/a_49470_n840# pll_full_0/divbuf_0/a_49950_n840# 0.07fF
C220 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C221 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49470_n1540# 0.19fF
C222 divbuf_1/a_9600_n1600# divbuf_1/a_9630_n1540# 0.19fF
C223 divbuf_1/a_9630_n840# divbuf_1/a_10110_n840# 0.07fF
C224 divbuf_1/a_36052_170# divbuf_1/OUT4 0.19fF
C225 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n1540# 0.19fF
C226 divbuf_0/a_40350_n840# divbuf_0/a_40830_n840# 0.07fF
C227 divbuf_0/a_10110_n840# divbuf_0/a_10110_n1540# 0.01fF
C228 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/a_20042_n240# 0.01fF
C229 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/a_39932_170# 0.07fF
C230 divbuf_3/a_35082_n240# divbuf_3/OUT4 0.04fF
C231 divbuf_3/a_59040_n1600# divbuf_3/a_59070_n840# 0.04fF
C232 divbuf_1/a_60990_n1540# divbuf_1/OUT5 0.19fF
C233 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9150_n840# 0.04fF
C234 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/a_19562_170# 0.07fF
C235 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_54750_n840# 0.04fF
C236 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C237 divbuf_2/a_23442_n240# divbuf_2/a_23550_n840# 0.03fF
C238 divbuf_2/a_32640_n1600# divbuf_2/a_33120_n1600# 0.26fF
C239 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12030_n1540# 0.19fF
C240 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/OUT2 0.07fF
C241 pll_full_0/divbuf_1/a_12030_n840# pll_full_0/divbuf_1/a_12510_n840# 0.07fF
C242 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/OUT4 0.19fF
C243 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C244 divbuf_2/a_24990_n1540# divbuf_2/a_25470_n1540# 0.11fF
C245 divbuf_2/a_55710_n840# divbuf_2/a_55710_n1540# 0.01fF
C246 divbuf_3/a_37022_n240# divbuf_3/a_37502_n240# 0.05fF
C247 divbuf_1/a_37022_n240# divbuf_1/OUT4 0.04fF
C248 divbuf_1/a_60000_n1600# divbuf_1/a_60030_n840# 0.04fF
C249 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/a_33142_n240# 0.04fF
C250 divbuf_3/a_18270_n840# divbuf_3/a_18270_n1540# 0.01fF
C251 divbuf_3/a_48510_n840# divbuf_3/a_48990_n840# 0.07fF
C252 divbuf_3/a_33120_n1600# divbuf_3/OUT4 0.01fF
C253 divbuf_3/a_48480_n1600# divbuf_3/a_48510_n1540# 0.19fF
C254 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59520_n1600# 0.26fF
C255 ro_div_0/divbuf_0/a_44190_n840# ro_div_0/divbuf_0/a_44670_n840# 0.07fF
C256 ro_div_0/divbuf_0/a_13950_n840# ro_div_0/divbuf_0/a_13950_n1540# 0.01fF
C257 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44190_n1540# 0.19fF
C258 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C259 divbuf_2/a_492_n240# divbuf_2/IN 0.13fF
C260 divbuf_2/a_22560_n1600# divbuf_2/a_22590_n840# 0.04fF
C261 pd_div_0/divbuf_0/a_51390_n1540# pd_div_0/divbuf_0/a_51870_n1540# 0.11fF
C262 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C263 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/OUT5 0.04fF
C264 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C265 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C266 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/tspc_0/Z3 0.05fF
C267 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C268 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/a_26910_n840# 0.04fF
C269 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36480_n1600# 0.26fF
C270 divbuf_1/a_37992_n240# divbuf_1/a_38472_n240# 0.05fF
C271 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/a_9150_n840# 0.03fF
C272 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C273 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C274 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C275 cp_0/a_1710_0# cp_0/out 0.84fF
C276 divbuf_0/a_17612_n240# divbuf_0/a_17790_n840# 0.02fF
C277 divbuf_0/a_26880_n1600# divbuf_0/a_27360_n1600# 0.26fF
C278 pll_full_0/divbuf_0/a_28350_n1540# pll_full_0/divbuf_0/a_28830_n1540# 0.11fF
C279 pll_full_0/divbuf_0/a_59070_n840# pll_full_0/divbuf_0/a_59070_n1540# 0.01fF
C280 divbuf_1/a_19230_n840# divbuf_1/a_19230_n1540# 0.01fF
C281 divbuf_1/a_49470_n840# divbuf_1/a_49950_n840# 0.07fF
C282 divbuf_1/a_35040_n1600# divbuf_1/OUT4 0.00fF
C283 divbuf_1/a_49440_n1600# divbuf_1/a_49470_n1540# 0.19fF
C284 divbuf_0/a_49950_n840# divbuf_0/a_49950_n1540# 0.01fF
C285 divbuf_0/a_19230_n1540# divbuf_0/a_19710_n1540# 0.11fF
C286 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/a_40902_n240# 0.04fF
C287 divbuf_2/a_20042_170# divbuf_2/a_20042_n240# 0.01fF
C288 divbuf_2/a_39442_170# divbuf_2/a_39932_170# 0.07fF
C289 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_48990_n840# 0.04fF
C290 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/a_20532_n240# 0.04fF
C291 pll_full_0/divbuf_1/a_21630_n840# pll_full_0/divbuf_1/a_21630_n1540# 0.01fF
C292 pll_full_0/divbuf_1/a_51870_n840# pll_full_0/divbuf_1/a_52350_n840# 0.07fF
C293 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_51870_n1540# 0.19fF
C294 divbuf_2/a_12000_n1600# divbuf_2/a_12030_n1540# 0.19fF
C295 divbuf_2/a_1352_n240# divbuf_2/OUT2 0.07fF
C296 divbuf_2/a_12030_n840# divbuf_2/a_12510_n840# 0.07fF
C297 divbuf_2/a_40902_170# divbuf_2/OUT4 0.19fF
C298 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C299 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/OUT3 0.19fF
C300 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_25950_n840# 0.04fF
C301 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n840# 0.04fF
C302 divbuf_3/a_25862_n240# divbuf_3/a_25950_n840# 0.03fF
C303 divbuf_3/a_35040_n1600# divbuf_3/a_35520_n1600# 0.26fF
C304 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/a_27322_n240# 0.04fF
C305 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/a_21630_n840# 0.03fF
C306 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_31200_n1600# 0.26fF
C307 divbuf_3/a_27390_n1540# divbuf_3/a_27870_n1540# 0.11fF
C308 divbuf_3/a_58110_n840# divbuf_3/a_58110_n1540# 0.01fF
C309 pd_div_0/divbuf_0/a_8190_n840# pd_div_0/divbuf_0/a_8190_n1540# 0.01fF
C310 pd_div_0/divbuf_0/a_38430_n840# pd_div_0/divbuf_0/a_38910_n840# 0.07fF
C311 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C312 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38430_n1540# 0.19fF
C313 ro_div_0/divbuf_0/a_53790_n840# ro_div_0/divbuf_0/a_53790_n1540# 0.01fF
C314 ro_div_0/divbuf_0/a_23070_n1540# ro_div_0/divbuf_0/a_23550_n1540# 0.11fF
C315 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_2/Z4 0.02fF
C316 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/a_23442_n240# 0.01fF
C317 divbuf_2/a_960_n1600# divbuf_2/OUT2 0.00fF
C318 divbuf_2/a_41382_n240# divbuf_2/OUT5 0.04fF
C319 divbuf_0/a_33622_170# divbuf_0/a_34112_170# 0.07fF
C320 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C321 pll_full_0/divbuf_0/a_15390_n840# pll_full_0/divbuf_0/a_15870_n840# 0.07fF
C322 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15390_n1540# 0.19fF
C323 divbuf_1/a_26832_n240# divbuf_1/a_26910_n840# 0.04fF
C324 divbuf_1/a_36000_n1600# divbuf_1/a_36480_n1600# 0.26fF
C325 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/OUT3 0.19fF
C326 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n1540# 0.19fF
C327 divbuf_0/a_29262_170# divbuf_0/OUT4 0.19fF
C328 divbuf_0/a_6270_n840# divbuf_0/a_6750_n840# 0.07fF
C329 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/a_4882_170# 0.07fF
C330 divbuf_3/a_5362_170# divbuf_3/OUT3 0.19fF
C331 divbuf_3/a_24960_n1600# divbuf_3/a_24990_n840# 0.04fF
C332 divbuf_1/a_28350_n1540# divbuf_1/a_28830_n1540# 0.11fF
C333 divbuf_1/a_59070_n840# divbuf_1/a_59070_n1540# 0.01fF
C334 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_20670_n840# 0.04fF
C335 divbuf_0/a_59070_n1540# divbuf_0/a_59550_n1540# 0.11fF
C336 divbuf_2/a_40412_n240# divbuf_2/a_40902_n240# 0.04fF
C337 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/a_29310_n840# 0.04fF
C338 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38880_n1600# 0.26fF
C339 pll_full_0/divbuf_1/a_30750_n1540# pll_full_0/divbuf_1/a_31230_n1540# 0.11fF
C340 divbuf_2/a_21630_n840# divbuf_2/a_21630_n1540# 0.01fF
C341 divbuf_2/a_51870_n840# divbuf_2/a_52350_n840# 0.07fF
C342 divbuf_2/a_51840_n1600# divbuf_2/a_51870_n1540# 0.19fF
C343 divbuf_3/a_492_n240# divbuf_3/a_960_n1600# 0.00fF
C344 divbuf_3/a_1352_n240# divbuf_3/a_1842_n240# 0.04fF
C345 divbuf_3/a_22472_170# divbuf_3/a_22472_n240# 0.01fF
C346 divbuf_1/a_6822_170# divbuf_1/OUT3 0.19fF
C347 divbuf_1/a_25920_n1600# divbuf_1/a_25950_n840# 0.04fF
C348 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C349 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/a_37992_170# 0.07fF
C350 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n840# 0.04fF
C351 divbuf_0/a_30232_n240# divbuf_0/OUT4 0.04fF
C352 divbuf_3/a_6332_n240# divbuf_3/OUT3 0.04fF
C353 divbuf_3/a_14430_n840# divbuf_3/a_14910_n840# 0.07fF
C354 divbuf_3/a_14400_n1600# divbuf_3/a_14430_n1540# 0.19fF
C355 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_25440_n1600# 0.26fF
C356 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C357 ro_div_0/ro_complete_0/a2 ro_div_0/divider_0/clk 0.05fF
C358 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/OUT4 0.19fF
C359 ro_div_0/divbuf_0/a_10110_n840# ro_div_0/divbuf_0/a_10590_n840# 0.07fF
C360 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10110_n1540# 0.19fF
C361 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C362 pd_div_0/divbuf_0/a_17310_n1540# pd_div_0/divbuf_0/a_17790_n1540# 0.11fF
C363 pd_div_0/divbuf_0/a_48030_n840# pd_div_0/divbuf_0/a_48030_n1540# 0.01fF
C364 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28350_n840# 0.04fF
C365 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/OUT4 0.19fF
C366 ro_div_0/divbuf_0/OUT2 ro_div_0/divbuf_0/OUT3 0.36fF
C367 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_2400_n1600# 0.26fF
C368 divbuf_0/a_34592_n240# divbuf_0/a_35082_n240# 0.04fF
C369 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55230_n1540# 0.19fF
C370 pll_full_0/divbuf_0/a_24990_n840# pll_full_0/divbuf_0/a_24990_n1540# 0.01fF
C371 pll_full_0/divbuf_0/a_55230_n840# pll_full_0/divbuf_0/a_55710_n840# 0.07fF
C372 divbuf_1/a_8272_n240# divbuf_1/OUT3 0.04fF
C373 divbuf_1/a_15390_n840# divbuf_1/a_15870_n840# 0.07fF
C374 divbuf_1/a_15360_n1600# divbuf_1/a_15390_n1540# 0.19fF
C375 divbuf_0/a_46110_n840# divbuf_0/a_46590_n840# 0.07fF
C376 divbuf_0/a_15870_n840# divbuf_0/a_15870_n1540# 0.01fF
C377 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n1540# 0.19fF
C378 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/a_5852_n240# 0.04fF
C379 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/a_25862_n240# 0.01fF
C380 divbuf_2/a_4392_170# divbuf_2/a_4882_170# 0.07fF
C381 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_14910_n840# 0.04fF
C382 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/a_25382_170# 0.07fF
C383 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/a_60510_n840# 0.04fF
C384 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C385 divbuf_2/a_29262_n240# divbuf_2/a_29310_n840# 0.04fF
C386 divbuf_2/a_38400_n1600# divbuf_2/a_38880_n1600# 0.26fF
C387 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C388 pll_full_0/divbuf_1/a_17790_n840# pll_full_0/divbuf_1/a_18270_n840# 0.07fF
C389 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_17790_n1540# 0.19fF
C390 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C391 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_0/a_630_n680# 0.01fF
C392 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_12510_n840# 0.01fF
C393 divbuf_2/a_30750_n1540# divbuf_2/a_31230_n1540# 0.11fF
C394 divbuf_3/a_960_n1600# divbuf_3/a_1440_n1600# 0.26fF
C395 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/a_38962_n240# 0.04fF
C396 divbuf_3/a_54240_n1600# divbuf_3/a_54270_n1540# 0.19fF
C397 divbuf_3/a_24030_n840# divbuf_3/a_24030_n1540# 0.01fF
C398 divbuf_3/a_54270_n840# divbuf_3/a_54750_n840# 0.07fF
C399 pd_div_0/divbuf_0/a_4350_n840# pd_div_0/divbuf_0/a_4830_n840# 0.07fF
C400 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4350_n1540# 0.19fF
C401 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_49950_n1540# 0.19fF
C402 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C403 ro_div_0/divbuf_0/a_49950_n840# ro_div_0/divbuf_0/a_50430_n840# 0.07fF
C404 ro_div_0/divbuf_0/a_19710_n840# ro_div_0/divbuf_0/a_19710_n1540# 0.01fF
C405 divbuf_2/a_28320_n1600# divbuf_2/a_28350_n840# 0.04fF
C406 divbuf_2/a_12282_170# divbuf_2/OUT4 0.19fF
C407 pd_div_0/divbuf_0/a_57150_n1540# pd_div_0/divbuf_0/a_57630_n1540# 0.11fF
C408 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C409 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/a_7302_170# 0.07fF
C410 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C411 ro_div_0/divider_0/tspc_2/Z3 ro_div_0/divbuf_0/IN 0.05fF
C412 ro_div_0/divider_0/tspc_2/Z2 ro_div_0/divider_0/tspc_2/Z4 0.36fF
C413 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z4 0.02fF
C414 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z2 0.20fF
C415 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C416 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_42240_n1600# 0.26fF
C417 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/a_32670_n840# 0.06fF
C418 divbuf_1/a_1920_n1600# divbuf_1/a_2400_n1600# 0.26fF
C419 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_15390_n840# 0.02fF
C420 divbuf_0/a_32640_n1600# divbuf_0/a_33120_n1600# 0.26fF
C421 divbuf_0/a_23442_n240# divbuf_0/a_23550_n840# 0.03fF
C422 pll_full_0/divbuf_0/a_34110_n1540# pll_full_0/divbuf_0/a_34590_n1540# 0.11fF
C423 divbuf_3/a_11802_n240# divbuf_3/a_11550_n840# 0.02fF
C424 divbuf_1/a_55200_n1600# divbuf_1/a_55230_n1540# 0.19fF
C425 divbuf_1/a_24990_n840# divbuf_1/a_24990_n1540# 0.01fF
C426 divbuf_1/a_55230_n840# divbuf_1/a_55710_n840# 0.07fF
C427 divbuf_0/a_55710_n840# divbuf_0/a_55710_n1540# 0.01fF
C428 divbuf_0/a_24990_n1540# divbuf_0/a_25470_n1540# 0.11fF
C429 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4800_n1600# 0.26fF
C430 divbuf_2/a_5362_n240# divbuf_2/a_5852_n240# 0.04fF
C431 divbuf_2/a_25862_170# divbuf_2/a_25862_n240# 0.01fF
C432 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C433 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_54750_n840# 0.04fF
C434 divbuf_2/a_13252_n240# divbuf_2/OUT4 0.04fF
C435 divbuf_2/a_17790_n840# divbuf_2/a_18270_n840# 0.07fF
C436 divbuf_2/a_17760_n1600# divbuf_2/a_17790_n1540# 0.19fF
C437 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C438 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_57630_n1540# 0.19fF
C439 pll_full_0/divbuf_1/a_27390_n840# pll_full_0/divbuf_1/a_27390_n1540# 0.01fF
C440 pll_full_0/divbuf_1/a_57630_n840# pll_full_0/divbuf_1/a_58110_n840# 0.07fF
C441 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_31710_n840# 0.04fF
C442 divbuf_3/a_6822_170# divbuf_3/a_7302_170# 0.07fF
C443 divbuf_1/a_12772_n240# divbuf_1/a_12510_n840# 0.01fF
C444 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/a0 0.13fF
C445 divbuf_0/a_2322_170# divbuf_0/OUT2 0.19fF
C446 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n840# 0.04fF
C447 divbuf_3/a_40800_n1600# divbuf_3/a_41280_n1600# 0.26fF
C448 divbuf_3/a_31682_n240# divbuf_3/a_31710_n840# 0.05fF
C449 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/a_33142_n240# 0.04fF
C450 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36960_n1600# 0.26fF
C451 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/a_27390_n840# 0.04fF
C452 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_14910_n840# 0.01fF
C453 divbuf_3/a_33150_n1540# divbuf_3/a_33630_n1540# 0.11fF
C454 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C455 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44190_n1540# 0.19fF
C456 pd_div_0/divbuf_0/a_13950_n840# pd_div_0/divbuf_0/a_13950_n1540# 0.01fF
C457 pd_div_0/divbuf_0/a_44190_n840# pd_div_0/divbuf_0/a_44670_n840# 0.07fF
C458 ro_div_0/divbuf_0/a_59550_n840# ro_div_0/divbuf_0/a_59550_n1540# 0.01fF
C459 ro_div_0/divbuf_0/a_28830_n1540# ro_div_0/divbuf_0/a_29310_n1540# 0.11fF
C460 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/tspc_0/Z3 0.05fF
C461 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/a_29262_n240# 0.01fF
C462 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/a_9242_n240# 0.05fF
C463 divbuf_2/a_11520_n1600# divbuf_2/OUT4 0.01fF
C464 divbuf_0/a_39442_170# divbuf_0/a_39932_170# 0.07fF
C465 divbuf_0/a_20042_170# divbuf_0/a_20042_n240# 0.01fF
C466 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21150_n1540# 0.19fF
C467 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C468 pll_full_0/divbuf_0/a_21150_n840# pll_full_0/divbuf_0/a_21630_n840# 0.07fF
C469 divbuf_1/a_41760_n1600# divbuf_1/a_42240_n1600# 0.26fF
C470 divbuf_1/a_32652_n240# divbuf_1/a_32670_n840# 0.06fF
C471 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/OUT4 0.19fF
C472 divbuf_0/a_40902_170# divbuf_0/OUT4 0.19fF
C473 divbuf_0/a_12030_n840# divbuf_0/a_12510_n840# 0.07fF
C474 divbuf_0/a_1352_n240# divbuf_0/OUT2 0.07fF
C475 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n1540# 0.19fF
C476 divbuf_3/a_30720_n1600# divbuf_3/a_30750_n840# 0.04fF
C477 divbuf_3/a_17122_170# divbuf_3/OUT4 0.19fF
C478 divbuf_1/a_34110_n1540# divbuf_1/a_34590_n1540# 0.11fF
C479 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26430_n840# 0.04fF
C480 ro_div_0/divbuf_0/a_7302_170# ro_div_0/divbuf_0/OUT3 0.19fF
C481 divbuf_2/a_4320_n1600# divbuf_2/a_4800_n1600# 0.26fF
C482 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/a_35070_n840# 0.05fF
C483 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44640_n1600# 0.26fF
C484 pll_full_0/divbuf_1/a_36510_n1540# pll_full_0/divbuf_1/a_36990_n1540# 0.11fF
C485 divbuf_2/a_57600_n1600# divbuf_2/a_57630_n1540# 0.19fF
C486 divbuf_2/a_27390_n840# divbuf_2/a_27390_n1540# 0.01fF
C487 divbuf_2/a_57630_n840# divbuf_2/a_58110_n840# 0.07fF
C488 divbuf_3/a_7792_n240# divbuf_3/a_8272_n240# 0.05fF
C489 divbuf_3/a_28292_170# divbuf_3/a_28292_n240# 0.01fF
C490 divbuf_1/a_5362_170# divbuf_1/OUT3 0.19fF
C491 divbuf_1/a_31680_n1600# divbuf_1/a_31710_n840# 0.04fF
C492 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/a_23922_n240# 0.01fF
C493 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/a_3912_n240# 0.04fF
C494 divbuf_0/a_41382_n240# divbuf_0/OUT5 0.04fF
C495 divbuf_0/a_960_n1600# divbuf_0/OUT2 0.00fF
C496 divbuf_3/a_20160_n1600# divbuf_3/a_20190_n1540# 0.19fF
C497 divbuf_3/a_18092_n240# divbuf_3/OUT4 0.04fF
C498 divbuf_3/a_20190_n840# divbuf_3/a_20670_n840# 0.07fF
C499 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_31200_n1600# 0.26fF
C500 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/a_21630_n840# 0.03fF
C501 ro_div_0/ro_complete_0/cbank_1/switch_0/vin ro_div_0/divider_0/clk 1.45fF
C502 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_15870_n1540# 0.19fF
C503 ro_div_0/divbuf_0/a_15870_n840# ro_div_0/divbuf_0/a_16350_n840# 0.07fF
C504 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C505 divbuf_2/a_15182_n240# divbuf_2/a_14910_n840# 0.01fF
C506 pd_div_0/divbuf_0/a_23070_n1540# pd_div_0/divbuf_0/a_23550_n1540# 0.11fF
C507 pd_div_0/divbuf_0/a_53790_n840# pd_div_0/divbuf_0/a_53790_n1540# 0.01fF
C508 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/OUT4 0.19fF
C509 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34110_n840# 0.04fF
C510 divbuf_0/a_17612_170# divbuf_0/a_18092_170# 0.07fF
C511 divbuf_1/a_8762_n240# divbuf_1/a_9242_n240# 0.05fF
C512 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_8160_n1600# 0.26fF
C513 divbuf_0/a_40412_n240# divbuf_0/a_40902_n240# 0.04fF
C514 pll_full_0/divbuf_0/a_30750_n840# pll_full_0/divbuf_0/a_30750_n1540# 0.01fF
C515 divbuf_1/a_21120_n1600# divbuf_1/a_21150_n1540# 0.19fF
C516 divbuf_1/a_20042_n240# divbuf_1/OUT4 0.04fF
C517 divbuf_1/a_21150_n840# divbuf_1/a_21630_n840# 0.07fF
C518 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n1540# 0.19fF
C519 divbuf_0/a_51870_n840# divbuf_0/a_52350_n840# 0.07fF
C520 divbuf_0/a_21630_n840# divbuf_0/a_21630_n1540# 0.01fF
C521 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/a_31682_n240# 0.01fF
C522 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_12282_n240# 0.05fF
C523 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_20670_n840# 0.04fF
C524 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/a_31202_170# 0.07fF
C525 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_4392_170# 0.07fF
C526 divbuf_2/a_35082_n240# divbuf_2/a_35070_n840# 0.05fF
C527 divbuf_2/a_44160_n1600# divbuf_2/a_44640_n1600# 0.26fF
C528 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_23550_n1540# 0.19fF
C529 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C530 pll_full_0/divbuf_1/a_23550_n840# pll_full_0/divbuf_1/a_24030_n840# 0.07fF
C531 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C532 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C533 divbuf_2/a_36510_n1540# divbuf_2/a_36990_n1540# 0.11fF
C534 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C535 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C536 divbuf_3/a_6720_n1600# divbuf_3/a_7200_n1600# 0.26fF
C537 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2880_n1600# 0.26fF
C538 divbuf_3/a_29790_n840# divbuf_3/a_29790_n1540# 0.01fF
C539 divbuf_3/a_60030_n840# divbuf_3/a_60510_n840# 0.07fF
C540 divbuf_3/a_60000_n1600# divbuf_3/a_60030_n1540# 0.19fF
C541 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10110_n1540# 0.19fF
C542 pd_div_0/divbuf_0/a_10110_n840# pd_div_0/divbuf_0/a_10590_n840# 0.07fF
C543 ro_div_0/divbuf_0/a_55710_n840# ro_div_0/divbuf_0/a_56190_n840# 0.07fF
C544 ro_div_0/divbuf_0/a_25470_n840# ro_div_0/divbuf_0/a_25470_n1540# 0.01fF
C545 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_55710_n1540# 0.19fF
C546 divbuf_2/a_23922_170# divbuf_2/OUT4 0.19fF
C547 divbuf_2/a_34080_n1600# divbuf_2/a_34110_n840# 0.04fF
C548 pd_div_0/divbuf_0/OUT2 pd_div_0/divbuf_0/OUT3 0.36fF
C549 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C550 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_7792_n240# 0.01fF
C551 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/a_16152_170# 0.07fF
C552 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C553 ro_div_0/divider_0/and_0/A ro_div_0/divider_0/and_0/B 0.18fF
C554 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C555 divbuf_0/a_8762_170# divbuf_0/a_8762_n240# 0.01fF
C556 divbuf_0/a_1352_170# divbuf_0/a_1352_n240# 0.01fF
C557 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.01fF
C558 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C559 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C560 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/OUT3 0.19fF
C561 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/a_38430_n840# 0.04fF
C562 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_48000_n1600# 0.26fF
C563 divbuf_1/a_7680_n1600# divbuf_1/a_8160_n1600# 0.26fF
C564 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/a_21150_n840# 0.03fF
C565 divbuf_0/a_38400_n1600# divbuf_0/a_38880_n1600# 0.26fF
C566 divbuf_0/a_29262_n240# divbuf_0/a_29310_n840# 0.04fF
C567 pll_full_0/divbuf_0/a_39870_n1540# pll_full_0/divbuf_0/a_40350_n1540# 0.11fF
C568 divbuf_3/a_17612_n240# divbuf_3/a_17310_n840# 0.00fF
C569 divbuf_1/a_30750_n840# divbuf_1/a_30750_n1540# 0.01fF
C570 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_12990_n840# 0.01fF
C571 divbuf_0/a_30750_n1540# divbuf_0/a_31230_n1540# 0.11fF
C572 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10560_n1600# 0.26fF
C573 divbuf_2/a_31682_170# divbuf_2/a_31682_n240# 0.01fF
C574 divbuf_2/a_11802_n240# divbuf_2/a_12282_n240# 0.05fF
C575 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C576 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/a_60510_n840# 0.04fF
C577 divbuf_2/a_23520_n1600# divbuf_2/a_23550_n1540# 0.19fF
C578 divbuf_2/a_24892_n240# divbuf_2/OUT4 0.04fF
C579 divbuf_2/a_23550_n840# divbuf_2/a_24030_n840# 0.07fF
C580 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_0/a_630_n680# 0.01fF
C581 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C582 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/OUT3 0.03fF
C583 pll_full_0/divbuf_1/a_2430_n1540# pll_full_0/divbuf_1/a_2910_n1540# 0.11fF
C584 pll_full_0/divbuf_1/a_33150_n840# pll_full_0/divbuf_1/a_33150_n1540# 0.01fF
C585 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/a_15672_n240# 0.01fF
C586 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/OUT4 0.19fF
C587 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37470_n840# 0.04fF
C588 divbuf_3/a_13252_170# divbuf_3/a_13742_170# 0.07fF
C589 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/OUT2 0.42fF
C590 divbuf_0/a_12282_170# divbuf_0/OUT4 0.19fF
C591 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n840# 0.04fF
C592 divbuf_3/a_37502_n240# divbuf_3/a_37470_n840# 0.05fF
C593 divbuf_3/a_46560_n1600# divbuf_3/a_47040_n1600# 0.26fF
C594 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/a_38962_n240# 0.04fF
C595 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/a_33150_n840# 0.06fF
C596 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42720_n1600# 0.26fF
C597 divbuf_3/a_38910_n1540# divbuf_3/a_39390_n1540# 0.11fF
C598 pd_div_0/divbuf_0/a_19710_n840# pd_div_0/divbuf_0/a_19710_n1540# 0.01fF
C599 pd_div_0/divbuf_0/a_49950_n840# pd_div_0/divbuf_0/a_50430_n840# 0.07fF
C600 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C601 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_49950_n1540# 0.19fF
C602 ro_div_0/divbuf_0/a_34590_n1540# ro_div_0/divbuf_0/a_35070_n1540# 0.11fF
C603 divbuf_2/a_23040_n1600# divbuf_2/OUT4 0.01fF
C604 pd_div_0/divider_0/tspc_2/Z2 pd_div_0/divider_0/tspc_2/Z4 0.36fF
C605 pd_div_0/divider_0/tspc_2/Z3 pd_div_0/bufin 0.05fF
C606 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/OUT5 0.03fF
C607 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_15672_n240# 0.04fF
C608 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/a_35082_n240# 0.01fF
C609 divbuf_0/a_25862_170# divbuf_0/a_25862_n240# 0.01fF
C610 divbuf_0/a_5362_n240# divbuf_0/a_5852_n240# 0.04fF
C611 pll_full_0/divbuf_0/a_26910_n840# pll_full_0/divbuf_0/a_27390_n840# 0.07fF
C612 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C613 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_26910_n1540# 0.19fF
C614 divbuf_1/a_38472_n240# divbuf_1/a_38430_n840# 0.04fF
C615 divbuf_1/a_47520_n1600# divbuf_1/a_48000_n1600# 0.26fF
C616 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/OUT4 0.19fF
C617 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n1540# 0.19fF
C618 divbuf_0/a_17790_n840# divbuf_0/a_18270_n840# 0.07fF
C619 divbuf_0/a_13252_n240# divbuf_0/OUT4 0.04fF
C620 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/a_17122_170# 0.07fF
C621 divbuf_3/a_28772_170# divbuf_3/OUT4 0.19fF
C622 divbuf_3/a_36480_n1600# divbuf_3/a_36510_n840# 0.04fF
C623 divbuf_1/a_39870_n1540# divbuf_1/a_40350_n1540# 0.11fF
C624 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32190_n840# 0.04fF
C625 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/OUT4 0.19fF
C626 divbuf_2/a_10080_n1600# divbuf_2/a_10560_n1600# 0.26fF
C627 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/a_40830_n840# 0.03fF
C628 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_50400_n1600# 0.26fF
C629 divbuf_1/a_13742_170# divbuf_1/a_13742_n240# 0.01fF
C630 pll_full_0/divbuf_1/a_42270_n1540# pll_full_0/divbuf_1/a_42750_n1540# 0.11fF
C631 divbuf_2/a_2910_n840# divbuf_2/OUT3 0.03fF
C632 divbuf_2/a_2430_n1540# divbuf_2/a_2910_n1540# 0.11fF
C633 divbuf_2/a_33150_n840# divbuf_2/a_33150_n1540# 0.01fF
C634 divbuf_3/a_14222_n240# divbuf_3/a_14702_n240# 0.05fF
C635 divbuf_3/a_34112_170# divbuf_3/a_34112_n240# 0.01fF
C636 divbuf_1/a_27322_170# divbuf_1/OUT4 0.19fF
C637 divbuf_1/a_37440_n1600# divbuf_1/a_37470_n840# 0.04fF
C638 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/a_9732_n240# 0.04fF
C639 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/a_29742_n240# 0.01fF
C640 divbuf_0/a_11520_n1600# divbuf_0/OUT4 0.01fF
C641 divbuf_3/a_25950_n840# divbuf_3/a_26430_n840# 0.07fF
C642 divbuf_3/a_29742_n240# divbuf_3/OUT4 0.04fF
C643 divbuf_3/a_25920_n1600# divbuf_3/a_25950_n1540# 0.19fF
C644 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/a_27390_n840# 0.04fF
C645 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36960_n1600# 0.26fF
C646 ro_div_0/divbuf_0/a_21630_n840# ro_div_0/divbuf_0/a_22110_n840# 0.07fF
C647 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C648 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_21630_n1540# 0.19fF
C649 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C650 pd_div_0/divbuf_0/a_28830_n1540# pd_div_0/divbuf_0/a_29310_n1540# 0.11fF
C651 pd_div_0/divbuf_0/a_59550_n840# pd_div_0/divbuf_0/a_59550_n1540# 0.01fF
C652 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_39870_n840# 0.04fF
C653 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/OUT4 0.19fF
C654 divbuf_1/a_15182_n240# divbuf_1/a_15672_n240# 0.04fF
C655 divbuf_1/a_35082_170# divbuf_1/a_35082_n240# 0.01fF
C656 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13920_n1600# 0.26fF
C657 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/a_3870_n840# 0.04fF
C658 divbuf_2/a_41790_n840# divbuf_2/OUT5 0.03fF
C659 divbuf_0/a_4320_n1600# divbuf_0/a_4800_n1600# 0.26fF
C660 pll_full_0/divbuf_0/a_5790_n1540# pll_full_0/divbuf_0/a_6270_n1540# 0.11fF
C661 pll_full_0/divbuf_0/a_36510_n840# pll_full_0/divbuf_0/a_36510_n1540# 0.01fF
C662 divbuf_1/a_26910_n840# divbuf_1/a_27390_n840# 0.07fF
C663 divbuf_1/a_31682_n240# divbuf_1/OUT4 0.04fF
C664 divbuf_1/a_26880_n1600# divbuf_1/a_26910_n1540# 0.19fF
C665 divbuf_0/a_57630_n840# divbuf_0/a_58110_n840# 0.07fF
C666 divbuf_0/a_27390_n840# divbuf_0/a_27390_n1540# 0.01fF
C667 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n1540# 0.19fF
C668 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_18092_n240# 0.05fF
C669 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/a_37502_n240# 0.01fF
C670 divbuf_2/a_16642_170# divbuf_2/a_17122_170# 0.07fF
C671 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26430_n840# 0.04fF
C672 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/a_17122_n240# 0.01fF
C673 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/a_37022_170# 0.07fF
C674 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C675 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C676 divbuf_2/a_40902_n240# divbuf_2/a_40830_n840# 0.03fF
C677 divbuf_2/a_49920_n1600# divbuf_2/a_50400_n1600# 0.26fF
C678 pll_full_0/divbuf_1/a_29310_n840# pll_full_0/divbuf_1/a_29790_n840# 0.07fF
C679 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C680 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29310_n1540# 0.19fF
C681 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/Out 0.19fF
C682 ro_div_0/divider_0/prescaler_0/tspc_0/D ro_div_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C683 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C684 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C685 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C686 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C687 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C688 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C689 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3390_n840# 0.04fF
C690 divbuf_2/a_42270_n1540# divbuf_2/a_42750_n1540# 0.11fF
C691 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C692 divbuf_0/a_15182_n240# divbuf_0/a_14910_n840# 0.01fF
C693 divbuf_3/a_12480_n1600# divbuf_3/a_12960_n1600# 0.26fF
C694 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8640_n1600# 0.26fF
C695 divbuf_3/a_4830_n1540# divbuf_3/a_5310_n1540# 0.11fF
C696 divbuf_3/a_35550_n840# divbuf_3/a_35550_n1540# 0.01fF
C697 pd_div_0/divbuf_0/a_15870_n840# pd_div_0/divbuf_0/a_16350_n840# 0.07fF
C698 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_15870_n1540# 0.19fF
C699 ro_div_0/divbuf_0/a_31230_n840# ro_div_0/divbuf_0/a_31230_n1540# 0.01fF
C700 ro_div_0/divbuf_0/a_510_n1540# ro_div_0/divbuf_0/a_990_n1540# 0.11fF
C701 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/a_20532_170# 0.07fF
C702 divbuf_2/a_39840_n1600# divbuf_2/a_39870_n840# 0.04fF
C703 divbuf_2/a_35562_170# divbuf_2/OUT4 0.19fF
C704 divbuf_1/a_31202_170# divbuf_1/a_31682_170# 0.07fF
C705 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C706 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C707 pll_full_0/divider_0/nor_0/B pll_full_0/divbuf_0/IN 0.29fF
C708 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.29fF
C709 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C710 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53760_n1600# 0.26fF
C711 divbuf_1/a_13440_n1600# divbuf_1/a_13920_n1600# 0.26fF
C712 divbuf_1/a_3912_n240# divbuf_1/a_3870_n840# 0.04fF
C713 divbuf_0/a_44160_n1600# divbuf_0/a_44640_n1600# 0.26fF
C714 divbuf_0/a_35082_n240# divbuf_0/a_35070_n840# 0.05fF
C715 divbuf_0/a_9242_170# divbuf_0/OUT3 0.19fF
C716 pll_full_0/divbuf_0/a_45630_n1540# pll_full_0/divbuf_0/a_46110_n1540# 0.11fF
C717 divbuf_3/a_2400_n1600# divbuf_3/a_2430_n840# 0.04fF
C718 divbuf_1/a_5790_n1540# divbuf_1/a_6270_n1540# 0.11fF
C719 divbuf_1/a_36510_n840# divbuf_1/a_36510_n1540# 0.01fF
C720 divbuf_0/a_36510_n1540# divbuf_0/a_36990_n1540# 0.11fF
C721 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_16320_n1600# 0.26fF
C722 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/a_6270_n840# 0.04fF
C723 divbuf_2/a_17612_n240# divbuf_2/a_18092_n240# 0.05fF
C724 divbuf_2/a_37502_170# divbuf_2/a_37502_n240# 0.01fF
C725 divbuf_2/a_29310_n840# divbuf_2/a_29790_n840# 0.07fF
C726 divbuf_2/a_36532_n240# divbuf_2/OUT4 0.04fF
C727 divbuf_2/a_29280_n1600# divbuf_2/a_29310_n1540# 0.19fF
C728 divbuf_1/a_3422_170# divbuf_1/a_3912_170# 0.07fF
C729 pll_full_0/divbuf_1/a_8190_n1540# pll_full_0/divbuf_1/a_8670_n1540# 0.11fF
C730 pll_full_0/divbuf_1/a_38910_n840# pll_full_0/divbuf_1/a_38910_n1540# 0.01fF
C731 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C732 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43230_n840# 0.04fF
C733 divbuf_3/a_19072_170# divbuf_3/a_19562_170# 0.07fF
C734 divbuf_1/a_3360_n1600# divbuf_1/a_3390_n840# 0.04fF
C735 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/OUT4 0.19fF
C736 ro_div_0/ro_complete_0/cbank_2/switch_4/vin ro_div_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C737 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/a_16642_170# 0.07fF
C738 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/a_8272_n240# 0.01fF
C739 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n840# 0.04fF
C740 divbuf_0/a_23922_170# divbuf_0/OUT4 0.19fF
C741 divbuf_3/a_52320_n1600# divbuf_3/a_52800_n1600# 0.26fF
C742 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2880_n1600# 0.26fF
C743 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48480_n1600# 0.26fF
C744 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/OUT3 0.19fF
C745 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/a_38910_n840# 0.04fF
C746 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_5790_n840# 0.04fF
C747 divbuf_3/a_44670_n1540# divbuf_3/a_45150_n1540# 0.11fF
C748 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_55710_n1540# 0.19fF
C749 pd_div_0/divbuf_0/a_25470_n840# pd_div_0/divbuf_0/a_25470_n1540# 0.01fF
C750 pd_div_0/divbuf_0/a_55710_n840# pd_div_0/divbuf_0/a_56190_n840# 0.07fF
C751 ro_div_0/divbuf_0/a_40350_n1540# ro_div_0/divbuf_0/a_40830_n1540# 0.11fF
C752 divbuf_2/a_34560_n1600# divbuf_2/OUT4 0.01fF
C753 pd_div_0/divider_0/and_0/A pd_div_0/divider_0/and_0/B 0.18fF
C754 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/a_40902_n240# 0.01fF
C755 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/a_21502_n240# 0.04fF
C756 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/a_23442_n240# 0.01fF
C757 divbuf_0/a_11802_n240# divbuf_0/a_12282_n240# 0.05fF
C758 divbuf_0/a_31682_170# divbuf_0/a_31682_n240# 0.01fF
C759 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C760 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_32670_n1540# 0.19fF
C761 pll_full_0/divbuf_0/a_2430_n840# pll_full_0/divbuf_0/a_2430_n1540# 0.01fF
C762 pll_full_0/divbuf_0/a_32670_n840# pll_full_0/divbuf_0/a_33150_n840# 0.07fF
C763 divbuf_1/a_53280_n1600# divbuf_1/a_53760_n1600# 0.26fF
C764 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C765 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/a_16152_n240# 0.01fF
C766 divbuf_0/a_23550_n840# divbuf_0/a_24030_n840# 0.07fF
C767 divbuf_0/a_24892_n240# divbuf_0/OUT4 0.04fF
C768 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n1540# 0.19fF
C769 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/a_22952_170# 0.07fF
C770 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/a_1842_n240# 0.01fF
C771 divbuf_3/a_42240_n1600# divbuf_3/a_42270_n840# 0.04fF
C772 divbuf_3/a_40412_170# divbuf_3/OUT4 0.19fF
C773 divbuf_1/a_45630_n1540# divbuf_1/a_46110_n1540# 0.11fF
C774 pd_div_0/pd_0/tspc_r_1/Z1 pd_div_0/pd_0/tspc_r_1/Z2 0.71fF
C775 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z4 0.20fF
C776 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/z5 0.04fF
C777 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_37950_n840# 0.04fF
C778 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/OUT4 0.19fF
C779 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/OUT3 0.19fF
C780 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_56160_n1600# 0.26fF
C781 divbuf_2/a_15840_n1600# divbuf_2/a_16320_n1600# 0.26fF
C782 divbuf_2/a_6332_n240# divbuf_2/a_6270_n840# 0.04fF
C783 divbuf_2/a_8190_n1540# divbuf_2/a_8670_n1540# 0.11fF
C784 divbuf_2/a_38910_n840# divbuf_2/a_38910_n1540# 0.01fF
C785 divbuf_1/a_19072_170# divbuf_1/a_19072_n240# 0.01fF
C786 pll_full_0/divbuf_1/a_48030_n1540# pll_full_0/divbuf_1/a_48510_n1540# 0.11fF
C787 divbuf_3/a_20042_n240# divbuf_3/a_20532_n240# 0.04fF
C788 divbuf_3/a_39932_170# divbuf_3/a_39932_n240# 0.01fF
C789 divbuf_1/a_2322_n240# divbuf_1/OUT3 0.04fF
C790 divbuf_1/a_43200_n1600# divbuf_1/a_43230_n840# 0.04fF
C791 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/a_35562_n240# 0.01fF
C792 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_16152_n240# 0.05fF
C793 divbuf_0/a_23040_n1600# divbuf_0/OUT4 0.01fF
C794 divbuf_3/a_41382_n240# divbuf_3/OUT4 0.04fF
C795 divbuf_3/a_31680_n1600# divbuf_3/a_31710_n1540# 0.19fF
C796 divbuf_3/a_1470_n840# divbuf_3/a_1470_n1540# 0.01fF
C797 divbuf_3/a_31710_n840# divbuf_3/a_32190_n840# 0.07fF
C798 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42720_n1600# 0.26fF
C799 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/a_33150_n840# 0.06fF
C800 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27390_n1540# 0.19fF
C801 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C802 ro_div_0/divbuf_0/a_27390_n840# ro_div_0/divbuf_0/a_27870_n840# 0.07fF
C803 divbuf_2/a_5760_n1600# divbuf_2/a_5790_n840# 0.04fF
C804 pd_div_0/divbuf_0/a_34590_n1540# pd_div_0/divbuf_0/a_35070_n1540# 0.11fF
C805 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C806 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_45630_n840# 0.04fF
C807 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z2 0.01fF
C808 divbuf_1/a_40902_170# divbuf_1/a_40902_n240# 0.01fF
C809 divbuf_1/a_21012_n240# divbuf_1/a_21502_n240# 0.04fF
C810 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19680_n1600# 0.26fF
C811 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/a_9630_n840# 0.03fF
C812 divbuf_0/a_10080_n1600# divbuf_0/a_10560_n1600# 0.26fF
C813 pll_full_0/divbuf_0/a_11550_n1540# pll_full_0/divbuf_0/a_12030_n1540# 0.11fF
C814 pll_full_0/divbuf_0/a_42270_n840# pll_full_0/divbuf_0/a_42270_n1540# 0.01fF
C815 divbuf_1/a_2400_n1600# divbuf_1/OUT2 0.00fF
C816 divbuf_1/a_32640_n1600# divbuf_1/a_32670_n1540# 0.19fF
C817 divbuf_1/a_2430_n840# divbuf_1/a_2430_n1540# 0.01fF
C818 divbuf_1/a_32670_n840# divbuf_1/a_33150_n840# 0.07fF
C819 divbuf_0/a_33150_n840# divbuf_0/a_33150_n1540# 0.01fF
C820 divbuf_0/a_2430_n1540# divbuf_0/a_2910_n1540# 0.11fF
C821 divbuf_0/a_2910_n840# divbuf_0/OUT3 0.03fF
C822 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/a_23922_n240# 0.05fF
C823 divbuf_2/a_22472_170# divbuf_2/a_22952_170# 0.07fF
C824 divbuf_2/a_1842_170# divbuf_2/a_1842_n240# 0.01fF
C825 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32190_n840# 0.04fF
C826 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/a_2322_n240# 0.05fF
C827 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C828 divbuf_2/a_6822_170# divbuf_2/OUT3 0.19fF
C829 divbuf_2/a_55680_n1600# divbuf_2/a_56160_n1600# 0.26fF
C830 pll_full_0/divbuf_1/a_4830_n840# pll_full_0/divbuf_1/a_4830_n1540# 0.01fF
C831 pll_full_0/divbuf_1/a_35070_n840# pll_full_0/divbuf_1/a_35550_n840# 0.07fF
C832 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35070_n1540# 0.19fF
C833 ro_div_0/divider_0/prescaler_0/tspc_0/D ro_div_0/divider_0/clk 0.26fF
C834 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C835 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C836 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C837 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C838 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9150_n840# 0.04fF
C839 divbuf_2/a_48030_n1540# divbuf_2/a_48510_n1540# 0.11fF
C840 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_12510_n840# 0.01fF
C841 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C842 divbuf_3/a_18240_n1600# divbuf_3/a_18720_n1600# 0.26fF
C843 divbuf_3/a_8762_n240# divbuf_3/a_8670_n840# 0.03fF
C844 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/a_4350_n840# 0.04fF
C845 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_14400_n1600# 0.26fF
C846 divbuf_0/a_41790_n840# divbuf_0/OUT5 0.03fF
C847 divbuf_3/a_10590_n1540# divbuf_3/a_11070_n1540# 0.11fF
C848 divbuf_3/a_41310_n840# divbuf_3/a_41310_n1540# 0.01fF
C849 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_21630_n1540# 0.19fF
C850 pd_div_0/divbuf_0/a_21630_n840# pd_div_0/divbuf_0/a_22110_n840# 0.07fF
C851 ro_div_0/divbuf_0/a_36990_n840# ro_div_0/divbuf_0/a_36990_n1540# 0.01fF
C852 ro_div_0/divbuf_0/a_6270_n1540# ro_div_0/divbuf_0/a_6750_n1540# 0.11fF
C853 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/a_26352_170# 0.07fF
C854 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_12772_n240# 0.01fF
C855 divbuf_2/a_7792_n240# divbuf_2/OUT3 0.04fF
C856 divbuf_2/a_45600_n1600# divbuf_2/a_45630_n840# 0.04fF
C857 divbuf_1/a_19200_n1600# divbuf_1/a_19680_n1600# 0.26fF
C858 divbuf_1/a_9732_n240# divbuf_1/a_9630_n840# 0.03fF
C859 divbuf_0/a_14222_170# divbuf_0/a_14702_170# 0.07fF
C860 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C861 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59520_n1600# 0.26fF
C862 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/OUT4 0.19fF
C863 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C864 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C865 divbuf_0/a_49920_n1600# divbuf_0/a_50400_n1600# 0.26fF
C866 divbuf_0/a_40902_n240# divbuf_0/a_40830_n840# 0.03fF
C867 pll_full_0/divbuf_0/a_51390_n1540# pll_full_0/divbuf_0/a_51870_n1540# 0.11fF
C868 divbuf_3/a_8160_n1600# divbuf_3/a_8190_n840# 0.04fF
C869 divbuf_1/a_11550_n1540# divbuf_1/a_12030_n1540# 0.11fF
C870 divbuf_1/a_42270_n840# divbuf_1/a_42270_n1540# 0.01fF
C871 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_3870_n840# 0.04fF
C872 divbuf_0/a_42270_n1540# divbuf_0/a_42750_n1540# 0.11fF
C873 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12510_n840# 0.02fF
C874 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_22080_n1600# 0.26fF
C875 divbuf_2/a_23442_n240# divbuf_2/a_23922_n240# 0.05fF
C876 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C877 divbuf_2/a_4830_n840# divbuf_2/a_4830_n1540# 0.01fF
C878 divbuf_2/a_35070_n840# divbuf_2/a_35550_n840# 0.07fF
C879 divbuf_2/a_35040_n1600# divbuf_2/a_35070_n1540# 0.19fF
C880 pd_div_0/divider_0/prescaler_0/tspc_0/D pd_div_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C881 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/Out 0.19fF
C882 pll_full_0/divbuf_1/a_13950_n1540# pll_full_0/divbuf_1/a_14430_n1540# 0.11fF
C883 pll_full_0/divbuf_1/a_44670_n840# pll_full_0/divbuf_1/a_44670_n1540# 0.01fF
C884 divbuf_0/a_16152_170# divbuf_0/a_16152_n240# 0.01fF
C885 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C886 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_48990_n840# 0.04fF
C887 divbuf_3/a_4882_170# divbuf_3/a_4882_n240# 0.01fF
C888 divbuf_3/a_24892_170# divbuf_3/a_25382_170# 0.07fF
C889 divbuf_1/a_9120_n1600# divbuf_1/a_9150_n840# 0.04fF
C890 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/OUT4 0.19fF
C891 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/a_2322_n240# 0.01fF
C892 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/a_21012_170# 0.07fF
C893 divbuf_0/a_35562_170# divbuf_0/OUT4 0.19fF
C894 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n840# 0.04fF
C895 divbuf_3/a_58080_n1600# divbuf_3/a_58560_n1600# 0.26fF
C896 divbuf_3/a_11802_170# divbuf_3/OUT4 0.19fF
C897 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8640_n1600# 0.26fF
C898 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_54240_n1600# 0.26fF
C899 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_11550_n840# 0.04fF
C900 divbuf_3/a_50430_n1540# divbuf_3/a_50910_n1540# 0.11fF
C901 pd_div_0/divbuf_0/a_510_n1540# pd_div_0/divbuf_0/a_990_n1540# 0.11fF
C902 pd_div_0/divbuf_0/a_31230_n840# pd_div_0/divbuf_0/a_31230_n1540# 0.01fF
C903 ro_div_0/divbuf_0/a_46110_n1540# ro_div_0/divbuf_0/a_46590_n1540# 0.11fF
C904 divbuf_1/a_32172_170# divbuf_1/a_32172_n240# 0.01fF
C905 divbuf_1/a_22472_170# divbuf_1/a_22952_170# 0.07fF
C906 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/a_27322_n240# 0.04fF
C907 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/a_29262_n240# 0.01fF
C908 divbuf_0/a_37502_170# divbuf_0/a_37502_n240# 0.01fF
C909 divbuf_0/a_17612_n240# divbuf_0/a_18092_n240# 0.05fF
C910 pll_full_0/divbuf_0/a_8190_n840# pll_full_0/divbuf_0/a_8190_n1540# 0.01fF
C911 pll_full_0/divbuf_0/a_38430_n840# pll_full_0/divbuf_0/a_38910_n840# 0.07fF
C912 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C913 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38430_n1540# 0.19fF
C914 divbuf_1/a_59040_n1600# divbuf_1/a_59520_n1600# 0.26fF
C915 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C916 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n1540# 0.19fF
C917 divbuf_0/a_36532_n240# divbuf_0/OUT4 0.04fF
C918 divbuf_0/a_29310_n840# divbuf_0/a_29790_n840# 0.07fF
C919 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/a_8272_n240# 0.01fF
C920 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/a_28772_170# 0.07fF
C921 divbuf_3/a_12772_n240# divbuf_3/OUT4 0.04fF
C922 divbuf_3/a_48000_n1600# divbuf_3/a_48030_n840# 0.04fF
C923 divbuf_1/a_51390_n1540# divbuf_1/a_51870_n1540# 0.11fF
C924 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_43710_n840# 0.04fF
C925 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C926 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_990_n1540# 0.19fF
C927 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/a_1470_n840# 0.07fF
C928 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/OUT4 0.19fF
C929 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C930 divbuf_2/a_12282_n240# divbuf_2/a_12510_n840# 0.02fF
C931 divbuf_2/a_21600_n1600# divbuf_2/a_22080_n1600# 0.26fF
C932 divbuf_2/a_13950_n1540# divbuf_2/a_14430_n1540# 0.11fF
C933 divbuf_2/a_44670_n840# divbuf_2/a_44670_n1540# 0.01fF
C934 divbuf_1/a_24892_170# divbuf_1/a_24892_n240# 0.01fF
C935 pll_full_0/divbuf_1/a_53790_n1540# pll_full_0/divbuf_1/a_54270_n1540# 0.11fF
C936 divbuf_3/a_25862_n240# divbuf_3/a_26352_n240# 0.04fF
C937 divbuf_1/a_14702_n240# divbuf_1/OUT4 0.04fF
C938 divbuf_1/a_48960_n1600# divbuf_1/a_48990_n840# 0.04fF
C939 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/a_21982_n240# 0.05fF
C940 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/a_41382_n240# 0.01fF
C941 divbuf_0/a_34560_n1600# divbuf_0/OUT4 0.01fF
C942 divbuf_3/a_7230_n840# divbuf_3/a_7230_n1540# 0.01fF
C943 divbuf_3/a_37470_n840# divbuf_3/a_37950_n840# 0.07fF
C944 divbuf_3/a_11040_n1600# divbuf_3/OUT4 0.00fF
C945 divbuf_3/a_37440_n1600# divbuf_3/a_37470_n1540# 0.19fF
C946 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/a_38910_n840# 0.04fF
C947 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48480_n1600# 0.26fF
C948 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/a_6822_n240# 0.01fF
C949 ro_div_0/divbuf_0/a_33150_n840# ro_div_0/divbuf_0/a_33630_n840# 0.07fF
C950 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/a_2910_n1540# 0.01fF
C951 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33150_n1540# 0.19fF
C952 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51390_n840# 0.04fF
C953 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C954 divbuf_2/a_11520_n1600# divbuf_2/a_11550_n840# 0.04fF
C955 pd_div_0/divbuf_0/a_40350_n1540# pd_div_0/divbuf_0/a_40830_n1540# 0.11fF
C956 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C957 divbuf_1/a_26832_n240# divbuf_1/a_27322_n240# 0.04fF
C958 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_25440_n1600# 0.26fF
C959 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_15870_n840# 0.02fF
C960 divbuf_0/a_6332_n240# divbuf_0/a_6270_n840# 0.04fF
C961 divbuf_0/a_15840_n1600# divbuf_0/a_16320_n1600# 0.26fF
C962 pll_full_0/divbuf_0/a_17310_n1540# pll_full_0/divbuf_0/a_17790_n1540# 0.11fF
C963 pll_full_0/divbuf_0/a_48030_n840# pll_full_0/divbuf_0/a_48030_n1540# 0.01fF
C964 divbuf_1/a_8190_n840# divbuf_1/a_8190_n1540# 0.01fF
C965 divbuf_1/a_38430_n840# divbuf_1/a_38910_n840# 0.07fF
C966 divbuf_1/a_12960_n1600# divbuf_1/OUT4 0.00fF
C967 divbuf_1/a_38400_n1600# divbuf_1/a_38430_n1540# 0.19fF
C968 divbuf_0/a_38910_n840# divbuf_0/a_38910_n1540# 0.01fF
C969 divbuf_0/a_8190_n1540# divbuf_0/a_8670_n1540# 0.11fF
C970 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/a_29742_n240# 0.05fF
C971 divbuf_2/a_8272_170# divbuf_2/a_8272_n240# 0.01fF
C972 divbuf_2/a_28292_170# divbuf_2/a_28772_170# 0.07fF
C973 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_37950_n840# 0.04fF
C974 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/a_8762_n240# 0.04fF
C975 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C976 divbuf_2/a_960_n1600# divbuf_2/a_990_n1540# 0.19fF
C977 divbuf_2/a_990_n840# divbuf_2/a_1470_n840# 0.07fF
C978 divbuf_2/a_18582_170# divbuf_2/OUT4 0.19fF
C979 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/a_10590_n1540# 0.01fF
C980 pll_full_0/divbuf_1/a_40830_n840# pll_full_0/divbuf_1/a_41310_n840# 0.07fF
C981 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_40830_n1540# 0.19fF
C982 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C983 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z1 0.01fF
C984 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C985 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C986 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/A 0.26fF
C987 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_14910_n840# 0.04fF
C988 divbuf_2/a_53790_n1540# divbuf_2/a_54270_n1540# 0.11fF
C989 divbuf_0/a_19562_170# divbuf_0/OUT4 0.19fF
C990 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n840# 0.04fF
C991 divbuf_3/a_24000_n1600# divbuf_3/a_24480_n1600# 0.26fF
C992 divbuf_3/a_14702_n240# divbuf_3/a_14910_n840# 0.02fF
C993 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/a_10110_n840# 0.03fF
C994 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_20160_n1600# 0.26fF
C995 divbuf_3/a_16350_n1540# divbuf_3/a_16830_n1540# 0.11fF
C996 divbuf_3/a_47070_n840# divbuf_3/a_47070_n1540# 0.01fF
C997 pd_div_0/divbuf_0/a_27390_n840# pd_div_0/divbuf_0/a_27870_n840# 0.07fF
C998 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C999 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27390_n1540# 0.19fF
C1000 ro_div_0/divbuf_0/a_42750_n840# ro_div_0/divbuf_0/a_42750_n1540# 0.01fF
C1001 ro_div_0/divbuf_0/a_12030_n1540# ro_div_0/divbuf_0/a_12510_n1540# 0.11fF
C1002 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/a_32172_170# 0.07fF
C1003 divbuf_2/a_51360_n1600# divbuf_2/a_51390_n840# 0.04fF
C1004 divbuf_2/a_19562_n240# divbuf_2/OUT4 0.04fF
C1005 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z2 0.01fF
C1006 divbuf_0/a_22472_170# divbuf_0/a_22952_170# 0.07fF
C1007 divbuf_1/a_24960_n1600# divbuf_1/a_25440_n1600# 0.26fF
C1008 divbuf_1/a_15672_n240# divbuf_1/a_15870_n840# 0.02fF
C1009 pll_full_0/divbuf_0/a_4350_n840# pll_full_0/divbuf_0/a_4830_n840# 0.07fF
C1010 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1011 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4350_n1540# 0.19fF
C1012 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/OUT2 0.19fF
C1013 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1014 divbuf_0/a_55680_n1600# divbuf_0/a_56160_n1600# 0.26fF
C1015 pll_full_0/divbuf_0/a_57150_n1540# pll_full_0/divbuf_0/a_57630_n1540# 0.11fF
C1016 divbuf_3/a_13920_n1600# divbuf_3/a_13950_n840# 0.04fF
C1017 divbuf_1/a_17310_n1540# divbuf_1/a_17790_n1540# 0.11fF
C1018 divbuf_1/a_48030_n840# divbuf_1/a_48030_n1540# 0.01fF
C1019 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_9630_n840# 0.04fF
C1020 divbuf_0/a_48030_n1540# divbuf_0/a_48510_n1540# 0.11fF
C1021 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27840_n1600# 0.26fF
C1022 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_18270_n840# 0.02fF
C1023 divbuf_2/a_29262_n240# divbuf_2/a_29742_n240# 0.05fF
C1024 ro_div_0/divbuf_0/a_60990_n840# ro_div_0/divbuf_0/OUT5 0.04fF
C1025 divbuf_2/a_10590_n840# divbuf_2/a_10590_n1540# 0.01fF
C1026 divbuf_2/a_40830_n840# divbuf_2/a_41310_n840# 0.07fF
C1027 divbuf_2/a_40800_n1600# divbuf_2/a_40830_n1540# 0.19fF
C1028 pd_div_0/divider_0/prescaler_0/tspc_0/D pd_div_0/divider_0/clk 0.26fF
C1029 pll_full_0/divbuf_1/a_19710_n1540# pll_full_0/divbuf_1/a_20190_n1540# 0.11fF
C1030 pll_full_0/divbuf_1/a_50430_n840# pll_full_0/divbuf_1/a_50430_n1540# 0.01fF
C1031 divbuf_1/a_5852_170# divbuf_1/OUT3 0.19fF
C1032 divbuf_1/a_14880_n1600# divbuf_1/a_14910_n840# 0.04fF
C1033 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1034 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_54750_n840# 0.04fF
C1035 divbuf_3/a_11312_170# divbuf_3/a_11312_n240# 0.01fF
C1036 divbuf_3/a_30712_170# divbuf_3/a_31202_170# 0.07fF
C1037 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1038 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/a_26832_170# 0.07fF
C1039 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/a_13252_n240# 0.01fF
C1040 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n840# 0.04fF
C1041 divbuf_0/a_7792_n240# divbuf_0/OUT3 0.04fF
C1042 divbuf_3/a_3390_n840# divbuf_3/a_3870_n840# 0.07fF
C1043 divbuf_3/a_23442_170# divbuf_3/OUT4 0.19fF
C1044 divbuf_3/a_3360_n1600# divbuf_3/a_3390_n1540# 0.19fF
C1045 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_14400_n1600# 0.26fF
C1046 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z1 0.09fF
C1047 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z2 0.19fF
C1048 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1049 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_60000_n1600# 0.26fF
C1050 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17310_n840# 0.04fF
C1051 divbuf_3/a_56190_n1540# divbuf_3/a_56670_n1540# 0.11fF
C1052 pd_div_0/divbuf_0/a_6270_n1540# pd_div_0/divbuf_0/a_6750_n1540# 0.11fF
C1053 pd_div_0/divbuf_0/a_36990_n840# pd_div_0/divbuf_0/a_36990_n1540# 0.01fF
C1054 ro_div_0/divbuf_0/a_51870_n1540# ro_div_0/divbuf_0/a_52350_n1540# 0.11fF
C1055 divbuf_1/a_28292_170# divbuf_1/a_28772_170# 0.07fF
C1056 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/a_33142_n240# 0.04fF
C1057 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/a_35082_n240# 0.01fF
C1058 divbuf_0/a_23442_n240# divbuf_0/a_23922_n240# 0.05fF
C1059 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C1060 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44190_n1540# 0.19fF
C1061 pll_full_0/divbuf_0/a_13950_n840# pll_full_0/divbuf_0/a_13950_n1540# 0.01fF
C1062 pll_full_0/divbuf_0/a_44190_n840# pll_full_0/divbuf_0/a_44670_n840# 0.07fF
C1063 divbuf_1/a_4350_n840# divbuf_1/a_4830_n840# 0.07fF
C1064 divbuf_1/a_21982_170# divbuf_1/OUT4 0.19fF
C1065 divbuf_1/a_4320_n1600# divbuf_1/a_4350_n1540# 0.19fF
C1066 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n1540# 0.19fF
C1067 divbuf_0/a_35070_n840# divbuf_0/a_35550_n840# 0.07fF
C1068 divbuf_0/a_4830_n840# divbuf_0/a_4830_n1540# 0.01fF
C1069 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/a_14702_n240# 0.01fF
C1070 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/a_34592_170# 0.07fF
C1071 divbuf_3/a_53760_n1600# divbuf_3/a_53790_n840# 0.04fF
C1072 divbuf_3/a_24412_n240# divbuf_3/OUT4 0.04fF
C1073 divbuf_1/a_57150_n1540# divbuf_1/a_57630_n1540# 0.11fF
C1074 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_3870_n840# 0.04fF
C1075 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/a_11802_170# 0.07fF
C1076 ro_div_0/ro_complete_0/cbank_1/switch_5/vin ro_div_0/divider_0/clk 1.30fF
C1077 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49470_n840# 0.04fF
C1078 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1079 pll_full_0/divbuf_1/a_6750_n840# pll_full_0/divbuf_1/a_7230_n840# 0.07fF
C1080 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1081 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_6750_n1540# 0.19fF
C1082 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1083 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C1084 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1085 divbuf_2/a_27360_n1600# divbuf_2/a_27840_n1600# 0.26fF
C1086 divbuf_2/a_18092_n240# divbuf_2/a_18270_n840# 0.02fF
C1087 divbuf_2/a_19710_n1540# divbuf_2/a_20190_n1540# 0.11fF
C1088 divbuf_2/a_50430_n840# divbuf_2/a_50430_n1540# 0.01fF
C1089 pll_full_0/divbuf_1/a_59550_n1540# pll_full_0/divbuf_1/a_60030_n1540# 0.11fF
C1090 divbuf_3/a_31682_n240# divbuf_3/a_32172_n240# 0.04fF
C1091 divbuf_1/a_26352_n240# divbuf_1/OUT4 0.04fF
C1092 divbuf_1/a_54720_n1600# divbuf_1/a_54750_n840# 0.04fF
C1093 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/a_27802_n240# 0.05fF
C1094 divbuf_3/a_22560_n1600# divbuf_3/OUT4 0.01fF
C1095 divbuf_3/a_43200_n1600# divbuf_3/a_43230_n1540# 0.19fF
C1096 divbuf_3/a_12990_n840# divbuf_3/a_12990_n1540# 0.01fF
C1097 divbuf_3/a_43230_n840# divbuf_3/a_43710_n840# 0.07fF
C1098 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_54240_n1600# 0.26fF
C1099 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_38910_n1540# 0.19fF
C1100 ro_div_0/divbuf_0/a_38910_n840# ro_div_0/divbuf_0/a_39390_n840# 0.07fF
C1101 ro_div_0/divbuf_0/a_8670_n840# ro_div_0/divbuf_0/a_8670_n1540# 0.01fF
C1102 divbuf_0/a_1842_170# divbuf_0/a_1842_n240# 0.01fF
C1103 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1104 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57150_n840# 0.04fF
C1105 divbuf_2/a_17280_n1600# divbuf_2/a_17310_n840# 0.04fF
C1106 pd_div_0/divbuf_0/a_46110_n1540# pd_div_0/divbuf_0/a_46590_n1540# 0.11fF
C1107 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/clk 0.45fF
C1108 divbuf_0/a_9732_170# divbuf_0/a_10212_170# 0.07fF
C1109 divbuf_1/a_32652_n240# divbuf_1/a_33142_n240# 0.04fF
C1110 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_31200_n1600# 0.26fF
C1111 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/a_21630_n840# 0.03fF
C1112 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/a_3870_n840# 0.04fF
C1113 divbuf_0/a_21600_n1600# divbuf_0/a_22080_n1600# 0.26fF
C1114 divbuf_0/a_12282_n240# divbuf_0/a_12510_n840# 0.02fF
C1115 pll_full_0/divbuf_0/a_23070_n1540# pll_full_0/divbuf_0/a_23550_n1540# 0.11fF
C1116 pll_full_0/divbuf_0/a_53790_n840# pll_full_0/divbuf_0/a_53790_n1540# 0.01fF
C1117 divbuf_1/a_24480_n1600# divbuf_1/OUT4 0.00fF
C1118 divbuf_1/a_44160_n1600# divbuf_1/a_44190_n1540# 0.19fF
C1119 divbuf_1/a_13950_n840# divbuf_1/a_13950_n1540# 0.01fF
C1120 divbuf_1/a_44190_n840# divbuf_1/a_44670_n840# 0.07fF
C1121 divbuf_0/a_44670_n840# divbuf_0/a_44670_n1540# 0.01fF
C1122 divbuf_0/a_13950_n1540# divbuf_0/a_14430_n1540# 0.11fF
C1123 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/a_35562_n240# 0.05fF
C1124 divbuf_2/a_14702_170# divbuf_2/a_14702_n240# 0.01fF
C1125 divbuf_2/a_34112_170# divbuf_2/a_34592_170# 0.07fF
C1126 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_43710_n840# 0.04fF
C1127 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_15182_n240# 0.05fF
C1128 pll_full_0/divbuf_1/a_16350_n840# pll_full_0/divbuf_1/a_16350_n1540# 0.01fF
C1129 pll_full_0/divbuf_1/a_46590_n840# pll_full_0/divbuf_1/a_47070_n840# 0.07fF
C1130 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_46590_n1540# 0.19fF
C1131 divbuf_2/a_6750_n840# divbuf_2/a_7230_n840# 0.07fF
C1132 divbuf_2/a_30232_170# divbuf_2/OUT4 0.19fF
C1133 divbuf_2/a_6720_n1600# divbuf_2/a_6750_n1540# 0.19fF
C1134 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/B 0.08fF
C1135 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_20670_n840# 0.04fF
C1136 divbuf_2/a_59550_n1540# divbuf_2/a_60030_n1540# 0.11fF
C1137 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_5362_170# 0.07fF
C1138 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n840# 0.04fF
C1139 divbuf_3/a_29760_n1600# divbuf_3/a_30240_n1600# 0.26fF
C1140 divbuf_3/a_20532_n240# divbuf_3/a_20670_n840# 0.03fF
C1141 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/a_21982_n240# 0.05fF
C1142 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_16350_n840# 0.02fF
C1143 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25920_n1600# 0.26fF
C1144 divbuf_3/a_22110_n1540# divbuf_3/a_22590_n1540# 0.11fF
C1145 divbuf_3/a_52830_n840# divbuf_3/a_52830_n1540# 0.01fF
C1146 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33150_n1540# 0.19fF
C1147 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/a_2910_n1540# 0.01fF
C1148 pd_div_0/divbuf_0/a_33150_n840# pd_div_0/divbuf_0/a_33630_n840# 0.07fF
C1149 ro_div_0/divbuf_0/a_48510_n840# ro_div_0/divbuf_0/a_48510_n1540# 0.01fF
C1150 ro_div_0/divbuf_0/a_17790_n1540# ro_div_0/divbuf_0/a_18270_n1540# 0.11fF
C1151 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/a_37992_170# 0.07fF
C1152 divbuf_2/a_31202_n240# divbuf_2/OUT4 0.04fF
C1153 divbuf_2/a_57120_n1600# divbuf_2/a_57150_n840# 0.04fF
C1154 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1155 divbuf_0/a_28292_170# divbuf_0/a_28772_170# 0.07fF
C1156 divbuf_1/a_30720_n1600# divbuf_1/a_31200_n1600# 0.26fF
C1157 divbuf_1/a_21502_n240# divbuf_1/a_21630_n840# 0.03fF
C1158 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10110_n1540# 0.19fF
C1159 pll_full_0/divbuf_0/a_10110_n840# pll_full_0/divbuf_0/a_10590_n840# 0.07fF
C1160 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1161 divbuf_0/a_16152_170# divbuf_0/OUT4 0.19fF
C1162 divbuf_0/a_990_n840# divbuf_0/a_1470_n840# 0.07fF
C1163 divbuf_0/a_960_n1600# divbuf_0/a_990_n1540# 0.19fF
C1164 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/OUT3 0.36fF
C1165 divbuf_3/a_19680_n1600# divbuf_3/a_19710_n840# 0.04fF
C1166 divbuf_1/a_23070_n1540# divbuf_1/a_23550_n1540# 0.11fF
C1167 divbuf_1/a_53790_n840# divbuf_1/a_53790_n1540# 0.01fF
C1168 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15390_n840# 0.04fF
C1169 divbuf_0/a_53790_n1540# divbuf_0/a_54270_n1540# 0.11fF
C1170 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/a_24030_n840# 0.03fF
C1171 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33600_n1600# 0.26fF
C1172 divbuf_2/a_35082_n240# divbuf_2/a_35562_n240# 0.05fF
C1173 divbuf_2/a_16350_n840# divbuf_2/a_16350_n1540# 0.01fF
C1174 divbuf_2/a_46590_n840# divbuf_2/a_47070_n840# 0.07fF
C1175 divbuf_2/a_46560_n1600# divbuf_2/a_46590_n1540# 0.19fF
C1176 divbuf_1/a_18092_170# divbuf_1/a_18092_n240# 0.01fF
C1177 pll_full_0/divbuf_1/a_25470_n1540# pll_full_0/divbuf_1/a_25950_n1540# 0.11fF
C1178 pll_full_0/divbuf_1/a_56190_n840# pll_full_0/divbuf_1/a_56190_n1540# 0.01fF
C1179 divbuf_1/a_20640_n1600# divbuf_1/a_20670_n840# 0.04fF
C1180 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1181 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/a_60510_n840# 0.04fF
C1182 divbuf_3/a_17122_170# divbuf_3/a_17122_n240# 0.01fF
C1183 divbuf_3/a_36532_170# divbuf_3/a_37022_170# 0.07fF
C1184 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C1185 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/a_32652_170# 0.07fF
C1186 divbuf_0/a_19562_n240# divbuf_0/OUT4 0.04fF
C1187 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n840# 0.04fF
C1188 divbuf_3/a_9120_n1600# divbuf_3/a_9150_n1540# 0.19fF
C1189 divbuf_3/a_9150_n840# divbuf_3/a_9630_n840# 0.07fF
C1190 divbuf_3/a_35082_170# divbuf_3/OUT4 0.19fF
C1191 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_20160_n1600# 0.26fF
C1192 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Qbar 0.03fF
C1193 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_4830_n1540# 0.19fF
C1194 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1195 ro_div_0/divbuf_0/a_4830_n840# ro_div_0/divbuf_0/a_5310_n840# 0.07fF
C1196 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/OUT2 0.23fF
C1197 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23070_n840# 0.04fF
C1198 pd_div_0/divbuf_0/a_12030_n1540# pd_div_0/divbuf_0/a_12510_n1540# 0.11fF
C1199 pd_div_0/divbuf_0/a_42750_n840# pd_div_0/divbuf_0/a_42750_n1540# 0.01fF
C1200 ro_div_0/divbuf_0/a_57630_n1540# ro_div_0/divbuf_0/a_58110_n1540# 0.11fF
C1201 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/a_38962_n240# 0.04fF
C1202 divbuf_1/a_37502_170# divbuf_1/a_37992_170# 0.07fF
C1203 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/a_40902_n240# 0.01fF
C1204 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/a_21502_n240# 0.04fF
C1205 divbuf_1/a_10080_n1600# divbuf_1/a_10110_n1540# 0.19fF
C1206 divbuf_1/a_10110_n840# divbuf_1/a_10590_n840# 0.07fF
C1207 divbuf_1/a_37022_170# divbuf_1/OUT4 0.19fF
C1208 divbuf_0/a_29262_n240# divbuf_0/a_29742_n240# 0.05fF
C1209 pll_full_0/divbuf_0/a_19710_n840# pll_full_0/divbuf_0/a_19710_n1540# 0.01fF
C1210 pll_full_0/divbuf_0/a_49950_n840# pll_full_0/divbuf_0/a_50430_n840# 0.07fF
C1211 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C1212 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_49950_n1540# 0.19fF
C1213 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n1540# 0.19fF
C1214 divbuf_0/a_40830_n840# divbuf_0/a_41310_n840# 0.07fF
C1215 divbuf_0/a_10590_n840# divbuf_0/a_10590_n1540# 0.01fF
C1216 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/a_20532_n240# 0.01fF
C1217 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/a_40412_170# 0.07fF
C1218 divbuf_3/a_36052_n240# divbuf_3/OUT4 0.04fF
C1219 divbuf_3/a_59520_n1600# divbuf_3/a_59550_n840# 0.04fF
C1220 divbuf_1/OUT2 divbuf_1/OUT3 0.36fF
C1221 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_9630_n840# 0.04fF
C1222 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/a_20042_170# 0.07fF
C1223 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55230_n840# 0.04fF
C1224 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1225 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/OUT2 0.04fF
C1226 pll_full_0/divbuf_1/a_12510_n840# pll_full_0/divbuf_1/a_12990_n840# 0.07fF
C1227 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/OUT5 0.07fF
C1228 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12510_n1540# 0.19fF
C1229 divbuf_2/a_23922_n240# divbuf_2/a_24030_n840# 0.03fF
C1230 divbuf_2/a_33120_n1600# divbuf_2/a_33600_n1600# 0.26fF
C1231 pd_div_0/divbuf_0/a_60990_n840# pd_div_0/divbuf_0/OUT5 0.04fF
C1232 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1233 divbuf_2/a_25470_n1540# divbuf_2/a_25950_n1540# 0.11fF
C1234 divbuf_2/a_56190_n840# divbuf_2/a_56190_n1540# 0.01fF
C1235 divbuf_3/a_37502_n240# divbuf_3/a_37992_n240# 0.04fF
C1236 divbuf_1/a_37992_n240# divbuf_1/OUT4 0.04fF
C1237 divbuf_1/a_60480_n1600# divbuf_1/a_60510_n840# 0.04fF
C1238 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/a_33622_n240# 0.05fF
C1239 divbuf_3/a_18750_n840# divbuf_3/a_18750_n1540# 0.01fF
C1240 divbuf_3/a_48990_n840# divbuf_3/a_49470_n840# 0.07fF
C1241 divbuf_3/a_34080_n1600# divbuf_3/OUT4 0.01fF
C1242 divbuf_3/a_48960_n1600# divbuf_3/a_48990_n1540# 0.19fF
C1243 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_60000_n1600# 0.26fF
C1244 ro_div_0/divbuf_0/a_44670_n840# ro_div_0/divbuf_0/a_45150_n840# 0.07fF
C1245 ro_div_0/divbuf_0/a_14430_n840# ro_div_0/divbuf_0/a_14430_n1540# 0.01fF
C1246 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_44670_n1540# 0.19fF
C1247 pll_full_0/divbuf_1/a_0_n1600# pll_full_0/divbuf_1/OUT 0.26fF
C1248 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C1249 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C1250 divbuf_2/a_1352_170# divbuf_2/OUT2 0.23fF
C1251 divbuf_2/a_23040_n1600# divbuf_2/a_23070_n840# 0.04fF
C1252 pd_div_0/divbuf_0/a_51870_n1540# pd_div_0/divbuf_0/a_52350_n1540# 0.11fF
C1253 divbuf_0/a_3912_170# divbuf_0/a_4392_170# 0.07fF
C1254 divbuf_1/a_38472_n240# divbuf_1/a_38962_n240# 0.04fF
C1255 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C1256 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C1257 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C1258 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1259 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/a_27390_n840# 0.04fF
C1260 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36960_n1600# 0.26fF
C1261 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/a_9630_n840# 0.03fF
C1262 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1263 cp_0/a_1710_0# cp_0/down 0.32fF
C1264 divbuf_0/a_18092_n240# divbuf_0/a_18270_n840# 0.02fF
C1265 divbuf_0/a_27360_n1600# divbuf_0/a_27840_n1600# 0.26fF
C1266 pll_full_0/divbuf_0/a_28830_n1540# pll_full_0/divbuf_0/a_29310_n1540# 0.11fF
C1267 pll_full_0/divbuf_0/a_59550_n840# pll_full_0/divbuf_0/a_59550_n1540# 0.01fF
C1268 divbuf_1/a_19710_n840# divbuf_1/a_19710_n1540# 0.01fF
C1269 divbuf_1/a_49950_n840# divbuf_1/a_50430_n840# 0.07fF
C1270 divbuf_1/a_36000_n1600# divbuf_1/OUT4 0.00fF
C1271 divbuf_1/a_49920_n1600# divbuf_1/a_49950_n1540# 0.19fF
C1272 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/a_1470_n840# 0.03fF
C1273 divbuf_0/a_50430_n840# divbuf_0/a_50430_n1540# 0.01fF
C1274 divbuf_0/a_19710_n1540# divbuf_0/a_20190_n1540# 0.11fF
C1275 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/a_41382_n240# 0.05fF
C1276 divbuf_2/a_20532_170# divbuf_2/a_20532_n240# 0.01fF
C1277 divbuf_2/a_39932_170# divbuf_2/a_40412_170# 0.07fF
C1278 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49470_n840# 0.04fF
C1279 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/a_21012_n240# 0.05fF
C1280 pll_full_0/divbuf_1/a_22110_n840# pll_full_0/divbuf_1/a_22110_n1540# 0.01fF
C1281 pll_full_0/divbuf_1/a_52350_n840# pll_full_0/divbuf_1/a_52830_n840# 0.07fF
C1282 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52350_n1540# 0.19fF
C1283 divbuf_2/a_2322_n240# divbuf_2/OUT2 0.04fF
C1284 divbuf_2/a_12510_n840# divbuf_2/a_12990_n840# 0.07fF
C1285 divbuf_2/a_41382_170# divbuf_2/OUT5 0.07fF
C1286 divbuf_2/a_12480_n1600# divbuf_2/a_12510_n1540# 0.19fF
C1287 pll_full_0/divbuf_0/a_7302_170# pll_full_0/divbuf_0/OUT3 0.19fF
C1288 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26430_n840# 0.04fF
C1289 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/a_27802_n240# 0.05fF
C1290 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1291 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n840# 0.04fF
C1292 divbuf_3/a_35520_n1600# divbuf_3/a_36000_n1600# 0.26fF
C1293 divbuf_3/a_26352_n240# divbuf_3/a_26430_n840# 0.04fF
C1294 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/a_22110_n840# 0.03fF
C1295 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31680_n1600# 0.26fF
C1296 divbuf_3/a_27870_n1540# divbuf_3/a_28350_n1540# 0.11fF
C1297 divbuf_3/a_58590_n840# divbuf_3/a_58590_n1540# 0.01fF
C1298 pd_div_0/divbuf_0/a_8670_n840# pd_div_0/divbuf_0/a_8670_n1540# 0.01fF
C1299 pd_div_0/divbuf_0/a_38910_n840# pd_div_0/divbuf_0/a_39390_n840# 0.07fF
C1300 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_38910_n1540# 0.19fF
C1301 ro_div_0/divbuf_0/a_54270_n840# ro_div_0/divbuf_0/a_54270_n1540# 0.01fF
C1302 ro_div_0/divbuf_0/a_23550_n1540# ro_div_0/divbuf_0/a_24030_n1540# 0.11fF
C1303 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/a_3912_n240# 0.04fF
C1304 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/a_23922_n240# 0.01fF
C1305 divbuf_2/a_0_n1600# divbuf_2/OUT 0.26fF
C1306 divbuf_2/a_1920_n1600# divbuf_2/OUT2 0.00fF
C1307 divbuf_1/a_14702_170# divbuf_1/a_15182_170# 0.07fF
C1308 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/clk 0.45fF
C1309 divbuf_0/a_34112_170# divbuf_0/a_34592_170# 0.07fF
C1310 divbuf_1/a_27322_n240# divbuf_1/a_27390_n840# 0.04fF
C1311 divbuf_1/a_36480_n1600# divbuf_1/a_36960_n1600# 0.26fF
C1312 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C1313 pll_full_0/divbuf_0/a_15870_n840# pll_full_0/divbuf_0/a_16350_n840# 0.07fF
C1314 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_15870_n1540# 0.19fF
C1315 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/OUT4 0.23fF
C1316 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n1540# 0.19fF
C1317 divbuf_0/a_30232_170# divbuf_0/OUT4 0.19fF
C1318 divbuf_0/a_6750_n840# divbuf_0/a_7230_n840# 0.07fF
C1319 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C1320 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/a_5362_170# 0.07fF
C1321 divbuf_3/a_6332_170# divbuf_3/OUT3 0.19fF
C1322 divbuf_3/a_25440_n1600# divbuf_3/a_25470_n840# 0.04fF
C1323 divbuf_1/a_28830_n1540# divbuf_1/a_29310_n1540# 0.11fF
C1324 divbuf_1/a_59550_n840# divbuf_1/a_59550_n1540# 0.01fF
C1325 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21150_n840# 0.04fF
C1326 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/OUT2 0.19fF
C1327 divbuf_0/a_59550_n1540# divbuf_0/a_60030_n1540# 0.11fF
C1328 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/a_29790_n840# 0.04fF
C1329 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_39360_n1600# 0.26fF
C1330 divbuf_2/a_40902_n240# divbuf_2/a_41382_n240# 0.05fF
C1331 divbuf_2/a_22110_n840# divbuf_2/a_22110_n1540# 0.01fF
C1332 divbuf_2/a_52350_n840# divbuf_2/a_52830_n840# 0.07fF
C1333 divbuf_2/a_52320_n1600# divbuf_2/a_52350_n1540# 0.19fF
C1334 pll_full_0/divbuf_1/a_31230_n1540# pll_full_0/divbuf_1/a_31710_n1540# 0.11fF
C1335 divbuf_1/a_26400_n1600# divbuf_1/a_26430_n840# 0.04fF
C1336 divbuf_3/a_1842_n240# divbuf_3/a_2322_n240# 0.05fF
C1337 divbuf_3/a_22952_170# divbuf_3/a_22952_n240# 0.01fF
C1338 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1339 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/a_38472_170# 0.07fF
C1340 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n840# 0.04fF
C1341 divbuf_0/a_31202_n240# divbuf_0/OUT4 0.04fF
C1342 divbuf_3/a_7302_n240# divbuf_3/OUT3 0.04fF
C1343 divbuf_3/a_14910_n840# divbuf_3/a_15390_n840# 0.07fF
C1344 divbuf_3/a_14880_n1600# divbuf_3/a_14910_n1540# 0.19fF
C1345 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25920_n1600# 0.26fF
C1346 pd_div_0/pd_0/tspc_r_1/Qbar pd_div_0/pd_0/and_pd_0/Out1 0.05fF
C1347 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1348 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/a_11070_n840# 0.07fF
C1349 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_10590_n1540# 0.19fF
C1350 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_28830_n840# 0.04fF
C1351 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1352 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1353 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C1354 pd_div_0/divbuf_0/a_17790_n1540# pd_div_0/divbuf_0/a_18270_n1540# 0.11fF
C1355 pd_div_0/divbuf_0/a_48510_n840# pd_div_0/divbuf_0/a_48510_n1540# 0.01fF
C1356 ro_div_0/divbuf_0/OUT3 ro_div_0/divbuf_0/OUT4 0.36fF
C1357 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2880_n1600# 0.26fF
C1358 divbuf_1/a_3422_n240# divbuf_1/a_3912_n240# 0.04fF
C1359 divbuf_0/a_35082_n240# divbuf_0/a_35562_n240# 0.05fF
C1360 divbuf_1/a_9242_n240# divbuf_1/OUT3 0.04fF
C1361 divbuf_1/a_15870_n840# divbuf_1/a_16350_n840# 0.07fF
C1362 divbuf_1/a_15840_n1600# divbuf_1/a_15870_n1540# 0.19fF
C1363 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_55710_n1540# 0.19fF
C1364 pll_full_0/divbuf_0/a_25470_n840# pll_full_0/divbuf_0/a_25470_n1540# 0.01fF
C1365 pll_full_0/divbuf_0/a_55710_n840# pll_full_0/divbuf_0/a_56190_n840# 0.07fF
C1366 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n1540# 0.19fF
C1367 divbuf_0/a_46590_n840# divbuf_0/a_47070_n840# 0.07fF
C1368 divbuf_0/a_16350_n840# divbuf_0/a_16350_n1540# 0.01fF
C1369 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/a_6332_n240# 0.05fF
C1370 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/a_26352_n240# 0.01fF
C1371 divbuf_2/a_4882_170# divbuf_2/a_5362_170# 0.07fF
C1372 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15390_n840# 0.04fF
C1373 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/a_25862_170# 0.07fF
C1374 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1375 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1376 pll_full_0/divbuf_1/a_18270_n840# pll_full_0/divbuf_1/a_18750_n840# 0.07fF
C1377 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18270_n1540# 0.19fF
C1378 divbuf_2/a_29742_n240# divbuf_2/a_29790_n840# 0.04fF
C1379 divbuf_2/a_38880_n1600# divbuf_2/a_39360_n1600# 0.26fF
C1380 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1381 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z4 0.12fF
C1382 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C1383 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_12990_n840# 0.01fF
C1384 divbuf_2/a_31230_n1540# divbuf_2/a_31710_n1540# 0.11fF
C1385 divbuf_3/a_1440_n1600# divbuf_3/a_1920_n1600# 0.26fF
C1386 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/a_39442_n240# 0.05fF
C1387 divbuf_3/a_54720_n1600# divbuf_3/a_54750_n1540# 0.19fF
C1388 divbuf_3/a_24510_n840# divbuf_3/a_24510_n1540# 0.01fF
C1389 divbuf_3/a_54750_n840# divbuf_3/a_55230_n840# 0.07fF
C1390 pd_div_0/divbuf_0/a_4830_n840# pd_div_0/divbuf_0/a_5310_n840# 0.07fF
C1391 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_4830_n1540# 0.19fF
C1392 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50430_n1540# 0.19fF
C1393 ro_div_0/divbuf_0/a_50430_n840# ro_div_0/divbuf_0/a_50910_n840# 0.07fF
C1394 ro_div_0/divbuf_0/a_20190_n840# ro_div_0/divbuf_0/a_20190_n1540# 0.01fF
C1395 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1396 divbuf_2/a_28800_n1600# divbuf_2/a_28830_n840# 0.04fF
C1397 divbuf_2/a_13252_170# divbuf_2/OUT4 0.19fF
C1398 pd_div_0/divbuf_0/a_57630_n1540# pd_div_0/divbuf_0/a_58110_n1540# 0.11fF
C1399 divbuf_1/a_2400_n1600# divbuf_1/a_2880_n1600# 0.26fF
C1400 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1401 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1402 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42720_n1600# 0.26fF
C1403 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/a_33150_n840# 0.06fF
C1404 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_15870_n840# 0.02fF
C1405 divbuf_0/a_33120_n1600# divbuf_0/a_33600_n1600# 0.26fF
C1406 divbuf_0/a_23922_n240# divbuf_0/a_24030_n840# 0.03fF
C1407 divbuf_0/a_8762_170# divbuf_0/OUT3 0.19fF
C1408 pll_full_0/divbuf_0/a_34590_n1540# pll_full_0/divbuf_0/a_35070_n1540# 0.11fF
C1409 divbuf_3/a_12282_n240# divbuf_3/a_12030_n840# 0.02fF
C1410 divbuf_1/a_55680_n1600# divbuf_1/a_55710_n1540# 0.19fF
C1411 divbuf_1/a_25470_n840# divbuf_1/a_25470_n1540# 0.01fF
C1412 divbuf_1/a_55710_n840# divbuf_1/a_56190_n840# 0.07fF
C1413 divbuf_0/a_56190_n840# divbuf_0/a_56190_n1540# 0.01fF
C1414 divbuf_0/a_25470_n1540# divbuf_0/a_25950_n1540# 0.11fF
C1415 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_5280_n1600# 0.26fF
C1416 divbuf_2/a_5852_n240# divbuf_2/a_6332_n240# 0.05fF
C1417 divbuf_2/a_26352_170# divbuf_2/a_26352_n240# 0.01fF
C1418 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1419 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55230_n840# 0.04fF
C1420 pll_full_0/divbuf_1/a_27870_n840# pll_full_0/divbuf_1/a_27870_n1540# 0.01fF
C1421 pll_full_0/divbuf_1/a_58110_n840# pll_full_0/divbuf_1/a_58590_n840# 0.07fF
C1422 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58110_n1540# 0.19fF
C1423 divbuf_2/a_14222_n240# divbuf_2/OUT4 0.04fF
C1424 divbuf_2/a_18270_n840# divbuf_2/a_18750_n840# 0.07fF
C1425 divbuf_2/a_18240_n1600# divbuf_2/a_18270_n1540# 0.19fF
C1426 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1427 divbuf_3/a_7302_170# divbuf_3/a_7792_170# 0.07fF
C1428 divbuf_1/a_13252_n240# divbuf_1/a_12990_n840# 0.01fF
C1429 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1430 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32190_n840# 0.04fF
C1431 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1432 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/a_33622_n240# 0.05fF
C1433 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n840# 0.04fF
C1434 divbuf_3/a_41280_n1600# divbuf_3/a_41760_n1600# 0.26fF
C1435 divbuf_3/a_32172_n240# divbuf_3/a_32190_n840# 0.06fF
C1436 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_37440_n1600# 0.26fF
C1437 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/a_27870_n840# 0.04fF
C1438 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_15390_n840# 0.01fF
C1439 divbuf_3/a_33630_n1540# divbuf_3/a_34110_n1540# 0.11fF
C1440 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_44670_n1540# 0.19fF
C1441 pd_div_0/divbuf_0/a_14430_n840# pd_div_0/divbuf_0/a_14430_n1540# 0.01fF
C1442 pd_div_0/divbuf_0/a_44670_n840# pd_div_0/divbuf_0/a_45150_n840# 0.07fF
C1443 ro_div_0/divbuf_0/a_60030_n840# ro_div_0/divbuf_0/a_60030_n1540# 0.01fF
C1444 ro_div_0/divbuf_0/a_29310_n1540# ro_div_0/divbuf_0/a_29790_n1540# 0.11fF
C1445 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/a_29742_n240# 0.01fF
C1446 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/a_9732_n240# 0.04fF
C1447 divbuf_2/a_12480_n1600# divbuf_2/OUT4 0.00fF
C1448 divbuf_0/a_39932_170# divbuf_0/a_40412_170# 0.07fF
C1449 divbuf_0/a_20532_170# divbuf_0/a_20532_n240# 0.01fF
C1450 divbuf_1/a_42240_n1600# divbuf_1/a_42720_n1600# 0.26fF
C1451 divbuf_1/a_31202_170# divbuf_1/OUT4 0.19fF
C1452 divbuf_1/a_33142_n240# divbuf_1/a_33150_n840# 0.06fF
C1453 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_21630_n1540# 0.19fF
C1454 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1455 pll_full_0/divbuf_0/a_21630_n840# pll_full_0/divbuf_0/a_22110_n840# 0.07fF
C1456 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1457 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n1540# 0.19fF
C1458 divbuf_0/a_41382_170# divbuf_0/OUT5 0.07fF
C1459 divbuf_0/a_12510_n840# divbuf_0/a_12990_n840# 0.07fF
C1460 divbuf_0/a_2322_n240# divbuf_0/OUT2 0.04fF
C1461 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/a_11802_170# 0.07fF
C1462 divbuf_3/a_31200_n1600# divbuf_3/a_31230_n840# 0.04fF
C1463 divbuf_3/a_18092_170# divbuf_3/OUT4 0.19fF
C1464 divbuf_1/a_34590_n1540# divbuf_1/a_35070_n1540# 0.11fF
C1465 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_26910_n840# 0.04fF
C1466 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/a_35550_n840# 0.05fF
C1467 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_45120_n1600# 0.26fF
C1468 divbuf_2/a_4800_n1600# divbuf_2/a_5280_n1600# 0.26fF
C1469 divbuf_2/a_27870_n840# divbuf_2/a_27870_n1540# 0.01fF
C1470 divbuf_2/a_58110_n840# divbuf_2/a_58590_n840# 0.07fF
C1471 divbuf_2/a_58080_n1600# divbuf_2/a_58110_n1540# 0.19fF
C1472 pll_full_0/divbuf_1/a_36990_n1540# pll_full_0/divbuf_1/a_37470_n1540# 0.11fF
C1473 divbuf_1/a_32160_n1600# divbuf_1/a_32190_n840# 0.04fF
C1474 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C1475 divbuf_3/a_8272_n240# divbuf_3/a_8762_n240# 0.04fF
C1476 divbuf_3/a_28772_170# divbuf_3/a_28772_n240# 0.01fF
C1477 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/a_24412_n240# 0.01fF
C1478 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/a_4392_n240# 0.05fF
C1479 divbuf_0/a_1920_n1600# divbuf_0/OUT2 0.00fF
C1480 divbuf_0/a_0_n1600# divbuf_0/OUT 0.26fF
C1481 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C1482 divbuf_3/a_20640_n1600# divbuf_3/a_20670_n1540# 0.19fF
C1483 divbuf_3/a_19072_n240# divbuf_3/OUT4 0.04fF
C1484 divbuf_3/a_20670_n840# divbuf_3/a_21150_n840# 0.07fF
C1485 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31680_n1600# 0.26fF
C1486 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/a_22110_n840# 0.03fF
C1487 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/a_15182_170# 0.07fF
C1488 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16350_n1540# 0.19fF
C1489 ro_div_0/divbuf_0/a_16350_n840# ro_div_0/divbuf_0/a_16830_n840# 0.07fF
C1490 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C1491 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1492 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_34590_n840# 0.04fF
C1493 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C1494 divbuf_2/a_15672_n240# divbuf_2/a_15390_n840# 0.01fF
C1495 pd_div_0/divbuf_0/a_23550_n1540# pd_div_0/divbuf_0/a_24030_n1540# 0.11fF
C1496 pd_div_0/divbuf_0/a_54270_n840# pd_div_0/divbuf_0/a_54270_n1540# 0.01fF
C1497 divbuf_0/a_18092_170# divbuf_0/a_18582_170# 0.07fF
C1498 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8640_n1600# 0.26fF
C1499 divbuf_1/a_9242_n240# divbuf_1/a_9732_n240# 0.04fF
C1500 divbuf_0/a_40902_n240# divbuf_0/a_41382_n240# 0.05fF
C1501 divbuf_1/a_21600_n1600# divbuf_1/a_21630_n1540# 0.19fF
C1502 divbuf_1/a_21012_n240# divbuf_1/OUT4 0.04fF
C1503 divbuf_1/a_21630_n840# divbuf_1/a_22110_n840# 0.07fF
C1504 pll_full_0/divbuf_0/a_510_n1540# pll_full_0/divbuf_0/a_990_n1540# 0.11fF
C1505 pll_full_0/divbuf_0/a_31230_n840# pll_full_0/divbuf_0/a_31230_n1540# 0.01fF
C1506 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n1540# 0.19fF
C1507 divbuf_0/a_52350_n840# divbuf_0/a_52830_n840# 0.07fF
C1508 divbuf_0/a_22110_n840# divbuf_0/a_22110_n1540# 0.01fF
C1509 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/a_32172_n240# 0.01fF
C1510 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12772_n240# 0.04fF
C1511 divbuf_2/a_11312_170# divbuf_2/a_11802_170# 0.07fF
C1512 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21150_n840# 0.04fF
C1513 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/a_31682_170# 0.07fF
C1514 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C1515 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1516 pll_full_0/divbuf_1/a_24030_n840# pll_full_0/divbuf_1/a_24510_n840# 0.07fF
C1517 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24030_n1540# 0.19fF
C1518 divbuf_2/a_35562_n240# divbuf_2/a_35550_n840# 0.05fF
C1519 divbuf_2/a_44640_n1600# divbuf_2/a_45120_n1600# 0.26fF
C1520 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1521 divbuf_2/a_36990_n1540# divbuf_2/a_37470_n1540# 0.11fF
C1522 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1523 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1524 divbuf_1/a_19200_n1600# divbuf_1/OUT4 0.00fF
C1525 divbuf_3/a_7200_n1600# divbuf_3/a_7680_n1600# 0.26fF
C1526 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_3360_n1600# 0.26fF
C1527 divbuf_3/a_30270_n840# divbuf_3/a_30270_n1540# 0.01fF
C1528 divbuf_3/a_60510_n840# divbuf_3/a_60990_n840# 0.07fF
C1529 divbuf_3/a_60480_n1600# divbuf_3/a_60510_n1540# 0.19fF
C1530 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_10590_n1540# 0.19fF
C1531 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/a_11070_n840# 0.07fF
C1532 ro_div_0/divbuf_0/a_56190_n840# ro_div_0/divbuf_0/a_56670_n840# 0.07fF
C1533 ro_div_0/divbuf_0/a_25950_n840# ro_div_0/divbuf_0/a_25950_n1540# 0.01fF
C1534 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56190_n1540# 0.19fF
C1535 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1536 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/a_8272_n240# 0.01fF
C1537 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/a_16642_170# 0.07fF
C1538 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1539 divbuf_2/a_24892_170# divbuf_2/OUT4 0.19fF
C1540 divbuf_2/a_34560_n1600# divbuf_2/a_34590_n840# 0.04fF
C1541 pd_div_0/divbuf_0/OUT3 pd_div_0/divbuf_0/OUT4 0.36fF
C1542 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/a_38910_n840# 0.04fF
C1543 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/OUT3 0.19fF
C1544 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48480_n1600# 0.26fF
C1545 divbuf_1/a_8160_n1600# divbuf_1/a_8640_n1600# 0.26fF
C1546 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C1547 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C1548 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1549 divbuf_0/a_38880_n1600# divbuf_0/a_39360_n1600# 0.26fF
C1550 divbuf_0/a_29742_n240# divbuf_0/a_29790_n840# 0.04fF
C1551 pll_full_0/divbuf_0/a_40350_n1540# pll_full_0/divbuf_0/a_40830_n1540# 0.11fF
C1552 divbuf_3/a_18092_n240# divbuf_3/a_17790_n840# 0.00fF
C1553 divbuf_1/a_510_n1540# divbuf_1/a_990_n1540# 0.11fF
C1554 divbuf_1/a_31230_n840# divbuf_1/a_31230_n1540# 0.01fF
C1555 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_13470_n840# 0.01fF
C1556 divbuf_0/a_31230_n1540# divbuf_0/a_31710_n1540# 0.11fF
C1557 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_11040_n1600# 0.26fF
C1558 divbuf_2/a_32172_170# divbuf_2/a_32172_n240# 0.01fF
C1559 divbuf_2/a_12282_n240# divbuf_2/a_12772_n240# 0.04fF
C1560 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1561 pll_full_0/divbuf_1/a_2910_n1540# pll_full_0/divbuf_1/a_3390_n1540# 0.11fF
C1562 pll_full_0/divbuf_1/a_33630_n840# pll_full_0/divbuf_1/a_33630_n1540# 0.01fF
C1563 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/a_16152_n240# 0.01fF
C1564 divbuf_2/a_25862_n240# divbuf_2/OUT4 0.04fF
C1565 divbuf_2/a_24030_n840# divbuf_2/a_24510_n840# 0.07fF
C1566 divbuf_2/a_24000_n1600# divbuf_2/a_24030_n1540# 0.19fF
C1567 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z4 0.12fF
C1568 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1569 divbuf_3/a_13742_170# divbuf_3/a_14222_170# 0.07fF
C1570 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1571 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_37950_n840# 0.04fF
C1572 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1573 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_2/v 0.08fF
C1574 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/a_39442_n240# 0.05fF
C1575 divbuf_0/a_12772_170# divbuf_0/OUT4 0.19fF
C1576 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n840# 0.04fF
C1577 divbuf_3/a_37992_n240# divbuf_3/a_37950_n840# 0.04fF
C1578 divbuf_3/a_47040_n1600# divbuf_3/a_47520_n1600# 0.26fF
C1579 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/a_33630_n840# 0.06fF
C1580 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/OUT3 0.19fF
C1581 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_43200_n1600# 0.26fF
C1582 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_510_n840# 0.04fF
C1583 divbuf_3/a_39390_n1540# divbuf_3/a_39870_n1540# 0.11fF
C1584 pd_div_0/divbuf_0/a_20190_n840# pd_div_0/divbuf_0/a_20190_n1540# 0.01fF
C1585 pd_div_0/divbuf_0/a_50430_n840# pd_div_0/divbuf_0/a_50910_n840# 0.07fF
C1586 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50430_n1540# 0.19fF
C1587 ro_div_0/divbuf_0/a_35070_n1540# ro_div_0/divbuf_0/a_35550_n1540# 0.11fF
C1588 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_510_n840# 0.07fF
C1589 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_16152_n240# 0.05fF
C1590 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/a_35562_n240# 0.01fF
C1591 divbuf_2/a_24000_n1600# divbuf_2/OUT4 0.00fF
C1592 divbuf_0/a_26352_170# divbuf_0/a_26352_n240# 0.01fF
C1593 divbuf_0/a_5852_n240# divbuf_0/a_6332_n240# 0.05fF
C1594 divbuf_1/a_38962_n240# divbuf_1/a_38910_n840# 0.04fF
C1595 divbuf_1/a_48000_n1600# divbuf_1/a_48480_n1600# 0.26fF
C1596 divbuf_1/a_2322_170# divbuf_1/OUT3 0.07fF
C1597 pll_full_0/divbuf_0/a_27390_n840# pll_full_0/divbuf_0/a_27870_n840# 0.07fF
C1598 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1599 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27390_n1540# 0.19fF
C1600 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1601 io_clamp_low[2] io_analog[6] 0.53fF
C1602 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n1540# 0.19fF
C1603 divbuf_0/a_18270_n840# divbuf_0/a_18750_n840# 0.07fF
C1604 divbuf_0/a_14222_n240# divbuf_0/OUT4 0.04fF
C1605 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/a_17612_170# 0.07fF
C1606 divbuf_3/a_29742_170# divbuf_3/OUT4 0.19fF
C1607 divbuf_3/a_36960_n1600# divbuf_3/a_36990_n840# 0.04fF
C1608 divbuf_1/a_40350_n1540# divbuf_1/a_40830_n1540# 0.11fF
C1609 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_32670_n840# 0.04fF
C1610 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1611 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50880_n1600# 0.26fF
C1612 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/a_41310_n840# 0.03fF
C1613 divbuf_2/a_10560_n1600# divbuf_2/a_11040_n1600# 0.26fF
C1614 pll_full_0/divbuf_1/a_42750_n1540# pll_full_0/divbuf_1/a_43230_n1540# 0.11fF
C1615 divbuf_2/a_2910_n1540# divbuf_2/a_3390_n1540# 0.11fF
C1616 divbuf_2/a_33630_n840# divbuf_2/a_33630_n1540# 0.01fF
C1617 divbuf_1/a_14222_170# divbuf_1/a_14222_n240# 0.01fF
C1618 divbuf_3/a_14702_n240# divbuf_3/a_15182_n240# 0.05fF
C1619 divbuf_3/a_34592_170# divbuf_3/a_34592_n240# 0.01fF
C1620 divbuf_1/a_28292_170# divbuf_1/OUT4 0.19fF
C1621 divbuf_1/a_37920_n1600# divbuf_1/a_37950_n840# 0.04fF
C1622 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/a_27870_n840# 0.04fF
C1623 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_37440_n1600# 0.26fF
C1624 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/a_10212_n240# 0.05fF
C1625 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/a_30232_n240# 0.01fF
C1626 divbuf_0/a_12480_n1600# divbuf_0/OUT4 0.00fF
C1627 divbuf_3/a_26430_n840# divbuf_3/a_26910_n840# 0.07fF
C1628 divbuf_3/a_30712_n240# divbuf_3/OUT4 0.04fF
C1629 divbuf_3/a_26400_n1600# divbuf_3/a_26430_n1540# 0.19fF
C1630 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/a_2322_n240# 0.01fF
C1631 ro_div_0/divbuf_0/a_22110_n840# ro_div_0/divbuf_0/a_22590_n840# 0.07fF
C1632 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1633 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22110_n1540# 0.19fF
C1634 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40350_n840# 0.04fF
C1635 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1636 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C1637 divbuf_2/a_480_n1600# divbuf_2/a_510_n840# 0.04fF
C1638 pd_div_0/divbuf_0/a_29310_n1540# pd_div_0/divbuf_0/a_29790_n1540# 0.11fF
C1639 pd_div_0/divbuf_0/a_60030_n840# pd_div_0/divbuf_0/a_60030_n1540# 0.01fF
C1640 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_14400_n1600# 0.26fF
C1641 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/a_4350_n840# 0.04fF
C1642 divbuf_1/a_15672_n240# divbuf_1/a_16152_n240# 0.05fF
C1643 divbuf_1/a_35562_170# divbuf_1/a_35562_n240# 0.01fF
C1644 divbuf_0/a_4800_n1600# divbuf_0/a_5280_n1600# 0.26fF
C1645 divbuf_1/a_27390_n840# divbuf_1/a_27870_n840# 0.07fF
C1646 divbuf_1/a_32652_n240# divbuf_1/OUT4 0.04fF
C1647 divbuf_1/a_27360_n1600# divbuf_1/a_27390_n1540# 0.19fF
C1648 pll_full_0/divbuf_0/a_6270_n1540# pll_full_0/divbuf_0/a_6750_n1540# 0.11fF
C1649 pll_full_0/divbuf_0/a_36990_n840# pll_full_0/divbuf_0/a_36990_n1540# 0.01fF
C1650 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n1540# 0.19fF
C1651 divbuf_0/a_58110_n840# divbuf_0/a_58590_n840# 0.07fF
C1652 divbuf_0/a_27870_n840# divbuf_0/a_27870_n1540# 0.01fF
C1653 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_18582_n240# 0.04fF
C1654 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/a_37992_n240# 0.01fF
C1655 divbuf_2/a_17122_170# divbuf_2/a_17612_170# 0.07fF
C1656 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_26910_n840# 0.04fF
C1657 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/a_17612_n240# 0.01fF
C1658 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/a_37502_170# 0.07fF
C1659 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C1660 pll_full_0/divbuf_1/a_29790_n840# pll_full_0/divbuf_1/a_30270_n840# 0.07fF
C1661 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1662 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_29790_n1540# 0.19fF
C1663 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1664 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1665 divbuf_2/a_50400_n1600# divbuf_2/a_50880_n1600# 0.26fF
C1666 divbuf_2/a_41382_n240# divbuf_2/a_41310_n840# 0.03fF
C1667 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/clk 0.45fF
C1668 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C1669 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_3870_n840# 0.04fF
C1670 divbuf_2/a_42750_n1540# divbuf_2/a_43230_n1540# 0.11fF
C1671 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1672 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1673 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1674 divbuf_0/a_15672_n240# divbuf_0/a_15390_n840# 0.01fF
C1675 divbuf_3/a_12960_n1600# divbuf_3/a_13440_n1600# 0.26fF
C1676 divbuf_3/a_3422_n240# divbuf_3/a_3390_n840# 0.05fF
C1677 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_9120_n1600# 0.26fF
C1678 divbuf_3/a_5310_n1540# divbuf_3/a_5790_n1540# 0.11fF
C1679 divbuf_3/a_36030_n840# divbuf_3/a_36030_n1540# 0.01fF
C1680 pd_div_0/divbuf_0/a_16350_n840# pd_div_0/divbuf_0/a_16830_n840# 0.07fF
C1681 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16350_n1540# 0.19fF
C1682 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/OUT2 0.02fF
C1683 ro_div_0/divbuf_0/a_31710_n840# ro_div_0/divbuf_0/a_31710_n1540# 0.01fF
C1684 ro_div_0/divbuf_0/a_990_n1540# ro_div_0/divbuf_0/a_1470_n1540# 0.11fF
C1685 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1686 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/a_21012_170# 0.07fF
C1687 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/a_2322_n240# 0.01fF
C1688 divbuf_2/a_40320_n1600# divbuf_2/a_40350_n840# 0.04fF
C1689 divbuf_2/a_36532_170# divbuf_2/OUT4 0.19fF
C1690 divbuf_1/a_31682_170# divbuf_1/a_32172_170# 0.07fF
C1691 divbuf_0/a_11312_170# divbuf_0/a_11802_170# 0.07fF
C1692 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_54240_n1600# 0.26fF
C1693 divbuf_1/a_13920_n1600# divbuf_1/a_14400_n1600# 0.26fF
C1694 divbuf_1/a_4392_n240# divbuf_1/a_4350_n840# 0.04fF
C1695 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C1696 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1697 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/a_3912_170# 0.07fF
C1698 divbuf_0/a_44640_n1600# divbuf_0/a_45120_n1600# 0.26fF
C1699 divbuf_0/a_35562_n240# divbuf_0/a_35550_n840# 0.05fF
C1700 divbuf_1/a_6270_n1540# divbuf_1/a_6750_n1540# 0.11fF
C1701 divbuf_1/a_36990_n840# divbuf_1/a_36990_n1540# 0.01fF
C1702 pll_full_0/divbuf_0/a_46110_n1540# pll_full_0/divbuf_0/a_46590_n1540# 0.11fF
C1703 divbuf_3/a_2880_n1600# divbuf_3/a_2910_n840# 0.04fF
C1704 divbuf_0/a_36990_n1540# divbuf_0/a_37470_n1540# 0.11fF
C1705 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16800_n1600# 0.26fF
C1706 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/a_6750_n840# 0.03fF
C1707 divbuf_2/a_18092_n240# divbuf_2/a_18582_n240# 0.04fF
C1708 divbuf_2/a_37992_170# divbuf_2/a_37992_n240# 0.01fF
C1709 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C1710 pll_full_0/divbuf_1/a_8670_n1540# pll_full_0/divbuf_1/a_9150_n1540# 0.11fF
C1711 pll_full_0/divbuf_1/a_39390_n840# pll_full_0/divbuf_1/a_39390_n1540# 0.01fF
C1712 divbuf_2/a_29790_n840# divbuf_2/a_30270_n840# 0.07fF
C1713 divbuf_2/a_37502_n240# divbuf_2/OUT4 0.04fF
C1714 divbuf_2/a_29760_n1600# divbuf_2/a_29790_n1540# 0.19fF
C1715 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1716 divbuf_3/a_19562_170# divbuf_3/a_20042_170# 0.07fF
C1717 divbuf_1/a_3840_n1600# divbuf_1/a_3870_n840# 0.04fF
C1718 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C1719 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_43710_n840# 0.04fF
C1720 pd_div_0/divbuf_0/a_3912_170# pd_div_0/divbuf_0/OUT3 0.19fF
C1721 ro_div_0/ro_complete_0/cbank_2/switch_4/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C1722 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/a_17122_170# 0.07fF
C1723 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/a_8762_n240# 0.01fF
C1724 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_3360_n1600# 0.26fF
C1725 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n840# 0.04fF
C1726 divbuf_0/a_24892_170# divbuf_0/OUT4 0.19fF
C1727 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C1728 divbuf_3/a_52800_n1600# divbuf_3/a_53280_n1600# 0.26fF
C1729 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48960_n1600# 0.26fF
C1730 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/OUT3 0.19fF
C1731 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/a_39390_n840# 0.04fF
C1732 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6270_n840# 0.04fF
C1733 divbuf_3/a_45150_n1540# divbuf_3/a_45630_n1540# 0.11fF
C1734 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56190_n1540# 0.19fF
C1735 pd_div_0/divbuf_0/a_25950_n840# pd_div_0/divbuf_0/a_25950_n1540# 0.01fF
C1736 pd_div_0/divbuf_0/a_56190_n840# pd_div_0/divbuf_0/a_56670_n840# 0.07fF
C1737 ro_div_0/divbuf_0/a_40830_n1540# ro_div_0/divbuf_0/a_41310_n1540# 0.11fF
C1738 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/a_41382_n240# 0.01fF
C1739 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/a_21982_n240# 0.05fF
C1740 divbuf_2/a_35520_n1600# divbuf_2/OUT4 0.00fF
C1741 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/a_23922_n240# 0.01fF
C1742 divbuf_0/a_12282_n240# divbuf_0/a_12772_n240# 0.04fF
C1743 divbuf_0/a_32172_170# divbuf_0/a_32172_n240# 0.01fF
C1744 divbuf_1/a_53760_n1600# divbuf_1/a_54240_n1600# 0.26fF
C1745 divbuf_1/a_14702_170# divbuf_1/OUT4 0.19fF
C1746 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33150_n1540# 0.19fF
C1747 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/a_2910_n1540# 0.01fF
C1748 pll_full_0/divbuf_0/a_33150_n840# pll_full_0/divbuf_0/a_33630_n840# 0.07fF
C1749 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C1750 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/a_16642_n240# 0.01fF
C1751 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n1540# 0.19fF
C1752 divbuf_0/a_24030_n840# divbuf_0/a_24510_n840# 0.07fF
C1753 divbuf_0/a_25862_n240# divbuf_0/OUT4 0.04fF
C1754 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/a_23442_170# 0.07fF
C1755 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/a_2322_n240# 0.01fF
C1756 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C1757 divbuf_3/a_42720_n1600# divbuf_3/a_42750_n840# 0.04fF
C1758 divbuf_3/a_1842_n240# divbuf_3/OUT2 0.04fF
C1759 divbuf_3/a_41382_170# divbuf_3/OUT4 0.19fF
C1760 divbuf_1/a_46110_n1540# divbuf_1/a_46590_n1540# 0.11fF
C1761 pd_div_0/pd_0/R pd_div_0/pd_0/and_pd_0/Z1 0.02fF
C1762 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/tspc_r_1/z5 0.20fF
C1763 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38430_n840# 0.04fF
C1764 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1765 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/OUT3 0.19fF
C1766 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56640_n1600# 0.26fF
C1767 divbuf_2/a_16320_n1600# divbuf_2/a_16800_n1600# 0.26fF
C1768 divbuf_2/a_6822_n240# divbuf_2/a_6750_n840# 0.03fF
C1769 pll_full_0/divbuf_1/a_48510_n1540# pll_full_0/divbuf_1/a_48990_n1540# 0.11fF
C1770 divbuf_2/a_8670_n1540# divbuf_2/a_9150_n1540# 0.11fF
C1771 divbuf_2/a_39390_n840# divbuf_2/a_39390_n1540# 0.01fF
C1772 divbuf_1/a_19562_170# divbuf_1/a_19562_n240# 0.01fF
C1773 divbuf_3/a_20532_n240# divbuf_3/a_21012_n240# 0.05fF
C1774 divbuf_3/a_40412_170# divbuf_3/a_40412_n240# 0.01fF
C1775 divbuf_1/a_3912_n240# divbuf_1/OUT3 0.04fF
C1776 divbuf_1/a_43680_n1600# divbuf_1/a_43710_n840# 0.04fF
C1777 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/a_36052_n240# 0.01fF
C1778 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_16642_n240# 0.04fF
C1779 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_43200_n1600# 0.26fF
C1780 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/a_33630_n840# 0.06fF
C1781 divbuf_0/a_24000_n1600# divbuf_0/OUT4 0.00fF
C1782 divbuf_3/a_1440_n1600# divbuf_3/OUT2 0.01fF
C1783 divbuf_3/a_32160_n1600# divbuf_3/a_32190_n1540# 0.19fF
C1784 divbuf_3/a_1950_n840# divbuf_3/a_1950_n1540# 0.01fF
C1785 divbuf_3/a_32190_n840# divbuf_3/a_32670_n840# 0.07fF
C1786 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_27870_n1540# 0.19fF
C1787 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1788 ro_div_0/divbuf_0/a_27870_n840# ro_div_0/divbuf_0/a_28350_n840# 0.07fF
C1789 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C1790 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46110_n840# 0.04fF
C1791 divbuf_2/a_6240_n1600# divbuf_2/a_6270_n840# 0.04fF
C1792 pd_div_0/divbuf_0/a_35070_n1540# pd_div_0/divbuf_0/a_35550_n1540# 0.11fF
C1793 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Q 0.04fF
C1794 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_20160_n1600# 0.26fF
C1795 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/a_10110_n840# 0.03fF
C1796 divbuf_1/a_41382_170# divbuf_1/a_41382_n240# 0.01fF
C1797 divbuf_1/a_21502_n240# divbuf_1/a_21982_n240# 0.05fF
C1798 divbuf_0/a_10560_n1600# divbuf_0/a_11040_n1600# 0.26fF
C1799 divbuf_1/a_33120_n1600# divbuf_1/a_33150_n1540# 0.19fF
C1800 divbuf_1/a_2910_n840# divbuf_1/a_2910_n1540# 0.01fF
C1801 divbuf_1/a_33150_n840# divbuf_1/a_33630_n840# 0.07fF
C1802 pll_full_0/divbuf_0/a_12030_n1540# pll_full_0/divbuf_0/a_12510_n1540# 0.11fF
C1803 pll_full_0/divbuf_0/a_42750_n840# pll_full_0/divbuf_0/a_42750_n1540# 0.01fF
C1804 divbuf_0/a_33630_n840# divbuf_0/a_33630_n1540# 0.01fF
C1805 divbuf_0/a_2910_n1540# divbuf_0/a_3390_n1540# 0.11fF
C1806 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/a_24412_n240# 0.04fF
C1807 divbuf_2/a_22952_170# divbuf_2/a_23442_170# 0.07fF
C1808 divbuf_2/a_2322_170# divbuf_2/a_2322_n240# 0.01fF
C1809 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_32670_n840# 0.04fF
C1810 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C1811 pll_full_0/divbuf_1/a_5310_n840# pll_full_0/divbuf_1/a_5310_n1540# 0.01fF
C1812 pll_full_0/divbuf_1/a_35550_n840# pll_full_0/divbuf_1/a_36030_n840# 0.07fF
C1813 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_35550_n1540# 0.19fF
C1814 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1815 divbuf_2/a_7792_170# divbuf_2/OUT3 0.19fF
C1816 divbuf_2/a_56160_n1600# divbuf_2/a_56640_n1600# 0.26fF
C1817 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/nor_0/B 0.35fF
C1818 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C1819 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_9630_n840# 0.04fF
C1820 divbuf_2/a_48510_n1540# divbuf_2/a_48990_n1540# 0.11fF
C1821 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.00fF
C1822 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/A 0.35fF
C1823 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1824 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1825 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1826 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_12990_n840# 0.01fF
C1827 divbuf_0/a_480_n1600# divbuf_0/a_510_n840# 0.04fF
C1828 pll_full_0/divbuf_0/a_60990_n840# pll_full_0/divbuf_0/OUT5 0.04fF
C1829 divbuf_3/a_18720_n1600# divbuf_3/a_19200_n1600# 0.26fF
C1830 divbuf_3/a_9242_n240# divbuf_3/a_9150_n840# 0.03fF
C1831 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/a_4830_n840# 0.04fF
C1832 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14880_n1600# 0.26fF
C1833 divbuf_3/a_11070_n1540# divbuf_3/a_11550_n1540# 0.11fF
C1834 divbuf_3/a_41790_n840# divbuf_3/a_41790_n1540# 0.01fF
C1835 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22110_n1540# 0.19fF
C1836 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1837 pd_div_0/divbuf_0/a_22110_n840# pd_div_0/divbuf_0/a_22590_n840# 0.07fF
C1838 ro_div_0/divbuf_0/a_37470_n840# ro_div_0/divbuf_0/a_37470_n1540# 0.01fF
C1839 ro_div_0/divbuf_0/a_6750_n1540# ro_div_0/divbuf_0/a_7230_n1540# 0.11fF
C1840 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/a_13252_n240# 0.01fF
C1841 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/a_26832_170# 0.07fF
C1842 divbuf_2/a_8762_n240# divbuf_2/OUT3 0.04fF
C1843 divbuf_2/a_46080_n1600# divbuf_2/a_46110_n840# 0.04fF
C1844 divbuf_0/a_14702_170# divbuf_0/a_15182_170# 0.07fF
C1845 divbuf_0/a_3912_170# divbuf_0/a_3912_n240# 0.01fF
C1846 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_60000_n1600# 0.26fF
C1847 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1848 divbuf_1/a_19680_n1600# divbuf_1/a_20160_n1600# 0.26fF
C1849 divbuf_1/a_10212_n240# divbuf_1/a_10110_n840# 0.03fF
C1850 divbuf_0/a_41382_n240# divbuf_0/a_41310_n840# 0.03fF
C1851 divbuf_0/a_50400_n1600# divbuf_0/a_50880_n1600# 0.26fF
C1852 divbuf_1/a_12030_n1540# divbuf_1/a_12510_n1540# 0.11fF
C1853 divbuf_1/a_42750_n840# divbuf_1/a_42750_n1540# 0.01fF
C1854 pll_full_0/divbuf_0/a_51870_n1540# pll_full_0/divbuf_0/a_52350_n1540# 0.11fF
C1855 divbuf_3/a_8640_n1600# divbuf_3/a_8670_n840# 0.04fF
C1856 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4350_n840# 0.04fF
C1857 divbuf_0/a_42750_n1540# divbuf_0/a_43230_n1540# 0.11fF
C1858 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_12990_n840# 0.02fF
C1859 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22560_n1600# 0.26fF
C1860 divbuf_2/a_23922_n240# divbuf_2/a_24412_n240# 0.04fF
C1861 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C1862 pll_full_0/divbuf_1/a_14430_n1540# pll_full_0/divbuf_1/a_14910_n1540# 0.11fF
C1863 pll_full_0/divbuf_1/a_45150_n840# pll_full_0/divbuf_1/a_45150_n1540# 0.01fF
C1864 divbuf_2/a_5310_n840# divbuf_2/a_5310_n1540# 0.01fF
C1865 divbuf_2/a_35550_n840# divbuf_2/a_36030_n840# 0.07fF
C1866 divbuf_2/a_35520_n1600# divbuf_2/a_35550_n1540# 0.19fF
C1867 divbuf_1/a_30712_170# divbuf_1/a_30232_170# 0.07fF
C1868 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C1869 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/clk 0.45fF
C1870 divbuf_0/a_492_n240# divbuf_0/a_960_n1600# 0.00fF
C1871 divbuf_0/a_16642_170# divbuf_0/a_16642_n240# 0.01fF
C1872 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1873 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49470_n840# 0.04fF
C1874 divbuf_3/a_5362_170# divbuf_3/a_5362_n240# 0.01fF
C1875 divbuf_3/a_25382_170# divbuf_3/a_25862_170# 0.07fF
C1876 divbuf_1/a_9600_n1600# divbuf_1/a_9630_n840# 0.04fF
C1877 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1878 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/a_21502_170# 0.07fF
C1879 divbuf_1/a_60990_n840# divbuf_1/OUT5 0.04fF
C1880 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_9120_n1600# 0.26fF
C1881 divbuf_0/a_36532_170# divbuf_0/OUT4 0.19fF
C1882 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n840# 0.04fF
C1883 divbuf_3/a_58560_n1600# divbuf_3/a_59040_n1600# 0.26fF
C1884 divbuf_3/a_12772_170# divbuf_3/OUT4 0.19fF
C1885 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54720_n1600# 0.26fF
C1886 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12030_n840# 0.04fF
C1887 divbuf_3/a_50910_n1540# divbuf_3/a_51390_n1540# 0.11fF
C1888 pd_div_0/divbuf_0/a_990_n1540# pd_div_0/divbuf_0/a_1470_n1540# 0.11fF
C1889 pd_div_0/divbuf_0/a_31710_n840# pd_div_0/divbuf_0/a_31710_n1540# 0.01fF
C1890 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/OUT2 0.02fF
C1891 ro_div_0/divbuf_0/a_46590_n1540# ro_div_0/divbuf_0/a_47070_n1540# 0.11fF
C1892 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/a_27802_n240# 0.05fF
C1893 divbuf_1/a_32652_170# divbuf_1/a_32652_n240# 0.01fF
C1894 divbuf_1/a_22952_170# divbuf_1/a_23442_170# 0.07fF
C1895 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/a_29742_n240# 0.01fF
C1896 divbuf_0/a_37992_170# divbuf_0/a_37992_n240# 0.01fF
C1897 divbuf_0/a_18092_n240# divbuf_0/a_18582_n240# 0.04fF
C1898 divbuf_1/a_59520_n1600# divbuf_1/a_60000_n1600# 0.26fF
C1899 pll_full_0/divbuf_0/a_8670_n840# pll_full_0/divbuf_0/a_8670_n1540# 0.01fF
C1900 pll_full_0/divbuf_0/a_38910_n840# pll_full_0/divbuf_0/a_39390_n840# 0.07fF
C1901 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_38910_n1540# 0.19fF
C1902 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1903 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n1540# 0.19fF
C1904 divbuf_0/a_37502_n240# divbuf_0/OUT4 0.04fF
C1905 divbuf_0/a_29790_n840# divbuf_0/a_30270_n840# 0.07fF
C1906 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/a_8762_n240# 0.01fF
C1907 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/a_29262_170# 0.07fF
C1908 divbuf_3/a_13742_n240# divbuf_3/OUT4 0.04fF
C1909 divbuf_3/a_48480_n1600# divbuf_3/a_48510_n840# 0.04fF
C1910 divbuf_1/a_51870_n1540# divbuf_1/a_52350_n1540# 0.11fF
C1911 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/a_3912_170# 0.07fF
C1912 pd_div_0/pd_0/and_pd_0/Out1 pd_div_0/pd_0/and_pd_0/Z1 0.18fF
C1913 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44190_n840# 0.04fF
C1914 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C1915 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C1916 pll_full_0/divbuf_1/a_1470_n840# pll_full_0/divbuf_1/a_1950_n840# 0.07fF
C1917 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1918 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1470_n1540# 0.19fF
C1919 divbuf_2/a_12772_n240# divbuf_2/a_12990_n840# 0.02fF
C1920 divbuf_2/a_22080_n1600# divbuf_2/a_22560_n1600# 0.26fF
C1921 pll_full_0/divbuf_1/a_54270_n1540# pll_full_0/divbuf_1/a_54750_n1540# 0.11fF
C1922 divbuf_2/a_14430_n1540# divbuf_2/a_14910_n1540# 0.11fF
C1923 divbuf_2/a_45150_n840# divbuf_2/a_45150_n1540# 0.01fF
C1924 divbuf_1/a_25382_170# divbuf_1/a_25382_n240# 0.01fF
C1925 divbuf_3/a_26352_n240# divbuf_3/a_26832_n240# 0.05fF
C1926 divbuf_1/a_15672_n240# divbuf_1/OUT4 0.04fF
C1927 divbuf_1/a_49440_n1600# divbuf_1/a_49470_n840# 0.04fF
C1928 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/a_22472_n240# 0.04fF
C1929 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/a_39390_n840# 0.04fF
C1930 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48960_n1600# 0.26fF
C1931 divbuf_0/a_35520_n1600# divbuf_0/OUT4 0.00fF
C1932 divbuf_3/a_7710_n840# divbuf_3/a_7710_n1540# 0.01fF
C1933 divbuf_3/a_37950_n840# divbuf_3/a_38430_n840# 0.07fF
C1934 divbuf_3/a_12000_n1600# divbuf_3/OUT4 0.00fF
C1935 divbuf_3/a_37920_n1600# divbuf_3/a_37950_n1540# 0.19fF
C1936 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_12772_n240# 0.01fF
C1937 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/a_7302_n240# 0.01fF
C1938 ro_div_0/divbuf_0/a_33630_n840# ro_div_0/divbuf_0/a_34110_n840# 0.07fF
C1939 ro_div_0/divbuf_0/a_3390_n840# ro_div_0/divbuf_0/a_3390_n1540# 0.01fF
C1940 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_33630_n1540# 0.19fF
C1941 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_51870_n840# 0.04fF
C1942 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1943 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_5362_170# 0.07fF
C1944 divbuf_2/a_12000_n1600# divbuf_2/a_12030_n840# 0.04fF
C1945 pd_div_0/divbuf_0/a_40830_n1540# pd_div_0/divbuf_0/a_41310_n1540# 0.11fF
C1946 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/and_0/OUT 0.14fF
C1947 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1948 divbuf_0/a_3422_170# divbuf_0/a_3912_170# 0.07fF
C1949 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C1950 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1951 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25920_n1600# 0.26fF
C1952 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_16350_n840# 0.02fF
C1953 divbuf_1/a_27322_n240# divbuf_1/a_27802_n240# 0.05fF
C1954 divbuf_0/a_6822_n240# divbuf_0/a_6750_n840# 0.03fF
C1955 divbuf_0/a_16320_n1600# divbuf_0/a_16800_n1600# 0.26fF
C1956 divbuf_1/a_8670_n840# divbuf_1/a_8670_n1540# 0.01fF
C1957 divbuf_1/a_38910_n840# divbuf_1/a_39390_n840# 0.07fF
C1958 divbuf_1/a_38880_n1600# divbuf_1/a_38910_n1540# 0.19fF
C1959 pll_full_0/divbuf_0/a_17790_n1540# pll_full_0/divbuf_0/a_18270_n1540# 0.11fF
C1960 pll_full_0/divbuf_0/a_48510_n840# pll_full_0/divbuf_0/a_48510_n1540# 0.01fF
C1961 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38430_n840# 0.04fF
C1962 divbuf_0/a_39390_n840# divbuf_0/a_39390_n1540# 0.01fF
C1963 divbuf_0/a_8670_n1540# divbuf_0/a_9150_n1540# 0.11fF
C1964 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/a_30232_n240# 0.04fF
C1965 divbuf_2/a_8762_170# divbuf_2/a_8762_n240# 0.01fF
C1966 divbuf_2/a_28772_170# divbuf_2/a_29262_170# 0.07fF
C1967 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/a_9242_n240# 0.05fF
C1968 pll_full_0/divbuf_1/a_11070_n840# pll_full_0/divbuf_1/a_11070_n1540# 0.01fF
C1969 pll_full_0/divbuf_1/a_41310_n840# pll_full_0/divbuf_1/a_41790_n840# 0.07fF
C1970 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41310_n1540# 0.19fF
C1971 divbuf_2/a_1470_n840# divbuf_2/a_1950_n840# 0.07fF
C1972 divbuf_2/a_19562_170# divbuf_2/OUT4 0.19fF
C1973 divbuf_2/a_1440_n1600# divbuf_2/a_1470_n1540# 0.19fF
C1974 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/tspc_0/Z2 0.11fF
C1975 divbuf_0/a_4392_170# divbuf_0/a_4882_170# 0.07fF
C1976 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z3 0.45fF
C1977 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1978 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/Out 0.08fF
C1979 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15390_n840# 0.04fF
C1980 divbuf_2/a_54270_n1540# divbuf_2/a_54750_n1540# 0.11fF
C1981 divbuf_0/a_1352_170# divbuf_0/OUT2 0.23fF
C1982 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n840# 0.04fF
C1983 divbuf_3/a_24480_n1600# divbuf_3/a_24960_n1600# 0.26fF
C1984 divbuf_3/a_15182_n240# divbuf_3/a_15390_n840# 0.02fF
C1985 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20640_n1600# 0.26fF
C1986 divbuf_3/a_16830_n1540# divbuf_3/a_17310_n1540# 0.11fF
C1987 divbuf_3/a_47550_n840# divbuf_3/a_47550_n1540# 0.01fF
C1988 pd_div_0/divbuf_0/a_27870_n840# pd_div_0/divbuf_0/a_28350_n840# 0.07fF
C1989 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1990 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_27870_n1540# 0.19fF
C1991 ro_div_0/divbuf_0/a_43230_n840# ro_div_0/divbuf_0/a_43230_n1540# 0.01fF
C1992 ro_div_0/divbuf_0/a_12510_n1540# ro_div_0/divbuf_0/a_12990_n1540# 0.11fF
C1993 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/a_32652_170# 0.07fF
C1994 divbuf_2/a_51840_n1600# divbuf_2/a_51870_n840# 0.04fF
C1995 divbuf_2/a_20532_n240# divbuf_2/OUT4 0.04fF
C1996 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Q 0.04fF
C1997 divbuf_0/a_22952_170# divbuf_0/a_23442_170# 0.07fF
C1998 pll_full_0/divbuf_0/a_4830_n840# pll_full_0/divbuf_0/a_5310_n840# 0.07fF
C1999 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2000 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_4830_n1540# 0.19fF
C2001 divbuf_1/a_25440_n1600# divbuf_1/a_25920_n1600# 0.26fF
C2002 divbuf_1/a_16152_n240# divbuf_1/a_16350_n840# 0.02fF
C2003 divbuf_0/a_56160_n1600# divbuf_0/a_56640_n1600# 0.26fF
C2004 divbuf_1/a_17790_n1540# divbuf_1/a_18270_n1540# 0.11fF
C2005 divbuf_1/a_48510_n840# divbuf_1/a_48510_n1540# 0.01fF
C2006 pll_full_0/divbuf_0/a_57630_n1540# pll_full_0/divbuf_0/a_58110_n1540# 0.11fF
C2007 divbuf_3/a_14400_n1600# divbuf_3/a_14430_n840# 0.04fF
C2008 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10110_n840# 0.04fF
C2009 divbuf_0/a_48510_n1540# divbuf_0/a_48990_n1540# 0.11fF
C2010 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_28320_n1600# 0.26fF
C2011 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/a_18750_n840# 0.02fF
C2012 divbuf_2/a_29742_n240# divbuf_2/a_30232_n240# 0.04fF
C2013 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C2014 ro_div_0/divbuf_0/a_510_n1540# ro_div_0/divbuf_0/OUT 0.11fF
C2015 pll_full_0/divbuf_1/a_20190_n1540# pll_full_0/divbuf_1/a_20670_n1540# 0.11fF
C2016 pll_full_0/divbuf_1/a_50910_n840# pll_full_0/divbuf_1/a_50910_n1540# 0.01fF
C2017 divbuf_2/a_11070_n840# divbuf_2/a_11070_n1540# 0.01fF
C2018 divbuf_2/a_41310_n840# divbuf_2/a_41790_n840# 0.07fF
C2019 divbuf_2/a_41280_n1600# divbuf_2/a_41310_n1540# 0.19fF
C2020 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/nor_0/B 0.35fF
C2021 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2022 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55230_n840# 0.04fF
C2023 divbuf_3/a_11802_170# divbuf_3/a_11802_n240# 0.01fF
C2024 divbuf_3/a_31202_170# divbuf_3/a_31682_170# 0.07fF
C2025 divbuf_1/a_7302_170# divbuf_1/OUT3 0.19fF
C2026 divbuf_1/a_15360_n1600# divbuf_1/a_15390_n840# 0.04fF
C2027 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2028 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/a_6332_n240# 0.01fF
C2029 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/a_27322_170# 0.07fF
C2030 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/a_13742_n240# 0.01fF
C2031 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n840# 0.04fF
C2032 divbuf_0/a_8762_n240# divbuf_0/OUT3 0.04fF
C2033 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14880_n1600# 0.26fF
C2034 divbuf_3/a_3870_n840# divbuf_3/a_4350_n840# 0.07fF
C2035 divbuf_3/a_24412_170# divbuf_3/OUT4 0.19fF
C2036 divbuf_3/a_3840_n1600# divbuf_3/a_3870_n1540# 0.19fF
C2037 pd_div_0/div pd_div_0/pd_0/R 0.51fF
C2038 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2039 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60480_n1600# 0.26fF
C2040 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_17790_n840# 0.04fF
C2041 divbuf_3/a_56670_n1540# divbuf_3/a_57150_n1540# 0.11fF
C2042 pd_div_0/divbuf_0/a_6750_n1540# pd_div_0/divbuf_0/a_7230_n1540# 0.11fF
C2043 pd_div_0/divbuf_0/a_37470_n840# pd_div_0/divbuf_0/a_37470_n1540# 0.01fF
C2044 ro_div_0/divbuf_0/a_52350_n1540# ro_div_0/divbuf_0/a_52830_n1540# 0.11fF
C2045 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/a_33622_n240# 0.05fF
C2046 divbuf_1/a_5362_170# divbuf_1/a_5362_n240# 0.01fF
C2047 divbuf_1/a_28772_170# divbuf_1/a_29262_170# 0.07fF
C2048 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/a_35562_n240# 0.01fF
C2049 divbuf_0/a_23922_n240# divbuf_0/a_24412_n240# 0.04fF
C2050 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_44670_n1540# 0.19fF
C2051 pll_full_0/divbuf_0/a_14430_n840# pll_full_0/divbuf_0/a_14430_n1540# 0.01fF
C2052 pll_full_0/divbuf_0/a_44670_n840# pll_full_0/divbuf_0/a_45150_n840# 0.07fF
C2053 divbuf_1/a_4830_n840# divbuf_1/a_5310_n840# 0.07fF
C2054 divbuf_1/a_22952_170# divbuf_1/OUT4 0.19fF
C2055 divbuf_1/a_4800_n1600# divbuf_1/a_4830_n1540# 0.19fF
C2056 divbuf_1/a_57630_n1540# divbuf_1/a_58110_n1540# 0.11fF
C2057 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4350_n840# 0.04fF
C2058 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n1540# 0.19fF
C2059 divbuf_0/a_35550_n840# divbuf_0/a_36030_n840# 0.07fF
C2060 divbuf_0/a_5310_n840# divbuf_0/a_5310_n1540# 0.01fF
C2061 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/a_15182_n240# 0.01fF
C2062 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/a_35082_170# 0.07fF
C2063 divbuf_3/a_25382_n240# divbuf_3/OUT4 0.04fF
C2064 divbuf_3/a_54240_n1600# divbuf_3/a_54270_n840# 0.04fF
C2065 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/a_12282_170# 0.07fF
C2066 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_49950_n840# 0.04fF
C2067 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2068 pll_full_0/divbuf_1/a_7230_n840# pll_full_0/divbuf_1/a_7710_n840# 0.07fF
C2069 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2070 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7230_n1540# 0.19fF
C2071 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C2072 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C2073 divbuf_2/a_27840_n1600# divbuf_2/a_28320_n1600# 0.26fF
C2074 divbuf_2/a_18582_n240# divbuf_2/a_18750_n840# 0.02fF
C2075 pll_full_0/divbuf_1/a_60030_n1540# pll_full_0/divbuf_1/a_60510_n1540# 0.11fF
C2076 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/a_1470_n840# 0.03fF
C2077 divbuf_2/a_20190_n1540# divbuf_2/a_20670_n1540# 0.11fF
C2078 divbuf_2/a_50910_n840# divbuf_2/a_50910_n1540# 0.01fF
C2079 divbuf_3/a_32172_n240# divbuf_3/a_32652_n240# 0.05fF
C2080 divbuf_1/a_27322_n240# divbuf_1/OUT4 0.04fF
C2081 divbuf_1/a_55200_n1600# divbuf_1/a_55230_n840# 0.04fF
C2082 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/a_28292_n240# 0.04fF
C2083 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54720_n1600# 0.26fF
C2084 divbuf_3/a_23520_n1600# divbuf_3/OUT4 0.00fF
C2085 divbuf_3/a_43680_n1600# divbuf_3/a_43710_n1540# 0.19fF
C2086 divbuf_3/a_13470_n840# divbuf_3/a_13470_n1540# 0.01fF
C2087 divbuf_3/a_43710_n840# divbuf_3/a_44190_n840# 0.07fF
C2088 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39390_n1540# 0.19fF
C2089 ro_div_0/divbuf_0/a_39390_n840# ro_div_0/divbuf_0/a_39870_n840# 0.07fF
C2090 ro_div_0/divbuf_0/a_9150_n840# ro_div_0/divbuf_0/a_9150_n1540# 0.01fF
C2091 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2092 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_57630_n840# 0.04fF
C2093 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C2094 divbuf_2/a_17760_n1600# divbuf_2/a_17790_n840# 0.04fF
C2095 pd_div_0/divbuf_0/a_46590_n1540# pd_div_0/divbuf_0/a_47070_n1540# 0.11fF
C2096 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 ro_div_0/divider_0/clk 0.12fF
C2097 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/tspc_0/Z2 1.07fF
C2098 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C2099 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C2100 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31680_n1600# 0.26fF
C2101 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/a_22110_n840# 0.03fF
C2102 divbuf_1/a_33142_n240# divbuf_1/a_33622_n240# 0.05fF
C2103 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/a_4350_n840# 0.04fF
C2104 divbuf_0/a_22080_n1600# divbuf_0/a_22560_n1600# 0.26fF
C2105 divbuf_0/a_12772_n240# divbuf_0/a_12990_n840# 0.02fF
C2106 divbuf_1/a_44640_n1600# divbuf_1/a_44670_n1540# 0.19fF
C2107 divbuf_1/a_14430_n840# divbuf_1/a_14430_n1540# 0.01fF
C2108 divbuf_1/a_44670_n840# divbuf_1/a_45150_n840# 0.07fF
C2109 pll_full_0/divbuf_0/a_23550_n1540# pll_full_0/divbuf_0/a_24030_n1540# 0.11fF
C2110 pll_full_0/divbuf_0/a_54270_n840# pll_full_0/divbuf_0/a_54270_n1540# 0.01fF
C2111 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44190_n840# 0.04fF
C2112 divbuf_0/a_45150_n840# divbuf_0/a_45150_n1540# 0.01fF
C2113 divbuf_0/a_14430_n1540# divbuf_0/a_14910_n1540# 0.11fF
C2114 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/a_36052_n240# 0.04fF
C2115 divbuf_2/a_15182_170# divbuf_2/a_15182_n240# 0.01fF
C2116 divbuf_2/a_34592_170# divbuf_2/a_35082_170# 0.07fF
C2117 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_15672_n240# 0.04fF
C2118 pll_full_0/divbuf_1/a_16830_n840# pll_full_0/divbuf_1/a_16830_n1540# 0.01fF
C2119 pll_full_0/divbuf_1/a_47070_n840# pll_full_0/divbuf_1/a_47550_n840# 0.07fF
C2120 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47070_n1540# 0.19fF
C2121 divbuf_2/a_7230_n840# divbuf_2/a_7710_n840# 0.07fF
C2122 divbuf_2/a_31202_170# divbuf_2/OUT4 0.19fF
C2123 divbuf_2/a_7200_n1600# divbuf_2/a_7230_n1540# 0.19fF
C2124 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C2125 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/OUT2 0.19fF
C2126 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21150_n840# 0.04fF
C2127 divbuf_2/a_60030_n1540# divbuf_2/a_60510_n1540# 0.11fF
C2128 divbuf_1/a_1352_n240# divbuf_1/a_1470_n840# 0.03fF
C2129 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_5852_170# 0.07fF
C2130 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n840# 0.04fF
C2131 divbuf_3/a_30240_n1600# divbuf_3/a_30720_n1600# 0.26fF
C2132 divbuf_3/a_21012_n240# divbuf_3/a_21150_n840# 0.03fF
C2133 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/a_22472_n240# 0.04fF
C2134 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_33630_n1540# 0.19fF
C2135 pd_div_0/divbuf_0/a_3390_n840# pd_div_0/divbuf_0/a_3390_n1540# 0.01fF
C2136 pd_div_0/divbuf_0/a_33630_n840# pd_div_0/divbuf_0/a_34110_n840# 0.07fF
C2137 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_16830_n840# 0.02fF
C2138 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_26400_n1600# 0.26fF
C2139 divbuf_3/a_22590_n1540# divbuf_3/a_23070_n1540# 0.11fF
C2140 divbuf_3/a_53310_n840# divbuf_3/a_53310_n1540# 0.01fF
C2141 ro_div_0/divbuf_0/a_48990_n840# ro_div_0/divbuf_0/a_48990_n1540# 0.01fF
C2142 ro_div_0/divbuf_0/a_18270_n1540# ro_div_0/divbuf_0/a_18750_n1540# 0.11fF
C2143 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/a_38472_170# 0.07fF
C2144 divbuf_2/a_32172_n240# divbuf_2/OUT4 0.04fF
C2145 divbuf_2/a_57600_n1600# divbuf_2/a_57630_n840# 0.04fF
C2146 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/and_0/OUT 0.14fF
C2147 divbuf_0/a_28772_170# divbuf_0/a_29262_170# 0.07fF
C2148 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_10590_n1540# 0.19fF
C2149 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/a_11070_n840# 0.07fF
C2150 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2151 divbuf_1/a_31200_n1600# divbuf_1/a_31680_n1600# 0.26fF
C2152 divbuf_1/a_21982_n240# divbuf_1/a_22110_n840# 0.03fF
C2153 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/OUT3 0.19fF
C2154 ro_div_0/ro_complete_0/cbank_0/v ro_div_0/ro_complete_0/cbank_2/v 0.04fF
C2155 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/a_1842_170# 0.07fF
C2156 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n1540# 0.19fF
C2157 divbuf_0/a_1470_n840# divbuf_0/a_1950_n840# 0.07fF
C2158 divbuf_1/a_23550_n1540# divbuf_1/a_24030_n1540# 0.11fF
C2159 divbuf_1/a_54270_n840# divbuf_1/a_54270_n1540# 0.01fF
C2160 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C2161 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 0.36fF
C2162 divbuf_3/a_20160_n1600# divbuf_3/a_20190_n840# 0.04fF
C2163 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_15870_n840# 0.04fF
C2164 divbuf_0/a_54270_n1540# divbuf_0/a_54750_n1540# 0.11fF
C2165 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/a_24510_n840# 0.03fF
C2166 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_34080_n1600# 0.26fF
C2167 divbuf_2/a_35562_n240# divbuf_2/a_36052_n240# 0.04fF
C2168 pll_full_0/divbuf_1/a_25950_n1540# pll_full_0/divbuf_1/a_26430_n1540# 0.11fF
C2169 pll_full_0/divbuf_1/a_56670_n840# pll_full_0/divbuf_1/a_56670_n1540# 0.01fF
C2170 divbuf_2/a_16830_n840# divbuf_2/a_16830_n1540# 0.01fF
C2171 divbuf_2/a_47070_n840# divbuf_2/a_47550_n840# 0.07fF
C2172 divbuf_2/a_47040_n1600# divbuf_2/a_47070_n1540# 0.19fF
C2173 divbuf_1/a_18582_170# divbuf_1/a_18582_n240# 0.01fF
C2174 divbuf_1/a_6332_170# divbuf_1/a_6332_n240# 0.01fF
C2175 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/tspc_0/Z2 0.11fF
C2176 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2177 divbuf_3/a_17612_170# divbuf_3/a_17612_n240# 0.01fF
C2178 divbuf_3/a_37022_170# divbuf_3/a_37502_170# 0.07fF
C2179 divbuf_1/a_21120_n1600# divbuf_1/a_21150_n840# 0.04fF
C2180 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C2181 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/a_33142_170# 0.07fF
C2182 divbuf_0/a_20532_n240# divbuf_0/OUT4 0.04fF
C2183 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n840# 0.04fF
C2184 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20640_n1600# 0.26fF
C2185 divbuf_3/a_9600_n1600# divbuf_3/a_9630_n1540# 0.19fF
C2186 divbuf_3/a_9630_n840# divbuf_3/a_10110_n840# 0.07fF
C2187 divbuf_3/a_36052_170# divbuf_3/OUT4 0.19fF
C2188 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Qbar1 0.12fF
C2189 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5310_n1540# 0.19fF
C2190 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2191 ro_div_0/divbuf_0/a_5310_n840# ro_div_0/divbuf_0/a_5790_n840# 0.07fF
C2192 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_23550_n840# 0.04fF
C2193 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/OUT2 0.19fF
C2194 divbuf_3/a_60990_n1540# divbuf_3/OUT5 0.19fF
C2195 pd_div_0/divbuf_0/a_12510_n1540# pd_div_0/divbuf_0/a_12990_n1540# 0.11fF
C2196 pd_div_0/divbuf_0/a_43230_n840# pd_div_0/divbuf_0/a_43230_n1540# 0.01fF
C2197 ro_div_0/divbuf_0/a_58110_n1540# ro_div_0/divbuf_0/a_58590_n1540# 0.11fF
C2198 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/a_39442_n240# 0.05fF
C2199 divbuf_1/a_37992_170# divbuf_1/a_38472_170# 0.07fF
C2200 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/a_41382_n240# 0.01fF
C2201 divbuf_0/a_29742_n240# divbuf_0/a_30232_n240# 0.04fF
C2202 pll_full_0/divbuf_0/a_20190_n840# pll_full_0/divbuf_0/a_20190_n1540# 0.01fF
C2203 pll_full_0/divbuf_0/a_50430_n840# pll_full_0/divbuf_0/a_50910_n840# 0.07fF
C2204 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50430_n1540# 0.19fF
C2205 divbuf_1/a_10560_n1600# divbuf_1/a_10590_n1540# 0.19fF
C2206 divbuf_1/a_10590_n840# divbuf_1/a_11070_n840# 0.07fF
C2207 divbuf_1/a_37992_170# divbuf_1/OUT4 0.19fF
C2208 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n1540# 0.19fF
C2209 divbuf_0/a_41310_n840# divbuf_0/a_41790_n840# 0.07fF
C2210 divbuf_0/a_11070_n840# divbuf_0/a_11070_n1540# 0.01fF
C2211 divbuf_1/OUT3 divbuf_1/OUT4 0.36fF
C2212 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10110_n840# 0.04fF
C2213 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/a_21012_n240# 0.01fF
C2214 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/a_40902_170# 0.07fF
C2215 divbuf_3/a_37022_n240# divbuf_3/OUT4 0.04fF
C2216 divbuf_3/a_60000_n1600# divbuf_3/a_60030_n840# 0.04fF
C2217 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/a_20532_170# 0.07fF
C2218 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_55710_n840# 0.04fF
C2219 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2220 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/OUT3 0.07fF
C2221 pll_full_0/divbuf_1/a_12990_n840# pll_full_0/divbuf_1/a_13470_n840# 0.07fF
C2222 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_12990_n1540# 0.19fF
C2223 divbuf_2/a_24412_n240# divbuf_2/a_24510_n840# 0.03fF
C2224 divbuf_2/a_33600_n1600# divbuf_2/a_34080_n1600# 0.26fF
C2225 divbuf_2/a_25950_n1540# divbuf_2/a_26430_n1540# 0.11fF
C2226 divbuf_2/a_56670_n840# divbuf_2/a_56670_n1540# 0.01fF
C2227 divbuf_3/a_37992_n240# divbuf_3/a_38472_n240# 0.05fF
C2228 divbuf_1/a_38962_n240# divbuf_1/OUT4 0.04fF
C2229 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/a_34112_n240# 0.04fF
C2230 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60480_n1600# 0.26fF
C2231 divbuf_3/a_19230_n840# divbuf_3/a_19230_n1540# 0.01fF
C2232 divbuf_3/a_49470_n840# divbuf_3/a_49950_n840# 0.07fF
C2233 divbuf_3/a_35040_n1600# divbuf_3/OUT4 0.00fF
C2234 divbuf_3/a_49440_n1600# divbuf_3/a_49470_n1540# 0.19fF
C2235 ro_div_0/divbuf_0/a_45150_n840# ro_div_0/divbuf_0/a_45630_n840# 0.07fF
C2236 ro_div_0/divbuf_0/a_14910_n840# ro_div_0/divbuf_0/a_14910_n1540# 0.01fF
C2237 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45150_n1540# 0.19fF
C2238 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C2239 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C2240 divbuf_2/a_23520_n1600# divbuf_2/a_23550_n840# 0.04fF
C2241 divbuf_2/a_2322_170# divbuf_2/OUT2 0.19fF
C2242 pd_div_0/divbuf_0/a_52350_n1540# pd_div_0/divbuf_0/a_52830_n1540# 0.11fF
C2243 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/clk 0.64fF
C2244 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/prescaler_0/Out 0.15fF
C2245 divbuf_0/a_5362_170# divbuf_0/a_4882_170# 0.07fF
C2246 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C2247 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/a_27870_n840# 0.04fF
C2248 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_37440_n1600# 0.26fF
C2249 divbuf_1/a_38962_n240# divbuf_1/a_39442_n240# 0.05fF
C2250 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/a_10110_n840# 0.03fF
C2251 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C2252 divbuf_0/a_18582_n240# divbuf_0/a_18750_n840# 0.02fF
C2253 divbuf_0/a_27840_n1600# divbuf_0/a_28320_n1600# 0.26fF
C2254 divbuf_1/a_20190_n840# divbuf_1/a_20190_n1540# 0.01fF
C2255 divbuf_1/a_50430_n840# divbuf_1/a_50910_n840# 0.07fF
C2256 divbuf_1/a_50400_n1600# divbuf_1/a_50430_n1540# 0.19fF
C2257 pll_full_0/divbuf_0/a_29310_n1540# pll_full_0/divbuf_0/a_29790_n1540# 0.11fF
C2258 pll_full_0/divbuf_0/a_60030_n840# pll_full_0/divbuf_0/a_60030_n1540# 0.01fF
C2259 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/a_1950_n840# 0.03fF
C2260 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_49950_n840# 0.04fF
C2261 divbuf_0/a_50910_n840# divbuf_0/a_50910_n1540# 0.01fF
C2262 divbuf_0/a_20190_n1540# divbuf_0/a_20670_n1540# 0.11fF
C2263 divbuf_2/a_21012_170# divbuf_2/a_21012_n240# 0.01fF
C2264 divbuf_2/a_40412_170# divbuf_2/a_40902_170# 0.07fF
C2265 pll_full_0/divbuf_1/a_22590_n840# pll_full_0/divbuf_1/a_22590_n1540# 0.01fF
C2266 pll_full_0/divbuf_1/a_52830_n840# pll_full_0/divbuf_1/a_53310_n840# 0.07fF
C2267 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_52830_n1540# 0.19fF
C2268 divbuf_2/a_3422_n240# divbuf_2/OUT3 0.07fF
C2269 divbuf_2/a_12990_n840# divbuf_2/a_13470_n840# 0.07fF
C2270 divbuf_2/a_12960_n1600# divbuf_2/a_12990_n1540# 0.19fF
C2271 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_26910_n840# 0.04fF
C2272 divbuf_3/a_1352_170# divbuf_3/a_1842_170# 0.07fF
C2273 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C2274 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n840# 0.04fF
C2275 divbuf_3/a_26832_n240# divbuf_3/a_26910_n840# 0.04fF
C2276 divbuf_3/a_36000_n1600# divbuf_3/a_36480_n1600# 0.26fF
C2277 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/a_28292_n240# 0.04fF
C2278 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/a_22590_n840# 0.03fF
C2279 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_32160_n1600# 0.26fF
C2280 pd_div_0/divbuf_0/a_9150_n840# pd_div_0/divbuf_0/a_9150_n1540# 0.01fF
C2281 pd_div_0/divbuf_0/a_39390_n840# pd_div_0/divbuf_0/a_39870_n840# 0.07fF
C2282 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39390_n1540# 0.19fF
C2283 divbuf_3/a_28350_n1540# divbuf_3/a_28830_n1540# 0.11fF
C2284 divbuf_3/a_59070_n840# divbuf_3/a_59070_n1540# 0.01fF
C2285 ro_div_0/divbuf_0/a_54750_n840# ro_div_0/divbuf_0/a_54750_n1540# 0.01fF
C2286 ro_div_0/divbuf_0/a_24030_n1540# ro_div_0/divbuf_0/a_24510_n1540# 0.11fF
C2287 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/a_4392_n240# 0.05fF
C2288 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/a_24412_n240# 0.01fF
C2289 divbuf_2/a_2880_n1600# divbuf_2/OUT2 0.00fF
C2290 divbuf_1/a_15182_170# divbuf_1/a_15672_170# 0.07fF
C2291 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/tspc_0/Z2 1.07fF
C2292 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 pd_div_0/divider_0/clk 0.12fF
C2293 divbuf_0/a_34592_170# divbuf_0/a_35082_170# 0.07fF
C2294 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C2295 pll_full_0/divbuf_0/a_16350_n840# pll_full_0/divbuf_0/a_16830_n840# 0.07fF
C2296 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16350_n1540# 0.19fF
C2297 divbuf_1/a_27802_n240# divbuf_1/a_27870_n840# 0.04fF
C2298 divbuf_1/a_36960_n1600# divbuf_1/a_37440_n1600# 0.26fF
C2299 pd_div_0/divbuf_0/a_12282_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2300 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n1540# 0.19fF
C2301 divbuf_0/a_31202_170# divbuf_0/OUT4 0.19fF
C2302 divbuf_0/a_7230_n840# divbuf_0/a_7710_n840# 0.07fF
C2303 divbuf_3/a_7302_170# divbuf_3/OUT3 0.19fF
C2304 divbuf_3/a_25920_n1600# divbuf_3/a_25950_n840# 0.04fF
C2305 divbuf_1/a_29310_n1540# divbuf_1/a_29790_n1540# 0.11fF
C2306 divbuf_1/a_60030_n840# divbuf_1/a_60030_n1540# 0.01fF
C2307 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/a_5852_170# 0.07fF
C2308 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_21630_n840# 0.04fF
C2309 divbuf_0/a_60030_n1540# divbuf_0/a_60510_n1540# 0.11fF
C2310 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39840_n1600# 0.26fF
C2311 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/a_30270_n840# 0.05fF
C2312 pll_full_0/divbuf_1/a_31710_n1540# pll_full_0/divbuf_1/a_32190_n1540# 0.11fF
C2313 divbuf_2/a_22590_n840# divbuf_2/a_22590_n1540# 0.01fF
C2314 divbuf_2/a_52830_n840# divbuf_2/a_53310_n840# 0.07fF
C2315 divbuf_2/a_52800_n1600# divbuf_2/a_52830_n1540# 0.19fF
C2316 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C2317 divbuf_3/a_23442_170# divbuf_3/a_23442_n240# 0.01fF
C2318 divbuf_1/a_26880_n1600# divbuf_1/a_26910_n840# 0.04fF
C2319 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2320 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/a_38962_170# 0.07fF
C2321 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n840# 0.04fF
C2322 divbuf_0/a_32172_n240# divbuf_0/OUT4 0.04fF
C2323 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_26400_n1600# 0.26fF
C2324 divbuf_3/a_8272_n240# divbuf_3/OUT3 0.04fF
C2325 divbuf_3/a_15390_n840# divbuf_3/a_15870_n840# 0.07fF
C2326 divbuf_3/a_15360_n1600# divbuf_3/a_15390_n1540# 0.19fF
C2327 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2328 ro_div_0/divbuf_0/a_11070_n840# ro_div_0/divbuf_0/a_11550_n840# 0.07fF
C2329 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11070_n1540# 0.19fF
C2330 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29310_n840# 0.04fF
C2331 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2332 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C2333 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C2334 pd_div_0/divbuf_0/a_18270_n1540# pd_div_0/divbuf_0/a_18750_n1540# 0.11fF
C2335 pd_div_0/divbuf_0/a_48990_n840# pd_div_0/divbuf_0/a_48990_n1540# 0.01fF
C2336 ro_div_0/divbuf_0/OUT4 ro_div_0/divbuf_0/OUT5 0.26fF
C2337 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_3360_n1600# 0.26fF
C2338 divbuf_1/a_3912_n240# divbuf_1/a_4392_n240# 0.05fF
C2339 divbuf_0/a_35562_n240# divbuf_0/a_36052_n240# 0.04fF
C2340 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56190_n1540# 0.19fF
C2341 pll_full_0/divbuf_0/a_25950_n840# pll_full_0/divbuf_0/a_25950_n1540# 0.01fF
C2342 pll_full_0/divbuf_0/a_56190_n840# pll_full_0/divbuf_0/a_56670_n840# 0.07fF
C2343 divbuf_1/a_10212_n240# divbuf_1/OUT3 0.04fF
C2344 divbuf_1/a_16350_n840# divbuf_1/a_16830_n840# 0.07fF
C2345 divbuf_1/a_16320_n1600# divbuf_1/a_16350_n1540# 0.19fF
C2346 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n1540# 0.19fF
C2347 divbuf_0/a_47070_n840# divbuf_0/a_47550_n840# 0.07fF
C2348 divbuf_0/a_16830_n840# divbuf_0/a_16830_n1540# 0.01fF
C2349 divbuf_2/a_5362_170# divbuf_2/a_5852_170# 0.07fF
C2350 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_15870_n840# 0.04fF
C2351 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/a_6822_n240# 0.04fF
C2352 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/a_26832_n240# 0.01fF
C2353 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/a_26352_170# 0.07fF
C2354 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2355 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2356 pll_full_0/divbuf_1/a_18750_n840# pll_full_0/divbuf_1/a_19230_n840# 0.07fF
C2357 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_18750_n1540# 0.19fF
C2358 divbuf_2/a_39360_n1600# divbuf_2/a_39840_n1600# 0.26fF
C2359 divbuf_2/a_30232_n240# divbuf_2/a_30270_n840# 0.05fF
C2360 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C2361 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/nor_1/A 0.03fF
C2362 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C2363 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_13470_n840# 0.01fF
C2364 divbuf_2/a_31710_n1540# divbuf_2/a_32190_n1540# 0.11fF
C2365 ashish_0/a_150_0# ashish_0/a_150_n710# 6.31fF
C2366 divbuf_3/a_1920_n1600# divbuf_3/a_2400_n1600# 0.26fF
C2367 divbuf_1/a_9120_n1600# divbuf_1/OUT3 0.00fF
C2368 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/a_39932_n240# 0.04fF
C2369 pd_div_0/divbuf_0/a_5310_n840# pd_div_0/divbuf_0/a_5790_n840# 0.07fF
C2370 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5310_n1540# 0.19fF
C2371 divbuf_3/a_55200_n1600# divbuf_3/a_55230_n1540# 0.19fF
C2372 divbuf_3/a_24990_n840# divbuf_3/a_24990_n1540# 0.01fF
C2373 divbuf_3/a_55230_n840# divbuf_3/a_55710_n840# 0.07fF
C2374 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_50910_n1540# 0.19fF
C2375 ro_div_0/divbuf_0/a_50910_n840# ro_div_0/divbuf_0/a_51390_n840# 0.07fF
C2376 ro_div_0/divbuf_0/a_20670_n840# ro_div_0/divbuf_0/a_20670_n1540# 0.01fF
C2377 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C2378 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C2379 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C2380 divbuf_2/a_29280_n1600# divbuf_2/a_29310_n840# 0.04fF
C2381 divbuf_2/a_14222_170# divbuf_2/OUT4 0.19fF
C2382 pd_div_0/divbuf_0/a_58110_n1540# pd_div_0/divbuf_0/a_58590_n1540# 0.11fF
C2383 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C2384 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_43200_n1600# 0.26fF
C2385 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/OUT3 0.19fF
C2386 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/a_33630_n840# 0.06fF
C2387 divbuf_1/a_2880_n1600# divbuf_1/a_3360_n1600# 0.26fF
C2388 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_16350_n840# 0.02fF
C2389 divbuf_0/a_33600_n1600# divbuf_0/a_34080_n1600# 0.26fF
C2390 divbuf_0/a_24412_n240# divbuf_0/a_24510_n840# 0.03fF
C2391 pll_full_0/divbuf_0/a_35070_n1540# pll_full_0/divbuf_0/a_35550_n1540# 0.11fF
C2392 divbuf_3/a_12772_n240# divbuf_3/a_12510_n840# 0.01fF
C2393 divbuf_1/a_56160_n1600# divbuf_1/a_56190_n1540# 0.19fF
C2394 divbuf_1/a_25950_n840# divbuf_1/a_25950_n1540# 0.01fF
C2395 divbuf_1/a_56190_n840# divbuf_1/a_56670_n840# 0.07fF
C2396 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2397 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_55710_n840# 0.04fF
C2398 divbuf_0/a_56670_n840# divbuf_0/a_56670_n1540# 0.01fF
C2399 divbuf_0/a_25950_n1540# divbuf_0/a_26430_n1540# 0.11fF
C2400 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5760_n1600# 0.26fF
C2401 divbuf_2/a_6332_n240# divbuf_2/a_6822_n240# 0.04fF
C2402 divbuf_2/a_26832_170# divbuf_2/a_26832_n240# 0.01fF
C2403 pll_full_0/divbuf_1/a_28350_n840# pll_full_0/divbuf_1/a_28350_n1540# 0.01fF
C2404 pll_full_0/divbuf_1/a_58590_n840# pll_full_0/divbuf_1/a_59070_n840# 0.07fF
C2405 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_58590_n1540# 0.19fF
C2406 divbuf_2/a_15182_n240# divbuf_2/OUT4 0.04fF
C2407 divbuf_2/a_18750_n840# divbuf_2/a_19230_n840# 0.07fF
C2408 divbuf_2/a_18720_n1600# divbuf_2/a_18750_n1540# 0.19fF
C2409 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2410 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_32670_n840# 0.04fF
C2411 divbuf_3/a_7792_170# divbuf_3/a_8272_170# 0.07fF
C2412 divbuf_1/a_13742_n240# divbuf_1/a_13470_n840# 0.01fF
C2413 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n840# 0.04fF
C2414 divbuf_3/a_41760_n1600# divbuf_3/a_42240_n1600# 0.26fF
C2415 divbuf_3/a_32652_n240# divbuf_3/a_32670_n840# 0.06fF
C2416 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/a_34112_n240# 0.04fF
C2417 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37920_n1600# 0.26fF
C2418 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/a_28350_n840# 0.04fF
C2419 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45150_n1540# 0.19fF
C2420 pd_div_0/divbuf_0/a_14910_n840# pd_div_0/divbuf_0/a_14910_n1540# 0.01fF
C2421 pd_div_0/divbuf_0/a_45150_n840# pd_div_0/divbuf_0/a_45630_n840# 0.07fF
C2422 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_15870_n840# 0.01fF
C2423 divbuf_3/a_34110_n1540# divbuf_3/a_34590_n1540# 0.11fF
C2424 ro_div_0/divbuf_0/a_60510_n840# ro_div_0/divbuf_0/a_60510_n1540# 0.01fF
C2425 ro_div_0/divbuf_0/a_29790_n1540# ro_div_0/divbuf_0/a_30270_n1540# 0.11fF
C2426 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/a_30232_n240# 0.01fF
C2427 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/a_10212_n240# 0.05fF
C2428 divbuf_2/a_13440_n1600# divbuf_2/OUT4 0.00fF
C2429 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/prescaler_0/Out 0.15fF
C2430 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/clk 0.64fF
C2431 divbuf_0/a_40412_170# divbuf_0/a_40902_170# 0.07fF
C2432 divbuf_0/a_21012_170# divbuf_0/a_21012_n240# 0.01fF
C2433 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22110_n1540# 0.19fF
C2434 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2435 pll_full_0/divbuf_0/a_22110_n840# pll_full_0/divbuf_0/a_22590_n840# 0.07fF
C2436 divbuf_1/a_42720_n1600# divbuf_1/a_43200_n1600# 0.26fF
C2437 divbuf_1/a_32172_170# divbuf_1/OUT4 0.19fF
C2438 divbuf_1/a_33622_n240# divbuf_1/a_33630_n840# 0.06fF
C2439 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2440 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n1540# 0.19fF
C2441 divbuf_0/a_12990_n840# divbuf_0/a_13470_n840# 0.07fF
C2442 divbuf_0/a_3422_n240# divbuf_0/OUT3 0.07fF
C2443 divbuf_3/a_19072_170# divbuf_3/OUT4 0.19fF
C2444 divbuf_3/a_31680_n1600# divbuf_3/a_31710_n840# 0.04fF
C2445 divbuf_1/a_35070_n1540# divbuf_1/a_35550_n1540# 0.11fF
C2446 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/a_12282_170# 0.07fF
C2447 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2448 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27390_n840# 0.04fF
C2449 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/a_36030_n840# 0.05fF
C2450 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45600_n1600# 0.26fF
C2451 divbuf_2/a_5280_n1600# divbuf_2/a_5760_n1600# 0.26fF
C2452 pll_full_0/divbuf_1/a_37470_n1540# pll_full_0/divbuf_1/a_37950_n1540# 0.11fF
C2453 divbuf_2/a_28350_n840# divbuf_2/a_28350_n1540# 0.01fF
C2454 divbuf_2/a_58590_n840# divbuf_2/a_59070_n840# 0.07fF
C2455 divbuf_2/a_58560_n1600# divbuf_2/a_58590_n1540# 0.19fF
C2456 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C2457 divbuf_3/a_29262_170# divbuf_3/a_29262_n240# 0.01fF
C2458 divbuf_3/a_8762_n240# divbuf_3/a_9242_n240# 0.05fF
C2459 divbuf_1/a_9242_170# divbuf_1/OUT3 0.19fF
C2460 divbuf_1/a_32640_n1600# divbuf_1/a_32670_n840# 0.04fF
C2461 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/a_24892_n240# 0.01fF
C2462 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/a_4882_n240# 0.04fF
C2463 divbuf_0/a_2880_n1600# divbuf_0/OUT2 0.00fF
C2464 divbuf_3/a_21120_n1600# divbuf_3/a_21150_n1540# 0.19fF
C2465 divbuf_3/a_20042_n240# divbuf_3/OUT4 0.04fF
C2466 divbuf_3/a_21150_n840# divbuf_3/a_21630_n840# 0.07fF
C2467 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_32160_n1600# 0.26fF
C2468 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/a_22590_n840# 0.03fF
C2469 pd_div_0/divbuf_0/a_24030_n1540# pd_div_0/divbuf_0/a_24510_n1540# 0.11fF
C2470 pd_div_0/divbuf_0/a_54750_n840# pd_div_0/divbuf_0/a_54750_n1540# 0.01fF
C2471 ro_div_0/ro_complete_0/a0 ro_div_0/divider_0/clk 0.05fF
C2472 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_16830_n1540# 0.19fF
C2473 ro_div_0/divbuf_0/a_16830_n840# ro_div_0/divbuf_0/a_17310_n840# 0.07fF
C2474 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/OUT4 0.07fF
C2475 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2476 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35070_n840# 0.04fF
C2477 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C2478 divbuf_2/a_16152_n240# divbuf_2/a_15870_n840# 0.01fF
C2479 divbuf_0/a_18582_170# divbuf_0/a_19072_170# 0.07fF
C2480 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_9120_n1600# 0.26fF
C2481 divbuf_1/a_9732_n240# divbuf_1/a_10212_n240# 0.05fF
C2482 pll_full_0/divbuf_0/a_990_n1540# pll_full_0/divbuf_0/a_1470_n1540# 0.11fF
C2483 pll_full_0/divbuf_0/a_31710_n840# pll_full_0/divbuf_0/a_31710_n1540# 0.01fF
C2484 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/OUT2 0.02fF
C2485 divbuf_1/a_22080_n1600# divbuf_1/a_22110_n1540# 0.19fF
C2486 divbuf_1/a_21982_n240# divbuf_1/OUT4 0.04fF
C2487 divbuf_1/a_22110_n840# divbuf_1/a_22590_n840# 0.07fF
C2488 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n1540# 0.19fF
C2489 divbuf_0/a_52830_n840# divbuf_0/a_53310_n840# 0.07fF
C2490 divbuf_0/a_22590_n840# divbuf_0/a_22590_n1540# 0.01fF
C2491 divbuf_2/a_11802_170# divbuf_2/a_12282_170# 0.07fF
C2492 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_21630_n840# 0.04fF
C2493 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/a_32652_n240# 0.01fF
C2494 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_13252_n240# 0.05fF
C2495 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/a_32172_170# 0.07fF
C2496 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C2497 pll_full_0/divbuf_1/a_24510_n840# pll_full_0/divbuf_1/a_24990_n840# 0.07fF
C2498 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2499 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24510_n1540# 0.19fF
C2500 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/a_3912_170# 0.07fF
C2501 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C2502 divbuf_2/a_36052_n240# divbuf_2/a_36030_n840# 0.05fF
C2503 divbuf_2/a_45120_n1600# divbuf_2/a_45600_n1600# 0.26fF
C2504 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C2505 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C2506 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/prescaler_0/Out 0.12fF
C2507 divbuf_0/a_9242_170# divbuf_0/a_9732_170# 0.07fF
C2508 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C2509 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C2510 divbuf_2/a_37470_n1540# divbuf_2/a_37950_n1540# 0.11fF
C2511 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/a_1470_n840# 0.03fF
C2512 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C2513 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C2514 divbuf_3/a_7680_n1600# divbuf_3/a_8160_n1600# 0.26fF
C2515 divbuf_1/a_20160_n1600# divbuf_1/OUT4 0.00fF
C2516 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3840_n1600# 0.26fF
C2517 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11070_n1540# 0.19fF
C2518 pd_div_0/divbuf_0/a_11070_n840# pd_div_0/divbuf_0/a_11550_n840# 0.07fF
C2519 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_510_n840# 0.00fF
C2520 divbuf_3/a_30750_n840# divbuf_3/a_30750_n1540# 0.01fF
C2521 ro_div_0/divbuf_0/a_56670_n840# ro_div_0/divbuf_0/a_57150_n840# 0.07fF
C2522 ro_div_0/divbuf_0/a_26430_n840# ro_div_0/divbuf_0/a_26430_n1540# 0.01fF
C2523 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_56670_n1540# 0.19fF
C2524 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C2525 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/a_8762_n240# 0.01fF
C2526 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/a_17122_170# 0.07fF
C2527 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C2528 divbuf_2/a_25862_170# divbuf_2/OUT4 0.19fF
C2529 divbuf_2/a_35040_n1600# divbuf_2/a_35070_n840# 0.04fF
C2530 pd_div_0/divbuf_0/OUT4 pd_div_0/divbuf_0/OUT5 0.26fF
C2531 ro_div_0/divider_0/and_0/B ro_div_0/divider_0/and_0/Z1 0.07fF
C2532 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C2533 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C2534 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/a_39390_n840# 0.04fF
C2535 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/OUT3 0.19fF
C2536 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48960_n1600# 0.26fF
C2537 divbuf_1/a_8640_n1600# divbuf_1/a_9120_n1600# 0.26fF
C2538 divbuf_0/a_30232_n240# divbuf_0/a_30270_n840# 0.05fF
C2539 divbuf_0/a_39360_n1600# divbuf_0/a_39840_n1600# 0.26fF
C2540 pll_full_0/divbuf_0/a_40830_n1540# pll_full_0/divbuf_0/a_41310_n1540# 0.11fF
C2541 divbuf_1/a_990_n1540# divbuf_1/a_1470_n1540# 0.11fF
C2542 divbuf_1/a_31710_n840# divbuf_1/a_31710_n1540# 0.01fF
C2543 divbuf_1/a_510_n840# divbuf_1/OUT2 0.02fF
C2544 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_13950_n840# 0.01fF
C2545 divbuf_0/a_31710_n1540# divbuf_0/a_32190_n1540# 0.11fF
C2546 divbuf_2/a_32652_170# divbuf_2/a_32652_n240# 0.01fF
C2547 divbuf_2/a_12772_n240# divbuf_2/a_13252_n240# 0.05fF
C2548 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2549 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11520_n1600# 0.26fF
C2550 pll_full_0/divbuf_1/a_3390_n1540# pll_full_0/divbuf_1/a_3870_n1540# 0.11fF
C2551 pll_full_0/divbuf_1/a_34110_n840# pll_full_0/divbuf_1/a_34110_n1540# 0.01fF
C2552 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/a_16642_n240# 0.01fF
C2553 divbuf_2/a_24510_n840# divbuf_2/a_24990_n840# 0.07fF
C2554 divbuf_2/a_26832_n240# divbuf_2/OUT4 0.04fF
C2555 divbuf_2/a_24480_n1600# divbuf_2/a_24510_n1540# 0.19fF
C2556 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/nor_1/A 0.03fF
C2557 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C2558 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2559 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38430_n840# 0.04fF
C2560 divbuf_3/a_14222_170# divbuf_3/a_14702_170# 0.07fF
C2561 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/OUT3 0.19fF
C2562 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/a_11802_170# 0.07fF
C2563 divbuf_0/a_13742_170# divbuf_0/OUT4 0.19fF
C2564 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n840# 0.04fF
C2565 divbuf_3/a_38472_n240# divbuf_3/a_38430_n840# 0.04fF
C2566 divbuf_3/a_47520_n1600# divbuf_3/a_48000_n1600# 0.26fF
C2567 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/a_39932_n240# 0.04fF
C2568 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43680_n1600# 0.26fF
C2569 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/a_34110_n840# 0.06fF
C2570 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/OUT3 0.19fF
C2571 pd_div_0/divbuf_0/a_20670_n840# pd_div_0/divbuf_0/a_20670_n1540# 0.01fF
C2572 pd_div_0/divbuf_0/a_50910_n840# pd_div_0/divbuf_0/a_51390_n840# 0.07fF
C2573 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_50910_n1540# 0.19fF
C2574 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_990_n840# 0.04fF
C2575 divbuf_3/a_39870_n1540# divbuf_3/a_40350_n1540# 0.11fF
C2576 divbuf_2/a_492_n240# divbuf_2/a_510_n840# 0.00fF
C2577 ro_div_0/divbuf_0/a_35550_n1540# ro_div_0/divbuf_0/a_36030_n1540# 0.11fF
C2578 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_16642_n240# 0.04fF
C2579 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/a_36052_n240# 0.01fF
C2580 divbuf_2/a_24960_n1600# divbuf_2/OUT4 0.00fF
C2581 divbuf_1/a_7792_170# divbuf_1/a_7792_n240# 0.01fF
C2582 divbuf_0/a_26832_170# divbuf_0/a_26832_n240# 0.01fF
C2583 divbuf_0/a_6332_n240# divbuf_0/a_6822_n240# 0.04fF
C2584 pll_full_0/divbuf_0/a_27870_n840# pll_full_0/divbuf_0/a_28350_n840# 0.07fF
C2585 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2586 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_27870_n1540# 0.19fF
C2587 divbuf_1/a_9732_170# divbuf_1/OUT3 0.19fF
C2588 divbuf_1/a_39442_n240# divbuf_1/a_39390_n840# 0.04fF
C2589 divbuf_1/a_48480_n1600# divbuf_1/a_48960_n1600# 0.26fF
C2590 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2591 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/a_11312_n240# 0.01fF
C2592 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n1540# 0.19fF
C2593 divbuf_0/a_18750_n840# divbuf_0/a_19230_n840# 0.07fF
C2594 divbuf_0/a_15182_n240# divbuf_0/OUT4 0.04fF
C2595 divbuf_3/a_30712_170# divbuf_3/OUT4 0.19fF
C2596 divbuf_3/a_37440_n1600# divbuf_3/a_37470_n840# 0.04fF
C2597 divbuf_1/a_40830_n1540# divbuf_1/a_41310_n1540# 0.11fF
C2598 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/a_18092_170# 0.07fF
C2599 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33150_n840# 0.04fF
C2600 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2601 pd_div_0/pd_0/DOWN pd_div_0/pd_0/UP 0.49fF
C2602 pd_div_0/pd_0/tspc_r_0/Z4 pd_div_0/pd_0/tspc_r_0/z5 0.04fF
C2603 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_51360_n1600# 0.26fF
C2604 divbuf_2/a_11040_n1600# divbuf_2/a_11520_n1600# 0.26fF
C2605 pll_full_0/divbuf_1/a_43230_n1540# pll_full_0/divbuf_1/a_43710_n1540# 0.11fF
C2606 divbuf_2/a_3390_n1540# divbuf_2/a_3870_n1540# 0.11fF
C2607 divbuf_2/a_34110_n840# divbuf_2/a_34110_n1540# 0.01fF
C2608 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C2609 divbuf_3/a_15182_n240# divbuf_3/a_15672_n240# 0.04fF
C2610 divbuf_3/a_35082_170# divbuf_3/a_35082_n240# 0.01fF
C2611 divbuf_1/a_29262_170# divbuf_1/OUT4 0.19fF
C2612 divbuf_1/a_38400_n1600# divbuf_1/a_38430_n840# 0.04fF
C2613 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/a_30712_n240# 0.01fF
C2614 divbuf_0/a_13440_n1600# divbuf_0/OUT4 0.00fF
C2615 divbuf_3/a_26910_n840# divbuf_3/a_27390_n840# 0.07fF
C2616 divbuf_3/a_31682_n240# divbuf_3/OUT4 0.04fF
C2617 divbuf_3/a_26880_n1600# divbuf_3/a_26910_n1540# 0.19fF
C2618 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/a_28350_n840# 0.04fF
C2619 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37920_n1600# 0.26fF
C2620 ro_div_0/divbuf_0/a_22590_n840# ro_div_0/divbuf_0/a_23070_n840# 0.07fF
C2621 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2622 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_22590_n1540# 0.19fF
C2623 pd_div_0/divbuf_0/a_29790_n1540# pd_div_0/divbuf_0/a_30270_n1540# 0.11fF
C2624 pd_div_0/divbuf_0/a_60510_n840# pd_div_0/divbuf_0/a_60510_n1540# 0.01fF
C2625 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_40830_n840# 0.04fF
C2626 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2627 divbuf_2/a_960_n1600# divbuf_2/a_990_n840# 0.04fF
C2628 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C2629 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z1 0.00fF
C2630 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14880_n1600# 0.26fF
C2631 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/a_4830_n840# 0.04fF
C2632 divbuf_1/a_16152_n240# divbuf_1/a_16642_n240# 0.04fF
C2633 divbuf_1/a_36052_170# divbuf_1/a_36052_n240# 0.01fF
C2634 divbuf_0/a_5280_n1600# divbuf_0/a_5760_n1600# 0.26fF
C2635 pll_full_0/divbuf_0/a_6750_n1540# pll_full_0/divbuf_0/a_7230_n1540# 0.11fF
C2636 pll_full_0/divbuf_0/a_37470_n840# pll_full_0/divbuf_0/a_37470_n1540# 0.01fF
C2637 divbuf_1/a_27870_n840# divbuf_1/a_28350_n840# 0.07fF
C2638 divbuf_1/a_33622_n240# divbuf_1/OUT4 0.04fF
C2639 divbuf_1/a_27840_n1600# divbuf_1/a_27870_n1540# 0.19fF
C2640 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n1540# 0.19fF
C2641 divbuf_0/a_58590_n840# divbuf_0/a_59070_n840# 0.07fF
C2642 divbuf_0/a_28350_n840# divbuf_0/a_28350_n1540# 0.01fF
C2643 divbuf_2/a_17612_170# divbuf_2/a_18092_170# 0.07fF
C2644 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27390_n840# 0.04fF
C2645 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/a_19072_n240# 0.04fF
C2646 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/a_38472_n240# 0.01fF
C2647 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/a_37992_170# 0.07fF
C2648 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/a_18092_n240# 0.01fF
C2649 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C2650 pll_full_0/divbuf_1/a_30270_n840# pll_full_0/divbuf_1/a_30750_n840# 0.07fF
C2651 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2652 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30270_n1540# 0.19fF
C2653 divbuf_2/a_50880_n1600# divbuf_2/a_51360_n1600# 0.26fF
C2654 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/clk 0.12fF
C2655 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C2656 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4350_n840# 0.04fF
C2657 divbuf_2/a_43230_n1540# divbuf_2/a_43710_n1540# 0.11fF
C2658 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C2659 divbuf_0/a_16152_n240# divbuf_0/a_15870_n840# 0.01fF
C2660 divbuf_3/a_13440_n1600# divbuf_3/a_13920_n1600# 0.26fF
C2661 divbuf_3/a_3912_n240# divbuf_3/a_3870_n840# 0.04fF
C2662 divbuf_1/a_31680_n1600# divbuf_1/OUT4 0.00fF
C2663 divbuf_1/a_492_n240# divbuf_1/a_510_n840# 0.00fF
C2664 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9600_n1600# 0.26fF
C2665 pd_div_0/divbuf_0/a_16830_n840# pd_div_0/divbuf_0/a_17310_n840# 0.07fF
C2666 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_16830_n1540# 0.19fF
C2667 divbuf_3/a_5790_n1540# divbuf_3/a_6270_n1540# 0.11fF
C2668 divbuf_3/a_36510_n840# divbuf_3/a_36510_n1540# 0.01fF
C2669 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/OUT5 0.26fF
C2670 ro_div_0/divbuf_0/a_32190_n840# ro_div_0/divbuf_0/a_32190_n1540# 0.01fF
C2671 ro_div_0/divbuf_0/a_1470_n1540# ro_div_0/divbuf_0/a_1950_n1540# 0.11fF
C2672 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C2673 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/a_21502_170# 0.07fF
C2674 divbuf_2/a_40800_n1600# divbuf_2/a_40830_n840# 0.04fF
C2675 divbuf_2/a_37502_170# divbuf_2/OUT4 0.19fF
C2676 divbuf_1/a_32172_170# divbuf_1/a_32652_170# 0.07fF
C2677 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C2678 divbuf_0/a_11802_170# divbuf_0/a_12282_170# 0.07fF
C2679 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C2680 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54720_n1600# 0.26fF
C2681 divbuf_1/a_14400_n1600# divbuf_1/a_14880_n1600# 0.26fF
C2682 divbuf_1/a_4882_n240# divbuf_1/a_4830_n840# 0.04fF
C2683 divbuf_0/a_45120_n1600# divbuf_0/a_45600_n1600# 0.26fF
C2684 divbuf_0/a_36052_n240# divbuf_0/a_36030_n840# 0.05fF
C2685 pll_full_0/divbuf_0/a_46590_n1540# pll_full_0/divbuf_0/a_47070_n1540# 0.11fF
C2686 divbuf_3/a_3360_n1600# divbuf_3/a_3390_n840# 0.04fF
C2687 divbuf_1/a_6750_n1540# divbuf_1/a_7230_n1540# 0.11fF
C2688 divbuf_1/a_37470_n840# divbuf_1/a_37470_n1540# 0.01fF
C2689 divbuf_0/a_37470_n1540# divbuf_0/a_37950_n1540# 0.11fF
C2690 divbuf_2/a_18582_n240# divbuf_2/a_19072_n240# 0.04fF
C2691 divbuf_2/a_38472_170# divbuf_2/a_38472_n240# 0.01fF
C2692 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C2693 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_17280_n1600# 0.26fF
C2694 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/a_7230_n840# 0.03fF
C2695 pll_full_0/divbuf_1/a_9150_n1540# pll_full_0/divbuf_1/a_9630_n1540# 0.11fF
C2696 pll_full_0/divbuf_1/a_39870_n840# pll_full_0/divbuf_1/a_39870_n1540# 0.01fF
C2697 divbuf_2/a_30270_n840# divbuf_2/a_30750_n840# 0.07fF
C2698 divbuf_2/a_38472_n240# divbuf_2/OUT4 0.04fF
C2699 divbuf_2/a_30240_n1600# divbuf_2/a_30270_n1540# 0.19fF
C2700 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/prescaler_0/Out 0.12fF
C2701 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C2702 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C2703 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C2704 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44190_n840# 0.04fF
C2705 divbuf_3/a_20042_170# divbuf_3/a_20532_170# 0.07fF
C2706 divbuf_1/a_4320_n1600# divbuf_1/a_4350_n840# 0.04fF
C2707 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/OUT3 0.19fF
C2708 ro_div_0/ro_complete_0/cbank_2/switch_0/vin ro_div_0/ro_complete_0/cbank_2/v 1.44fF
C2709 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/a_17612_170# 0.07fF
C2710 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n840# 0.04fF
C2711 divbuf_0/a_25862_170# divbuf_0/OUT4 0.19fF
C2712 divbuf_3/a_53280_n1600# divbuf_3/a_53760_n1600# 0.26fF
C2713 divbuf_3/a_1842_170# divbuf_3/OUT2 0.19fF
C2714 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3840_n1600# 0.26fF
C2715 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_49440_n1600# 0.26fF
C2716 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/a_39870_n840# 0.04fF
C2717 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_56670_n1540# 0.19fF
C2718 pd_div_0/divbuf_0/a_26430_n840# pd_div_0/divbuf_0/a_26430_n1540# 0.01fF
C2719 pd_div_0/divbuf_0/a_56670_n840# pd_div_0/divbuf_0/a_57150_n840# 0.07fF
C2720 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_6750_n840# 0.04fF
C2721 divbuf_3/a_45630_n1540# divbuf_3/a_46110_n1540# 0.11fF
C2722 ro_div_0/divbuf_0/a_41310_n1540# ro_div_0/divbuf_0/a_41790_n1540# 0.11fF
C2723 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/a_22472_n240# 0.04fF
C2724 divbuf_2/a_36480_n1600# divbuf_2/OUT4 0.00fF
C2725 divbuf_1/a_8762_170# divbuf_1/a_9242_170# 0.07fF
C2726 divbuf_1/a_9732_170# divbuf_1/a_9732_n240# 0.01fF
C2727 pd_div_0/divider_0/and_0/B pd_div_0/divider_0/and_0/Z1 0.07fF
C2728 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/a_24412_n240# 0.01fF
C2729 divbuf_0/a_12772_n240# divbuf_0/a_13252_n240# 0.05fF
C2730 divbuf_0/a_32652_170# divbuf_0/a_32652_n240# 0.01fF
C2731 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_33630_n1540# 0.19fF
C2732 pll_full_0/divbuf_0/a_3390_n840# pll_full_0/divbuf_0/a_3390_n1540# 0.01fF
C2733 pll_full_0/divbuf_0/a_33630_n840# pll_full_0/divbuf_0/a_34110_n840# 0.07fF
C2734 divbuf_1/a_54240_n1600# divbuf_1/a_54720_n1600# 0.26fF
C2735 divbuf_1/a_15672_170# divbuf_1/OUT4 0.19fF
C2736 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C2737 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/a_17122_n240# 0.01fF
C2738 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n1540# 0.19fF
C2739 divbuf_0/a_26832_n240# divbuf_0/OUT4 0.04fF
C2740 divbuf_0/a_24510_n840# divbuf_0/a_24990_n840# 0.07fF
C2741 divbuf_3/a_2322_n240# divbuf_3/OUT3 0.04fF
C2742 divbuf_3/a_43200_n1600# divbuf_3/a_43230_n840# 0.04fF
C2743 divbuf_1/a_46590_n1540# divbuf_1/a_47070_n1540# 0.11fF
C2744 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/a_23922_170# 0.07fF
C2745 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/a_3422_n240# 0.01fF
C2746 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2747 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_38910_n840# 0.04fF
C2748 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/OUT3 0.19fF
C2749 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_57120_n1600# 0.26fF
C2750 divbuf_2/a_16800_n1600# divbuf_2/a_17280_n1600# 0.26fF
C2751 divbuf_2/a_7302_n240# divbuf_2/a_7230_n840# 0.03fF
C2752 pll_full_0/divbuf_1/a_48990_n1540# pll_full_0/divbuf_1/a_49470_n1540# 0.11fF
C2753 divbuf_2/a_9150_n1540# divbuf_2/a_9630_n1540# 0.11fF
C2754 divbuf_2/a_39870_n840# divbuf_2/a_39870_n1540# 0.01fF
C2755 divbuf_1/a_20042_170# divbuf_1/a_20042_n240# 0.01fF
C2756 divbuf_3/a_40902_170# divbuf_3/a_40902_n240# 0.01fF
C2757 divbuf_3/a_21012_n240# divbuf_3/a_21502_n240# 0.04fF
C2758 divbuf_1/a_4882_n240# divbuf_1/OUT3 0.04fF
C2759 divbuf_1/a_44160_n1600# divbuf_1/a_44190_n840# 0.04fF
C2760 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/a_36532_n240# 0.01fF
C2761 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_17122_n240# 0.05fF
C2762 divbuf_0/a_24960_n1600# divbuf_0/OUT4 0.00fF
C2763 divbuf_3/a_2400_n1600# divbuf_3/OUT2 0.00fF
C2764 divbuf_3/a_32640_n1600# divbuf_3/a_32670_n1540# 0.19fF
C2765 divbuf_3/a_2430_n840# divbuf_3/a_2430_n1540# 0.01fF
C2766 divbuf_3/a_32670_n840# divbuf_3/a_33150_n840# 0.07fF
C2767 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/a_34110_n840# 0.06fF
C2768 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43680_n1600# 0.26fF
C2769 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28350_n1540# 0.19fF
C2770 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2771 ro_div_0/divbuf_0/a_28350_n840# ro_div_0/divbuf_0/a_28830_n840# 0.07fF
C2772 pd_div_0/divbuf_0/a_35550_n1540# pd_div_0/divbuf_0/a_36030_n1540# 0.11fF
C2773 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C2774 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_46590_n840# 0.04fF
C2775 divbuf_2/a_6720_n1600# divbuf_2/a_6750_n840# 0.04fF
C2776 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20640_n1600# 0.26fF
C2777 divbuf_1/a_21982_n240# divbuf_1/a_22472_n240# 0.04fF
C2778 divbuf_0/a_11040_n1600# divbuf_0/a_11520_n1600# 0.26fF
C2779 pll_full_0/divbuf_0/a_12510_n1540# pll_full_0/divbuf_0/a_12990_n1540# 0.11fF
C2780 pll_full_0/divbuf_0/a_43230_n840# pll_full_0/divbuf_0/a_43230_n1540# 0.01fF
C2781 divbuf_1/a_33600_n1600# divbuf_1/a_33630_n1540# 0.19fF
C2782 divbuf_1/a_3390_n840# divbuf_1/a_3390_n1540# 0.01fF
C2783 divbuf_1/a_33630_n840# divbuf_1/a_34110_n840# 0.07fF
C2784 divbuf_0/a_34110_n840# divbuf_0/a_34110_n1540# 0.01fF
C2785 divbuf_0/a_3390_n1540# divbuf_0/a_3870_n1540# 0.11fF
C2786 divbuf_2/a_23442_170# divbuf_2/a_23922_170# 0.07fF
C2787 divbuf_2/a_3422_170# divbuf_2/a_3422_n240# 0.01fF
C2788 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33150_n840# 0.04fF
C2789 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/a_24892_n240# 0.05fF
C2790 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C2791 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/a_3912_n240# 0.04fF
C2792 pll_full_0/divbuf_1/a_5790_n840# pll_full_0/divbuf_1/a_5790_n1540# 0.01fF
C2793 pll_full_0/divbuf_1/a_36030_n840# pll_full_0/divbuf_1/a_36510_n840# 0.07fF
C2794 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C2795 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36030_n1540# 0.19fF
C2796 divbuf_2/a_8762_170# divbuf_2/OUT3 0.19fF
C2797 divbuf_2/a_56640_n1600# divbuf_2/a_57120_n1600# 0.26fF
C2798 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/clk 0.60fF
C2799 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z2 0.01fF
C2800 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C2801 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C2802 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10110_n840# 0.04fF
C2803 divbuf_2/a_48990_n1540# divbuf_2/a_49470_n1540# 0.11fF
C2804 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_13470_n840# 0.01fF
C2805 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C2806 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_8272_170# 0.07fF
C2807 divbuf_0/a_960_n1600# divbuf_0/a_990_n840# 0.04fF
C2808 divbuf_0/a_6332_170# divbuf_0/OUT3 0.19fF
C2809 divbuf_3/a_19200_n1600# divbuf_3/a_19680_n1600# 0.26fF
C2810 divbuf_3/a_9732_n240# divbuf_3/a_9630_n840# 0.03fF
C2811 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/a_5310_n840# 0.04fF
C2812 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_15360_n1600# 0.26fF
C2813 divbuf_3/a_11550_n1540# divbuf_3/a_12030_n1540# 0.11fF
C2814 divbuf_3/a_42270_n840# divbuf_3/a_42270_n1540# 0.01fF
C2815 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_22590_n1540# 0.19fF
C2816 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2817 pd_div_0/divbuf_0/a_22590_n840# pd_div_0/divbuf_0/a_23070_n840# 0.07fF
C2818 ro_div_0/divbuf_0/a_37950_n840# ro_div_0/divbuf_0/a_37950_n1540# 0.01fF
C2819 ro_div_0/divbuf_0/a_7230_n1540# ro_div_0/divbuf_0/a_7710_n1540# 0.11fF
C2820 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/a_13742_n240# 0.01fF
C2821 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/a_27322_170# 0.07fF
C2822 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/a_6332_n240# 0.01fF
C2823 divbuf_2/a_9732_n240# divbuf_2/OUT3 0.04fF
C2824 divbuf_2/a_46560_n1600# divbuf_2/a_46590_n840# 0.04fF
C2825 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z1 0.00fF
C2826 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C2827 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C2828 divbuf_0/a_15182_170# divbuf_0/a_15672_170# 0.07fF
C2829 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60480_n1600# 0.26fF
C2830 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2831 divbuf_1/a_20160_n1600# divbuf_1/a_20640_n1600# 0.26fF
C2832 ro_div_0/ro_complete_0/cbank_0/switch_2/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C2833 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C2834 divbuf_0/a_50880_n1600# divbuf_0/a_51360_n1600# 0.26fF
C2835 pll_full_0/divbuf_0/a_52350_n1540# pll_full_0/divbuf_0/a_52830_n1540# 0.11fF
C2836 divbuf_3/a_9120_n1600# divbuf_3/a_9150_n840# 0.04fF
C2837 divbuf_1/a_12510_n1540# divbuf_1/a_12990_n1540# 0.11fF
C2838 divbuf_1/a_43230_n840# divbuf_1/a_43230_n1540# 0.01fF
C2839 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_4830_n840# 0.04fF
C2840 divbuf_0/a_43230_n1540# divbuf_0/a_43710_n1540# 0.11fF
C2841 divbuf_2/a_24412_n240# divbuf_2/a_24892_n240# 0.05fF
C2842 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C2843 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_13470_n840# 0.02fF
C2844 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_23040_n1600# 0.26fF
C2845 pll_full_0/divbuf_1/a_14910_n1540# pll_full_0/divbuf_1/a_15390_n1540# 0.11fF
C2846 pll_full_0/divbuf_1/a_45630_n840# pll_full_0/divbuf_1/a_45630_n1540# 0.01fF
C2847 divbuf_2/a_5790_n840# divbuf_2/a_5790_n1540# 0.01fF
C2848 divbuf_2/a_36030_n840# divbuf_2/a_36510_n840# 0.07fF
C2849 divbuf_2/a_8640_n1600# divbuf_2/OUT3 0.00fF
C2850 divbuf_2/a_36000_n1600# divbuf_2/a_36030_n1540# 0.19fF
C2851 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/clk 0.12fF
C2852 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_480_n1600# 0.00fF
C2853 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2854 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_49950_n840# 0.04fF
C2855 divbuf_3/a_25862_170# divbuf_3/a_26352_170# 0.07fF
C2856 divbuf_3/a_5852_170# divbuf_3/a_5852_n240# 0.01fF
C2857 divbuf_1/a_10080_n1600# divbuf_1/a_10110_n840# 0.04fF
C2858 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2859 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/a_21982_170# 0.07fF
C2860 divbuf_0/a_37502_170# divbuf_0/OUT4 0.19fF
C2861 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n840# 0.04fF
C2862 divbuf_3/a_59040_n1600# divbuf_3/a_59520_n1600# 0.26fF
C2863 divbuf_3/a_13742_170# divbuf_3/OUT4 0.19fF
C2864 divbuf_1/a_510_n1540# divbuf_1/OUT 0.11fF
C2865 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9600_n1600# 0.26fF
C2866 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_55200_n1600# 0.26fF
C2867 pd_div_0/divbuf_0/a_1470_n1540# pd_div_0/divbuf_0/a_1950_n1540# 0.11fF
C2868 pd_div_0/divbuf_0/a_32190_n840# pd_div_0/divbuf_0/a_32190_n1540# 0.01fF
C2869 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/OUT5 0.26fF
C2870 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12510_n840# 0.04fF
C2871 divbuf_3/a_51390_n1540# divbuf_3/a_51870_n1540# 0.11fF
C2872 ro_div_0/divbuf_0/a_47070_n1540# ro_div_0/divbuf_0/a_47550_n1540# 0.11fF
C2873 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/a_28292_n240# 0.04fF
C2874 divbuf_1/a_23442_170# divbuf_1/a_23922_170# 0.07fF
C2875 divbuf_1/a_33142_170# divbuf_1/a_33142_n240# 0.01fF
C2876 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/a_30232_n240# 0.01fF
C2877 divbuf_0/a_38472_170# divbuf_0/a_38472_n240# 0.01fF
C2878 divbuf_0/a_18582_n240# divbuf_0/a_19072_n240# 0.04fF
C2879 pll_full_0/divbuf_0/a_9150_n840# pll_full_0/divbuf_0/a_9150_n1540# 0.01fF
C2880 pll_full_0/divbuf_0/a_39390_n840# pll_full_0/divbuf_0/a_39870_n840# 0.07fF
C2881 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39390_n1540# 0.19fF
C2882 divbuf_1/a_60000_n1600# divbuf_1/a_60480_n1600# 0.26fF
C2883 divbuf_1/a_13252_170# divbuf_1/OUT4 0.19fF
C2884 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n1540# 0.19fF
C2885 divbuf_0/a_38472_n240# divbuf_0/OUT4 0.04fF
C2886 divbuf_0/a_30270_n840# divbuf_0/a_30750_n840# 0.07fF
C2887 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/a_9242_n240# 0.01fF
C2888 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/a_29742_170# 0.07fF
C2889 divbuf_3/a_14702_n240# divbuf_3/OUT4 0.04fF
C2890 divbuf_3/a_48960_n1600# divbuf_3/a_48990_n840# 0.04fF
C2891 divbuf_1/a_52350_n1540# divbuf_1/a_52830_n1540# 0.11fF
C2892 ro_div_0/ro_complete_0/a3 ro_div_0/divider_0/clk 0.05fF
C2893 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_44670_n840# 0.04fF
C2894 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C2895 divbuf_2/a_13252_n240# divbuf_2/a_13470_n840# 0.02fF
C2896 divbuf_2/a_22560_n1600# divbuf_2/a_23040_n1600# 0.26fF
C2897 pll_full_0/divbuf_1/a_1950_n840# pll_full_0/divbuf_1/a_2430_n840# 0.07fF
C2898 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2899 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_1950_n1540# 0.19fF
C2900 pll_full_0/divbuf_1/a_54750_n1540# pll_full_0/divbuf_1/a_55230_n1540# 0.11fF
C2901 divbuf_2/a_14910_n1540# divbuf_2/a_15390_n1540# 0.11fF
C2902 divbuf_2/a_45630_n840# divbuf_2/a_45630_n1540# 0.01fF
C2903 divbuf_1/a_25862_170# divbuf_1/a_25862_n240# 0.01fF
C2904 divbuf_3/a_26832_n240# divbuf_3/a_27322_n240# 0.04fF
C2905 divbuf_1/a_16642_n240# divbuf_1/OUT4 0.04fF
C2906 divbuf_1/a_49920_n1600# divbuf_1/a_49950_n840# 0.04fF
C2907 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/a_22952_n240# 0.05fF
C2908 divbuf_0/a_36480_n1600# divbuf_0/OUT4 0.00fF
C2909 divbuf_3/a_8190_n840# divbuf_3/a_8190_n1540# 0.01fF
C2910 divbuf_3/a_38430_n840# divbuf_3/a_38910_n840# 0.07fF
C2911 divbuf_3/a_12960_n1600# divbuf_3/OUT4 0.00fF
C2912 divbuf_3/a_38400_n1600# divbuf_3/a_38430_n1540# 0.19fF
C2913 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/a_39870_n840# 0.04fF
C2914 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_49440_n1600# 0.26fF
C2915 ro_div_0/divbuf_0/a_34110_n840# ro_div_0/divbuf_0/a_34590_n840# 0.07fF
C2916 ro_div_0/divbuf_0/a_3870_n840# ro_div_0/divbuf_0/a_3870_n1540# 0.01fF
C2917 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34110_n1540# 0.19fF
C2918 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/a_13252_n240# 0.01fF
C2919 pd_div_0/divbuf_0/a_41310_n1540# pd_div_0/divbuf_0/a_41790_n1540# 0.11fF
C2920 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/a_7792_n240# 0.01fF
C2921 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52350_n840# 0.04fF
C2922 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2923 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/a_5852_170# 0.07fF
C2924 divbuf_2/a_12480_n1600# divbuf_2/a_12510_n840# 0.04fF
C2925 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C2926 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C2927 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/a4 0.09fF
C2928 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_26400_n1600# 0.26fF
C2929 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_16830_n840# 0.02fF
C2930 divbuf_1/a_27802_n240# divbuf_1/a_28292_n240# 0.04fF
C2931 divbuf_0/a_7302_n240# divbuf_0/a_7230_n840# 0.03fF
C2932 divbuf_0/a_16800_n1600# divbuf_0/a_17280_n1600# 0.26fF
C2933 pll_full_0/divbuf_0/a_18270_n1540# pll_full_0/divbuf_0/a_18750_n1540# 0.11fF
C2934 pll_full_0/divbuf_0/a_48990_n840# pll_full_0/divbuf_0/a_48990_n1540# 0.01fF
C2935 divbuf_1/a_9150_n840# divbuf_1/a_9150_n1540# 0.01fF
C2936 divbuf_1/a_39390_n840# divbuf_1/a_39870_n840# 0.07fF
C2937 divbuf_1/a_39360_n1600# divbuf_1/a_39390_n1540# 0.19fF
C2938 divbuf_0/a_39870_n840# divbuf_0/a_39870_n1540# 0.01fF
C2939 divbuf_0/a_9150_n1540# divbuf_0/a_9630_n1540# 0.11fF
C2940 divbuf_2/a_9242_170# divbuf_2/a_9242_n240# 0.01fF
C2941 divbuf_2/a_29262_170# divbuf_2/a_29742_170# 0.07fF
C2942 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_38910_n840# 0.04fF
C2943 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/a_30712_n240# 0.05fF
C2944 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/a_9732_n240# 0.04fF
C2945 pll_full_0/divbuf_1/a_11550_n840# pll_full_0/divbuf_1/a_11550_n1540# 0.01fF
C2946 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/a_42270_n840# 0.07fF
C2947 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C2948 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_41790_n1540# 0.19fF
C2949 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/a_1842_170# 0.07fF
C2950 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C2951 divbuf_2/a_1950_n840# divbuf_2/a_2430_n840# 0.07fF
C2952 divbuf_2/a_20532_170# divbuf_2/OUT4 0.19fF
C2953 divbuf_2/a_1920_n1600# divbuf_2/a_1950_n1540# 0.19fF
C2954 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/A 0.01fF
C2955 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z4 0.15fF
C2956 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/Out 0.11fF
C2957 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C2958 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_15870_n840# 0.04fF
C2959 divbuf_2/a_54750_n1540# divbuf_2/a_55230_n1540# 0.11fF
C2960 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n840# 0.04fF
C2961 divbuf_3/a_24960_n1600# divbuf_3/a_25440_n1600# 0.26fF
C2962 divbuf_3/a_15672_n240# divbuf_3/a_15870_n840# 0.02fF
C2963 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_21120_n1600# 0.26fF
C2964 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11550_n840# 0.02fF
C2965 divbuf_3/a_17310_n1540# divbuf_3/a_17790_n1540# 0.11fF
C2966 divbuf_3/a_48030_n840# divbuf_3/a_48030_n1540# 0.01fF
C2967 pd_div_0/divbuf_0/a_28350_n840# pd_div_0/divbuf_0/a_28830_n840# 0.07fF
C2968 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2969 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28350_n1540# 0.19fF
C2970 ro_div_0/divbuf_0/a_43710_n840# ro_div_0/divbuf_0/a_43710_n1540# 0.01fF
C2971 ro_div_0/divbuf_0/a_12990_n1540# ro_div_0/divbuf_0/a_13470_n1540# 0.11fF
C2972 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/a_33142_170# 0.07fF
C2973 divbuf_2/a_52320_n1600# divbuf_2/a_52350_n840# 0.04fF
C2974 divbuf_2/a_21502_n240# divbuf_2/OUT4 0.04fF
C2975 divbuf_0/a_23442_170# divbuf_0/a_23922_170# 0.07fF
C2976 pll_full_0/divbuf_0/a_5310_n840# pll_full_0/divbuf_0/a_5790_n840# 0.07fF
C2977 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2978 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5310_n1540# 0.19fF
C2979 divbuf_1/a_25920_n1600# divbuf_1/a_26400_n1600# 0.26fF
C2980 divbuf_1/a_16642_n240# divbuf_1/a_16830_n840# 0.02fF
C2981 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/a_14702_170# 0.07fF
C2982 divbuf_0/a_56640_n1600# divbuf_0/a_57120_n1600# 0.26fF
C2983 pll_full_0/divbuf_0/a_58110_n1540# pll_full_0/divbuf_0/a_58590_n1540# 0.11fF
C2984 divbuf_3/a_14880_n1600# divbuf_3/a_14910_n840# 0.04fF
C2985 divbuf_1/a_18270_n1540# divbuf_1/a_18750_n1540# 0.11fF
C2986 divbuf_1/a_48990_n840# divbuf_1/a_48990_n1540# 0.01fF
C2987 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_10590_n840# 0.04fF
C2988 divbuf_0/a_48990_n1540# divbuf_0/a_49470_n1540# 0.11fF
C2989 divbuf_2/a_30232_n240# divbuf_2/a_30712_n240# 0.05fF
C2990 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C2991 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28800_n1600# 0.26fF
C2992 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/a_19230_n840# 0.02fF
C2993 pll_full_0/divbuf_1/a_20670_n1540# pll_full_0/divbuf_1/a_21150_n1540# 0.11fF
C2994 pll_full_0/divbuf_1/a_51390_n840# pll_full_0/divbuf_1/a_51390_n1540# 0.01fF
C2995 divbuf_2/a_11550_n840# divbuf_2/a_11550_n1540# 0.01fF
C2996 divbuf_2/a_41790_n840# divbuf_2/a_42270_n840# 0.07fF
C2997 divbuf_2/a_19680_n1600# divbuf_2/OUT4 0.00fF
C2998 divbuf_2/a_41760_n1600# divbuf_2/a_41790_n1540# 0.19fF
C2999 divbuf_1/a_4882_170# divbuf_1/a_5362_170# 0.07fF
C3000 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z2 0.01fF
C3001 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/clk 0.60fF
C3002 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3003 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_55710_n840# 0.04fF
C3004 divbuf_3/a_12282_170# divbuf_3/a_12282_n240# 0.01fF
C3005 divbuf_3/a_31682_170# divbuf_3/a_32172_170# 0.07fF
C3006 divbuf_1/a_15840_n1600# divbuf_1/a_15870_n840# 0.04fF
C3007 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3008 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/a_6822_n240# 0.01fF
C3009 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/a_27802_170# 0.07fF
C3010 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/a_14222_n240# 0.01fF
C3011 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n840# 0.04fF
C3012 divbuf_0/a_9732_n240# divbuf_0/OUT3 0.04fF
C3013 divbuf_3/a_4350_n840# divbuf_3/a_4830_n840# 0.07fF
C3014 divbuf_3/a_25382_170# divbuf_3/OUT4 0.19fF
C3015 divbuf_3/a_4320_n1600# divbuf_3/a_4350_n1540# 0.19fF
C3016 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_15360_n1600# 0.26fF
C3017 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/R 0.01fF
C3018 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_0/Qbar 0.21fF
C3019 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z4 0.02fF
C3020 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3021 pd_div_0/divbuf_0/a_7230_n1540# pd_div_0/divbuf_0/a_7710_n1540# 0.11fF
C3022 pd_div_0/divbuf_0/a_37950_n840# pd_div_0/divbuf_0/a_37950_n1540# 0.01fF
C3023 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18270_n840# 0.04fF
C3024 divbuf_3/a_57150_n1540# divbuf_3/a_57630_n1540# 0.11fF
C3025 ro_div_0/divbuf_0/a_52830_n1540# ro_div_0/divbuf_0/a_53310_n1540# 0.11fF
C3026 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/a_34112_n240# 0.04fF
C3027 divbuf_1/a_29262_170# divbuf_1/a_29742_170# 0.07fF
C3028 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/a_36052_n240# 0.01fF
C3029 divbuf_0/a_24412_n240# divbuf_0/a_24892_n240# 0.05fF
C3030 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45150_n1540# 0.19fF
C3031 pll_full_0/divbuf_0/a_14910_n840# pll_full_0/divbuf_0/a_14910_n1540# 0.01fF
C3032 pll_full_0/divbuf_0/a_45150_n840# pll_full_0/divbuf_0/a_45630_n840# 0.07fF
C3033 divbuf_1/a_5310_n840# divbuf_1/a_5790_n840# 0.07fF
C3034 divbuf_1/a_23922_170# divbuf_1/OUT4 0.19fF
C3035 divbuf_1/a_5280_n1600# divbuf_1/a_5310_n1540# 0.19fF
C3036 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n1540# 0.19fF
C3037 divbuf_0/a_8640_n1600# divbuf_0/OUT3 0.00fF
C3038 divbuf_0/a_36030_n840# divbuf_0/a_36510_n840# 0.07fF
C3039 divbuf_0/a_5790_n840# divbuf_0/a_5790_n1540# 0.01fF
C3040 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/a_15672_n240# 0.01fF
C3041 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/a_35562_170# 0.07fF
C3042 divbuf_3/a_26352_n240# divbuf_3/OUT4 0.04fF
C3043 divbuf_3/a_54720_n1600# divbuf_3/a_54750_n840# 0.04fF
C3044 divbuf_1/a_58110_n1540# divbuf_1/a_58590_n1540# 0.11fF
C3045 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_4830_n840# 0.04fF
C3046 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3047 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50430_n840# 0.04fF
C3048 divbuf_2/a_28320_n1600# divbuf_2/a_28800_n1600# 0.26fF
C3049 divbuf_2/a_19072_n240# divbuf_2/a_19230_n840# 0.02fF
C3050 pll_full_0/divbuf_1/a_7710_n840# pll_full_0/divbuf_1/a_8190_n840# 0.07fF
C3051 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3052 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_7710_n1540# 0.19fF
C3053 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C3054 pll_full_0/divbuf_1/a_60510_n1540# pll_full_0/divbuf_1/a_60990_n1540# 0.11fF
C3055 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/a_1950_n840# 0.03fF
C3056 divbuf_2/a_20670_n1540# divbuf_2/a_21150_n1540# 0.11fF
C3057 divbuf_2/a_51390_n840# divbuf_2/a_51390_n1540# 0.01fF
C3058 divbuf_3/a_32652_n240# divbuf_3/a_33142_n240# 0.04fF
C3059 divbuf_1/a_28292_n240# divbuf_1/OUT4 0.04fF
C3060 divbuf_1/a_55680_n1600# divbuf_1/a_55710_n840# 0.04fF
C3061 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/a_28772_n240# 0.05fF
C3062 divbuf_3/a_24480_n1600# divbuf_3/OUT4 0.00fF
C3063 divbuf_3/a_44160_n1600# divbuf_3/a_44190_n1540# 0.19fF
C3064 divbuf_3/a_13950_n840# divbuf_3/a_13950_n1540# 0.01fF
C3065 divbuf_3/a_44190_n840# divbuf_3/a_44670_n840# 0.07fF
C3066 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_55200_n1600# 0.26fF
C3067 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_39870_n1540# 0.19fF
C3068 ro_div_0/divbuf_0/a_39870_n840# ro_div_0/divbuf_0/a_40350_n840# 0.07fF
C3069 ro_div_0/divbuf_0/a_9630_n840# ro_div_0/divbuf_0/a_9630_n1540# 0.01fF
C3070 divbuf_2/a_18240_n1600# divbuf_2/a_18270_n840# 0.04fF
C3071 pd_div_0/divbuf_0/a_47070_n1540# pd_div_0/divbuf_0/a_47550_n1540# 0.11fF
C3072 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3073 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58110_n840# 0.04fF
C3074 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C3075 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C3076 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C3077 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C3078 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C3079 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_32160_n1600# 0.26fF
C3080 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/a_22590_n840# 0.03fF
C3081 divbuf_1/a_33622_n240# divbuf_1/a_34112_n240# 0.04fF
C3082 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/a_4830_n840# 0.04fF
C3083 divbuf_0/a_22560_n1600# divbuf_0/a_23040_n1600# 0.26fF
C3084 divbuf_0/a_13252_n240# divbuf_0/a_13470_n840# 0.02fF
C3085 pll_full_0/divbuf_0/a_24030_n1540# pll_full_0/divbuf_0/a_24510_n1540# 0.11fF
C3086 pll_full_0/divbuf_0/a_54750_n840# pll_full_0/divbuf_0/a_54750_n1540# 0.01fF
C3087 divbuf_1/a_45120_n1600# divbuf_1/a_45150_n1540# 0.19fF
C3088 divbuf_1/a_14910_n840# divbuf_1/a_14910_n1540# 0.01fF
C3089 divbuf_1/a_45150_n840# divbuf_1/a_45630_n840# 0.07fF
C3090 divbuf_0/a_45630_n840# divbuf_0/a_45630_n1540# 0.01fF
C3091 divbuf_0/a_14910_n1540# divbuf_0/a_15390_n1540# 0.11fF
C3092 divbuf_2/a_15672_170# divbuf_2/a_15672_n240# 0.01fF
C3093 divbuf_2/a_35082_170# divbuf_2/a_35562_170# 0.07fF
C3094 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_44670_n840# 0.04fF
C3095 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/a_36532_n240# 0.05fF
C3096 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_16152_n240# 0.05fF
C3097 pll_full_0/divbuf_1/a_17310_n840# pll_full_0/divbuf_1/a_17310_n1540# 0.01fF
C3098 pll_full_0/divbuf_1/a_47550_n840# pll_full_0/divbuf_1/a_48030_n840# 0.07fF
C3099 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C3100 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_47550_n1540# 0.19fF
C3101 divbuf_2/a_7710_n840# divbuf_2/a_8190_n840# 0.07fF
C3102 divbuf_2/a_32172_170# divbuf_2/OUT4 0.19fF
C3103 divbuf_2/a_7680_n1600# divbuf_2/a_7710_n1540# 0.19fF
C3104 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_21630_n840# 0.04fF
C3105 divbuf_2/a_60510_n1540# divbuf_2/a_60990_n1540# 0.11fF
C3106 divbuf_1/a_1842_n240# divbuf_1/a_1950_n840# 0.03fF
C3107 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n840# 0.04fF
C3108 divbuf_3/a_30720_n1600# divbuf_3/a_31200_n1600# 0.26fF
C3109 divbuf_3/a_21502_n240# divbuf_3/a_21630_n840# 0.03fF
C3110 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/a_22952_n240# 0.05fF
C3111 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_17310_n840# 0.02fF
C3112 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26880_n1600# 0.26fF
C3113 divbuf_3/a_23070_n1540# divbuf_3/a_23550_n1540# 0.11fF
C3114 divbuf_3/a_53790_n840# divbuf_3/a_53790_n1540# 0.01fF
C3115 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34110_n1540# 0.19fF
C3116 pd_div_0/divbuf_0/a_3870_n840# pd_div_0/divbuf_0/a_3870_n1540# 0.01fF
C3117 pd_div_0/divbuf_0/a_34110_n840# pd_div_0/divbuf_0/a_34590_n840# 0.07fF
C3118 ro_div_0/divbuf_0/a_49470_n840# ro_div_0/divbuf_0/a_49470_n1540# 0.01fF
C3119 ro_div_0/divbuf_0/a_18750_n1540# ro_div_0/divbuf_0/a_19230_n1540# 0.11fF
C3120 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C3121 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C3122 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/OUT4 0.03fF
C3123 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/a_38962_170# 0.07fF
C3124 divbuf_2/a_33142_n240# divbuf_2/OUT4 0.04fF
C3125 divbuf_2/a_58080_n1600# divbuf_2/a_58110_n840# 0.04fF
C3126 divbuf_0/a_29262_170# divbuf_0/a_29742_170# 0.07fF
C3127 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11070_n1540# 0.19fF
C3128 pll_full_0/divbuf_0/a_11070_n840# pll_full_0/divbuf_0/a_11550_n840# 0.07fF
C3129 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3130 divbuf_1/a_31680_n1600# divbuf_1/a_32160_n1600# 0.26fF
C3131 divbuf_1/a_22472_n240# divbuf_1/a_22590_n840# 0.03fF
C3132 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n1540# 0.19fF
C3133 divbuf_0/a_20532_170# divbuf_0/OUT4 0.19fF
C3134 divbuf_0/a_1950_n840# divbuf_0/a_2430_n840# 0.07fF
C3135 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 0.26fF
C3136 divbuf_3/a_20640_n1600# divbuf_3/a_20670_n840# 0.04fF
C3137 divbuf_1/a_24030_n1540# divbuf_1/a_24510_n1540# 0.11fF
C3138 divbuf_1/a_54750_n840# divbuf_1/a_54750_n1540# 0.01fF
C3139 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16350_n840# 0.04fF
C3140 divbuf_0/a_54750_n1540# divbuf_0/a_55230_n1540# 0.11fF
C3141 divbuf_2/a_36052_n240# divbuf_2/a_36532_n240# 0.05fF
C3142 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/a_24990_n840# 0.03fF
C3143 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34560_n1600# 0.26fF
C3144 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/A 0.01fF
C3145 pll_full_0/divbuf_1/a_26430_n1540# pll_full_0/divbuf_1/a_26910_n1540# 0.11fF
C3146 pll_full_0/divbuf_1/a_57150_n840# pll_full_0/divbuf_1/a_57150_n1540# 0.01fF
C3147 divbuf_2/a_17310_n840# divbuf_2/a_17310_n1540# 0.01fF
C3148 divbuf_2/a_47550_n840# divbuf_2/a_48030_n840# 0.07fF
C3149 divbuf_2/a_31200_n1600# divbuf_2/OUT4 0.00fF
C3150 divbuf_2/a_47520_n1600# divbuf_2/a_47550_n1540# 0.19fF
C3151 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3152 divbuf_3/a_37502_170# divbuf_3/a_37992_170# 0.07fF
C3153 divbuf_3/a_18092_170# divbuf_3/a_18092_n240# 0.01fF
C3154 divbuf_1/a_21600_n1600# divbuf_1/a_21630_n840# 0.04fF
C3155 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C3156 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/a_33622_170# 0.07fF
C3157 divbuf_0/a_21502_n240# divbuf_0/OUT4 0.04fF
C3158 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n840# 0.04fF
C3159 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C3160 divbuf_3/a_10080_n1600# divbuf_3/a_10110_n1540# 0.19fF
C3161 divbuf_3/a_10110_n840# divbuf_3/a_10590_n840# 0.07fF
C3162 divbuf_3/a_37022_170# divbuf_3/OUT4 0.19fF
C3163 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_21120_n1600# 0.26fF
C3164 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/UP 0.03fF
C3165 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_5790_n1540# 0.19fF
C3166 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3167 ro_div_0/divbuf_0/a_5790_n840# ro_div_0/divbuf_0/a_6270_n840# 0.07fF
C3168 pd_div_0/divbuf_0/a_12990_n1540# pd_div_0/divbuf_0/a_13470_n1540# 0.11fF
C3169 pd_div_0/divbuf_0/a_43710_n840# pd_div_0/divbuf_0/a_43710_n1540# 0.01fF
C3170 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24030_n840# 0.04fF
C3171 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/OUT3 0.23fF
C3172 divbuf_3/OUT2 divbuf_3/OUT3 0.36fF
C3173 ro_div_0/divbuf_0/a_58590_n1540# ro_div_0/divbuf_0/a_59070_n1540# 0.11fF
C3174 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/a_39932_n240# 0.04fF
C3175 divbuf_2/a_10590_n840# divbuf_2/OUT4 0.03fF
C3176 divbuf_1/a_38472_170# divbuf_1/a_38962_170# 0.07fF
C3177 divbuf_0/a_30232_n240# divbuf_0/a_30712_n240# 0.05fF
C3178 pll_full_0/divbuf_0/a_20670_n840# pll_full_0/divbuf_0/a_20670_n1540# 0.01fF
C3179 pll_full_0/divbuf_0/a_50910_n840# pll_full_0/divbuf_0/a_51390_n840# 0.07fF
C3180 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_50910_n1540# 0.19fF
C3181 divbuf_1/a_11040_n1600# divbuf_1/a_11070_n1540# 0.19fF
C3182 divbuf_1/a_11070_n840# divbuf_1/a_11550_n840# 0.07fF
C3183 divbuf_1/a_38962_170# divbuf_1/OUT4 0.19fF
C3184 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n1540# 0.19fF
C3185 divbuf_0/a_19680_n1600# divbuf_0/OUT4 0.00fF
C3186 divbuf_0/a_41790_n840# divbuf_0/a_42270_n840# 0.07fF
C3187 divbuf_0/a_11550_n840# divbuf_0/a_11550_n1540# 0.01fF
C3188 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/a_21502_n240# 0.01fF
C3189 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/a_41382_170# 0.07fF
C3190 divbuf_3/a_37992_n240# divbuf_3/OUT4 0.04fF
C3191 divbuf_3/a_60480_n1600# divbuf_3/a_60510_n840# 0.04fF
C3192 divbuf_1/OUT4 divbuf_1/OUT5 0.26fF
C3193 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_10590_n840# 0.04fF
C3194 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/a_21012_170# 0.07fF
C3195 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56190_n840# 0.04fF
C3196 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3197 divbuf_2/a_24892_n240# divbuf_2/a_24990_n840# 0.03fF
C3198 divbuf_2/a_34080_n1600# divbuf_2/a_34560_n1600# 0.26fF
C3199 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C3200 pll_full_0/divbuf_1/a_13470_n840# pll_full_0/divbuf_1/a_13950_n840# 0.07fF
C3201 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13470_n1540# 0.19fF
C3202 divbuf_2/a_26430_n1540# divbuf_2/a_26910_n1540# 0.11fF
C3203 divbuf_2/a_57150_n840# divbuf_2/a_57150_n1540# 0.01fF
C3204 divbuf_3/a_38472_n240# divbuf_3/a_38962_n240# 0.04fF
C3205 divbuf_1/a_39932_n240# divbuf_1/OUT4 0.04fF
C3206 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/a_34592_n240# 0.05fF
C3207 divbuf_3/a_19710_n840# divbuf_3/a_19710_n1540# 0.01fF
C3208 divbuf_3/a_49950_n840# divbuf_3/a_50430_n840# 0.07fF
C3209 divbuf_3/a_36000_n1600# divbuf_3/OUT4 0.00fF
C3210 divbuf_3/a_49920_n1600# divbuf_3/a_49950_n1540# 0.19fF
C3211 ro_div_0/divbuf_0/a_45630_n840# ro_div_0/divbuf_0/a_46110_n840# 0.07fF
C3212 ro_div_0/divbuf_0/a_15390_n840# ro_div_0/divbuf_0/a_15390_n1540# 0.01fF
C3213 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_45630_n1540# 0.19fF
C3214 divbuf_2/a_24000_n1600# divbuf_2/a_24030_n840# 0.04fF
C3215 divbuf_2/a_3422_170# divbuf_2/OUT3 0.23fF
C3216 pd_div_0/divbuf_0/a_52830_n1540# pd_div_0/divbuf_0/a_53310_n1540# 0.11fF
C3217 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/clk 0.12fF
C3218 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_0/Z2 0.23fF
C3219 divbuf_0/a_5362_170# divbuf_0/a_5852_170# 0.07fF
C3220 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/a_28350_n840# 0.04fF
C3221 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37920_n1600# 0.26fF
C3222 divbuf_1/a_39442_n240# divbuf_1/a_39932_n240# 0.04fF
C3223 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C3224 divbuf_0/a_19072_n240# divbuf_0/a_19230_n840# 0.02fF
C3225 divbuf_0/a_28320_n1600# divbuf_0/a_28800_n1600# 0.26fF
C3226 pll_full_0/divbuf_0/a_29790_n1540# pll_full_0/divbuf_0/a_30270_n1540# 0.11fF
C3227 pll_full_0/divbuf_0/a_60510_n840# pll_full_0/divbuf_0/a_60510_n1540# 0.01fF
C3228 divbuf_1/a_20670_n840# divbuf_1/a_20670_n1540# 0.01fF
C3229 divbuf_1/a_50910_n840# divbuf_1/a_51390_n840# 0.07fF
C3230 divbuf_1/a_50880_n1600# divbuf_1/a_50910_n1540# 0.19fF
C3231 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/a_2430_n840# 0.03fF
C3232 divbuf_0/a_51390_n840# divbuf_0/a_51390_n1540# 0.01fF
C3233 divbuf_0/a_20670_n1540# divbuf_0/a_21150_n1540# 0.11fF
C3234 pll_full_0/divbuf_1/a_0_n1600# pll_full_0/divbuf_1/a_480_n1600# 0.26fF
C3235 divbuf_2/a_21502_170# divbuf_2/a_21502_n240# 0.01fF
C3236 divbuf_2/a_40902_170# divbuf_2/a_41382_170# 0.07fF
C3237 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50430_n840# 0.04fF
C3238 divbuf_2/a_4392_n240# divbuf_2/OUT3 0.04fF
C3239 divbuf_2/a_13470_n840# divbuf_2/a_13950_n840# 0.07fF
C3240 divbuf_2/a_13440_n1600# divbuf_2/a_13470_n1540# 0.19fF
C3241 pll_full_0/divbuf_1/a_23070_n840# pll_full_0/divbuf_1/a_23070_n1540# 0.01fF
C3242 pll_full_0/divbuf_1/a_53310_n840# pll_full_0/divbuf_1/a_53790_n840# 0.07fF
C3243 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53310_n1540# 0.19fF
C3244 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_0_n1600# 0.26fF
C3245 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C3246 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C3247 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27390_n840# 0.04fF
C3248 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3249 divbuf_3/a_1842_170# divbuf_3/a_2322_170# 0.07fF
C3250 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n840# 0.04fF
C3251 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C3252 divbuf_3/a_27322_n240# divbuf_3/a_27390_n840# 0.04fF
C3253 divbuf_3/a_36480_n1600# divbuf_3/a_36960_n1600# 0.26fF
C3254 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/a_28772_n240# 0.05fF
C3255 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32640_n1600# 0.26fF
C3256 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/a_23070_n840# 0.03fF
C3257 divbuf_3/a_28830_n1540# divbuf_3/a_29310_n1540# 0.11fF
C3258 divbuf_3/a_59550_n840# divbuf_3/a_59550_n1540# 0.01fF
C3259 pd_div_0/divbuf_0/a_9630_n840# pd_div_0/divbuf_0/a_9630_n1540# 0.01fF
C3260 pd_div_0/divbuf_0/a_39870_n840# pd_div_0/divbuf_0/a_40350_n840# 0.07fF
C3261 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_39870_n1540# 0.19fF
C3262 ro_div_0/divbuf_0/a_55230_n840# ro_div_0/divbuf_0/a_55230_n1540# 0.01fF
C3263 ro_div_0/divbuf_0/a_24510_n1540# ro_div_0/divbuf_0/a_24990_n1540# 0.11fF
C3264 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C3265 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/a_4882_n240# 0.04fF
C3266 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/a_24892_n240# 0.01fF
C3267 divbuf_0/a_35082_170# divbuf_0/a_35562_170# 0.07fF
C3268 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/OUT4 0.07fF
C3269 pll_full_0/divbuf_0/a_16830_n840# pll_full_0/divbuf_0/a_17310_n840# 0.07fF
C3270 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_16830_n1540# 0.19fF
C3271 divbuf_1/a_28292_n240# divbuf_1/a_28350_n840# 0.04fF
C3272 divbuf_1/a_37440_n1600# divbuf_1/a_37920_n1600# 0.26fF
C3273 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3274 ro_div_0/ro_complete_0/cbank_2/switch_5/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C3275 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/a_3422_n240# 0.01fF
C3276 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/a_20042_170# 0.07fF
C3277 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n1540# 0.19fF
C3278 divbuf_0/a_32172_170# divbuf_0/OUT4 0.19fF
C3279 divbuf_0/a_7710_n840# divbuf_0/a_8190_n840# 0.07fF
C3280 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/a_6332_170# 0.07fF
C3281 divbuf_3/a_8272_170# divbuf_3/OUT3 0.19fF
C3282 divbuf_3/a_26400_n1600# divbuf_3/a_26430_n840# 0.04fF
C3283 divbuf_1/a_29790_n1540# divbuf_1/a_30270_n1540# 0.11fF
C3284 divbuf_1/a_60510_n840# divbuf_1/a_60510_n1540# 0.01fF
C3285 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22110_n840# 0.04fF
C3286 divbuf_0/a_60510_n1540# divbuf_0/a_60990_n1540# 0.11fF
C3287 divbuf_2/a_0_n1600# divbuf_2/a_480_n1600# 0.26fF
C3288 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_40320_n1600# 0.26fF
C3289 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/a_30750_n840# 0.05fF
C3290 divbuf_1/a_3912_170# divbuf_1/a_3912_n240# 0.01fF
C3291 pll_full_0/divbuf_1/a_32190_n1540# pll_full_0/divbuf_1/a_32670_n1540# 0.11fF
C3292 divbuf_2/a_23070_n840# divbuf_2/a_23070_n1540# 0.01fF
C3293 divbuf_2/a_53310_n840# divbuf_2/a_53790_n840# 0.07fF
C3294 divbuf_2/a_53280_n1600# divbuf_2/a_53310_n1540# 0.19fF
C3295 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C3296 divbuf_3/a_3422_n240# divbuf_3/a_3912_n240# 0.04fF
C3297 divbuf_3/a_23922_170# divbuf_3/a_23922_n240# 0.01fF
C3298 divbuf_1/a_27360_n1600# divbuf_1/a_27390_n840# 0.04fF
C3299 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3300 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/a_39442_170# 0.07fF
C3301 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n840# 0.04fF
C3302 divbuf_0/a_33142_n240# divbuf_0/OUT4 0.04fF
C3303 divbuf_3/a_9242_n240# divbuf_3/OUT3 0.04fF
C3304 divbuf_3/a_15870_n840# divbuf_3/a_16350_n840# 0.07fF
C3305 divbuf_3/a_15840_n1600# divbuf_3/a_15870_n1540# 0.19fF
C3306 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26880_n1600# 0.26fF
C3307 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3308 ro_div_0/divbuf_0/a_11550_n840# ro_div_0/divbuf_0/a_12030_n840# 0.07fF
C3309 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_11550_n1540# 0.19fF
C3310 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C3311 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C3312 pd_div_0/divbuf_0/a_18750_n1540# pd_div_0/divbuf_0/a_19230_n1540# 0.11fF
C3313 pd_div_0/divbuf_0/a_49470_n840# pd_div_0/divbuf_0/a_49470_n1540# 0.01fF
C3314 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_29790_n840# 0.04fF
C3315 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3316 divbuf_1/a_4392_n240# divbuf_1/a_4882_n240# 0.04fF
C3317 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3840_n1600# 0.26fF
C3318 divbuf_0/a_36052_n240# divbuf_0/a_36532_n240# 0.05fF
C3319 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_56670_n1540# 0.19fF
C3320 pll_full_0/divbuf_0/a_26430_n840# pll_full_0/divbuf_0/a_26430_n1540# 0.01fF
C3321 pll_full_0/divbuf_0/a_56670_n840# pll_full_0/divbuf_0/a_57150_n840# 0.07fF
C3322 divbuf_1/a_11312_n240# divbuf_1/OUT4 0.07fF
C3323 divbuf_1/a_16830_n840# divbuf_1/a_17310_n840# 0.07fF
C3324 divbuf_1/a_16800_n1600# divbuf_1/a_16830_n1540# 0.19fF
C3325 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n1540# 0.19fF
C3326 divbuf_0/a_31200_n1600# divbuf_0/OUT4 0.00fF
C3327 divbuf_0/a_47550_n840# divbuf_0/a_48030_n840# 0.07fF
C3328 divbuf_0/a_17310_n840# divbuf_0/a_17310_n1540# 0.01fF
C3329 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/a_7302_n240# 0.05fF
C3330 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/a_27322_n240# 0.01fF
C3331 divbuf_2/a_5852_170# divbuf_2/a_6332_170# 0.07fF
C3332 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16350_n840# 0.04fF
C3333 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/a_26832_170# 0.07fF
C3334 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3335 divbuf_2/a_39840_n1600# divbuf_2/a_40320_n1600# 0.26fF
C3336 divbuf_2/a_30712_n240# divbuf_2/a_30750_n840# 0.05fF
C3337 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3338 pll_full_0/divbuf_1/a_19230_n840# pll_full_0/divbuf_1/a_19710_n840# 0.07fF
C3339 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19230_n1540# 0.19fF
C3340 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/nor_0/B 0.06fF
C3341 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_13950_n840# 0.01fF
C3342 divbuf_2/a_32190_n1540# divbuf_2/a_32670_n1540# 0.11fF
C3343 ashish_0/a_150_0# ashish_0/vop 4.44fF
C3344 ashish_0/a_150_n710# ashish_0/von 4.33fF
C3345 divbuf_3/a_2400_n1600# divbuf_3/a_2880_n1600# 0.26fF
C3346 divbuf_1/a_10080_n1600# divbuf_1/OUT3 0.00fF
C3347 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/a_40412_n240# 0.05fF
C3348 divbuf_0/a_10590_n840# divbuf_0/OUT4 0.03fF
C3349 divbuf_3/a_55680_n1600# divbuf_3/a_55710_n1540# 0.19fF
C3350 divbuf_3/a_25470_n840# divbuf_3/a_25470_n1540# 0.01fF
C3351 divbuf_3/a_55710_n840# divbuf_3/a_56190_n840# 0.07fF
C3352 pd_div_0/divbuf_0/a_5790_n840# pd_div_0/divbuf_0/a_6270_n840# 0.07fF
C3353 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_5790_n1540# 0.19fF
C3354 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51390_n1540# 0.19fF
C3355 ro_div_0/divbuf_0/a_51390_n840# ro_div_0/divbuf_0/a_51870_n840# 0.07fF
C3356 ro_div_0/divbuf_0/a_21150_n840# ro_div_0/divbuf_0/a_21150_n1540# 0.01fF
C3357 divbuf_2/a_29760_n1600# divbuf_2/a_29790_n840# 0.04fF
C3358 divbuf_2/a_15182_170# divbuf_2/OUT4 0.19fF
C3359 pd_div_0/divbuf_0/a_58590_n1540# pd_div_0/divbuf_0/a_59070_n1540# 0.11fF
C3360 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/a_11802_170# 0.07fF
C3361 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/OUT3 0.19fF
C3362 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/a_34110_n840# 0.06fF
C3363 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43680_n1600# 0.26fF
C3364 divbuf_1/a_3360_n1600# divbuf_1/a_3840_n1600# 0.26fF
C3365 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_16830_n840# 0.02fF
C3366 divbuf_0/a_34080_n1600# divbuf_0/a_34560_n1600# 0.26fF
C3367 divbuf_0/a_24892_n240# divbuf_0/a_24990_n840# 0.03fF
C3368 pll_full_0/divbuf_0/a_35550_n1540# pll_full_0/divbuf_0/a_36030_n1540# 0.11fF
C3369 divbuf_3/a_13252_n240# divbuf_3/a_12990_n840# 0.01fF
C3370 divbuf_1/a_56640_n1600# divbuf_1/a_56670_n1540# 0.19fF
C3371 divbuf_1/a_26430_n840# divbuf_1/a_26430_n1540# 0.01fF
C3372 divbuf_1/a_56670_n840# divbuf_1/a_57150_n840# 0.07fF
C3373 divbuf_0/a_57150_n840# divbuf_0/a_57150_n1540# 0.01fF
C3374 divbuf_0/a_26430_n1540# divbuf_0/a_26910_n1540# 0.11fF
C3375 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_6240_n1600# 0.26fF
C3376 divbuf_2/a_6822_n240# divbuf_2/a_7302_n240# 0.05fF
C3377 divbuf_2/a_27322_170# divbuf_2/a_27322_n240# 0.01fF
C3378 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3379 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56190_n840# 0.04fF
C3380 divbuf_2/a_16152_n240# divbuf_2/OUT4 0.04fF
C3381 divbuf_2/a_19230_n840# divbuf_2/a_19710_n840# 0.07fF
C3382 divbuf_2/a_19200_n1600# divbuf_2/a_19230_n1540# 0.19fF
C3383 divbuf_1/a_16152_170# divbuf_1/a_15672_170# 0.07fF
C3384 pll_full_0/divbuf_1/a_28830_n840# pll_full_0/divbuf_1/a_28830_n1540# 0.01fF
C3385 pll_full_0/divbuf_1/a_59070_n840# pll_full_0/divbuf_1/a_59550_n840# 0.07fF
C3386 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59070_n1540# 0.19fF
C3387 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/a_11312_n240# 0.01fF
C3388 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3389 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33150_n840# 0.04fF
C3390 divbuf_3/a_8272_170# divbuf_3/a_8762_170# 0.07fF
C3391 divbuf_1/a_14222_n240# divbuf_1/a_13950_n840# 0.01fF
C3392 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n840# 0.04fF
C3393 divbuf_3/a_42240_n1600# divbuf_3/a_42720_n1600# 0.26fF
C3394 divbuf_3/a_33142_n240# divbuf_3/a_33150_n840# 0.06fF
C3395 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/a_34592_n240# 0.05fF
C3396 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_38400_n1600# 0.26fF
C3397 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/a_28830_n840# 0.04fF
C3398 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_16350_n840# 0.00fF
C3399 divbuf_3/a_34590_n1540# divbuf_3/a_35070_n1540# 0.11fF
C3400 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_45630_n1540# 0.19fF
C3401 pd_div_0/divbuf_0/a_15390_n840# pd_div_0/divbuf_0/a_15390_n1540# 0.01fF
C3402 pd_div_0/divbuf_0/a_45630_n840# pd_div_0/divbuf_0/a_46110_n840# 0.07fF
C3403 ro_div_0/divbuf_0/a_60990_n840# ro_div_0/divbuf_0/a_60990_n1540# 0.01fF
C3404 ro_div_0/divbuf_0/a_30270_n1540# ro_div_0/divbuf_0/a_30750_n1540# 0.11fF
C3405 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_0/Z2 0.23fF
C3406 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/clk 0.12fF
C3407 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/a_30712_n240# 0.01fF
C3408 divbuf_0/a_40902_170# divbuf_0/a_41382_170# 0.07fF
C3409 divbuf_0/a_21502_170# divbuf_0/a_21502_n240# 0.01fF
C3410 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_22590_n1540# 0.19fF
C3411 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3412 pll_full_0/divbuf_0/a_22590_n840# pll_full_0/divbuf_0/a_23070_n840# 0.07fF
C3413 divbuf_1/a_33142_170# divbuf_1/OUT4 0.19fF
C3414 divbuf_1/a_34112_n240# divbuf_1/a_34110_n840# 0.06fF
C3415 divbuf_1/a_43200_n1600# divbuf_1/a_43680_n1600# 0.26fF
C3416 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3417 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n1540# 0.19fF
C3418 divbuf_0/a_13470_n840# divbuf_0/a_13950_n840# 0.07fF
C3419 divbuf_0/a_4392_n240# divbuf_0/OUT3 0.04fF
C3420 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/a_12772_170# 0.07fF
C3421 divbuf_3/a_20042_170# divbuf_3/OUT4 0.19fF
C3422 divbuf_3/a_32160_n1600# divbuf_3/a_32190_n840# 0.04fF
C3423 divbuf_1/a_35550_n1540# divbuf_1/a_36030_n1540# 0.11fF
C3424 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_27870_n840# 0.04fF
C3425 divbuf_2/a_5760_n1600# divbuf_2/a_6240_n1600# 0.26fF
C3426 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/a_36510_n840# 0.05fF
C3427 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_46080_n1600# 0.26fF
C3428 pll_full_0/divbuf_1/a_37950_n1540# pll_full_0/divbuf_1/a_38430_n1540# 0.11fF
C3429 divbuf_2/a_28830_n840# divbuf_2/a_28830_n1540# 0.01fF
C3430 divbuf_2/a_59070_n840# divbuf_2/a_59550_n840# 0.07fF
C3431 divbuf_2/a_59040_n1600# divbuf_2/a_59070_n1540# 0.19fF
C3432 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C3433 divbuf_3/a_29742_170# divbuf_3/a_29742_n240# 0.01fF
C3434 divbuf_3/a_9242_n240# divbuf_3/a_9732_n240# 0.04fF
C3435 divbuf_1/a_33120_n1600# divbuf_1/a_33150_n840# 0.04fF
C3436 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/a_25382_n240# 0.01fF
C3437 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/a_5362_n240# 0.05fF
C3438 divbuf_3/a_21600_n1600# divbuf_3/a_21630_n1540# 0.19fF
C3439 divbuf_3/a_21012_n240# divbuf_3/OUT4 0.04fF
C3440 divbuf_3/a_21630_n840# divbuf_3/a_22110_n840# 0.07fF
C3441 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/a_23070_n840# 0.03fF
C3442 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32640_n1600# 0.26fF
C3443 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17310_n1540# 0.19fF
C3444 ro_div_0/divbuf_0/a_17310_n840# ro_div_0/divbuf_0/a_17790_n840# 0.07fF
C3445 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3446 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C3447 divbuf_2/a_16642_n240# divbuf_2/a_16350_n840# 0.00fF
C3448 pd_div_0/divbuf_0/a_24510_n1540# pd_div_0/divbuf_0/a_24990_n1540# 0.11fF
C3449 pd_div_0/divbuf_0/a_55230_n840# pd_div_0/divbuf_0/a_55230_n1540# 0.01fF
C3450 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3451 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_35550_n840# 0.04fF
C3452 divbuf_0/a_19072_170# divbuf_0/a_19562_170# 0.07fF
C3453 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9600_n1600# 0.26fF
C3454 divbuf_0/a_0_n1600# divbuf_0/a_480_n1600# 0.26fF
C3455 pll_full_0/divbuf_0/a_1470_n1540# pll_full_0/divbuf_0/a_1950_n1540# 0.11fF
C3456 pll_full_0/divbuf_0/a_32190_n840# pll_full_0/divbuf_0/a_32190_n1540# 0.01fF
C3457 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/OUT5 0.26fF
C3458 divbuf_1/a_22560_n1600# divbuf_1/a_22590_n1540# 0.19fF
C3459 divbuf_1/a_22952_n240# divbuf_1/OUT4 0.04fF
C3460 divbuf_1/a_22590_n840# divbuf_1/a_23070_n840# 0.07fF
C3461 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n1540# 0.19fF
C3462 divbuf_0/a_53310_n840# divbuf_0/a_53790_n840# 0.07fF
C3463 divbuf_0/a_23070_n840# divbuf_0/a_23070_n1540# 0.01fF
C3464 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_13742_n240# 0.04fF
C3465 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/a_33142_n240# 0.01fF
C3466 divbuf_3/a_19200_n1600# divbuf_3/OUT4 0.00fF
C3467 divbuf_2/a_12282_170# divbuf_2/a_12772_170# 0.07fF
C3468 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22110_n840# 0.04fF
C3469 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/a_32652_170# 0.07fF
C3470 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C3471 divbuf_2/a_36532_n240# divbuf_2/a_36510_n840# 0.05fF
C3472 divbuf_2/a_45600_n1600# divbuf_2/a_46080_n1600# 0.26fF
C3473 pll_full_0/divbuf_1/a_24990_n840# pll_full_0/divbuf_1/a_25470_n840# 0.07fF
C3474 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3475 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_24990_n1540# 0.19fF
C3476 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/clk 0.01fF
C3477 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C3478 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_0/Z3 0.05fF
C3479 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z2 0.36fF
C3480 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/nor_0/B 0.47fF
C3481 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/and_0/B 0.18fF
C3482 divbuf_2/a_37950_n1540# divbuf_2/a_38430_n1540# 0.11fF
C3483 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/a_1950_n840# 0.03fF
C3484 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C3485 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C3486 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C3487 pd_0/DOWN pd_0/R 0.36fF
C3488 divbuf_3/a_8160_n1600# divbuf_3/a_8640_n1600# 0.26fF
C3489 divbuf_1/a_21120_n1600# divbuf_1/OUT4 0.00fF
C3490 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_4320_n1600# 0.26fF
C3491 divbuf_3/a_510_n1540# divbuf_3/a_990_n1540# 0.11fF
C3492 divbuf_3/a_31230_n840# divbuf_3/a_31230_n1540# 0.01fF
C3493 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_11550_n1540# 0.19fF
C3494 pd_div_0/divbuf_0/a_11550_n840# pd_div_0/divbuf_0/a_12030_n840# 0.07fF
C3495 ro_div_0/divbuf_0/a_57150_n840# ro_div_0/divbuf_0/a_57630_n840# 0.07fF
C3496 ro_div_0/divbuf_0/a_26910_n840# ro_div_0/divbuf_0/a_26910_n1540# 0.01fF
C3497 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57150_n1540# 0.19fF
C3498 divbuf_2/a_26832_170# divbuf_2/OUT4 0.19fF
C3499 divbuf_2/a_35520_n1600# divbuf_2/a_35550_n840# 0.04fF
C3500 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/a_17612_170# 0.07fF
C3501 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.44fF
C3502 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C3503 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C3504 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C3505 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/a_39870_n840# 0.04fF
C3506 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_49440_n1600# 0.26fF
C3507 divbuf_1/a_9120_n1600# divbuf_1/a_9600_n1600# 0.26fF
C3508 divbuf_0/a_30712_n240# divbuf_0/a_30750_n840# 0.05fF
C3509 divbuf_0/a_39840_n1600# divbuf_0/a_40320_n1600# 0.26fF
C3510 io_clamp_low[2] io_clamp_high[2] 0.53fF
C3511 pll_full_0/divbuf_0/a_41310_n1540# pll_full_0/divbuf_0/a_41790_n1540# 0.11fF
C3512 divbuf_1/a_1470_n1540# divbuf_1/a_1950_n1540# 0.11fF
C3513 divbuf_1/a_32190_n840# divbuf_1/a_32190_n1540# 0.01fF
C3514 divbuf_1/a_60480_n1600# divbuf_1/OUT5 0.26fF
C3515 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_14430_n840# 0.01fF
C3516 divbuf_0/a_32190_n1540# divbuf_0/a_32670_n1540# 0.11fF
C3517 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_12000_n1600# 0.26fF
C3518 divbuf_2/a_13252_n240# divbuf_2/a_13742_n240# 0.04fF
C3519 divbuf_2/a_33142_170# divbuf_2/a_33142_n240# 0.01fF
C3520 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3521 divbuf_2/a_24990_n840# divbuf_2/a_25470_n840# 0.07fF
C3522 divbuf_2/a_27802_n240# divbuf_2/OUT4 0.04fF
C3523 divbuf_2/a_24960_n1600# divbuf_2/a_24990_n1540# 0.19fF
C3524 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/nor_0/B 0.06fF
C3525 pll_full_0/divbuf_1/a_3870_n1540# pll_full_0/divbuf_1/a_4350_n1540# 0.11fF
C3526 pll_full_0/divbuf_1/a_34590_n840# pll_full_0/divbuf_1/a_34590_n1540# 0.01fF
C3527 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/a_17122_n240# 0.01fF
C3528 divbuf_0/a_4882_170# divbuf_0/a_4882_n240# 0.01fF
C3529 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_38910_n840# 0.04fF
C3530 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3531 divbuf_3/a_14702_170# divbuf_3/a_15182_170# 0.07fF
C3532 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/OUT3 0.19fF
C3533 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/a_12282_170# 0.07fF
C3534 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n840# 0.04fF
C3535 divbuf_0/a_7302_170# divbuf_0/OUT3 0.19fF
C3536 divbuf_3/a_38962_n240# divbuf_3/a_38910_n840# 0.04fF
C3537 divbuf_3/a_48000_n1600# divbuf_3/a_48480_n1600# 0.26fF
C3538 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/a_40412_n240# 0.05fF
C3539 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_44160_n1600# 0.26fF
C3540 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/a_34590_n840# 0.06fF
C3541 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1470_n840# 0.04fF
C3542 divbuf_3/a_40350_n1540# divbuf_3/a_40830_n1540# 0.11fF
C3543 pd_div_0/divbuf_0/a_21150_n840# pd_div_0/divbuf_0/a_21150_n1540# 0.01fF
C3544 pd_div_0/divbuf_0/a_51390_n840# pd_div_0/divbuf_0/a_51870_n840# 0.07fF
C3545 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51390_n1540# 0.19fF
C3546 ro_div_0/divbuf_0/a_36030_n1540# ro_div_0/divbuf_0/a_36510_n1540# 0.11fF
C3547 divbuf_1/a_13252_170# divbuf_1/a_13742_170# 0.07fF
C3548 divbuf_1/a_8272_170# divbuf_1/a_8272_n240# 0.01fF
C3549 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_17122_n240# 0.05fF
C3550 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/a_36532_n240# 0.01fF
C3551 divbuf_0/a_27322_170# divbuf_0/a_27322_n240# 0.01fF
C3552 divbuf_0/a_6822_n240# divbuf_0/a_7302_n240# 0.05fF
C3553 pll_full_0/divbuf_0/a_28350_n840# pll_full_0/divbuf_0/a_28830_n840# 0.07fF
C3554 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3555 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28350_n1540# 0.19fF
C3556 divbuf_1/a_39932_n240# divbuf_1/a_39870_n840# 0.04fF
C3557 divbuf_1/a_48960_n1600# divbuf_1/a_49440_n1600# 0.26fF
C3558 divbuf_1/a_10212_170# divbuf_1/OUT4 0.07fF
C3559 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3560 ro_div_0/divbuf_0/a_1842_170# ro_div_0/divbuf_0/a_1842_n240# 0.01fF
C3561 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/a_11802_n240# 0.01fF
C3562 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n1540# 0.19fF
C3563 divbuf_0/a_19230_n840# divbuf_0/a_19710_n840# 0.07fF
C3564 divbuf_0/a_16152_n240# divbuf_0/OUT4 0.04fF
C3565 io_clamp_high[1] io_analog[5] 0.53fF
C3566 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/a_18582_170# 0.07fF
C3567 divbuf_3/a_31682_170# divbuf_3/OUT4 0.19fF
C3568 divbuf_3/a_37920_n1600# divbuf_3/a_37950_n840# 0.04fF
C3569 divbuf_1/a_41310_n1540# divbuf_1/a_41790_n1540# 0.11fF
C3570 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/a_1352_170# 0.07fF
C3571 pd_div_0/pd_0/R pd_div_0/pd_0/REF 0.61fF
C3572 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_33630_n840# 0.04fF
C3573 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3574 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51840_n1600# 0.26fF
C3575 divbuf_2/a_11520_n1600# divbuf_2/a_12000_n1600# 0.26fF
C3576 pll_full_0/divbuf_1/a_43710_n1540# pll_full_0/divbuf_1/a_44190_n1540# 0.11fF
C3577 divbuf_2/a_3870_n1540# divbuf_2/a_4350_n1540# 0.11fF
C3578 divbuf_2/a_34590_n840# divbuf_2/a_34590_n1540# 0.01fF
C3579 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C3580 divbuf_3/a_15672_n240# divbuf_3/a_16152_n240# 0.05fF
C3581 divbuf_3/a_35562_170# divbuf_3/a_35562_n240# 0.01fF
C3582 divbuf_1/a_30232_170# divbuf_1/OUT4 0.19fF
C3583 divbuf_1/a_38880_n1600# divbuf_1/a_38910_n840# 0.04fF
C3584 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11802_n240# 0.04fF
C3585 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/a_31202_n240# 0.01fF
C3586 divbuf_3/a_27390_n840# divbuf_3/a_27870_n840# 0.07fF
C3587 divbuf_3/a_32652_n240# divbuf_3/OUT4 0.04fF
C3588 divbuf_3/a_27360_n1600# divbuf_3/a_27390_n1540# 0.19fF
C3589 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/a_28830_n840# 0.04fF
C3590 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_38400_n1600# 0.26fF
C3591 ro_div_0/divbuf_0/a_23070_n840# ro_div_0/divbuf_0/a_23550_n840# 0.07fF
C3592 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3593 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23070_n1540# 0.19fF
C3594 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_8272_170# 0.07fF
C3595 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C3596 divbuf_2/a_1440_n1600# divbuf_2/a_1470_n840# 0.04fF
C3597 pd_div_0/divbuf_0/a_30270_n1540# pd_div_0/divbuf_0/a_30750_n1540# 0.11fF
C3598 pd_div_0/divbuf_0/a_60990_n840# pd_div_0/divbuf_0/a_60990_n1540# 0.01fF
C3599 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41310_n840# 0.04fF
C3600 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3601 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C3602 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C3603 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/nor_1/B 0.22fF
C3604 divbuf_1/a_16642_n240# divbuf_1/a_17122_n240# 0.05fF
C3605 divbuf_1/a_36532_170# divbuf_1/a_36532_n240# 0.01fF
C3606 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_15360_n1600# 0.26fF
C3607 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/a_5310_n840# 0.04fF
C3608 divbuf_0/a_5760_n1600# divbuf_0/a_6240_n1600# 0.26fF
C3609 pll_full_0/divbuf_0/a_7230_n1540# pll_full_0/divbuf_0/a_7710_n1540# 0.11fF
C3610 pll_full_0/divbuf_0/a_37950_n840# pll_full_0/divbuf_0/a_37950_n1540# 0.01fF
C3611 divbuf_1/a_28350_n840# divbuf_1/a_28830_n840# 0.07fF
C3612 divbuf_1/a_34592_n240# divbuf_1/OUT4 0.04fF
C3613 divbuf_1/a_28320_n1600# divbuf_1/a_28350_n1540# 0.19fF
C3614 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n1540# 0.19fF
C3615 divbuf_0/a_59070_n840# divbuf_0/a_59550_n840# 0.07fF
C3616 divbuf_0/a_28830_n840# divbuf_0/a_28830_n1540# 0.01fF
C3617 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/a_19562_n240# 0.04fF
C3618 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/a_38962_n240# 0.01fF
C3619 divbuf_2/a_18092_170# divbuf_2/a_18582_170# 0.07fF
C3620 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_27870_n840# 0.04fF
C3621 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/a_18582_n240# 0.01fF
C3622 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/a_38472_170# 0.07fF
C3623 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C3624 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C3625 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C3626 divbuf_2/a_51360_n1600# divbuf_2/a_51840_n1600# 0.26fF
C3627 pll_full_0/divbuf_1/a_30750_n840# pll_full_0/divbuf_1/a_31230_n840# 0.07fF
C3628 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3629 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/a_510_n1540# 0.01fF
C3630 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_30750_n1540# 0.19fF
C3631 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C3632 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C3633 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C3634 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_4830_n840# 0.04fF
C3635 divbuf_2/a_43710_n1540# divbuf_2/a_44190_n1540# 0.11fF
C3636 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C3637 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C3638 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C3639 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C3640 divbuf_0/a_16642_n240# divbuf_0/a_16350_n840# 0.00fF
C3641 divbuf_3/a_13920_n1600# divbuf_3/a_14400_n1600# 0.26fF
C3642 divbuf_3/a_4392_n240# divbuf_3/a_4350_n840# 0.04fF
C3643 divbuf_1/a_32640_n1600# divbuf_1/OUT4 0.00fF
C3644 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_10080_n1600# 0.26fF
C3645 divbuf_3/a_6270_n1540# divbuf_3/a_6750_n1540# 0.11fF
C3646 divbuf_3/a_36990_n840# divbuf_3/a_36990_n1540# 0.01fF
C3647 pd_div_0/divbuf_0/a_17310_n840# pd_div_0/divbuf_0/a_17790_n840# 0.07fF
C3648 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17310_n1540# 0.19fF
C3649 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/OUT 0.07fF
C3650 ro_div_0/divbuf_0/a_32670_n840# ro_div_0/divbuf_0/a_32670_n1540# 0.01fF
C3651 ro_div_0/divbuf_0/a_1950_n1540# ro_div_0/divbuf_0/a_2430_n1540# 0.11fF
C3652 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/a_21982_170# 0.07fF
C3653 divbuf_2/a_41280_n1600# divbuf_2/a_41310_n840# 0.04fF
C3654 divbuf_2/a_38472_170# divbuf_2/OUT4 0.19fF
C3655 divbuf_1/a_32652_170# divbuf_1/a_33142_170# 0.07fF
C3656 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_55200_n1600# 0.26fF
C3657 divbuf_1/a_14880_n1600# divbuf_1/a_15360_n1600# 0.26fF
C3658 divbuf_1/a_5362_n240# divbuf_1/a_5310_n840# 0.04fF
C3659 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C3660 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_4392_170# 0.07fF
C3661 divbuf_0/a_45600_n1600# divbuf_0/a_46080_n1600# 0.26fF
C3662 divbuf_0/a_36532_n240# divbuf_0/a_36510_n840# 0.05fF
C3663 pll_full_0/divbuf_0/a_47070_n1540# pll_full_0/divbuf_0/a_47550_n1540# 0.11fF
C3664 divbuf_3/a_3840_n1600# divbuf_3/a_3870_n840# 0.04fF
C3665 divbuf_1/a_7230_n1540# divbuf_1/a_7710_n1540# 0.11fF
C3666 divbuf_1/a_37950_n840# divbuf_1/a_37950_n1540# 0.01fF
C3667 divbuf_0/a_37950_n1540# divbuf_0/a_38430_n1540# 0.11fF
C3668 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17760_n1600# 0.26fF
C3669 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/a_7710_n840# 0.03fF
C3670 divbuf_2/a_19072_n240# divbuf_2/a_19562_n240# 0.04fF
C3671 divbuf_2/a_38962_170# divbuf_2/a_38962_n240# 0.01fF
C3672 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C3673 divbuf_2/a_30750_n840# divbuf_2/a_31230_n840# 0.07fF
C3674 divbuf_2/a_39442_n240# divbuf_2/OUT4 0.04fF
C3675 divbuf_2/a_510_n840# divbuf_2/a_510_n1540# 0.01fF
C3676 divbuf_2/a_30720_n1600# divbuf_2/a_30750_n1540# 0.19fF
C3677 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/and_0/B 0.18fF
C3678 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/nor_0/B 0.47fF
C3679 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z2 0.36fF
C3680 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_0/Z3 0.05fF
C3681 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C3682 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/clk 0.01fF
C3683 pll_full_0/divbuf_1/a_9630_n1540# pll_full_0/divbuf_1/a_10110_n1540# 0.11fF
C3684 pll_full_0/divbuf_1/a_40350_n840# pll_full_0/divbuf_1/a_40350_n1540# 0.01fF
C3685 divbuf_0/a_12772_170# divbuf_0/a_12772_n240# 0.01fF
C3686 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C3687 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_44670_n840# 0.04fF
C3688 divbuf_3/a_20532_170# divbuf_3/a_21012_170# 0.07fF
C3689 divbuf_1/a_4800_n1600# divbuf_1/a_4830_n840# 0.04fF
C3690 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/OUT3 0.19fF
C3691 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/a_18092_170# 0.07fF
C3692 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n840# 0.04fF
C3693 divbuf_0/a_26832_170# divbuf_0/OUT4 0.19fF
C3694 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C3695 divbuf_3/a_53760_n1600# divbuf_3/a_54240_n1600# 0.26fF
C3696 divbuf_3/a_2322_170# divbuf_3/OUT3 0.07fF
C3697 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_4320_n1600# 0.26fF
C3698 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/OUT3 0.23fF
C3699 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49920_n1600# 0.26fF
C3700 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/a_40350_n840# 0.04fF
C3701 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7230_n840# 0.04fF
C3702 divbuf_3/a_46110_n1540# divbuf_3/a_46590_n1540# 0.11fF
C3703 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57150_n1540# 0.19fF
C3704 pd_div_0/divbuf_0/a_26910_n840# pd_div_0/divbuf_0/a_26910_n1540# 0.01fF
C3705 pd_div_0/divbuf_0/a_57150_n840# pd_div_0/divbuf_0/a_57630_n840# 0.07fF
C3706 ro_div_0/divbuf_0/a_41790_n1540# ro_div_0/divbuf_0/a_42270_n1540# 0.11fF
C3707 divbuf_1/a_10212_170# divbuf_1/a_10212_n240# 0.01fF
C3708 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/a_22952_n240# 0.05fF
C3709 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/a_24892_n240# 0.01fF
C3710 divbuf_0/a_33142_170# divbuf_0/a_33142_n240# 0.01fF
C3711 divbuf_0/a_13252_n240# divbuf_0/a_13742_n240# 0.04fF
C3712 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34110_n1540# 0.19fF
C3713 pll_full_0/divbuf_0/a_3870_n840# pll_full_0/divbuf_0/a_3870_n1540# 0.01fF
C3714 pll_full_0/divbuf_0/a_34110_n840# pll_full_0/divbuf_0/a_34590_n840# 0.07fF
C3715 divbuf_1/a_54720_n1600# divbuf_1/a_55200_n1600# 0.26fF
C3716 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/OUT4 0.07fF
C3717 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/a_17612_n240# 0.01fF
C3718 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n1540# 0.19fF
C3719 divbuf_0/a_27802_n240# divbuf_0/OUT4 0.04fF
C3720 divbuf_0/a_24990_n840# divbuf_0/a_25470_n840# 0.07fF
C3721 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/a_24412_170# 0.07fF
C3722 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/a_3912_n240# 0.01fF
C3723 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C3724 divbuf_3/a_3912_n240# divbuf_3/OUT3 0.04fF
C3725 divbuf_3/a_43680_n1600# divbuf_3/a_43710_n840# 0.04fF
C3726 divbuf_1/a_47070_n1540# divbuf_1/a_47550_n1540# 0.11fF
C3727 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_4882_170# 0.07fF
C3728 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3729 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39390_n840# 0.04fF
C3730 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/OUT3 0.19fF
C3731 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57600_n1600# 0.26fF
C3732 divbuf_2/a_17280_n1600# divbuf_2/a_17760_n1600# 0.26fF
C3733 divbuf_2/a_7792_n240# divbuf_2/a_7710_n840# 0.03fF
C3734 divbuf_2/a_9630_n1540# divbuf_2/a_10110_n1540# 0.11fF
C3735 divbuf_2/a_40350_n840# divbuf_2/a_40350_n1540# 0.01fF
C3736 divbuf_1/a_20532_170# divbuf_1/a_20532_n240# 0.01fF
C3737 pll_full_0/divbuf_1/a_49470_n1540# pll_full_0/divbuf_1/a_49950_n1540# 0.11fF
C3738 divbuf_3/a_41382_170# divbuf_3/a_41382_n240# 0.01fF
C3739 divbuf_3/a_21502_n240# divbuf_3/a_21982_n240# 0.05fF
C3740 divbuf_1/a_5852_n240# divbuf_1/OUT3 0.04fF
C3741 divbuf_1/a_44640_n1600# divbuf_1/a_44670_n840# 0.04fF
C3742 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/a_37022_n240# 0.01fF
C3743 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_17612_n240# 0.04fF
C3744 divbuf_3/a_33120_n1600# divbuf_3/a_33150_n1540# 0.19fF
C3745 divbuf_3/a_2910_n840# divbuf_3/a_2910_n1540# 0.01fF
C3746 divbuf_3/a_33150_n840# divbuf_3/a_33630_n840# 0.07fF
C3747 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/a_34590_n840# 0.06fF
C3748 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_44160_n1600# 0.26fF
C3749 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_4392_n240# 0.01fF
C3750 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_28830_n1540# 0.19fF
C3751 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3752 ro_div_0/divbuf_0/a_28830_n840# ro_div_0/divbuf_0/a_29310_n840# 0.07fF
C3753 divbuf_2/a_7200_n1600# divbuf_2/a_7230_n840# 0.04fF
C3754 pd_div_0/divbuf_0/a_36030_n1540# pd_div_0/divbuf_0/a_36510_n1540# 0.11fF
C3755 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3756 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47070_n840# 0.04fF
C3757 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C3758 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/nor_1/A 0.21fF
C3759 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C3760 divbuf_1/a_22472_n240# divbuf_1/a_22952_n240# 0.05fF
C3761 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11550_n840# 0.02fF
C3762 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_21120_n1600# 0.26fF
C3763 divbuf_0/a_11520_n1600# divbuf_0/a_12000_n1600# 0.26fF
C3764 pll_full_0/divbuf_0/a_12990_n1540# pll_full_0/divbuf_0/a_13470_n1540# 0.11fF
C3765 pll_full_0/divbuf_0/a_43710_n840# pll_full_0/divbuf_0/a_43710_n1540# 0.01fF
C3766 divbuf_1/a_34080_n1600# divbuf_1/a_34110_n1540# 0.19fF
C3767 divbuf_1/a_3870_n840# divbuf_1/a_3870_n1540# 0.01fF
C3768 divbuf_1/a_34110_n840# divbuf_1/a_34590_n840# 0.07fF
C3769 divbuf_0/a_34590_n840# divbuf_0/a_34590_n1540# 0.01fF
C3770 divbuf_0/a_3870_n1540# divbuf_0/a_4350_n1540# 0.11fF
C3771 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/a_25382_n240# 0.04fF
C3772 divbuf_2/a_23922_170# divbuf_2/a_24412_170# 0.07fF
C3773 divbuf_2/a_3912_170# divbuf_2/a_3912_n240# 0.01fF
C3774 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_33630_n840# 0.04fF
C3775 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/a_4392_n240# 0.05fF
C3776 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C3777 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/a_14702_170# 0.07fF
C3778 divbuf_2/a_9732_170# divbuf_2/OUT3 0.19fF
C3779 divbuf_2/a_57120_n1600# divbuf_2/a_57600_n1600# 0.26fF
C3780 pll_full_0/divbuf_1/a_6270_n840# pll_full_0/divbuf_1/a_6270_n1540# 0.01fF
C3781 pll_full_0/divbuf_1/a_36510_n840# pll_full_0/divbuf_1/a_36990_n840# 0.07fF
C3782 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C3783 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36510_n1540# 0.19fF
C3784 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/clk 0.05fF
C3785 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z2 0.40fF
C3786 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divbuf_0/IN 0.04fF
C3787 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/Z1 0.04fF
C3788 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C3789 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C3790 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C3791 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C3792 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_10590_n840# 0.04fF
C3793 divbuf_2/a_49470_n1540# divbuf_2/a_49950_n1540# 0.11fF
C3794 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_13950_n840# 0.01fF
C3795 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/a_8762_170# 0.07fF
C3796 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n840# 0.04fF
C3797 divbuf_3/a_19680_n1600# divbuf_3/a_20160_n1600# 0.26fF
C3798 divbuf_3/a_10212_n240# divbuf_3/a_10110_n840# 0.03fF
C3799 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/a_5790_n840# 0.04fF
C3800 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15840_n1600# 0.26fF
C3801 divbuf_3/a_12030_n1540# divbuf_3/a_12510_n1540# 0.11fF
C3802 divbuf_3/a_42750_n840# divbuf_3/a_42750_n1540# 0.01fF
C3803 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23070_n1540# 0.19fF
C3804 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3805 pd_div_0/divbuf_0/a_23070_n840# pd_div_0/divbuf_0/a_23550_n840# 0.07fF
C3806 ro_div_0/divbuf_0/a_38430_n840# ro_div_0/divbuf_0/a_38430_n1540# 0.01fF
C3807 ro_div_0/divbuf_0/a_7710_n1540# ro_div_0/divbuf_0/a_8190_n1540# 0.11fF
C3808 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/a_14222_n240# 0.01fF
C3809 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/a_27802_170# 0.07fF
C3810 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/a_6822_n240# 0.01fF
C3811 divbuf_2/a_10212_n240# divbuf_2/OUT4 0.04fF
C3812 divbuf_2/a_47040_n1600# divbuf_2/a_47070_n840# 0.04fF
C3813 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/nor_1/B 0.22fF
C3814 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C3815 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C3816 divbuf_0/a_15672_170# divbuf_0/a_16152_170# 0.07fF
C3817 divbuf_1/a_11312_n240# divbuf_1/a_11550_n840# 0.02fF
C3818 divbuf_1/a_20640_n1600# divbuf_1/a_21120_n1600# 0.26fF
C3819 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3820 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C3821 divbuf_0/a_51360_n1600# divbuf_0/a_51840_n1600# 0.26fF
C3822 pll_full_0/divbuf_0/a_52830_n1540# pll_full_0/divbuf_0/a_53310_n1540# 0.11fF
C3823 divbuf_3/a_9600_n1600# divbuf_3/a_9630_n840# 0.04fF
C3824 divbuf_1/a_12990_n1540# divbuf_1/a_13470_n1540# 0.11fF
C3825 divbuf_1/a_43710_n840# divbuf_1/a_43710_n1540# 0.01fF
C3826 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5310_n840# 0.04fF
C3827 divbuf_0/a_43710_n1540# divbuf_0/a_44190_n1540# 0.11fF
C3828 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_13950_n840# 0.02fF
C3829 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23520_n1600# 0.26fF
C3830 divbuf_3/a_60990_n840# divbuf_3/OUT5 0.04fF
C3831 divbuf_2/a_24892_n240# divbuf_2/a_25382_n240# 0.04fF
C3832 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C3833 divbuf_2/a_6270_n840# divbuf_2/a_6270_n1540# 0.01fF
C3834 divbuf_2/a_36510_n840# divbuf_2/a_36990_n840# 0.07fF
C3835 divbuf_2/a_9600_n1600# divbuf_2/OUT3 0.00fF
C3836 divbuf_2/a_36480_n1600# divbuf_2/a_36510_n1540# 0.19fF
C3837 pll_full_0/divbuf_1/a_15390_n1540# pll_full_0/divbuf_1/a_15870_n1540# 0.11fF
C3838 pll_full_0/divbuf_1/a_46110_n840# pll_full_0/divbuf_1/a_46110_n1540# 0.01fF
C3839 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50430_n840# 0.04fF
C3840 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3841 divbuf_3/a_6332_170# divbuf_3/a_6332_n240# 0.01fF
C3842 divbuf_3/a_26352_170# divbuf_3/a_26832_170# 0.07fF
C3843 divbuf_1/a_16642_170# divbuf_1/OUT4 0.19fF
C3844 divbuf_1/a_10560_n1600# divbuf_1/a_10590_n840# 0.04fF
C3845 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3846 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/a_22472_170# 0.07fF
C3847 divbuf_0/a_38472_170# divbuf_0/OUT4 0.19fF
C3848 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n840# 0.04fF
C3849 divbuf_3/a_59520_n1600# divbuf_3/a_60000_n1600# 0.26fF
C3850 divbuf_3/a_14702_170# divbuf_3/OUT4 0.19fF
C3851 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_10080_n1600# 0.26fF
C3852 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55680_n1600# 0.26fF
C3853 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_12990_n840# 0.04fF
C3854 divbuf_3/a_51870_n1540# divbuf_3/a_52350_n1540# 0.11fF
C3855 pd_div_0/divbuf_0/a_1950_n1540# pd_div_0/divbuf_0/a_2430_n1540# 0.11fF
C3856 pd_div_0/divbuf_0/a_32670_n840# pd_div_0/divbuf_0/a_32670_n1540# 0.01fF
C3857 ro_div_0/divbuf_0/a_47550_n1540# ro_div_0/divbuf_0/a_48030_n1540# 0.11fF
C3858 divbuf_1/a_23922_170# divbuf_1/a_24412_170# 0.07fF
C3859 divbuf_1/a_33622_170# divbuf_1/a_33622_n240# 0.01fF
C3860 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/a_28772_n240# 0.05fF
C3861 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/a_30712_n240# 0.01fF
C3862 divbuf_0/a_38962_170# divbuf_0/a_38962_n240# 0.01fF
C3863 divbuf_0/a_19072_n240# divbuf_0/a_19562_n240# 0.04fF
C3864 pll_full_0/divbuf_0/a_9630_n840# pll_full_0/divbuf_0/a_9630_n1540# 0.01fF
C3865 pll_full_0/divbuf_0/a_39870_n840# pll_full_0/divbuf_0/a_40350_n840# 0.07fF
C3866 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_39870_n1540# 0.19fF
C3867 divbuf_1/a_14222_170# divbuf_1/OUT4 0.19fF
C3868 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_480_n1600# 0.00fF
C3869 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n1540# 0.19fF
C3870 divbuf_0/a_510_n840# divbuf_0/a_510_n1540# 0.01fF
C3871 divbuf_0/a_39442_n240# divbuf_0/OUT4 0.04fF
C3872 divbuf_0/a_30750_n840# divbuf_0/a_31230_n840# 0.07fF
C3873 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/a_9732_n240# 0.01fF
C3874 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/a_30232_170# 0.07fF
C3875 divbuf_3/a_15672_n240# divbuf_3/OUT4 0.04fF
C3876 divbuf_3/a_49440_n1600# divbuf_3/a_49470_n840# 0.04fF
C3877 divbuf_1/a_52830_n1540# divbuf_1/a_53310_n1540# 0.11fF
C3878 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45150_n840# 0.04fF
C3879 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C3880 pll_full_0/divbuf_1/a_2430_n840# pll_full_0/divbuf_1/a_2910_n840# 0.07fF
C3881 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3882 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2430_n1540# 0.19fF
C3883 divbuf_2/a_13742_n240# divbuf_2/a_13950_n840# 0.02fF
C3884 divbuf_2/a_23040_n1600# divbuf_2/a_23520_n1600# 0.26fF
C3885 divbuf_2/a_15390_n1540# divbuf_2/a_15870_n1540# 0.11fF
C3886 divbuf_2/a_46110_n840# divbuf_2/a_46110_n1540# 0.01fF
C3887 divbuf_1/a_26352_170# divbuf_1/a_26352_n240# 0.01fF
C3888 pll_full_0/divbuf_1/a_55230_n1540# pll_full_0/divbuf_1/a_55710_n1540# 0.11fF
C3889 divbuf_3/a_27322_n240# divbuf_3/a_27802_n240# 0.05fF
C3890 divbuf_1/a_50400_n1600# divbuf_1/a_50430_n840# 0.04fF
C3891 divbuf_1/a_17612_n240# divbuf_1/OUT4 0.04fF
C3892 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/a_23442_n240# 0.04fF
C3893 divbuf_3/a_8670_n840# divbuf_3/a_8670_n1540# 0.01fF
C3894 divbuf_3/a_38910_n840# divbuf_3/a_39390_n840# 0.07fF
C3895 divbuf_3/a_38880_n1600# divbuf_3/a_38910_n1540# 0.19fF
C3896 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/a_40350_n840# 0.04fF
C3897 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49920_n1600# 0.26fF
C3898 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/a_13742_n240# 0.01fF
C3899 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/a_8272_n240# 0.01fF
C3900 ro_div_0/divbuf_0/a_34590_n840# ro_div_0/divbuf_0/a_35070_n840# 0.07fF
C3901 ro_div_0/divbuf_0/a_4350_n840# ro_div_0/divbuf_0/a_4350_n1540# 0.01fF
C3902 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_34590_n1540# 0.19fF
C3903 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_52830_n840# 0.04fF
C3904 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3905 divbuf_2/a_12960_n1600# divbuf_2/a_12990_n840# 0.04fF
C3906 pd_div_0/divbuf_0/a_41790_n1540# pd_div_0/divbuf_0/a_42270_n1540# 0.11fF
C3907 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C3908 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/nor_1/A 0.15fF
C3909 divbuf_0/a_8762_170# divbuf_0/a_8272_170# 0.07fF
C3910 divbuf_1/a_28292_n240# divbuf_1/a_28772_n240# 0.05fF
C3911 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C3912 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26880_n1600# 0.26fF
C3913 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_17310_n840# 0.02fF
C3914 divbuf_0/a_7792_n240# divbuf_0/a_7710_n840# 0.03fF
C3915 divbuf_0/a_17280_n1600# divbuf_0/a_17760_n1600# 0.26fF
C3916 pll_full_0/divbuf_0/a_18750_n1540# pll_full_0/divbuf_0/a_19230_n1540# 0.11fF
C3917 pll_full_0/divbuf_0/a_49470_n840# pll_full_0/divbuf_0/a_49470_n1540# 0.01fF
C3918 divbuf_1/a_9630_n840# divbuf_1/a_9630_n1540# 0.01fF
C3919 divbuf_1/a_39870_n840# divbuf_1/a_40350_n840# 0.07fF
C3920 divbuf_1/a_39840_n1600# divbuf_1/a_39870_n1540# 0.19fF
C3921 divbuf_0/a_40350_n840# divbuf_0/a_40350_n1540# 0.01fF
C3922 divbuf_0/a_9630_n1540# divbuf_0/a_10110_n1540# 0.11fF
C3923 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/a_31202_n240# 0.04fF
C3924 divbuf_2/a_9732_170# divbuf_2/a_9732_n240# 0.01fF
C3925 divbuf_2/a_29742_170# divbuf_2/a_30232_170# 0.07fF
C3926 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39390_n840# 0.04fF
C3927 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/a_10212_n240# 0.05fF
C3928 divbuf_2/a_2430_n840# divbuf_2/a_2910_n840# 0.07fF
C3929 divbuf_2/a_21502_170# divbuf_2/OUT4 0.19fF
C3930 divbuf_2/a_2400_n1600# divbuf_2/a_2430_n1540# 0.19fF
C3931 pll_full_0/divbuf_1/a_12030_n840# pll_full_0/divbuf_1/a_12030_n1540# 0.01fF
C3932 pll_full_0/divbuf_1/a_42270_n840# pll_full_0/divbuf_1/a_42750_n840# 0.07fF
C3933 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C3934 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42270_n1540# 0.19fF
C3935 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/Out 0.28fF
C3936 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16350_n840# 0.04fF
C3937 divbuf_2/a_55230_n1540# divbuf_2/a_55710_n1540# 0.11fF
C3938 filter_0/a_4216_n2998# filter_0/v 0.31fF
C3939 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n840# 0.04fF
C3940 divbuf_3/a_25440_n1600# divbuf_3/a_25920_n1600# 0.26fF
C3941 divbuf_3/a_16152_n240# divbuf_3/a_16350_n840# 0.02fF
C3942 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21600_n1600# 0.26fF
C3943 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_12030_n840# 0.02fF
C3944 divbuf_3/a_17790_n1540# divbuf_3/a_18270_n1540# 0.11fF
C3945 divbuf_3/a_48510_n840# divbuf_3/a_48510_n1540# 0.01fF
C3946 pd_div_0/divbuf_0/a_28830_n840# pd_div_0/divbuf_0/a_29310_n840# 0.07fF
C3947 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3948 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_28830_n1540# 0.19fF
C3949 ro_div_0/divbuf_0/a_44190_n840# ro_div_0/divbuf_0/a_44190_n1540# 0.01fF
C3950 ro_div_0/divbuf_0/a_13470_n1540# ro_div_0/divbuf_0/a_13950_n1540# 0.11fF
C3951 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/a_33622_170# 0.07fF
C3952 divbuf_2/a_52800_n1600# divbuf_2/a_52830_n840# 0.04fF
C3953 divbuf_2/a_22472_n240# divbuf_2/OUT4 0.04fF
C3954 divbuf_1/a_9732_170# divbuf_1/a_10212_170# 0.07fF
C3955 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/nor_1/A 0.21fF
C3956 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C3957 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/OUT2 0.02fF
C3958 divbuf_0/a_7792_170# divbuf_0/a_7792_n240# 0.01fF
C3959 divbuf_0/a_23922_170# divbuf_0/a_24412_170# 0.07fF
C3960 divbuf_1/a_26400_n1600# divbuf_1/a_26880_n1600# 0.26fF
C3961 divbuf_1/a_17122_n240# divbuf_1/a_17310_n840# 0.02fF
C3962 pll_full_0/divbuf_0/a_5790_n840# pll_full_0/divbuf_0/a_6270_n840# 0.07fF
C3963 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3964 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_5790_n1540# 0.19fF
C3965 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/OUT2 0.19fF
C3966 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C3967 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C3968 divbuf_0/a_57120_n1600# divbuf_0/a_57600_n1600# 0.26fF
C3969 pll_full_0/divbuf_0/a_58590_n1540# pll_full_0/divbuf_0/a_59070_n1540# 0.11fF
C3970 divbuf_3/a_15360_n1600# divbuf_3/a_15390_n840# 0.04fF
C3971 divbuf_1/a_18750_n1540# divbuf_1/a_19230_n1540# 0.11fF
C3972 divbuf_1/a_49470_n840# divbuf_1/a_49470_n1540# 0.01fF
C3973 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11070_n840# 0.04fF
C3974 divbuf_0/a_49470_n1540# divbuf_0/a_49950_n1540# 0.11fF
C3975 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_29280_n1600# 0.26fF
C3976 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/a_19710_n840# 0.03fF
C3977 divbuf_2/a_30712_n240# divbuf_2/a_31202_n240# 0.04fF
C3978 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C3979 divbuf_2/a_12030_n840# divbuf_2/a_12030_n1540# 0.01fF
C3980 divbuf_2/a_42270_n840# divbuf_2/a_42750_n840# 0.07fF
C3981 divbuf_2/a_20640_n1600# divbuf_2/OUT4 0.00fF
C3982 divbuf_2/a_42240_n1600# divbuf_2/a_42270_n1540# 0.19fF
C3983 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/Z1 0.04fF
C3984 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/bufin 0.04fF
C3985 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z2 0.40fF
C3986 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/clk 0.05fF
C3987 pll_full_0/divbuf_1/a_21150_n1540# pll_full_0/divbuf_1/a_21630_n1540# 0.11fF
C3988 pll_full_0/divbuf_1/a_51870_n840# pll_full_0/divbuf_1/a_51870_n1540# 0.01fF
C3989 divbuf_1/a_16320_n1600# divbuf_1/a_16350_n840# 0.04fF
C3990 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3991 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56190_n840# 0.04fF
C3992 divbuf_3/a_12772_170# divbuf_3/a_12772_n240# 0.01fF
C3993 divbuf_3/a_32172_170# divbuf_3/a_32652_170# 0.07fF
C3994 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3995 ro_div_0/divbuf_0/a_7302_170# ro_div_0/divbuf_0/a_7302_n240# 0.01fF
C3996 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/a_28292_170# 0.07fF
C3997 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n840# 0.04fF
C3998 divbuf_0/a_10212_n240# divbuf_0/OUT4 0.04fF
C3999 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C4000 divbuf_3/a_4830_n840# divbuf_3/a_5310_n840# 0.07fF
C4001 divbuf_3/a_26352_170# divbuf_3/OUT4 0.19fF
C4002 divbuf_3/a_4800_n1600# divbuf_3/a_4830_n1540# 0.19fF
C4003 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15840_n1600# 0.26fF
C4004 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/z5 0.11fF
C4005 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4006 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_510_n1540# 0.19fF
C4007 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/a_990_n840# 0.07fF
C4008 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_18750_n840# 0.04fF
C4009 divbuf_3/a_57630_n1540# divbuf_3/a_58110_n1540# 0.11fF
C4010 pd_div_0/divbuf_0/a_7710_n1540# pd_div_0/divbuf_0/a_8190_n1540# 0.11fF
C4011 pd_div_0/divbuf_0/a_38430_n840# pd_div_0/divbuf_0/a_38430_n1540# 0.01fF
C4012 ro_div_0/divbuf_0/a_53310_n1540# ro_div_0/divbuf_0/a_53790_n1540# 0.11fF
C4013 divbuf_2/a_990_n840# divbuf_2/OUT2 0.02fF
C4014 divbuf_1/a_29742_170# divbuf_1/a_30232_170# 0.07fF
C4015 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/a_34592_n240# 0.05fF
C4016 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/a_36532_n240# 0.01fF
C4017 divbuf_0/a_24892_n240# divbuf_0/a_25382_n240# 0.04fF
C4018 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_45630_n1540# 0.19fF
C4019 pll_full_0/divbuf_0/a_15390_n840# pll_full_0/divbuf_0/a_15390_n1540# 0.01fF
C4020 pll_full_0/divbuf_0/a_45630_n840# pll_full_0/divbuf_0/a_46110_n840# 0.07fF
C4021 divbuf_1/a_5790_n840# divbuf_1/a_6270_n840# 0.07fF
C4022 divbuf_1/a_24892_170# divbuf_1/OUT4 0.19fF
C4023 divbuf_1/a_5760_n1600# divbuf_1/a_5790_n1540# 0.19fF
C4024 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n1540# 0.19fF
C4025 divbuf_0/a_9600_n1600# divbuf_0/OUT3 0.00fF
C4026 divbuf_0/a_36510_n840# divbuf_0/a_36990_n840# 0.07fF
C4027 divbuf_0/a_6270_n840# divbuf_0/a_6270_n1540# 0.01fF
C4028 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/a_16152_n240# 0.01fF
C4029 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/a_36052_170# 0.07fF
C4030 divbuf_3/a_27322_n240# divbuf_3/OUT4 0.04fF
C4031 divbuf_3/a_55200_n1600# divbuf_3/a_55230_n840# 0.04fF
C4032 divbuf_1/a_58590_n1540# divbuf_1/a_59070_n1540# 0.11fF
C4033 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5310_n840# 0.04fF
C4034 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/a_15672_170# 0.07fF
C4035 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4036 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_50910_n840# 0.04fF
C4037 pll_full_0/divbuf_1/a_8190_n840# pll_full_0/divbuf_1/a_8670_n840# 0.07fF
C4038 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4039 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8190_n1540# 0.19fF
C4040 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C4041 divbuf_2/a_28800_n1600# divbuf_2/a_29280_n1600# 0.26fF
C4042 divbuf_2/a_19562_n240# divbuf_2/a_19710_n840# 0.03fF
C4043 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/nor_1/B 0.18fF
C4044 divbuf_2/a_21150_n1540# divbuf_2/a_21630_n1540# 0.11fF
C4045 divbuf_2/a_51870_n840# divbuf_2/a_51870_n1540# 0.01fF
C4046 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/a_2430_n840# 0.03fF
C4047 divbuf_3/a_33142_n240# divbuf_3/a_33622_n240# 0.05fF
C4048 divbuf_1/a_29262_n240# divbuf_1/OUT4 0.04fF
C4049 divbuf_1/a_56160_n1600# divbuf_1/a_56190_n840# 0.04fF
C4050 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/a_29262_n240# 0.04fF
C4051 divbuf_3/a_44640_n1600# divbuf_3/a_44670_n1540# 0.19fF
C4052 divbuf_3/a_14430_n840# divbuf_3/a_14430_n1540# 0.01fF
C4053 divbuf_3/a_44670_n840# divbuf_3/a_45150_n840# 0.07fF
C4054 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55680_n1600# 0.26fF
C4055 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40350_n1540# 0.19fF
C4056 ro_div_0/divbuf_0/a_40350_n840# ro_div_0/divbuf_0/a_40830_n840# 0.07fF
C4057 ro_div_0/divbuf_0/a_10110_n840# ro_div_0/divbuf_0/a_10110_n1540# 0.01fF
C4058 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4059 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_58590_n840# 0.04fF
C4060 divbuf_2/a_18720_n1600# divbuf_2/a_18750_n840# 0.04fF
C4061 pd_div_0/divbuf_0/a_47550_n1540# pd_div_0/divbuf_0/a_48030_n1540# 0.11fF
C4062 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/clk 0.01fF
C4063 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C4064 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C4065 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C4066 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C4067 divbuf_1/a_34112_n240# divbuf_1/a_34592_n240# 0.05fF
C4068 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/a_23070_n840# 0.03fF
C4069 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32640_n1600# 0.26fF
C4070 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/a_5310_n840# 0.04fF
C4071 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C4072 divbuf_0/a_23040_n1600# divbuf_0/a_23520_n1600# 0.26fF
C4073 divbuf_0/a_13742_n240# divbuf_0/a_13950_n840# 0.02fF
C4074 pll_full_0/divbuf_0/a_24510_n1540# pll_full_0/divbuf_0/a_24990_n1540# 0.11fF
C4075 pll_full_0/divbuf_0/a_55230_n840# pll_full_0/divbuf_0/a_55230_n1540# 0.01fF
C4076 divbuf_3/a_1352_n240# divbuf_3/a_1470_n840# 0.03fF
C4077 divbuf_1/a_45600_n1600# divbuf_1/a_45630_n1540# 0.19fF
C4078 divbuf_1/a_15390_n840# divbuf_1/a_15390_n1540# 0.01fF
C4079 divbuf_1/a_45630_n840# divbuf_1/a_46110_n840# 0.07fF
C4080 divbuf_0/a_46110_n840# divbuf_0/a_46110_n1540# 0.01fF
C4081 divbuf_0/a_15390_n1540# divbuf_0/a_15870_n1540# 0.11fF
C4082 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/a_37022_n240# 0.04fF
C4083 divbuf_2/a_16152_170# divbuf_2/a_16152_n240# 0.01fF
C4084 divbuf_2/a_35562_170# divbuf_2/a_36052_170# 0.07fF
C4085 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45150_n840# 0.04fF
C4086 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_16642_n240# 0.04fF
C4087 pll_full_0/divbuf_1/a_17790_n840# pll_full_0/divbuf_1/a_17790_n1540# 0.01fF
C4088 pll_full_0/divbuf_1/a_48030_n840# pll_full_0/divbuf_1/a_48510_n840# 0.07fF
C4089 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C4090 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48030_n1540# 0.19fF
C4091 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/a_20042_170# 0.07fF
C4092 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/a_3422_n240# 0.01fF
C4093 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C4094 divbuf_2/a_8190_n840# divbuf_2/a_8670_n840# 0.07fF
C4095 divbuf_2/a_33142_170# divbuf_2/OUT4 0.19fF
C4096 divbuf_2/a_8160_n1600# divbuf_2/a_8190_n1540# 0.19fF
C4097 divbuf_1/a_2322_n240# divbuf_1/a_2430_n840# 0.03fF
C4098 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C4099 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/Out 0.91fF
C4100 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22110_n840# 0.04fF
C4101 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n840# 0.04fF
C4102 divbuf_3/a_31200_n1600# divbuf_3/a_31680_n1600# 0.26fF
C4103 divbuf_3/a_21982_n240# divbuf_3/a_22110_n840# 0.03fF
C4104 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/a_23442_n240# 0.04fF
C4105 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_17790_n840# 0.02fF
C4106 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_27360_n1600# 0.26fF
C4107 divbuf_3/a_23550_n1540# divbuf_3/a_24030_n1540# 0.11fF
C4108 divbuf_3/a_54270_n840# divbuf_3/a_54270_n1540# 0.01fF
C4109 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_34590_n1540# 0.19fF
C4110 pd_div_0/divbuf_0/a_4350_n840# pd_div_0/divbuf_0/a_4350_n1540# 0.01fF
C4111 pd_div_0/divbuf_0/a_34590_n840# pd_div_0/divbuf_0/a_35070_n840# 0.07fF
C4112 ro_div_0/divbuf_0/a_49950_n840# ro_div_0/divbuf_0/a_49950_n1540# 0.01fF
C4113 ro_div_0/divbuf_0/a_19230_n1540# ro_div_0/divbuf_0/a_19710_n1540# 0.11fF
C4114 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/a_39442_170# 0.07fF
C4115 divbuf_2/a_34112_n240# divbuf_2/OUT4 0.04fF
C4116 divbuf_2/a_58560_n1600# divbuf_2/a_58590_n840# 0.04fF
C4117 divbuf_1/a_6332_170# divbuf_1/a_6822_170# 0.07fF
C4118 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/nor_1/A 0.15fF
C4119 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C4120 divbuf_0/a_29742_170# divbuf_0/a_30232_170# 0.07fF
C4121 divbuf_1/a_22952_n240# divbuf_1/a_23070_n840# 0.03fF
C4122 divbuf_1/a_32160_n1600# divbuf_1/a_32640_n1600# 0.26fF
C4123 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_11550_n1540# 0.19fF
C4124 pll_full_0/divbuf_0/a_11550_n840# pll_full_0/divbuf_0/a_12030_n840# 0.07fF
C4125 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4126 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n1540# 0.19fF
C4127 divbuf_0/a_21502_170# divbuf_0/OUT4 0.19fF
C4128 divbuf_0/a_2430_n840# divbuf_0/a_2910_n840# 0.07fF
C4129 divbuf_3/a_21120_n1600# divbuf_3/a_21150_n840# 0.04fF
C4130 divbuf_1/a_24510_n1540# divbuf_1/a_24990_n1540# 0.11fF
C4131 divbuf_1/a_55230_n840# divbuf_1/a_55230_n1540# 0.01fF
C4132 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_16830_n840# 0.04fF
C4133 divbuf_0/a_55230_n1540# divbuf_0/a_55710_n1540# 0.11fF
C4134 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/a_25470_n840# 0.03fF
C4135 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_35040_n1600# 0.26fF
C4136 divbuf_2/a_36532_n240# divbuf_2/a_37022_n240# 0.04fF
C4137 divbuf_2/a_17790_n840# divbuf_2/a_17790_n1540# 0.01fF
C4138 divbuf_2/a_48030_n840# divbuf_2/a_48510_n840# 0.07fF
C4139 divbuf_2/a_32160_n1600# divbuf_2/OUT4 0.00fF
C4140 divbuf_2/a_48000_n1600# divbuf_2/a_48030_n1540# 0.19fF
C4141 pll_full_0/divbuf_1/a_26910_n1540# pll_full_0/divbuf_1/a_27390_n1540# 0.11fF
C4142 pll_full_0/divbuf_1/a_57630_n840# pll_full_0/divbuf_1/a_57630_n1540# 0.01fF
C4143 divbuf_1/a_22080_n1600# divbuf_1/a_22110_n840# 0.04fF
C4144 divbuf_1/a_11802_170# divbuf_1/OUT4 0.19fF
C4145 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4146 divbuf_3/a_18582_170# divbuf_3/a_18582_n240# 0.01fF
C4147 divbuf_3/a_37992_170# divbuf_3/a_38472_170# 0.07fF
C4148 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C4149 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/a_34112_170# 0.07fF
C4150 divbuf_0/a_22472_n240# divbuf_0/OUT4 0.04fF
C4151 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n840# 0.04fF
C4152 divbuf_3/a_10560_n1600# divbuf_3/a_10590_n1540# 0.19fF
C4153 divbuf_3/a_10590_n840# divbuf_3/a_11070_n840# 0.07fF
C4154 divbuf_3/a_37992_170# divbuf_3/OUT4 0.19fF
C4155 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21600_n1600# 0.26fF
C4156 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_4882_170# 0.07fF
C4157 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z1 0.09fF
C4158 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z2 0.19fF
C4159 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6270_n1540# 0.19fF
C4160 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4161 ro_div_0/divbuf_0/a_6270_n840# ro_div_0/divbuf_0/a_6750_n840# 0.07fF
C4162 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/OUT3 0.19fF
C4163 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24510_n840# 0.04fF
C4164 divbuf_3/OUT3 divbuf_3/OUT4 0.36fF
C4165 pd_div_0/divbuf_0/a_13470_n1540# pd_div_0/divbuf_0/a_13950_n1540# 0.11fF
C4166 pd_div_0/divbuf_0/a_44190_n840# pd_div_0/divbuf_0/a_44190_n1540# 0.01fF
C4167 ro_div_0/divbuf_0/a_59070_n1540# ro_div_0/divbuf_0/a_59550_n1540# 0.11fF
C4168 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/a_40412_n240# 0.05fF
C4169 divbuf_1/a_38962_170# divbuf_1/a_39442_170# 0.07fF
C4170 divbuf_1/a_11520_n1600# divbuf_1/a_11550_n1540# 0.19fF
C4171 divbuf_1/a_11550_n840# divbuf_1/a_12030_n840# 0.07fF
C4172 divbuf_1/a_39932_170# divbuf_1/OUT4 0.19fF
C4173 divbuf_0/a_30712_n240# divbuf_0/a_31202_n240# 0.04fF
C4174 pll_full_0/divbuf_0/a_21150_n840# pll_full_0/divbuf_0/a_21150_n1540# 0.01fF
C4175 pll_full_0/divbuf_0/a_51390_n840# pll_full_0/divbuf_0/a_51870_n840# 0.07fF
C4176 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51390_n1540# 0.19fF
C4177 divbuf_0/a_12030_n840# divbuf_0/a_12030_n1540# 0.01fF
C4178 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n1540# 0.19fF
C4179 divbuf_0/a_20640_n1600# divbuf_0/OUT4 0.00fF
C4180 divbuf_0/a_42270_n840# divbuf_0/a_42750_n840# 0.07fF
C4181 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/a_21982_n240# 0.01fF
C4182 divbuf_3/a_38962_n240# divbuf_3/OUT4 0.04fF
C4183 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11070_n840# 0.04fF
C4184 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/a_21502_170# 0.07fF
C4185 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_56670_n840# 0.04fF
C4186 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4187 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C4188 pll_full_0/divbuf_1/a_13950_n840# pll_full_0/divbuf_1/a_14430_n840# 0.07fF
C4189 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_13950_n1540# 0.19fF
C4190 divbuf_2/a_25382_n240# divbuf_2/a_25470_n840# 0.03fF
C4191 divbuf_2/a_34560_n1600# divbuf_2/a_35040_n1600# 0.26fF
C4192 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z3 0.45fF
C4193 divbuf_2/a_26910_n1540# divbuf_2/a_27390_n1540# 0.11fF
C4194 divbuf_2/a_57630_n840# divbuf_2/a_57630_n1540# 0.01fF
C4195 divbuf_3/a_38962_n240# divbuf_3/a_39442_n240# 0.05fF
C4196 divbuf_1/a_40902_n240# divbuf_1/OUT4 0.04fF
C4197 divbuf_1/a_480_n1600# divbuf_1/IN 0.00fF
C4198 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/a_35082_n240# 0.04fF
C4199 divbuf_0/a_990_n840# divbuf_0/OUT2 0.02fF
C4200 divbuf_3/a_20190_n840# divbuf_3/a_20190_n1540# 0.01fF
C4201 divbuf_3/a_50430_n840# divbuf_3/a_50910_n840# 0.07fF
C4202 divbuf_3/a_50400_n1600# divbuf_3/a_50430_n1540# 0.19fF
C4203 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/a_990_n840# 0.07fF
C4204 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_510_n1540# 0.19fF
C4205 ro_div_0/divbuf_0/a_46110_n840# ro_div_0/divbuf_0/a_46590_n840# 0.07fF
C4206 ro_div_0/divbuf_0/a_15870_n840# ro_div_0/divbuf_0/a_15870_n1540# 0.01fF
C4207 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46110_n1540# 0.19fF
C4208 divbuf_2/a_4392_170# divbuf_2/OUT3 0.19fF
C4209 divbuf_2/a_24480_n1600# divbuf_2/a_24510_n840# 0.04fF
C4210 pd_div_0/divbuf_0/a_53310_n1540# pd_div_0/divbuf_0/a_53790_n1540# 0.11fF
C4211 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/switch_3/vin 0.20fF
C4212 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C4213 divbuf_1/a_39932_n240# divbuf_1/a_40412_n240# 0.05fF
C4214 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C4215 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/a_28830_n840# 0.04fF
C4216 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_38400_n1600# 0.26fF
C4217 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11550_n840# 0.02fF
C4218 divbuf_0/a_19562_n240# divbuf_0/a_19710_n840# 0.03fF
C4219 divbuf_0/a_28800_n1600# divbuf_0/a_29280_n1600# 0.26fF
C4220 pll_full_0/divbuf_0/a_30270_n1540# pll_full_0/divbuf_0/a_30750_n1540# 0.11fF
C4221 pll_full_0/divbuf_0/a_60990_n840# pll_full_0/divbuf_0/a_60990_n1540# 0.01fF
C4222 divbuf_1/a_21150_n840# divbuf_1/a_21150_n1540# 0.01fF
C4223 divbuf_1/a_51390_n840# divbuf_1/a_51870_n840# 0.07fF
C4224 divbuf_1/a_51360_n1600# divbuf_1/a_51390_n1540# 0.19fF
C4225 divbuf_0/a_51870_n840# divbuf_0/a_51870_n1540# 0.01fF
C4226 divbuf_0/a_21150_n1540# divbuf_0/a_21630_n1540# 0.11fF
C4227 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_960_n1600# 0.26fF
C4228 divbuf_2/a_21982_170# divbuf_2/a_21982_n240# 0.01fF
C4229 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_50910_n840# 0.04fF
C4230 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_53790_n1540# 0.19fF
C4231 pll_full_0/divbuf_1/a_23550_n840# pll_full_0/divbuf_1/a_23550_n1540# 0.01fF
C4232 pll_full_0/divbuf_1/a_53790_n840# pll_full_0/divbuf_1/a_54270_n840# 0.07fF
C4233 divbuf_2/a_5362_n240# divbuf_2/OUT3 0.04fF
C4234 divbuf_2/a_13950_n840# divbuf_2/a_14430_n840# 0.07fF
C4235 divbuf_2/a_13920_n1600# divbuf_2/a_13950_n1540# 0.19fF
C4236 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/nor_1/B 0.18fF
C4237 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C4238 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z3 0.45fF
C4239 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_27870_n840# 0.04fF
C4240 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C4241 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/a_29262_n240# 0.04fF
C4242 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n840# 0.04fF
C4243 divbuf_3/a_27802_n240# divbuf_3/a_27870_n840# 0.04fF
C4244 divbuf_3/a_36960_n1600# divbuf_3/a_37440_n1600# 0.26fF
C4245 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_33120_n1600# 0.26fF
C4246 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/a_23550_n840# 0.03fF
C4247 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11070_n840# 0.02fF
C4248 divbuf_3/a_29310_n1540# divbuf_3/a_29790_n1540# 0.11fF
C4249 divbuf_3/a_60030_n840# divbuf_3/a_60030_n1540# 0.01fF
C4250 pd_div_0/divbuf_0/a_10110_n840# pd_div_0/divbuf_0/a_10110_n1540# 0.01fF
C4251 pd_div_0/divbuf_0/a_40350_n840# pd_div_0/divbuf_0/a_40830_n840# 0.07fF
C4252 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40350_n1540# 0.19fF
C4253 ro_div_0/divbuf_0/a_55710_n840# ro_div_0/divbuf_0/a_55710_n1540# 0.01fF
C4254 ro_div_0/divbuf_0/a_24990_n1540# ro_div_0/divbuf_0/a_25470_n1540# 0.11fF
C4255 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/a_5362_n240# 0.05fF
C4256 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/a_25382_n240# 0.01fF
C4257 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C4258 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C4259 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/clk 0.01fF
C4260 divbuf_0/a_35562_170# divbuf_0/a_36052_170# 0.07fF
C4261 divbuf_1/a_28772_n240# divbuf_1/a_28830_n840# 0.04fF
C4262 divbuf_1/a_37920_n1600# divbuf_1/a_38400_n1600# 0.26fF
C4263 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4264 pll_full_0/divbuf_0/a_17310_n840# pll_full_0/divbuf_0/a_17790_n840# 0.07fF
C4265 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17310_n1540# 0.19fF
C4266 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4267 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/a_9242_n240# 0.01fF
C4268 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n1540# 0.19fF
C4269 divbuf_0/a_33142_170# divbuf_0/OUT4 0.19fF
C4270 divbuf_0/a_8190_n840# divbuf_0/a_8670_n840# 0.07fF
C4271 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/a_6822_170# 0.07fF
C4272 divbuf_3/a_9242_170# divbuf_3/OUT3 0.19fF
C4273 divbuf_3/a_26880_n1600# divbuf_3/a_26910_n840# 0.04fF
C4274 divbuf_1/a_30270_n1540# divbuf_1/a_30750_n1540# 0.11fF
C4275 divbuf_1/a_60990_n840# divbuf_1/a_60990_n1540# 0.01fF
C4276 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4277 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_22590_n840# 0.04fF
C4278 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40800_n1600# 0.26fF
C4279 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/a_31230_n840# 0.05fF
C4280 divbuf_2/a_480_n1600# divbuf_2/a_960_n1600# 0.26fF
C4281 divbuf_2/a_53760_n1600# divbuf_2/a_53790_n1540# 0.19fF
C4282 divbuf_2/a_23550_n840# divbuf_2/a_23550_n1540# 0.01fF
C4283 divbuf_2/a_53790_n840# divbuf_2/a_54270_n840# 0.07fF
C4284 divbuf_1/a_11312_170# divbuf_1/a_11312_n240# 0.01fF
C4285 pll_full_0/divbuf_1/a_32670_n1540# pll_full_0/divbuf_1/a_33150_n1540# 0.11fF
C4286 divbuf_1/a_27840_n1600# divbuf_1/a_27870_n840# 0.04fF
C4287 divbuf_1/a_12772_170# divbuf_1/OUT4 0.19fF
C4288 divbuf_1/a_1842_170# divbuf_1/OUT2 0.19fF
C4289 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C4290 divbuf_3/a_3912_n240# divbuf_3/a_4392_n240# 0.05fF
C4291 divbuf_3/a_24412_170# divbuf_3/a_24412_n240# 0.01fF
C4292 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4293 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/a_39932_170# 0.07fF
C4294 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/a_20042_n240# 0.01fF
C4295 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n840# 0.04fF
C4296 divbuf_0/a_34112_n240# divbuf_0/OUT4 0.04fF
C4297 divbuf_3/a_10212_n240# divbuf_3/OUT3 0.04fF
C4298 divbuf_3/a_16350_n840# divbuf_3/a_16830_n840# 0.07fF
C4299 divbuf_3/a_16320_n1600# divbuf_3/a_16350_n1540# 0.19fF
C4300 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_27360_n1600# 0.26fF
C4301 ro_div_0/ro_complete_0/a4 ro_div_0/divider_0/clk 0.05fF
C4302 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4303 ro_div_0/divbuf_0/a_12030_n840# ro_div_0/divbuf_0/a_12510_n840# 0.07fF
C4304 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/OUT2 0.07fF
C4305 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12030_n1540# 0.19fF
C4306 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30270_n840# 0.04fF
C4307 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4308 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C4309 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C4310 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C4311 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C4312 divbuf_2/a_11312_n240# divbuf_2/a_11070_n840# 0.02fF
C4313 pd_div_0/divbuf_0/a_19230_n1540# pd_div_0/divbuf_0/a_19710_n1540# 0.11fF
C4314 pd_div_0/divbuf_0/a_49950_n840# pd_div_0/divbuf_0/a_49950_n1540# 0.01fF
C4315 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_4320_n1600# 0.26fF
C4316 divbuf_1/a_4882_n240# divbuf_1/a_5362_n240# 0.05fF
C4317 divbuf_0/a_36532_n240# divbuf_0/a_37022_n240# 0.04fF
C4318 divbuf_1/a_12282_n240# divbuf_1/OUT4 0.04fF
C4319 divbuf_1/a_17310_n840# divbuf_1/a_17790_n840# 0.07fF
C4320 divbuf_1/a_17280_n1600# divbuf_1/a_17310_n1540# 0.19fF
C4321 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57150_n1540# 0.19fF
C4322 pll_full_0/divbuf_0/a_26910_n840# pll_full_0/divbuf_0/a_26910_n1540# 0.01fF
C4323 pll_full_0/divbuf_0/a_57150_n840# pll_full_0/divbuf_0/a_57630_n840# 0.07fF
C4324 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n1540# 0.19fF
C4325 divbuf_0/a_32160_n1600# divbuf_0/OUT4 0.00fF
C4326 divbuf_0/a_48030_n840# divbuf_0/a_48510_n840# 0.07fF
C4327 divbuf_0/a_17790_n840# divbuf_0/a_17790_n1540# 0.01fF
C4328 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/a_7792_n240# 0.04fF
C4329 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/a_27802_n240# 0.01fF
C4330 divbuf_3/a_9120_n1600# divbuf_3/OUT3 0.00fF
C4331 divbuf_2/a_6332_170# divbuf_2/a_6822_170# 0.07fF
C4332 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_16830_n840# 0.04fF
C4333 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/a_27322_170# 0.07fF
C4334 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/OUT5 0.04fF
C4335 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C4336 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_19710_n1540# 0.19fF
C4337 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4338 pll_full_0/divbuf_1/a_19710_n840# pll_full_0/divbuf_1/a_20190_n840# 0.07fF
C4339 divbuf_2/a_40320_n1600# divbuf_2/a_40800_n1600# 0.26fF
C4340 divbuf_2/a_31202_n240# divbuf_2/a_31230_n840# 0.05fF
C4341 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/and_0/OUT 0.05fF
C4342 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_14430_n840# 0.01fF
C4343 divbuf_2/a_32670_n1540# divbuf_2/a_33150_n1540# 0.11fF
C4344 ashish_0/von ashish_0/vop 12.87fF
C4345 ashish_0/a_150_n710# ashish_0/Gnd 1.71fF
C4346 divbuf_1/a_11040_n1600# divbuf_1/OUT3 0.00fF
C4347 divbuf_3/a_2880_n1600# divbuf_3/a_3360_n1600# 0.26fF
C4348 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/a_40902_n240# 0.04fF
C4349 divbuf_3/a_56160_n1600# divbuf_3/a_56190_n1540# 0.19fF
C4350 divbuf_3/a_25950_n840# divbuf_3/a_25950_n1540# 0.01fF
C4351 divbuf_3/a_56190_n840# divbuf_3/a_56670_n840# 0.07fF
C4352 pd_div_0/divbuf_0/a_6270_n840# pd_div_0/divbuf_0/a_6750_n840# 0.07fF
C4353 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6270_n1540# 0.19fF
C4354 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/IN 0.00fF
C4355 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_51870_n1540# 0.19fF
C4356 ro_div_0/divbuf_0/a_51870_n840# ro_div_0/divbuf_0/a_52350_n840# 0.07fF
C4357 ro_div_0/divbuf_0/a_21630_n840# ro_div_0/divbuf_0/a_21630_n1540# 0.01fF
C4358 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/a_12282_170# 0.07fF
C4359 divbuf_2/a_30240_n1600# divbuf_2/a_30270_n840# 0.04fF
C4360 divbuf_2/a_16152_170# divbuf_2/OUT4 0.19fF
C4361 pd_div_0/divbuf_0/a_59070_n1540# pd_div_0/divbuf_0/a_59550_n1540# 0.11fF
C4362 divbuf_1/a_3840_n1600# divbuf_1/a_4320_n1600# 0.26fF
C4363 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C4364 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C4365 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/a_34590_n840# 0.06fF
C4366 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_44160_n1600# 0.26fF
C4367 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_17310_n840# 0.02fF
C4368 divbuf_0/a_34560_n1600# divbuf_0/a_35040_n1600# 0.26fF
C4369 divbuf_0/a_17122_170# divbuf_0/OUT4 0.19fF
C4370 divbuf_0/a_25382_n240# divbuf_0/a_25470_n840# 0.03fF
C4371 pll_full_0/divbuf_0/a_36030_n1540# pll_full_0/divbuf_0/a_36510_n1540# 0.11fF
C4372 divbuf_3/a_13742_n240# divbuf_3/a_13470_n840# 0.01fF
C4373 divbuf_1/a_57120_n1600# divbuf_1/a_57150_n1540# 0.19fF
C4374 divbuf_1/a_26910_n840# divbuf_1/a_26910_n1540# 0.01fF
C4375 divbuf_1/a_57150_n840# divbuf_1/a_57630_n840# 0.07fF
C4376 divbuf_0/a_57630_n840# divbuf_0/a_57630_n1540# 0.01fF
C4377 divbuf_0/a_26910_n1540# divbuf_0/a_27390_n1540# 0.11fF
C4378 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6720_n1600# 0.26fF
C4379 divbuf_2/a_7302_n240# divbuf_2/a_7792_n240# 0.04fF
C4380 divbuf_2/a_27802_170# divbuf_2/a_27802_n240# 0.01fF
C4381 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4382 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_56670_n840# 0.04fF
C4383 pll_full_0/divbuf_1/a_29310_n840# pll_full_0/divbuf_1/a_29310_n1540# 0.01fF
C4384 pll_full_0/divbuf_1/a_59550_n840# pll_full_0/divbuf_1/a_60030_n840# 0.07fF
C4385 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_59550_n1540# 0.19fF
C4386 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/a_11802_n240# 0.01fF
C4387 pll_full_0/divbuf_0/a_1842_170# pll_full_0/divbuf_0/a_1842_n240# 0.01fF
C4388 divbuf_2/a_19680_n1600# divbuf_2/a_19710_n1540# 0.19fF
C4389 divbuf_2/a_17122_n240# divbuf_2/OUT4 0.04fF
C4390 divbuf_2/a_19710_n840# divbuf_2/a_20190_n840# 0.07fF
C4391 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z3 0.45fF
C4392 divbuf_0/a_6822_170# divbuf_0/a_6822_n240# 0.01fF
C4393 divbuf_3/a_8762_170# divbuf_3/a_9242_170# 0.07fF
C4394 divbuf_1/a_14702_n240# divbuf_1/a_14430_n840# 0.01fF
C4395 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4396 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_33630_n840# 0.04fF
C4397 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/a_35082_n240# 0.04fF
C4398 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n840# 0.04fF
C4399 divbuf_3/a_42720_n1600# divbuf_3/a_43200_n1600# 0.26fF
C4400 divbuf_3/a_33622_n240# divbuf_3/a_33630_n840# 0.06fF
C4401 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38880_n1600# 0.26fF
C4402 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/a_29310_n840# 0.04fF
C4403 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_16830_n840# 0.00fF
C4404 divbuf_3/a_35070_n1540# divbuf_3/a_35550_n1540# 0.11fF
C4405 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46110_n1540# 0.19fF
C4406 pd_div_0/divbuf_0/a_15870_n840# pd_div_0/divbuf_0/a_15870_n1540# 0.01fF
C4407 pd_div_0/divbuf_0/a_46110_n840# pd_div_0/divbuf_0/a_46590_n840# 0.07fF
C4408 ro_div_0/divbuf_0/a_30750_n1540# ro_div_0/divbuf_0/a_31230_n1540# 0.11fF
C4409 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/a_31202_n240# 0.01fF
C4410 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11802_n240# 0.04fF
C4411 divbuf_0/a_21982_170# divbuf_0/a_21982_n240# 0.01fF
C4412 divbuf_1/a_7792_170# divbuf_1/OUT3 0.19fF
C4413 divbuf_1/a_34592_n240# divbuf_1/a_34590_n840# 0.06fF
C4414 divbuf_1/a_43680_n1600# divbuf_1/a_44160_n1600# 0.26fF
C4415 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23070_n1540# 0.19fF
C4416 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4417 pll_full_0/divbuf_0/a_23070_n840# pll_full_0/divbuf_0/a_23550_n840# 0.07fF
C4418 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4419 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n1540# 0.19fF
C4420 divbuf_0/a_13950_n840# divbuf_0/a_14430_n840# 0.07fF
C4421 divbuf_0/a_5362_n240# divbuf_0/OUT3 0.04fF
C4422 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/a_13252_170# 0.07fF
C4423 divbuf_3/a_21012_170# divbuf_3/OUT4 0.19fF
C4424 divbuf_3/a_32640_n1600# divbuf_3/a_32670_n840# 0.04fF
C4425 divbuf_1/a_36030_n1540# divbuf_1/a_36510_n1540# 0.11fF
C4426 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z3 0.65fF
C4427 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28350_n840# 0.04fF
C4428 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/a_36990_n840# 0.05fF
C4429 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46560_n1600# 0.26fF
C4430 divbuf_2/a_6240_n1600# divbuf_2/a_6720_n1600# 0.26fF
C4431 pll_full_0/divbuf_1/a_38430_n1540# pll_full_0/divbuf_1/a_38910_n1540# 0.11fF
C4432 divbuf_2/a_29310_n840# divbuf_2/a_29310_n1540# 0.01fF
C4433 divbuf_2/a_59550_n840# divbuf_2/a_60030_n840# 0.07fF
C4434 divbuf_2/a_59520_n1600# divbuf_2/a_59550_n1540# 0.19fF
C4435 divbuf_1/a_19562_170# divbuf_1/OUT4 0.19fF
C4436 divbuf_1/a_33600_n1600# divbuf_1/a_33630_n840# 0.04fF
C4437 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C4438 divbuf_3/a_30232_170# divbuf_3/a_30232_n240# 0.01fF
C4439 divbuf_3/a_9732_n240# divbuf_3/a_10212_n240# 0.05fF
C4440 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/a_25862_n240# 0.01fF
C4441 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/a_5852_n240# 0.04fF
C4442 divbuf_3/a_22080_n1600# divbuf_3/a_22110_n1540# 0.19fF
C4443 divbuf_3/a_21982_n240# divbuf_3/OUT4 0.04fF
C4444 divbuf_3/a_22110_n840# divbuf_3/a_22590_n840# 0.07fF
C4445 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/a_23550_n840# 0.03fF
C4446 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_33120_n1600# 0.26fF
C4447 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_17790_n1540# 0.19fF
C4448 ro_div_0/divbuf_0/a_17790_n840# ro_div_0/divbuf_0/a_18270_n840# 0.07fF
C4449 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4450 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4451 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36030_n840# 0.04fF
C4452 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C4453 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C4454 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C4455 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C4456 divbuf_2/a_17122_n240# divbuf_2/a_16830_n840# 0.00fF
C4457 pd_div_0/divbuf_0/a_24990_n1540# pd_div_0/divbuf_0/a_25470_n1540# 0.11fF
C4458 pd_div_0/divbuf_0/a_55710_n840# pd_div_0/divbuf_0/a_55710_n1540# 0.01fF
C4459 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_10080_n1600# 0.26fF
C4460 divbuf_1/a_11312_n240# divbuf_1/a_11802_n240# 0.04fF
C4461 divbuf_0/a_480_n1600# divbuf_0/a_960_n1600# 0.26fF
C4462 divbuf_1/a_23040_n1600# divbuf_1/a_23070_n1540# 0.19fF
C4463 divbuf_1/a_23922_n240# divbuf_1/OUT4 0.04fF
C4464 divbuf_1/a_23070_n840# divbuf_1/a_23550_n840# 0.07fF
C4465 pll_full_0/divbuf_0/a_1950_n1540# pll_full_0/divbuf_0/a_2430_n1540# 0.11fF
C4466 pll_full_0/divbuf_0/a_32670_n840# pll_full_0/divbuf_0/a_32670_n1540# 0.01fF
C4467 divbuf_0/a_53790_n840# divbuf_0/a_54270_n840# 0.07fF
C4468 divbuf_0/a_23550_n840# divbuf_0/a_23550_n1540# 0.01fF
C4469 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n1540# 0.19fF
C4470 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_14222_n240# 0.05fF
C4471 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/a_33622_n240# 0.01fF
C4472 divbuf_3/a_20160_n1600# divbuf_3/OUT4 0.00fF
C4473 divbuf_2/a_12772_170# divbuf_2/a_13252_170# 0.07fF
C4474 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_22590_n840# 0.04fF
C4475 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/a_33142_170# 0.07fF
C4476 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C4477 pll_full_0/divbuf_1/a_25470_n840# pll_full_0/divbuf_1/a_25950_n840# 0.07fF
C4478 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4479 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25470_n1540# 0.19fF
C4480 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/a_4392_170# 0.07fF
C4481 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C4482 divbuf_2/a_37022_n240# divbuf_2/a_36990_n840# 0.05fF
C4483 divbuf_2/a_46080_n1600# divbuf_2/a_46560_n1600# 0.26fF
C4484 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C4485 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_2/Z2 0.20fF
C4486 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_1/Z4 0.02fF
C4487 divbuf_2/a_38430_n1540# divbuf_2/a_38910_n1540# 0.11fF
C4488 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/a_2430_n840# 0.03fF
C4489 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C4490 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C4491 divbuf_0/a_11312_n240# divbuf_0/a_11070_n840# 0.02fF
C4492 divbuf_1/a_22080_n1600# divbuf_1/OUT4 0.01fF
C4493 divbuf_3/a_8640_n1600# divbuf_3/a_9120_n1600# 0.26fF
C4494 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4800_n1600# 0.26fF
C4495 divbuf_3/a_990_n1540# divbuf_3/a_1470_n1540# 0.11fF
C4496 divbuf_3/a_31710_n840# divbuf_3/a_31710_n1540# 0.01fF
C4497 divbuf_3/a_510_n840# divbuf_3/OUT2 0.02fF
C4498 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12030_n1540# 0.19fF
C4499 pd_div_0/divbuf_0/a_12030_n840# pd_div_0/divbuf_0/a_12510_n840# 0.07fF
C4500 ro_div_0/divbuf_0/a_57630_n840# ro_div_0/divbuf_0/a_58110_n840# 0.07fF
C4501 ro_div_0/divbuf_0/a_27390_n840# ro_div_0/divbuf_0/a_27390_n1540# 0.01fF
C4502 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_57630_n1540# 0.19fF
C4503 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/a_18092_170# 0.07fF
C4504 divbuf_2/a_27802_170# divbuf_2/OUT4 0.19fF
C4505 divbuf_2/a_36000_n1600# divbuf_2/a_36030_n840# 0.04fF
C4506 divbuf_1/a_16152_170# divbuf_1/a_16642_170# 0.07fF
C4507 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/a_40350_n840# 0.04fF
C4508 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49920_n1600# 0.26fF
C4509 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/OUT3 0.23fF
C4510 divbuf_1/a_9600_n1600# divbuf_1/a_10080_n1600# 0.26fF
C4511 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C4512 divbuf_1/a_1950_n1540# divbuf_1/a_2430_n1540# 0.11fF
C4513 divbuf_1/a_32670_n840# divbuf_1/a_32670_n1540# 0.01fF
C4514 divbuf_1/a_510_n840# divbuf_1/OUT 0.07fF
C4515 divbuf_0/a_31202_n240# divbuf_0/a_31230_n840# 0.05fF
C4516 divbuf_0/a_40320_n1600# divbuf_0/a_40800_n1600# 0.26fF
C4517 pll_full_0/divbuf_0/a_41790_n1540# pll_full_0/divbuf_0/a_42270_n1540# 0.11fF
C4518 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_14910_n840# 0.01fF
C4519 divbuf_0/a_32670_n1540# divbuf_0/a_33150_n1540# 0.11fF
C4520 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12480_n1600# 0.26fF
C4521 divbuf_2/a_13742_n240# divbuf_2/a_14222_n240# 0.05fF
C4522 divbuf_2/a_33622_170# divbuf_2/a_33622_n240# 0.01fF
C4523 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C4524 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/OUT5 0.04fF
C4525 pll_full_0/divbuf_1/a_4350_n1540# pll_full_0/divbuf_1/a_4830_n1540# 0.11fF
C4526 pll_full_0/divbuf_1/a_35070_n840# pll_full_0/divbuf_1/a_35070_n1540# 0.01fF
C4527 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/a_17612_n240# 0.01fF
C4528 divbuf_2/a_25470_n840# divbuf_2/a_25950_n840# 0.07fF
C4529 divbuf_2/a_28772_n240# divbuf_2/OUT4 0.04fF
C4530 divbuf_2/a_25440_n1600# divbuf_2/a_25470_n1540# 0.19fF
C4531 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/and_0/OUT 0.05fF
C4532 divbuf_3/a_15182_170# divbuf_3/a_15672_170# 0.07fF
C4533 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39390_n840# 0.04fF
C4534 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4535 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/a_40902_n240# 0.04fF
C4536 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n840# 0.04fF
C4537 divbuf_3/a_39442_n240# divbuf_3/a_39390_n840# 0.04fF
C4538 divbuf_3/a_48480_n1600# divbuf_3/a_48960_n1600# 0.26fF
C4539 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44640_n1600# 0.26fF
C4540 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/a_35070_n840# 0.05fF
C4541 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_1950_n840# 0.04fF
C4542 divbuf_3/a_40830_n1540# divbuf_3/a_41310_n1540# 0.11fF
C4543 pd_div_0/divbuf_0/a_21630_n840# pd_div_0/divbuf_0/a_21630_n1540# 0.01fF
C4544 pd_div_0/divbuf_0/a_51870_n840# pd_div_0/divbuf_0/a_52350_n840# 0.07fF
C4545 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_51870_n1540# 0.19fF
C4546 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/bufin 0.00fF
C4547 ro_div_0/divbuf_0/a_36510_n1540# ro_div_0/divbuf_0/a_36990_n1540# 0.11fF
C4548 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_17612_n240# 0.04fF
C4549 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/a_37022_n240# 0.01fF
C4550 divbuf_1/a_13742_170# divbuf_1/a_14222_170# 0.07fF
C4551 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_480_n1600# 0.00fF
C4552 divbuf_0/a_27802_170# divbuf_0/a_27802_n240# 0.01fF
C4553 divbuf_0/a_7302_n240# divbuf_0/a_7792_n240# 0.04fF
C4554 divbuf_1/a_40412_n240# divbuf_1/a_40350_n840# 0.04fF
C4555 divbuf_1/a_49440_n1600# divbuf_1/a_49920_n1600# 0.26fF
C4556 pll_full_0/divbuf_0/a_28830_n840# pll_full_0/divbuf_0/a_29310_n840# 0.07fF
C4557 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4558 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_28830_n1540# 0.19fF
C4559 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4560 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/a_12282_n240# 0.01fF
C4561 io_clamp_low[0] io_analog[4] 0.53fF
C4562 divbuf_0/a_19710_n840# divbuf_0/a_20190_n840# 0.07fF
C4563 divbuf_0/a_17122_n240# divbuf_0/OUT4 0.04fF
C4564 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n1540# 0.19fF
C4565 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/a_19072_170# 0.07fF
C4566 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C4567 divbuf_3/a_32652_170# divbuf_3/OUT4 0.19fF
C4568 divbuf_3/a_38400_n1600# divbuf_3/a_38430_n840# 0.04fF
C4569 divbuf_1/a_41790_n1540# divbuf_1/a_42270_n1540# 0.11fF
C4570 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_5852_170# 0.07fF
C4571 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_1/Qbar 0.02fF
C4572 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Qbar1 0.30fF
C4573 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34110_n840# 0.04fF
C4574 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4575 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_52320_n1600# 0.26fF
C4576 divbuf_2/a_12000_n1600# divbuf_2/a_12480_n1600# 0.26fF
C4577 pll_full_0/divbuf_1/a_44190_n1540# pll_full_0/divbuf_1/a_44670_n1540# 0.11fF
C4578 divbuf_2/a_4350_n1540# divbuf_2/a_4830_n1540# 0.11fF
C4579 divbuf_2/a_35070_n840# divbuf_2/a_35070_n1540# 0.01fF
C4580 divbuf_3/a_16152_n240# divbuf_3/a_16642_n240# 0.04fF
C4581 divbuf_3/a_36052_170# divbuf_3/a_36052_n240# 0.01fF
C4582 divbuf_1/a_39360_n1600# divbuf_1/a_39390_n840# 0.04fF
C4583 divbuf_1/a_34592_170# divbuf_1/OUT4 0.19fF
C4584 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C4585 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/a_29310_n840# 0.04fF
C4586 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38880_n1600# 0.26fF
C4587 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_12282_n240# 0.05fF
C4588 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/a_31682_n240# 0.01fF
C4589 divbuf_3/a_27870_n840# divbuf_3/a_28350_n840# 0.07fF
C4590 divbuf_3/a_33622_n240# divbuf_3/OUT4 0.04fF
C4591 divbuf_3/a_27840_n1600# divbuf_3/a_27870_n1540# 0.19fF
C4592 ro_div_0/divbuf_0/a_23550_n840# ro_div_0/divbuf_0/a_24030_n840# 0.07fF
C4593 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4594 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_23550_n1540# 0.19fF
C4595 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_41790_n840# 0.04fF
C4596 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4597 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/a_8762_170# 0.07fF
C4598 divbuf_2/a_1920_n1600# divbuf_2/a_1950_n840# 0.04fF
C4599 pd_div_0/divbuf_0/a_30750_n1540# pd_div_0/divbuf_0/a_31230_n1540# 0.11fF
C4600 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C4601 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C4602 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15840_n1600# 0.26fF
C4603 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/a_5790_n840# 0.04fF
C4604 divbuf_1/a_17122_n240# divbuf_1/a_17612_n240# 0.04fF
C4605 divbuf_1/a_37022_170# divbuf_1/a_37022_n240# 0.01fF
C4606 divbuf_0/a_6240_n1600# divbuf_0/a_6720_n1600# 0.26fF
C4607 divbuf_1/a_28830_n840# divbuf_1/a_29310_n840# 0.07fF
C4608 divbuf_1/a_35562_n240# divbuf_1/OUT4 0.04fF
C4609 divbuf_1/a_28800_n1600# divbuf_1/a_28830_n1540# 0.19fF
C4610 pll_full_0/divbuf_0/a_7710_n1540# pll_full_0/divbuf_0/a_8190_n1540# 0.11fF
C4611 pll_full_0/divbuf_0/a_38430_n840# pll_full_0/divbuf_0/a_38430_n1540# 0.01fF
C4612 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n1540# 0.19fF
C4613 divbuf_0/a_59550_n840# divbuf_0/a_60030_n840# 0.07fF
C4614 divbuf_0/a_29310_n840# divbuf_0/a_29310_n1540# 0.01fF
C4615 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/a_20042_n240# 0.05fF
C4616 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/a_39442_n240# 0.01fF
C4617 divbuf_3/a_31680_n1600# divbuf_3/OUT4 0.00fF
C4618 divbuf_2/a_18582_170# divbuf_2/a_19072_170# 0.07fF
C4619 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28350_n840# 0.04fF
C4620 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/a_19072_n240# 0.01fF
C4621 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/a_38962_170# 0.07fF
C4622 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C4623 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4624 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31230_n1540# 0.19fF
C4625 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/a_990_n1540# 0.01fF
C4626 pll_full_0/divbuf_1/a_31230_n840# pll_full_0/divbuf_1/a_31710_n840# 0.07fF
C4627 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C4628 divbuf_2/a_51840_n1600# divbuf_2/a_52320_n1600# 0.26fF
C4629 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/clk 0.14fF
C4630 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C4631 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/Out 0.01fF
C4632 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/a3 0.13fF
C4633 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5310_n840# 0.04fF
C4634 divbuf_2/a_44190_n1540# divbuf_2/a_44670_n1540# 0.11fF
C4635 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C4636 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C4637 divbuf_0/a_17122_n240# divbuf_0/a_16830_n840# 0.00fF
C4638 divbuf_1/a_33600_n1600# divbuf_1/OUT4 0.01fF
C4639 divbuf_3/a_14400_n1600# divbuf_3/a_14880_n1600# 0.26fF
C4640 divbuf_3/a_4882_n240# divbuf_3/a_4830_n840# 0.04fF
C4641 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10560_n1600# 0.26fF
C4642 divbuf_3/a_6750_n1540# divbuf_3/a_7230_n1540# 0.11fF
C4643 divbuf_3/a_37470_n840# divbuf_3/a_37470_n1540# 0.01fF
C4644 pd_div_0/divbuf_0/a_17790_n840# pd_div_0/divbuf_0/a_18270_n840# 0.07fF
C4645 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_17790_n1540# 0.19fF
C4646 ro_div_0/divbuf_0/a_33150_n840# ro_div_0/divbuf_0/a_33150_n1540# 0.01fF
C4647 ro_div_0/divbuf_0/a_2430_n1540# ro_div_0/divbuf_0/a_2910_n1540# 0.11fF
C4648 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/OUT3 0.03fF
C4649 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/a_22472_170# 0.07fF
C4650 divbuf_2/a_41760_n1600# divbuf_2/a_41790_n840# 0.04fF
C4651 divbuf_2/a_39442_170# divbuf_2/OUT4 0.19fF
C4652 divbuf_1/a_33142_170# divbuf_1/a_33622_170# 0.07fF
C4653 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C4654 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55680_n1600# 0.26fF
C4655 divbuf_1/a_15360_n1600# divbuf_1/a_15840_n1600# 0.26fF
C4656 divbuf_1/a_5852_n240# divbuf_1/a_5790_n840# 0.04fF
C4657 divbuf_0/a_46080_n1600# divbuf_0/a_46560_n1600# 0.26fF
C4658 divbuf_0/a_37022_n240# divbuf_0/a_36990_n840# 0.05fF
C4659 divbuf_0/a_9732_170# divbuf_0/OUT3 0.19fF
C4660 divbuf_1/a_7710_n1540# divbuf_1/a_8190_n1540# 0.11fF
C4661 divbuf_1/a_38430_n840# divbuf_1/a_38430_n1540# 0.01fF
C4662 pll_full_0/divbuf_0/a_47550_n1540# pll_full_0/divbuf_0/a_48030_n1540# 0.11fF
C4663 divbuf_3/a_4320_n1600# divbuf_3/a_4350_n840# 0.04fF
C4664 divbuf_0/a_38430_n1540# divbuf_0/a_38910_n1540# 0.11fF
C4665 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_18240_n1600# 0.26fF
C4666 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/a_8190_n840# 0.03fF
C4667 divbuf_2/a_19562_n240# divbuf_2/a_20042_n240# 0.05fF
C4668 divbuf_2/a_39442_170# divbuf_2/a_39442_n240# 0.01fF
C4669 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C4670 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/OUT5 0.03fF
C4671 pll_full_0/divbuf_1/a_10110_n1540# pll_full_0/divbuf_1/a_10590_n1540# 0.11fF
C4672 pll_full_0/divbuf_1/a_40830_n840# pll_full_0/divbuf_1/a_40830_n1540# 0.01fF
C4673 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_480_n1600# 0.00fF
C4674 divbuf_2/a_40412_n240# divbuf_2/OUT4 0.04fF
C4675 divbuf_2/a_31200_n1600# divbuf_2/a_31230_n1540# 0.19fF
C4676 divbuf_2/a_990_n840# divbuf_2/a_990_n1540# 0.01fF
C4677 divbuf_2/a_31230_n840# divbuf_2/a_31710_n840# 0.07fF
C4678 divbuf_1/a_2322_170# divbuf_1/a_1842_170# 0.07fF
C4679 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_1/Z4 0.02fF
C4680 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_2/Z2 0.20fF
C4681 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C4682 divbuf_0/a_13252_170# divbuf_0/a_13252_n240# 0.01fF
C4683 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C4684 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45150_n840# 0.04fF
C4685 divbuf_3/a_21012_170# divbuf_3/a_21502_170# 0.07fF
C4686 divbuf_1/a_5280_n1600# divbuf_1/a_5310_n840# 0.04fF
C4687 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/OUT3 0.19fF
C4688 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/a_18582_170# 0.07fF
C4689 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4800_n1600# 0.26fF
C4690 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n840# 0.04fF
C4691 divbuf_0/a_27802_170# divbuf_0/OUT4 0.19fF
C4692 divbuf_3/a_54240_n1600# divbuf_3/a_54720_n1600# 0.26fF
C4693 divbuf_3/a_3912_170# divbuf_3/OUT3 0.19fF
C4694 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/OUT3 0.19fF
C4695 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_50400_n1600# 0.26fF
C4696 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/a_40830_n840# 0.03fF
C4697 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_7710_n840# 0.04fF
C4698 divbuf_3/a_46590_n1540# divbuf_3/a_47070_n1540# 0.11fF
C4699 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_57630_n1540# 0.19fF
C4700 pd_div_0/divbuf_0/a_27390_n840# pd_div_0/divbuf_0/a_27390_n1540# 0.01fF
C4701 pd_div_0/divbuf_0/a_57630_n840# pd_div_0/divbuf_0/a_58110_n840# 0.07fF
C4702 ro_div_0/divbuf_0/a_42270_n1540# ro_div_0/divbuf_0/a_42750_n1540# 0.11fF
C4703 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/a_23442_n240# 0.04fF
C4704 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/a_25382_n240# 0.01fF
C4705 divbuf_0/a_33622_170# divbuf_0/a_33622_n240# 0.01fF
C4706 divbuf_0/a_13742_n240# divbuf_0/a_14222_n240# 0.05fF
C4707 divbuf_1/a_55200_n1600# divbuf_1/a_55680_n1600# 0.26fF
C4708 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_34590_n1540# 0.19fF
C4709 pll_full_0/divbuf_0/a_4350_n840# pll_full_0/divbuf_0/a_4350_n1540# 0.01fF
C4710 pll_full_0/divbuf_0/a_34590_n840# pll_full_0/divbuf_0/a_35070_n840# 0.07fF
C4711 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4712 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/a_18092_n240# 0.01fF
C4713 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n1540# 0.19fF
C4714 divbuf_0/a_28772_n240# divbuf_0/OUT4 0.04fF
C4715 divbuf_0/a_25470_n840# divbuf_0/a_25950_n840# 0.07fF
C4716 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/a_4392_n240# 0.01fF
C4717 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/a_24892_170# 0.07fF
C4718 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.61fF
C4719 divbuf_3/a_4882_n240# divbuf_3/OUT3 0.04fF
C4720 divbuf_3/a_44160_n1600# divbuf_3/a_44190_n840# 0.04fF
C4721 divbuf_1/a_47550_n1540# divbuf_1/a_48030_n1540# 0.11fF
C4722 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4723 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_39870_n840# 0.04fF
C4724 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_58080_n1600# 0.26fF
C4725 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/OUT4 0.07fF
C4726 divbuf_2/a_17760_n1600# divbuf_2/a_18240_n1600# 0.26fF
C4727 divbuf_2/a_8272_n240# divbuf_2/a_8190_n840# 0.03fF
C4728 pll_full_0/divbuf_1/a_49950_n1540# pll_full_0/divbuf_1/a_50430_n1540# 0.11fF
C4729 divbuf_2/a_10110_n1540# divbuf_2/a_10590_n1540# 0.11fF
C4730 divbuf_2/a_40830_n840# divbuf_2/a_40830_n1540# 0.01fF
C4731 divbuf_1/a_21012_170# divbuf_1/a_21012_n240# 0.01fF
C4732 divbuf_3/a_21982_n240# divbuf_3/a_22472_n240# 0.04fF
C4733 divbuf_1/a_6822_n240# divbuf_1/OUT3 0.04fF
C4734 divbuf_1/a_45120_n1600# divbuf_1/a_45150_n840# 0.04fF
C4735 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/a_37502_n240# 0.01fF
C4736 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_18092_n240# 0.05fF
C4737 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/a_35070_n840# 0.05fF
C4738 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44640_n1600# 0.26fF
C4739 divbuf_3/a_33600_n1600# divbuf_3/a_33630_n1540# 0.19fF
C4740 divbuf_3/a_3390_n840# divbuf_3/a_3390_n1540# 0.01fF
C4741 divbuf_3/a_33630_n840# divbuf_3/a_34110_n840# 0.07fF
C4742 pd_div_0/divbuf_0/a_4882_170# pd_div_0/divbuf_0/a_4882_n240# 0.01fF
C4743 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29310_n1540# 0.19fF
C4744 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4745 ro_div_0/divbuf_0/a_29310_n840# ro_div_0/divbuf_0/a_29790_n840# 0.07fF
C4746 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4747 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_47550_n840# 0.04fF
C4748 divbuf_2/a_7680_n1600# divbuf_2/a_7710_n840# 0.04fF
C4749 pd_div_0/divbuf_0/a_36510_n1540# pd_div_0/divbuf_0/a_36990_n1540# 0.11fF
C4750 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C4751 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C4752 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z3 0.38fF
C4753 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z2 1.07fF
C4754 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/switch_1/vin 0.20fF
C4755 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_12030_n840# 0.02fF
C4756 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21600_n1600# 0.26fF
C4757 divbuf_1/a_22952_n240# divbuf_1/a_23442_n240# 0.04fF
C4758 divbuf_0/a_12000_n1600# divbuf_0/a_12480_n1600# 0.26fF
C4759 divbuf_1/a_34560_n1600# divbuf_1/a_34590_n1540# 0.19fF
C4760 divbuf_1/a_4350_n840# divbuf_1/a_4350_n1540# 0.01fF
C4761 divbuf_1/a_34590_n840# divbuf_1/a_35070_n840# 0.07fF
C4762 pll_full_0/divbuf_0/a_13470_n1540# pll_full_0/divbuf_0/a_13950_n1540# 0.11fF
C4763 pll_full_0/divbuf_0/a_44190_n840# pll_full_0/divbuf_0/a_44190_n1540# 0.01fF
C4764 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34110_n840# 0.04fF
C4765 divbuf_0/a_35070_n840# divbuf_0/a_35070_n1540# 0.01fF
C4766 divbuf_0/a_4350_n1540# divbuf_0/a_4830_n1540# 0.11fF
C4767 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/a_25862_n240# 0.05fF
C4768 divbuf_2/a_4392_170# divbuf_2/a_4392_n240# 0.01fF
C4769 divbuf_2/a_24412_170# divbuf_2/a_24892_170# 0.07fF
C4770 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/a_4882_n240# 0.04fF
C4771 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C4772 pll_full_0/divbuf_1/a_6750_n840# pll_full_0/divbuf_1/a_6750_n1540# 0.01fF
C4773 pll_full_0/divbuf_1/a_36990_n840# pll_full_0/divbuf_1/a_37470_n840# 0.07fF
C4774 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/OUT3 0.01fF
C4775 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_36990_n1540# 0.19fF
C4776 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C4777 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C4778 divbuf_2/a_57600_n1600# divbuf_2/a_58080_n1600# 0.26fF
C4779 divbuf_2/a_10212_170# divbuf_2/OUT4 0.07fF
C4780 ro_div_0/divider_0/prescaler_0/tspc_2/D ro_div_0/divider_0/clk 0.29fF
C4781 ro_div_0/divider_0/nor_0/B ro_div_0/divbuf_0/IN 0.30fF
C4782 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z3 0.06fF
C4783 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C4784 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11070_n840# 0.04fF
C4785 divbuf_2/a_49950_n1540# divbuf_2/a_50430_n1540# 0.11fF
C4786 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C4787 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C4788 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_14430_n840# 0.01fF
C4789 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n840# 0.04fF
C4790 divbuf_3/a_20160_n1600# divbuf_3/a_20640_n1600# 0.26fF
C4791 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/a_6270_n840# 0.04fF
C4792 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_16320_n1600# 0.26fF
C4793 divbuf_3/a_12510_n1540# divbuf_3/a_12990_n1540# 0.11fF
C4794 divbuf_3/a_43230_n840# divbuf_3/a_43230_n1540# 0.01fF
C4795 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_23550_n1540# 0.19fF
C4796 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4797 pd_div_0/divbuf_0/a_23550_n840# pd_div_0/divbuf_0/a_24030_n840# 0.07fF
C4798 ro_div_0/divbuf_0/a_38910_n840# ro_div_0/divbuf_0/a_38910_n1540# 0.01fF
C4799 ro_div_0/divbuf_0/a_8190_n1540# ro_div_0/divbuf_0/a_8670_n1540# 0.11fF
C4800 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/a_28292_170# 0.07fF
C4801 pll_full_0/divbuf_0/a_7302_170# pll_full_0/divbuf_0/a_7302_n240# 0.01fF
C4802 divbuf_2/a_11802_n240# divbuf_2/OUT4 0.04fF
C4803 divbuf_2/a_47520_n1600# divbuf_2/a_47550_n840# 0.04fF
C4804 divbuf_1/a_5852_170# divbuf_1/a_6332_170# 0.07fF
C4805 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C4806 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C4807 divbuf_0/a_16152_170# divbuf_0/a_16642_170# 0.07fF
C4808 divbuf_0/a_9732_170# divbuf_0/a_9732_n240# 0.01fF
C4809 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/a_990_n840# 0.07fF
C4810 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_510_n1540# 0.19fF
C4811 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4812 divbuf_1/a_11802_n240# divbuf_1/a_12030_n840# 0.02fF
C4813 divbuf_1/a_21120_n1600# divbuf_1/a_21600_n1600# 0.26fF
C4814 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C4815 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C4816 divbuf_0/a_51840_n1600# divbuf_0/a_52320_n1600# 0.26fF
C4817 divbuf_1/a_13470_n1540# divbuf_1/a_13950_n1540# 0.11fF
C4818 divbuf_1/a_44190_n840# divbuf_1/a_44190_n1540# 0.01fF
C4819 pll_full_0/divbuf_0/a_53310_n1540# pll_full_0/divbuf_0/a_53790_n1540# 0.11fF
C4820 divbuf_3/a_10080_n1600# divbuf_3/a_10110_n840# 0.04fF
C4821 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_5790_n840# 0.04fF
C4822 divbuf_0/a_44190_n1540# divbuf_0/a_44670_n1540# 0.11fF
C4823 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_14430_n840# 0.02fF
C4824 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_24000_n1600# 0.26fF
C4825 divbuf_3/a_510_n1540# divbuf_3/OUT 0.11fF
C4826 divbuf_2/a_25382_n240# divbuf_2/a_25862_n240# 0.05fF
C4827 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C4828 pll_full_0/divbuf_1/a_15870_n1540# pll_full_0/divbuf_1/a_16350_n1540# 0.11fF
C4829 pll_full_0/divbuf_1/a_46590_n840# pll_full_0/divbuf_1/a_46590_n1540# 0.01fF
C4830 divbuf_2/a_6750_n840# divbuf_2/a_6750_n1540# 0.01fF
C4831 divbuf_2/a_36990_n840# divbuf_2/a_37470_n840# 0.07fF
C4832 divbuf_2/a_10560_n1600# divbuf_2/OUT3 0.01fF
C4833 divbuf_2/a_36960_n1600# divbuf_2/a_36990_n1540# 0.19fF
C4834 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/Out 0.01fF
C4835 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C4836 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/clk 0.14fF
C4837 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_50910_n840# 0.04fF
C4838 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4839 divbuf_3/a_6822_170# divbuf_3/a_6822_n240# 0.01fF
C4840 divbuf_3/a_26832_170# divbuf_3/a_27322_170# 0.07fF
C4841 divbuf_1/a_17612_170# divbuf_1/OUT4 0.19fF
C4842 divbuf_1/a_11040_n1600# divbuf_1/a_11070_n840# 0.04fF
C4843 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4844 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/a_22952_170# 0.07fF
C4845 divbuf_0/a_39442_170# divbuf_0/OUT4 0.19fF
C4846 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n840# 0.04fF
C4847 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10560_n1600# 0.26fF
C4848 divbuf_3/a_60000_n1600# divbuf_3/a_60480_n1600# 0.26fF
C4849 divbuf_3/a_15672_170# divbuf_3/OUT4 0.19fF
C4850 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_56160_n1600# 0.26fF
C4851 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13470_n840# 0.04fF
C4852 divbuf_3/a_52350_n1540# divbuf_3/a_52830_n1540# 0.11fF
C4853 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/OUT3 0.03fF
C4854 pd_div_0/divbuf_0/a_2430_n1540# pd_div_0/divbuf_0/a_2910_n1540# 0.11fF
C4855 pd_div_0/divbuf_0/a_33150_n840# pd_div_0/divbuf_0/a_33150_n1540# 0.01fF
C4856 ro_div_0/divbuf_0/a_48030_n1540# ro_div_0/divbuf_0/a_48510_n1540# 0.11fF
C4857 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/a_29262_n240# 0.04fF
C4858 divbuf_1/a_24412_170# divbuf_1/a_24892_170# 0.07fF
C4859 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/a_31202_n240# 0.01fF
C4860 divbuf_0/a_39442_170# divbuf_0/a_39442_n240# 0.01fF
C4861 divbuf_0/a_19562_n240# divbuf_0/a_20042_n240# 0.05fF
C4862 pll_full_0/divbuf_0/a_10110_n840# pll_full_0/divbuf_0/a_10110_n1540# 0.01fF
C4863 pll_full_0/divbuf_0/a_40350_n840# pll_full_0/divbuf_0/a_40830_n840# 0.07fF
C4864 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40350_n1540# 0.19fF
C4865 divbuf_1/a_510_n840# divbuf_1/a_990_n840# 0.07fF
C4866 divbuf_1/a_480_n1600# divbuf_1/a_510_n1540# 0.19fF
C4867 divbuf_0/a_31230_n840# divbuf_0/a_31710_n840# 0.07fF
C4868 divbuf_0/a_990_n840# divbuf_0/a_990_n1540# 0.01fF
C4869 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n1540# 0.19fF
C4870 divbuf_0/a_40412_n240# divbuf_0/OUT4 0.04fF
C4871 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/a_10212_n240# 0.01fF
C4872 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/a_30712_170# 0.07fF
C4873 divbuf_3/a_16642_n240# divbuf_3/OUT4 0.04fF
C4874 divbuf_3/a_49920_n1600# divbuf_3/a_49950_n840# 0.04fF
C4875 divbuf_1/a_53310_n1540# divbuf_1/a_53790_n1540# 0.11fF
C4876 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_12282_170# 0.07fF
C4877 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/a_7302_170# 0.07fF
C4878 ro_div_0/ro_complete_0/a1 ro_div_0/divider_0/clk 0.05fF
C4879 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_45630_n840# 0.04fF
C4880 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C4881 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/a_3390_n840# 0.07fF
C4882 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4883 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_2910_n1540# 0.19fF
C4884 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C4885 divbuf_2/a_14222_n240# divbuf_2/a_14430_n840# 0.02fF
C4886 divbuf_2/a_23520_n1600# divbuf_2/a_24000_n1600# 0.26fF
C4887 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/OUT5 0.03fF
C4888 pll_full_0/divbuf_1/a_55710_n1540# pll_full_0/divbuf_1/a_56190_n1540# 0.11fF
C4889 divbuf_2/a_15870_n1540# divbuf_2/a_16350_n1540# 0.11fF
C4890 divbuf_2/a_46590_n840# divbuf_2/a_46590_n1540# 0.01fF
C4891 divbuf_1/a_26832_170# divbuf_1/a_26832_n240# 0.01fF
C4892 divbuf_3/a_27802_n240# divbuf_3/a_28292_n240# 0.04fF
C4893 divbuf_1/a_50880_n1600# divbuf_1/a_50910_n840# 0.04fF
C4894 divbuf_1/a_18582_n240# divbuf_1/OUT4 0.04fF
C4895 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/a_23922_n240# 0.05fF
C4896 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/a_40830_n840# 0.03fF
C4897 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_50400_n1600# 0.26fF
C4898 divbuf_3/a_9150_n840# divbuf_3/a_9150_n1540# 0.01fF
C4899 divbuf_3/a_39390_n840# divbuf_3/a_39870_n840# 0.07fF
C4900 divbuf_3/a_39360_n1600# divbuf_3/a_39390_n1540# 0.19fF
C4901 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/a_14222_n240# 0.01fF
C4902 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/a_8762_n240# 0.01fF
C4903 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35070_n1540# 0.19fF
C4904 ro_div_0/divbuf_0/a_35070_n840# ro_div_0/divbuf_0/a_35550_n840# 0.07fF
C4905 ro_div_0/divbuf_0/a_4830_n840# ro_div_0/divbuf_0/a_4830_n1540# 0.01fF
C4906 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53310_n840# 0.04fF
C4907 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4908 divbuf_2/a_13440_n1600# divbuf_2/a_13470_n840# 0.04fF
C4909 pd_div_0/divbuf_0/a_42270_n1540# pd_div_0/divbuf_0/a_42750_n1540# 0.11fF
C4910 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C4911 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C4912 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/and_0/OUT 0.06fF
C4913 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/tspc_1/Z4 0.36fF
C4914 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C4915 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_27360_n1600# 0.26fF
C4916 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_17790_n840# 0.02fF
C4917 divbuf_1/a_28772_n240# divbuf_1/a_29262_n240# 0.04fF
C4918 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C4919 divbuf_0/a_8272_n240# divbuf_0/a_8190_n840# 0.03fF
C4920 divbuf_0/a_17760_n1600# divbuf_0/a_18240_n1600# 0.26fF
C4921 divbuf_1/a_10110_n840# divbuf_1/a_10110_n1540# 0.01fF
C4922 divbuf_1/a_40350_n840# divbuf_1/a_40830_n840# 0.07fF
C4923 divbuf_1/a_40320_n1600# divbuf_1/a_40350_n1540# 0.19fF
C4924 pll_full_0/divbuf_0/a_19230_n1540# pll_full_0/divbuf_0/a_19710_n1540# 0.11fF
C4925 pll_full_0/divbuf_0/a_49950_n840# pll_full_0/divbuf_0/a_49950_n1540# 0.01fF
C4926 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_39870_n840# 0.04fF
C4927 divbuf_0/a_40830_n840# divbuf_0/a_40830_n1540# 0.01fF
C4928 divbuf_0/a_10110_n1540# divbuf_0/a_10590_n1540# 0.11fF
C4929 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/a_31682_n240# 0.05fF
C4930 divbuf_2/a_10212_170# divbuf_2/a_10212_n240# 0.01fF
C4931 divbuf_2/a_30232_170# divbuf_2/a_30712_170# 0.07fF
C4932 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C4933 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_42750_n1540# 0.19fF
C4934 pll_full_0/divbuf_1/a_12510_n840# pll_full_0/divbuf_1/a_12510_n1540# 0.01fF
C4935 pll_full_0/divbuf_1/a_42750_n840# pll_full_0/divbuf_1/a_43230_n840# 0.07fF
C4936 divbuf_2/a_2910_n840# divbuf_2/a_3390_n840# 0.07fF
C4937 divbuf_2/a_22472_170# divbuf_2/OUT4 0.19fF
C4938 divbuf_2/a_2880_n1600# divbuf_2/a_2910_n1540# 0.19fF
C4939 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/Z1 0.36fF
C4940 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_16830_n840# 0.04fF
C4941 divbuf_2/a_55710_n1540# divbuf_2/a_56190_n1540# 0.11fF
C4942 filter_0/a_4216_n5230# filter_0/v 0.19fF
C4943 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n840# 0.04fF
C4944 divbuf_3/a_25920_n1600# divbuf_3/a_26400_n1600# 0.26fF
C4945 divbuf_3/a_16642_n240# divbuf_3/a_16830_n840# 0.02fF
C4946 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_22080_n1600# 0.26fF
C4947 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12510_n840# 0.02fF
C4948 divbuf_3/a_18270_n1540# divbuf_3/a_18750_n1540# 0.11fF
C4949 divbuf_3/a_48990_n840# divbuf_3/a_48990_n1540# 0.01fF
C4950 pd_div_0/divbuf_0/a_29310_n840# pd_div_0/divbuf_0/a_29790_n840# 0.07fF
C4951 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4952 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29310_n1540# 0.19fF
C4953 ro_div_0/divbuf_0/a_44670_n840# ro_div_0/divbuf_0/a_44670_n1540# 0.01fF
C4954 ro_div_0/divbuf_0/a_13950_n1540# ro_div_0/divbuf_0/a_14430_n1540# 0.11fF
C4955 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/a_34112_170# 0.07fF
C4956 divbuf_2/a_53280_n1600# divbuf_2/a_53310_n840# 0.04fF
C4957 divbuf_2/a_23442_n240# divbuf_2/OUT4 0.04fF
C4958 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z2 1.07fF
C4959 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z3 0.38fF
C4960 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C4961 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C4962 divbuf_0/a_24412_170# divbuf_0/a_24892_170# 0.07fF
C4963 pll_full_0/divbuf_0/a_6270_n840# pll_full_0/divbuf_0/a_6750_n840# 0.07fF
C4964 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4965 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6270_n1540# 0.19fF
C4966 divbuf_1/a_26880_n1600# divbuf_1/a_27360_n1600# 0.26fF
C4967 divbuf_1/a_17612_n240# divbuf_1/a_17790_n840# 0.02fF
C4968 divbuf_0/a_57600_n1600# divbuf_0/a_58080_n1600# 0.26fF
C4969 divbuf_1/a_19230_n1540# divbuf_1/a_19710_n1540# 0.11fF
C4970 divbuf_1/a_49950_n840# divbuf_1/a_49950_n1540# 0.01fF
C4971 pll_full_0/divbuf_0/a_59070_n1540# pll_full_0/divbuf_0/a_59550_n1540# 0.11fF
C4972 divbuf_3/a_15840_n1600# divbuf_3/a_15870_n840# 0.04fF
C4973 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_11550_n840# 0.04fF
C4974 divbuf_0/a_49950_n1540# divbuf_0/a_50430_n1540# 0.11fF
C4975 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29760_n1600# 0.26fF
C4976 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/a_20190_n840# 0.03fF
C4977 divbuf_2/a_31202_n240# divbuf_2/a_31682_n240# 0.05fF
C4978 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C4979 pll_full_0/divbuf_1/a_21630_n1540# pll_full_0/divbuf_1/a_22110_n1540# 0.11fF
C4980 pll_full_0/divbuf_1/a_52350_n840# pll_full_0/divbuf_1/a_52350_n1540# 0.01fF
C4981 divbuf_2/a_21600_n1600# divbuf_2/OUT4 0.01fF
C4982 divbuf_2/a_42720_n1600# divbuf_2/a_42750_n1540# 0.19fF
C4983 divbuf_2/a_12510_n840# divbuf_2/a_12510_n1540# 0.01fF
C4984 divbuf_2/a_42750_n840# divbuf_2/a_43230_n840# 0.07fF
C4985 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z3 0.06fF
C4986 pd_div_0/divider_0/nor_0/B pd_div_0/bufin 0.29fF
C4987 pd_div_0/divider_0/prescaler_0/tspc_2/D pd_div_0/divider_0/clk 0.29fF
C4988 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4989 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_56670_n840# 0.04fF
C4990 divbuf_3/a_13252_170# divbuf_3/a_13252_n240# 0.01fF
C4991 divbuf_3/a_32652_170# divbuf_3/a_33142_170# 0.07fF
C4992 divbuf_1/a_16800_n1600# divbuf_1/a_16830_n840# 0.04fF
C4993 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4994 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/a_28772_170# 0.07fF
C4995 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n840# 0.04fF
C4996 divbuf_0/a_11802_n240# divbuf_0/OUT4 0.04fF
C4997 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_16320_n1600# 0.26fF
C4998 divbuf_3/a_5310_n840# divbuf_3/a_5790_n840# 0.07fF
C4999 divbuf_3/a_27322_170# divbuf_3/OUT4 0.19fF
C5000 divbuf_3/a_5280_n1600# divbuf_3/a_5310_n1540# 0.19fF
C5001 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_0/z5 0.03fF
C5002 pd_div_0/pd_0/tspc_r_0/Z2 pd_div_0/pd_0/R 0.21fF
C5003 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/a_1470_n840# 0.07fF
C5004 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_990_n1540# 0.19fF
C5005 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19230_n840# 0.04fF
C5006 divbuf_3/a_58110_n1540# divbuf_3/a_58590_n1540# 0.11fF
C5007 pd_div_0/divbuf_0/a_8190_n1540# pd_div_0/divbuf_0/a_8670_n1540# 0.11fF
C5008 pd_div_0/divbuf_0/a_38910_n840# pd_div_0/divbuf_0/a_38910_n1540# 0.01fF
C5009 ro_div_0/divbuf_0/a_53790_n1540# ro_div_0/divbuf_0/a_54270_n1540# 0.11fF
C5010 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/a_35082_n240# 0.04fF
C5011 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/a_37022_n240# 0.01fF
C5012 divbuf_0/a_25382_n240# divbuf_0/a_25862_n240# 0.05fF
C5013 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46110_n1540# 0.19fF
C5014 pll_full_0/divbuf_0/a_15870_n840# pll_full_0/divbuf_0/a_15870_n1540# 0.01fF
C5015 pll_full_0/divbuf_0/a_46110_n840# pll_full_0/divbuf_0/a_46590_n840# 0.07fF
C5016 divbuf_1/a_6270_n840# divbuf_1/a_6750_n840# 0.07fF
C5017 divbuf_1/a_25862_170# divbuf_1/OUT4 0.19fF
C5018 divbuf_1/a_6240_n1600# divbuf_1/a_6270_n1540# 0.19fF
C5019 divbuf_1/a_59070_n1540# divbuf_1/a_59550_n1540# 0.11fF
C5020 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_5790_n840# 0.04fF
C5021 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n1540# 0.19fF
C5022 divbuf_0/a_10560_n1600# divbuf_0/OUT3 0.01fF
C5023 divbuf_0/a_36990_n840# divbuf_0/a_37470_n840# 0.07fF
C5024 divbuf_0/a_6750_n840# divbuf_0/a_6750_n1540# 0.01fF
C5025 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/a_16642_n240# 0.01fF
C5026 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/a_36532_170# 0.07fF
C5027 divbuf_3/a_28292_n240# divbuf_3/OUT4 0.04fF
C5028 divbuf_3/a_55680_n1600# divbuf_3/a_55710_n840# 0.04fF
C5029 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/a_16152_170# 0.07fF
C5030 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5031 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51390_n840# 0.04fF
C5032 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_8670_n1540# 0.19fF
C5033 pll_full_0/divbuf_1/a_8670_n840# pll_full_0/divbuf_1/a_9150_n840# 0.07fF
C5034 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5035 divbuf_2/a_29280_n1600# divbuf_2/a_29760_n1600# 0.26fF
C5036 divbuf_2/a_20042_n240# divbuf_2/a_20190_n840# 0.03fF
C5037 divbuf_2/a_21630_n1540# divbuf_2/a_22110_n1540# 0.11fF
C5038 divbuf_2/a_52350_n840# divbuf_2/a_52350_n1540# 0.01fF
C5039 divbuf_3/a_33622_n240# divbuf_3/a_34112_n240# 0.04fF
C5040 divbuf_1/a_30232_n240# divbuf_1/OUT4 0.04fF
C5041 divbuf_1/a_56640_n1600# divbuf_1/a_56670_n840# 0.04fF
C5042 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/a_29742_n240# 0.05fF
C5043 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_56160_n1600# 0.26fF
C5044 divbuf_3/a_45120_n1600# divbuf_3/a_45150_n1540# 0.19fF
C5045 divbuf_3/a_14910_n840# divbuf_3/a_14910_n1540# 0.01fF
C5046 divbuf_3/a_45150_n840# divbuf_3/a_45630_n840# 0.07fF
C5047 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_40830_n1540# 0.19fF
C5048 ro_div_0/divbuf_0/a_40830_n840# ro_div_0/divbuf_0/a_41310_n840# 0.07fF
C5049 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/a_10590_n1540# 0.01fF
C5050 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5051 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59070_n840# 0.04fF
C5052 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C5053 divbuf_2/a_19200_n1600# divbuf_2/a_19230_n840# 0.04fF
C5054 pd_div_0/divbuf_0/a_48030_n1540# pd_div_0/divbuf_0/a_48510_n1540# 0.11fF
C5055 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/and_0/A 0.26fF
C5056 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C5057 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C5058 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z1 0.01fF
C5059 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/A 0.55fF
C5060 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/a_23550_n840# 0.03fF
C5061 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_33120_n1600# 0.26fF
C5062 divbuf_1/a_34592_n240# divbuf_1/a_35082_n240# 0.04fF
C5063 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/a_5790_n840# 0.04fF
C5064 pd_0/R pd_0/UP 0.45fF
C5065 divbuf_0/a_23520_n1600# divbuf_0/a_24000_n1600# 0.26fF
C5066 divbuf_0/a_14222_n240# divbuf_0/a_14430_n840# 0.02fF
C5067 divbuf_3/a_1842_n240# divbuf_3/a_1950_n840# 0.03fF
C5068 divbuf_1/a_46080_n1600# divbuf_1/a_46110_n1540# 0.19fF
C5069 divbuf_1/a_15870_n840# divbuf_1/a_15870_n1540# 0.01fF
C5070 divbuf_1/a_46110_n840# divbuf_1/a_46590_n840# 0.07fF
C5071 pll_full_0/divbuf_0/a_24990_n1540# pll_full_0/divbuf_0/a_25470_n1540# 0.11fF
C5072 pll_full_0/divbuf_0/a_55710_n840# pll_full_0/divbuf_0/a_55710_n1540# 0.01fF
C5073 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_45630_n840# 0.04fF
C5074 divbuf_0/a_46590_n840# divbuf_0/a_46590_n1540# 0.01fF
C5075 divbuf_0/a_15870_n1540# divbuf_0/a_16350_n1540# 0.11fF
C5076 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/a_37502_n240# 0.05fF
C5077 divbuf_2/a_16642_170# divbuf_2/a_16642_n240# 0.01fF
C5078 divbuf_2/a_36052_170# divbuf_2/a_36532_170# 0.07fF
C5079 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_17122_n240# 0.05fF
C5080 pll_full_0/divbuf_1/a_18270_n840# pll_full_0/divbuf_1/a_18270_n1540# 0.01fF
C5081 pll_full_0/divbuf_1/a_48510_n840# pll_full_0/divbuf_1/a_48990_n840# 0.07fF
C5082 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C5083 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48510_n1540# 0.19fF
C5084 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/a_9242_n240# 0.01fF
C5085 divbuf_2/a_8640_n1600# divbuf_2/a_8670_n1540# 0.19fF
C5086 divbuf_2/a_8670_n840# divbuf_2/a_9150_n840# 0.07fF
C5087 divbuf_2/a_34112_170# divbuf_2/OUT4 0.19fF
C5088 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C5089 divbuf_0/a_17122_170# divbuf_0/a_17122_n240# 0.01fF
C5090 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z1 0.03fF
C5091 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C5092 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_22590_n840# 0.04fF
C5093 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5094 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C5095 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n840# 0.04fF
C5096 divbuf_3/a_31680_n1600# divbuf_3/a_32160_n1600# 0.26fF
C5097 divbuf_3/a_22472_n240# divbuf_3/a_22590_n840# 0.03fF
C5098 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/a_23922_n240# 0.05fF
C5099 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_18270_n840# 0.02fF
C5100 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27840_n1600# 0.26fF
C5101 pd_div_0/divbuf_0/a_4830_n840# pd_div_0/divbuf_0/a_4830_n1540# 0.01fF
C5102 pd_div_0/divbuf_0/a_35070_n840# pd_div_0/divbuf_0/a_35550_n840# 0.07fF
C5103 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35070_n1540# 0.19fF
C5104 divbuf_3/a_24030_n1540# divbuf_3/a_24510_n1540# 0.11fF
C5105 divbuf_3/a_54750_n840# divbuf_3/a_54750_n1540# 0.01fF
C5106 ro_div_0/divbuf_0/a_50430_n840# ro_div_0/divbuf_0/a_50430_n1540# 0.01fF
C5107 ro_div_0/divbuf_0/a_19710_n1540# ro_div_0/divbuf_0/a_20190_n1540# 0.11fF
C5108 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/a_20042_n240# 0.01fF
C5109 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/a_39932_170# 0.07fF
C5110 divbuf_2/a_35082_n240# divbuf_2/OUT4 0.04fF
C5111 divbuf_2/a_59040_n1600# divbuf_2/a_59070_n840# 0.04fF
C5112 divbuf_1/a_11312_170# divbuf_1/a_11802_170# 0.07fF
C5113 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/tspc_1/Z4 0.36fF
C5114 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/and_0/OUT 0.06fF
C5115 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C5116 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C5117 divbuf_0/a_30232_170# divbuf_0/a_30712_170# 0.07fF
C5118 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12030_n1540# 0.19fF
C5119 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/OUT2 0.07fF
C5120 pll_full_0/divbuf_0/a_12030_n840# pll_full_0/divbuf_0/a_12510_n840# 0.07fF
C5121 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5122 divbuf_1/a_23442_n240# divbuf_1/a_23550_n840# 0.03fF
C5123 divbuf_1/a_32640_n1600# divbuf_1/a_33120_n1600# 0.26fF
C5124 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5125 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n1540# 0.19fF
C5126 divbuf_0/a_22472_170# divbuf_0/OUT4 0.19fF
C5127 divbuf_0/a_2910_n840# divbuf_0/a_3390_n840# 0.07fF
C5128 divbuf_3/a_21600_n1600# divbuf_3/a_21630_n840# 0.04fF
C5129 divbuf_1/a_24990_n1540# divbuf_1/a_25470_n1540# 0.11fF
C5130 divbuf_1/a_55710_n840# divbuf_1/a_55710_n1540# 0.01fF
C5131 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17310_n840# 0.04fF
C5132 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/OUT3 0.19fF
C5133 divbuf_0/a_55710_n1540# divbuf_0/a_56190_n1540# 0.11fF
C5134 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/a_25950_n840# 0.03fF
C5135 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35520_n1600# 0.26fF
C5136 divbuf_2/a_37022_n240# divbuf_2/a_37502_n240# 0.05fF
C5137 pll_full_0/divbuf_1/a_27390_n1540# pll_full_0/divbuf_1/a_27870_n1540# 0.11fF
C5138 pll_full_0/divbuf_1/a_58110_n840# pll_full_0/divbuf_1/a_58110_n1540# 0.01fF
C5139 divbuf_2/a_18270_n840# divbuf_2/a_18270_n1540# 0.01fF
C5140 divbuf_2/a_48510_n840# divbuf_2/a_48990_n840# 0.07fF
C5141 divbuf_2/a_33120_n1600# divbuf_2/OUT4 0.01fF
C5142 divbuf_2/a_48480_n1600# divbuf_2/a_48510_n1540# 0.19fF
C5143 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/Z1 0.36fF
C5144 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C5145 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/OUT5 0.04fF
C5146 divbuf_3/a_19072_170# divbuf_3/a_19072_n240# 0.01fF
C5147 divbuf_3/a_38472_170# divbuf_3/a_38962_170# 0.07fF
C5148 divbuf_1/a_22560_n1600# divbuf_1/a_22590_n840# 0.04fF
C5149 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C5150 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/a_34592_170# 0.07fF
C5151 divbuf_0/a_23442_n240# divbuf_0/OUT4 0.04fF
C5152 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n840# 0.04fF
C5153 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_22080_n1600# 0.26fF
C5154 divbuf_3/a_11040_n1600# divbuf_3/a_11070_n1540# 0.19fF
C5155 divbuf_3/a_11070_n840# divbuf_3/a_11550_n840# 0.07fF
C5156 divbuf_3/a_38962_170# divbuf_3/OUT4 0.19fF
C5157 pd_div_0/pd_0/DOWN pd_div_0/pd_0/and_pd_0/Z1 0.07fF
C5158 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_6750_n1540# 0.19fF
C5159 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5160 ro_div_0/divbuf_0/a_6750_n840# ro_div_0/divbuf_0/a_7230_n840# 0.07fF
C5161 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/OUT3 0.19fF
C5162 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_24990_n840# 0.04fF
C5163 divbuf_3/OUT4 divbuf_3/OUT5 0.26fF
C5164 pd_div_0/divbuf_0/a_13950_n1540# pd_div_0/divbuf_0/a_14430_n1540# 0.11fF
C5165 pd_div_0/divbuf_0/a_44670_n840# pd_div_0/divbuf_0/a_44670_n1540# 0.01fF
C5166 ro_div_0/divbuf_0/a_59550_n1540# ro_div_0/divbuf_0/a_60030_n1540# 0.11fF
C5167 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/a_40902_n240# 0.04fF
C5168 divbuf_1/a_39442_170# divbuf_1/a_39932_170# 0.07fF
C5169 divbuf_0/a_31202_n240# divbuf_0/a_31682_n240# 0.05fF
C5170 pll_full_0/divbuf_0/a_21630_n840# pll_full_0/divbuf_0/a_21630_n1540# 0.01fF
C5171 pll_full_0/divbuf_0/a_51870_n840# pll_full_0/divbuf_0/a_52350_n840# 0.07fF
C5172 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_51870_n1540# 0.19fF
C5173 divbuf_1/a_12000_n1600# divbuf_1/a_12030_n1540# 0.19fF
C5174 divbuf_1/a_1352_n240# divbuf_1/OUT2 0.07fF
C5175 divbuf_1/a_12030_n840# divbuf_1/a_12510_n840# 0.07fF
C5176 divbuf_1/a_40902_170# divbuf_1/OUT4 0.19fF
C5177 divbuf_0/a_42750_n840# divbuf_0/a_43230_n840# 0.07fF
C5178 divbuf_0/a_12510_n840# divbuf_0/a_12510_n1540# 0.01fF
C5179 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n1540# 0.19fF
C5180 divbuf_0/a_21600_n1600# divbuf_0/OUT4 0.01fF
C5181 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_11550_n840# 0.04fF
C5182 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_960_n1600# 0.00fF
C5183 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/a_1842_n240# 0.04fF
C5184 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/a_22472_n240# 0.01fF
C5185 divbuf_3/a_39932_n240# divbuf_3/OUT4 0.04fF
C5186 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_5362_n240# 0.01fF
C5187 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/a_21982_170# 0.07fF
C5188 pd_div_0/divbuf_0/a_1352_170# pd_div_0/divbuf_0/a_1352_n240# 0.01fF
C5189 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57150_n840# 0.04fF
C5190 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5191 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C5192 pll_full_0/divbuf_1/a_14430_n840# pll_full_0/divbuf_1/a_14910_n840# 0.07fF
C5193 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14430_n1540# 0.19fF
C5194 divbuf_2/a_25862_n240# divbuf_2/a_25950_n840# 0.03fF
C5195 divbuf_2/a_35040_n1600# divbuf_2/a_35520_n1600# 0.26fF
C5196 divbuf_2/a_27390_n1540# divbuf_2/a_27870_n1540# 0.11fF
C5197 divbuf_2/a_58110_n840# divbuf_2/a_58110_n1540# 0.01fF
C5198 divbuf_3/a_39442_n240# divbuf_3/a_39932_n240# 0.04fF
C5199 divbuf_1/a_960_n1600# divbuf_1/OUT2 0.00fF
C5200 divbuf_1/a_41382_n240# divbuf_1/OUT5 0.04fF
C5201 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/a_35562_n240# 0.05fF
C5202 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_990_n1540# 0.19fF
C5203 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/a_1470_n840# 0.07fF
C5204 divbuf_3/a_20670_n840# divbuf_3/a_20670_n1540# 0.01fF
C5205 divbuf_3/a_50910_n840# divbuf_3/a_51390_n840# 0.07fF
C5206 divbuf_3/a_50880_n1600# divbuf_3/a_50910_n1540# 0.19fF
C5207 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_46590_n1540# 0.19fF
C5208 ro_div_0/divbuf_0/a_46590_n840# ro_div_0/divbuf_0/a_47070_n840# 0.07fF
C5209 ro_div_0/divbuf_0/a_16350_n840# ro_div_0/divbuf_0/a_16350_n1540# 0.01fF
C5210 divbuf_2/a_5362_170# divbuf_2/OUT3 0.19fF
C5211 divbuf_2/a_24960_n1600# divbuf_2/a_24990_n840# 0.04fF
C5212 pd_div_0/divbuf_0/a_53790_n1540# pd_div_0/divbuf_0/a_54270_n1540# 0.11fF
C5213 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/and_0/B 0.08fF
C5214 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/a_29310_n840# 0.04fF
C5215 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38880_n1600# 0.26fF
C5216 divbuf_1/a_40412_n240# divbuf_1/a_40902_n240# 0.04fF
C5217 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_12030_n840# 0.02fF
C5218 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C5219 divbuf_0/a_20042_n240# divbuf_0/a_20190_n840# 0.03fF
C5220 divbuf_0/a_29280_n1600# divbuf_0/a_29760_n1600# 0.26fF
C5221 divbuf_1/a_21630_n840# divbuf_1/a_21630_n1540# 0.01fF
C5222 divbuf_1/a_51870_n840# divbuf_1/a_52350_n840# 0.07fF
C5223 divbuf_1/a_51840_n1600# divbuf_1/a_51870_n1540# 0.19fF
C5224 pll_full_0/divbuf_0/a_30750_n1540# pll_full_0/divbuf_0/a_31230_n1540# 0.11fF
C5225 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51390_n840# 0.04fF
C5226 divbuf_0/a_52350_n840# divbuf_0/a_52350_n1540# 0.01fF
C5227 divbuf_0/a_21630_n1540# divbuf_0/a_22110_n1540# 0.11fF
C5228 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_1440_n1600# 0.26fF
C5229 divbuf_2/a_492_n240# divbuf_2/a_960_n1600# 0.00fF
C5230 divbuf_2/a_1352_n240# divbuf_2/a_1842_n240# 0.04fF
C5231 divbuf_2/a_22472_170# divbuf_2/a_22472_n240# 0.01fF
C5232 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54270_n1540# 0.19fF
C5233 pll_full_0/divbuf_1/a_24030_n840# pll_full_0/divbuf_1/a_24030_n1540# 0.01fF
C5234 pll_full_0/divbuf_1/a_54270_n840# pll_full_0/divbuf_1/a_54750_n840# 0.07fF
C5235 divbuf_2/a_6332_n240# divbuf_2/OUT3 0.04fF
C5236 divbuf_2/a_14430_n840# divbuf_2/a_14910_n840# 0.07fF
C5237 divbuf_2/a_14400_n1600# divbuf_2/a_14430_n1540# 0.19fF
C5238 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C5239 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C5240 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C5241 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28350_n840# 0.04fF
C5242 divbuf_3/a_3422_170# divbuf_3/a_3912_170# 0.07fF
C5243 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n840# 0.04fF
C5244 divbuf_3/a_28292_n240# divbuf_3/a_28350_n840# 0.04fF
C5245 divbuf_3/a_37440_n1600# divbuf_3/a_37920_n1600# 0.26fF
C5246 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/a_29742_n240# 0.05fF
C5247 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33600_n1600# 0.26fF
C5248 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/a_24030_n840# 0.03fF
C5249 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/a_10590_n1540# 0.01fF
C5250 pd_div_0/divbuf_0/a_40830_n840# pd_div_0/divbuf_0/a_41310_n840# 0.07fF
C5251 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_40830_n1540# 0.19fF
C5252 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_11550_n840# 0.02fF
C5253 divbuf_3/a_29790_n1540# divbuf_3/a_30270_n1540# 0.11fF
C5254 divbuf_3/a_60510_n840# divbuf_3/a_60510_n1540# 0.01fF
C5255 ro_div_0/divbuf_0/a_56190_n840# ro_div_0/divbuf_0/a_56190_n1540# 0.01fF
C5256 ro_div_0/divbuf_0/a_25470_n1540# ro_div_0/divbuf_0/a_25950_n1540# 0.11fF
C5257 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/a_5852_n240# 0.04fF
C5258 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/a_25862_n240# 0.01fF
C5259 divbuf_1/a_11802_170# divbuf_1/a_12282_170# 0.07fF
C5260 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z1 0.01fF
C5261 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C5262 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C5263 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/and_0/A 0.26fF
C5264 divbuf_0/a_36052_170# divbuf_0/a_36532_170# 0.07fF
C5265 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5266 pll_full_0/divbuf_0/a_17790_n840# pll_full_0/divbuf_0/a_18270_n840# 0.07fF
C5267 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_17790_n1540# 0.19fF
C5268 divbuf_1/a_29262_n240# divbuf_1/a_29310_n840# 0.04fF
C5269 divbuf_1/a_38400_n1600# divbuf_1/a_38880_n1600# 0.26fF
C5270 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5271 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/a_9732_n240# 0.01fF
C5272 divbuf_0/a_34112_170# divbuf_0/OUT4 0.19fF
C5273 divbuf_0/a_8670_n840# divbuf_0/a_9150_n840# 0.07fF
C5274 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n1540# 0.19fF
C5275 divbuf_3/a_10212_170# divbuf_3/OUT3 0.19fF
C5276 divbuf_3/a_27360_n1600# divbuf_3/a_27390_n840# 0.04fF
C5277 divbuf_1/a_30750_n1540# divbuf_1/a_31230_n1540# 0.11fF
C5278 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/a_7302_170# 0.07fF
C5279 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5280 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23070_n840# 0.04fF
C5281 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_41280_n1600# 0.26fF
C5282 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/a_31710_n840# 0.05fF
C5283 divbuf_2/a_960_n1600# divbuf_2/a_1440_n1600# 0.26fF
C5284 pll_full_0/divbuf_1/a_33150_n1540# pll_full_0/divbuf_1/a_33630_n1540# 0.11fF
C5285 divbuf_2/a_54240_n1600# divbuf_2/a_54270_n1540# 0.19fF
C5286 divbuf_2/a_24030_n840# divbuf_2/a_24030_n1540# 0.01fF
C5287 divbuf_2/a_54270_n840# divbuf_2/a_54750_n840# 0.07fF
C5288 divbuf_1/a_4882_170# divbuf_1/a_4882_n240# 0.01fF
C5289 divbuf_1/a_11802_170# divbuf_1/a_11802_n240# 0.01fF
C5290 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C5291 divbuf_3/a_4392_n240# divbuf_3/a_4882_n240# 0.04fF
C5292 divbuf_3/a_24892_170# divbuf_3/a_24892_n240# 0.01fF
C5293 divbuf_1/a_28320_n1600# divbuf_1/a_28350_n840# 0.04fF
C5294 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5295 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/a_40412_170# 0.07fF
C5296 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/a_20532_n240# 0.01fF
C5297 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n840# 0.04fF
C5298 divbuf_0/a_35082_n240# divbuf_0/OUT4 0.04fF
C5299 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27840_n1600# 0.26fF
C5300 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C5301 divbuf_3/a_11312_n240# divbuf_3/OUT4 0.07fF
C5302 divbuf_3/a_16830_n840# divbuf_3/a_17310_n840# 0.07fF
C5303 divbuf_3/a_16800_n1600# divbuf_3/a_16830_n1540# 0.19fF
C5304 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12510_n1540# 0.19fF
C5305 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/OUT5 0.07fF
C5306 ro_div_0/divbuf_0/a_12510_n840# ro_div_0/divbuf_0/a_12990_n840# 0.07fF
C5307 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/OUT2 0.04fF
C5308 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_30750_n840# 0.04fF
C5309 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5310 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C5311 divbuf_2/a_11802_n240# divbuf_2/a_11550_n840# 0.02fF
C5312 pd_div_0/divbuf_0/a_19710_n1540# pd_div_0/divbuf_0/a_20190_n1540# 0.11fF
C5313 pd_div_0/divbuf_0/a_50430_n840# pd_div_0/divbuf_0/a_50430_n1540# 0.01fF
C5314 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4800_n1600# 0.26fF
C5315 divbuf_1/a_5362_n240# divbuf_1/a_5852_n240# 0.04fF
C5316 divbuf_0/a_37022_n240# divbuf_0/a_37502_n240# 0.05fF
C5317 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_57630_n1540# 0.19fF
C5318 pll_full_0/divbuf_0/a_27390_n840# pll_full_0/divbuf_0/a_27390_n1540# 0.01fF
C5319 pll_full_0/divbuf_0/a_57630_n840# pll_full_0/divbuf_0/a_58110_n840# 0.07fF
C5320 divbuf_1/a_13252_n240# divbuf_1/OUT4 0.04fF
C5321 divbuf_1/a_17790_n840# divbuf_1/a_18270_n840# 0.07fF
C5322 divbuf_1/a_17760_n1600# divbuf_1/a_17790_n1540# 0.19fF
C5323 divbuf_1/a_492_n240# divbuf_1/a_960_n1600# 0.00fF
C5324 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n1540# 0.19fF
C5325 divbuf_0/a_33120_n1600# divbuf_0/OUT4 0.01fF
C5326 divbuf_0/a_48510_n840# divbuf_0/a_48990_n840# 0.07fF
C5327 divbuf_0/a_18270_n840# divbuf_0/a_18270_n1540# 0.01fF
C5328 divbuf_2/a_6822_170# divbuf_2/a_7302_170# 0.07fF
C5329 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17310_n840# 0.04fF
C5330 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/a_8272_n240# 0.05fF
C5331 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/a_28292_n240# 0.01fF
C5332 divbuf_3/a_10080_n1600# divbuf_3/OUT3 0.00fF
C5333 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/a_27802_170# 0.07fF
C5334 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C5335 ro_div_0/divbuf_0/a_0_n1600# ro_div_0/divbuf_0/OUT 0.26fF
C5336 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20190_n1540# 0.19fF
C5337 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5338 pll_full_0/divbuf_1/a_20190_n840# pll_full_0/divbuf_1/a_20670_n840# 0.07fF
C5339 divbuf_2/a_40800_n1600# divbuf_2/a_41280_n1600# 0.26fF
C5340 divbuf_2/a_31682_n240# divbuf_2/a_31710_n840# 0.05fF
C5341 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C5342 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C5343 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C5344 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z4 0.00fF
C5345 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_14910_n840# 0.01fF
C5346 divbuf_2/a_33150_n1540# divbuf_2/a_33630_n1540# 0.11fF
C5347 ashish_0/vop ashish_0/Gnd 0.33fF
C5348 divbuf_3/a_3360_n1600# divbuf_3/a_3840_n1600# 0.26fF
C5349 divbuf_1/a_11520_n1600# divbuf_1/OUT4 0.01fF
C5350 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/a_41382_n240# 0.05fF
C5351 pd_div_0/divbuf_0/a_6750_n840# pd_div_0/divbuf_0/a_7230_n840# 0.07fF
C5352 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_6750_n1540# 0.19fF
C5353 divbuf_3/a_56640_n1600# divbuf_3/a_56670_n1540# 0.19fF
C5354 divbuf_3/a_26430_n840# divbuf_3/a_26430_n1540# 0.01fF
C5355 divbuf_3/a_56670_n840# divbuf_3/a_57150_n840# 0.07fF
C5356 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52350_n1540# 0.19fF
C5357 ro_div_0/divbuf_0/a_52350_n840# ro_div_0/divbuf_0/a_52830_n840# 0.07fF
C5358 ro_div_0/divbuf_0/a_22110_n840# ro_div_0/divbuf_0/a_22110_n1540# 0.01fF
C5359 divbuf_2/a_30720_n1600# divbuf_2/a_30750_n840# 0.04fF
C5360 divbuf_2/a_17122_170# divbuf_2/OUT4 0.19fF
C5361 pd_div_0/divbuf_0/a_59550_n1540# pd_div_0/divbuf_0/a_60030_n1540# 0.11fF
C5362 divbuf_0/a_6332_170# divbuf_0/a_6332_n240# 0.01fF
C5363 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C5364 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C5365 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/Out 0.11fF
C5366 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/a_35070_n840# 0.05fF
C5367 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44640_n1600# 0.26fF
C5368 divbuf_1/a_4320_n1600# divbuf_1/a_4800_n1600# 0.26fF
C5369 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_17790_n840# 0.02fF
C5370 divbuf_0/a_35040_n1600# divbuf_0/a_35520_n1600# 0.26fF
C5371 divbuf_0/a_18092_170# divbuf_0/OUT4 0.19fF
C5372 divbuf_0/a_25862_n240# divbuf_0/a_25950_n840# 0.03fF
C5373 pll_full_0/divbuf_0/a_36510_n1540# pll_full_0/divbuf_0/a_36990_n1540# 0.11fF
C5374 divbuf_3/a_14222_n240# divbuf_3/a_13950_n840# 0.01fF
C5375 divbuf_1/a_57600_n1600# divbuf_1/a_57630_n1540# 0.19fF
C5376 divbuf_1/a_27390_n840# divbuf_1/a_27390_n1540# 0.01fF
C5377 divbuf_1/a_57630_n840# divbuf_1/a_58110_n840# 0.07fF
C5378 divbuf_2/a_7792_n240# divbuf_2/a_8272_n240# 0.05fF
C5379 divbuf_2/a_28292_170# divbuf_2/a_28292_n240# 0.01fF
C5380 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5381 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57150_n840# 0.04fF
C5382 divbuf_0/a_58110_n840# divbuf_0/a_58110_n1540# 0.01fF
C5383 divbuf_0/a_27390_n1540# divbuf_0/a_27870_n1540# 0.11fF
C5384 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_7200_n1600# 0.26fF
C5385 pll_full_0/divbuf_1/a_29790_n840# pll_full_0/divbuf_1/a_29790_n1540# 0.01fF
C5386 pll_full_0/divbuf_1/a_60030_n840# pll_full_0/divbuf_1/a_60510_n840# 0.07fF
C5387 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60030_n1540# 0.19fF
C5388 pll_full_0/divbuf_0/a_12282_170# pll_full_0/divbuf_0/a_12282_n240# 0.01fF
C5389 divbuf_2/a_20160_n1600# divbuf_2/a_20190_n1540# 0.19fF
C5390 divbuf_2/a_18092_n240# divbuf_2/OUT4 0.04fF
C5391 divbuf_2/a_20190_n840# divbuf_2/a_20670_n840# 0.07fF
C5392 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5393 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34110_n840# 0.04fF
C5394 divbuf_3/a_9242_170# divbuf_3/a_9732_170# 0.07fF
C5395 divbuf_1/a_15182_n240# divbuf_1/a_14910_n840# 0.01fF
C5396 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C5397 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n840# 0.04fF
C5398 divbuf_0/a_8272_170# divbuf_0/OUT3 0.19fF
C5399 divbuf_3/a_34112_n240# divbuf_3/a_34110_n840# 0.06fF
C5400 divbuf_3/a_43200_n1600# divbuf_3/a_43680_n1600# 0.26fF
C5401 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/a_35562_n240# 0.05fF
C5402 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_39360_n1600# 0.26fF
C5403 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/a_29790_n840# 0.04fF
C5404 pd_div_0/divbuf_0/a_16350_n840# pd_div_0/divbuf_0/a_16350_n1540# 0.01fF
C5405 pd_div_0/divbuf_0/a_46590_n840# pd_div_0/divbuf_0/a_47070_n840# 0.07fF
C5406 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_46590_n1540# 0.19fF
C5407 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_17310_n840# 0.00fF
C5408 divbuf_3/a_35550_n1540# divbuf_3/a_36030_n1540# 0.11fF
C5409 ro_div_0/divbuf_0/a_31230_n1540# ro_div_0/divbuf_0/a_31710_n1540# 0.11fF
C5410 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/a_31682_n240# 0.01fF
C5411 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_12282_n240# 0.05fF
C5412 divbuf_1/a_12282_170# divbuf_1/a_12772_170# 0.07fF
C5413 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/and_0/B 0.08fF
C5414 divbuf_0/a_22472_170# divbuf_0/a_22472_n240# 0.01fF
C5415 divbuf_0/a_1352_n240# divbuf_0/a_1842_n240# 0.04fF
C5416 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_23550_n1540# 0.19fF
C5417 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5418 pll_full_0/divbuf_0/a_23550_n840# pll_full_0/divbuf_0/a_24030_n840# 0.07fF
C5419 divbuf_1/a_35082_n240# divbuf_1/a_35070_n840# 0.05fF
C5420 divbuf_1/a_44160_n1600# divbuf_1/a_44640_n1600# 0.26fF
C5421 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5422 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n1540# 0.19fF
C5423 divbuf_0/a_14430_n840# divbuf_0/a_14910_n840# 0.07fF
C5424 divbuf_0/a_6332_n240# divbuf_0/OUT3 0.04fF
C5425 divbuf_3/a_21982_170# divbuf_3/OUT4 0.19fF
C5426 divbuf_3/a_33120_n1600# divbuf_3/a_33150_n840# 0.04fF
C5427 divbuf_1/a_36510_n1540# divbuf_1/a_36990_n1540# 0.11fF
C5428 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/a_13742_170# 0.07fF
C5429 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5430 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_28830_n840# 0.04fF
C5431 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Qbar1 0.38fF
C5432 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/a_37470_n840# 0.05fF
C5433 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_47040_n1600# 0.26fF
C5434 divbuf_2/a_6720_n1600# divbuf_2/a_7200_n1600# 0.26fF
C5435 pll_full_0/divbuf_1/a_38910_n1540# pll_full_0/divbuf_1/a_39390_n1540# 0.11fF
C5436 divbuf_2/a_29790_n840# divbuf_2/a_29790_n1540# 0.01fF
C5437 divbuf_2/a_60030_n840# divbuf_2/a_60510_n840# 0.07fF
C5438 divbuf_2/a_60000_n1600# divbuf_2/a_60030_n1540# 0.19fF
C5439 divbuf_1/a_12282_170# divbuf_1/a_12282_n240# 0.01fF
C5440 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C5441 divbuf_3/a_30712_170# divbuf_3/a_30712_n240# 0.01fF
C5442 divbuf_1/a_20532_170# divbuf_1/OUT4 0.19fF
C5443 divbuf_1/a_34080_n1600# divbuf_1/a_34110_n840# 0.04fF
C5444 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/a_26352_n240# 0.01fF
C5445 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/a_6332_n240# 0.05fF
C5446 divbuf_3/a_22560_n1600# divbuf_3/a_22590_n1540# 0.19fF
C5447 divbuf_3/a_22952_n240# divbuf_3/OUT4 0.04fF
C5448 divbuf_3/a_22590_n840# divbuf_3/a_23070_n840# 0.07fF
C5449 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/a_24030_n840# 0.03fF
C5450 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33600_n1600# 0.26fF
C5451 pd_div_0/divbuf_0/a_25470_n1540# pd_div_0/divbuf_0/a_25950_n1540# 0.11fF
C5452 pd_div_0/divbuf_0/a_56190_n840# pd_div_0/divbuf_0/a_56190_n1540# 0.01fF
C5453 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18270_n1540# 0.19fF
C5454 ro_div_0/divbuf_0/a_18270_n840# ro_div_0/divbuf_0/a_18750_n840# 0.07fF
C5455 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5456 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5457 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36510_n840# 0.04fF
C5458 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C5459 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C5460 divbuf_2/a_17612_n240# divbuf_2/a_17310_n840# 0.00fF
C5461 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10560_n1600# 0.26fF
C5462 divbuf_1/a_11802_n240# divbuf_1/a_12282_n240# 0.05fF
C5463 divbuf_0/a_960_n1600# divbuf_0/a_1440_n1600# 0.26fF
C5464 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/OUT3 0.03fF
C5465 pll_full_0/divbuf_0/a_2430_n1540# pll_full_0/divbuf_0/a_2910_n1540# 0.11fF
C5466 pll_full_0/divbuf_0/a_33150_n840# pll_full_0/divbuf_0/a_33150_n1540# 0.01fF
C5467 divbuf_1/a_23520_n1600# divbuf_1/a_23550_n1540# 0.19fF
C5468 divbuf_1/a_24892_n240# divbuf_1/OUT4 0.04fF
C5469 divbuf_1/a_23550_n840# divbuf_1/a_24030_n840# 0.07fF
C5470 divbuf_0/a_54270_n840# divbuf_0/a_54750_n840# 0.07fF
C5471 divbuf_0/a_24030_n840# divbuf_0/a_24030_n1540# 0.01fF
C5472 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n1540# 0.19fF
C5473 divbuf_2/a_13252_170# divbuf_2/a_13742_170# 0.07fF
C5474 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23070_n840# 0.04fF
C5475 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_14702_n240# 0.05fF
C5476 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/a_34112_n240# 0.01fF
C5477 divbuf_3/a_21120_n1600# divbuf_3/OUT4 0.00fF
C5478 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/a_33622_170# 0.07fF
C5479 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C5480 pll_full_0/divbuf_1/a_25950_n840# pll_full_0/divbuf_1/a_26430_n840# 0.07fF
C5481 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5482 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_25950_n1540# 0.19fF
C5483 divbuf_2/a_37502_n240# divbuf_2/a_37470_n840# 0.05fF
C5484 divbuf_2/a_46560_n1600# divbuf_2/a_47040_n1600# 0.26fF
C5485 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/and_0/OUT 0.06fF
C5486 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C5487 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C5488 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C5489 divbuf_2/a_38910_n1540# divbuf_2/a_39390_n1540# 0.11fF
C5490 divbuf_0/a_11802_n240# divbuf_0/a_11550_n840# 0.02fF
C5491 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/OUT5 0.03fF
C5492 divbuf_3/a_9120_n1600# divbuf_3/a_9600_n1600# 0.26fF
C5493 divbuf_1/a_23040_n1600# divbuf_1/OUT4 0.01fF
C5494 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_5280_n1600# 0.26fF
C5495 pd_div_0/divbuf_0/a_12510_n840# pd_div_0/divbuf_0/a_12990_n840# 0.07fF
C5496 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12510_n1540# 0.19fF
C5497 divbuf_3/a_1470_n1540# divbuf_3/a_1950_n1540# 0.11fF
C5498 divbuf_3/a_32190_n840# divbuf_3/a_32190_n1540# 0.01fF
C5499 divbuf_3/a_60480_n1600# divbuf_3/OUT5 0.26fF
C5500 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58110_n1540# 0.19fF
C5501 ro_div_0/divbuf_0/a_58110_n840# ro_div_0/divbuf_0/a_58590_n840# 0.07fF
C5502 ro_div_0/divbuf_0/a_27870_n840# ro_div_0/divbuf_0/a_27870_n1540# 0.01fF
C5503 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/a_18582_170# 0.07fF
C5504 divbuf_2/a_28772_170# divbuf_2/OUT4 0.19fF
C5505 divbuf_2/a_36480_n1600# divbuf_2/a_36510_n840# 0.04fF
C5506 divbuf_1/a_16642_170# divbuf_1/a_17122_170# 0.07fF
C5507 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z3 0.38fF
C5508 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/a_40830_n840# 0.03fF
C5509 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_50400_n1600# 0.26fF
C5510 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/OUT3 0.19fF
C5511 divbuf_1/a_10080_n1600# divbuf_1/a_10560_n1600# 0.26fF
C5512 divbuf_0/a_31682_n240# divbuf_0/a_31710_n840# 0.05fF
C5513 divbuf_0/a_40800_n1600# divbuf_0/a_41280_n1600# 0.26fF
C5514 io_clamp_low[1] io_clamp_high[1] 0.53fF
C5515 pll_full_0/divbuf_0/a_42270_n1540# pll_full_0/divbuf_0/a_42750_n1540# 0.11fF
C5516 divbuf_1/a_2910_n840# divbuf_1/OUT3 0.03fF
C5517 divbuf_1/a_2430_n1540# divbuf_1/a_2910_n1540# 0.11fF
C5518 divbuf_1/a_33150_n840# divbuf_1/a_33150_n1540# 0.01fF
C5519 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_15390_n840# 0.01fF
C5520 divbuf_0/a_33150_n1540# divbuf_0/a_33630_n1540# 0.11fF
C5521 divbuf_2/a_14222_n240# divbuf_2/a_14702_n240# 0.05fF
C5522 divbuf_2/a_34112_170# divbuf_2/a_34112_n240# 0.01fF
C5523 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C5524 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12960_n1600# 0.26fF
C5525 pll_full_0/divbuf_1/a_4830_n1540# pll_full_0/divbuf_1/a_5310_n1540# 0.11fF
C5526 pll_full_0/divbuf_1/a_35550_n840# pll_full_0/divbuf_1/a_35550_n1540# 0.01fF
C5527 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/a_18092_n240# 0.01fF
C5528 divbuf_2/a_25950_n840# divbuf_2/a_26430_n840# 0.07fF
C5529 divbuf_2/a_29742_n240# divbuf_2/OUT4 0.04fF
C5530 divbuf_2/a_25920_n1600# divbuf_2/a_25950_n1540# 0.19fF
C5531 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z4 0.00fF
C5532 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C5533 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C5534 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C5535 divbuf_0/a_5852_170# divbuf_0/a_5852_n240# 0.01fF
C5536 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_39870_n840# 0.04fF
C5537 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5538 divbuf_3/a_15672_170# divbuf_3/a_16152_170# 0.07fF
C5539 pd_div_0/divbuf_0/a_1352_170# pd_div_0/divbuf_0/OUT2 0.23fF
C5540 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C5541 divbuf_0/a_14702_170# divbuf_0/OUT4 0.19fF
C5542 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n840# 0.04fF
C5543 divbuf_3/a_39932_n240# divbuf_3/a_39870_n840# 0.04fF
C5544 divbuf_3/a_48960_n1600# divbuf_3/a_49440_n1600# 0.26fF
C5545 divbuf_1/a_41790_n840# divbuf_1/OUT5 0.03fF
C5546 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/a_41382_n240# 0.05fF
C5547 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_45120_n1600# 0.26fF
C5548 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/a_35550_n840# 0.05fF
C5549 pd_div_0/divbuf_0/a_22110_n840# pd_div_0/divbuf_0/a_22110_n1540# 0.01fF
C5550 pd_div_0/divbuf_0/a_52350_n840# pd_div_0/divbuf_0/a_52830_n840# 0.07fF
C5551 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52350_n1540# 0.19fF
C5552 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2430_n840# 0.04fF
C5553 divbuf_3/a_41310_n1540# divbuf_3/a_41790_n1540# 0.11fF
C5554 ro_div_0/divbuf_0/a_36990_n1540# ro_div_0/divbuf_0/a_37470_n1540# 0.11fF
C5555 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_18092_n240# 0.05fF
C5556 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/a_37502_n240# 0.01fF
C5557 divbuf_1/a_7302_170# divbuf_1/a_7302_n240# 0.01fF
C5558 divbuf_0/a_28292_170# divbuf_0/a_28292_n240# 0.01fF
C5559 divbuf_0/a_7792_n240# divbuf_0/a_8272_n240# 0.05fF
C5560 pll_full_0/divbuf_0/a_29310_n840# pll_full_0/divbuf_0/a_29790_n840# 0.07fF
C5561 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5562 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29310_n1540# 0.19fF
C5563 divbuf_1/a_40902_n240# divbuf_1/a_40830_n840# 0.03fF
C5564 divbuf_1/a_49920_n1600# divbuf_1/a_50400_n1600# 0.26fF
C5565 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/OUT2 0.07fF
C5566 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5567 divbuf_0/a_20190_n840# divbuf_0/a_20670_n840# 0.07fF
C5568 divbuf_0/a_18092_n240# divbuf_0/OUT4 0.04fF
C5569 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n1540# 0.19fF
C5570 divbuf_3/a_38880_n1600# divbuf_3/a_38910_n840# 0.04fF
C5571 divbuf_3/a_33622_170# divbuf_3/OUT4 0.19fF
C5572 divbuf_1/a_42270_n1540# divbuf_1/a_42750_n1540# 0.11fF
C5573 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/a_19562_170# 0.07fF
C5574 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_34590_n840# 0.04fF
C5575 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5576 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/a_6332_170# 0.07fF
C5577 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52800_n1600# 0.26fF
C5578 divbuf_2/a_12480_n1600# divbuf_2/a_12960_n1600# 0.26fF
C5579 pll_full_0/divbuf_1/a_44670_n1540# pll_full_0/divbuf_1/a_45150_n1540# 0.11fF
C5580 divbuf_2/a_4830_n1540# divbuf_2/a_5310_n1540# 0.11fF
C5581 divbuf_2/a_35550_n840# divbuf_2/a_35550_n1540# 0.01fF
C5582 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C5583 divbuf_3/a_16642_n240# divbuf_3/a_17122_n240# 0.05fF
C5584 divbuf_3/a_36532_170# divbuf_3/a_36532_n240# 0.01fF
C5585 divbuf_1/a_39840_n1600# divbuf_1/a_39870_n840# 0.04fF
C5586 divbuf_1/a_35562_170# divbuf_1/OUT4 0.19fF
C5587 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12772_n240# 0.04fF
C5588 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/a_32172_n240# 0.01fF
C5589 divbuf_3/a_28350_n840# divbuf_3/a_28830_n840# 0.07fF
C5590 divbuf_3/a_34592_n240# divbuf_3/OUT4 0.04fF
C5591 divbuf_3/a_28320_n1600# divbuf_3/a_28350_n1540# 0.19fF
C5592 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/a_29790_n840# 0.04fF
C5593 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_39360_n1600# 0.26fF
C5594 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24030_n1540# 0.19fF
C5595 ro_div_0/divbuf_0/a_24030_n840# ro_div_0/divbuf_0/a_24510_n840# 0.07fF
C5596 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5597 pd_div_0/divbuf_0/a_31230_n1540# pd_div_0/divbuf_0/a_31710_n1540# 0.11fF
C5598 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42270_n840# 0.04fF
C5599 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5600 divbuf_2/a_2400_n1600# divbuf_2/a_2430_n840# 0.04fF
C5601 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C5602 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/a2 0.09fF
C5603 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_16320_n1600# 0.26fF
C5604 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/a_6270_n840# 0.04fF
C5605 divbuf_1/a_17612_n240# divbuf_1/a_18092_n240# 0.05fF
C5606 divbuf_1/a_37502_170# divbuf_1/a_37502_n240# 0.01fF
C5607 divbuf_0/a_6720_n1600# divbuf_0/a_7200_n1600# 0.26fF
C5608 pll_full_0/divbuf_0/a_8190_n1540# pll_full_0/divbuf_0/a_8670_n1540# 0.11fF
C5609 pll_full_0/divbuf_0/a_38910_n840# pll_full_0/divbuf_0/a_38910_n1540# 0.01fF
C5610 divbuf_1/a_29310_n840# divbuf_1/a_29790_n840# 0.07fF
C5611 divbuf_1/a_36532_n240# divbuf_1/OUT4 0.04fF
C5612 divbuf_1/a_29280_n1600# divbuf_1/a_29310_n1540# 0.19fF
C5613 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n1540# 0.19fF
C5614 divbuf_0/a_60030_n840# divbuf_0/a_60510_n840# 0.07fF
C5615 divbuf_0/a_29790_n840# divbuf_0/a_29790_n1540# 0.01fF
C5616 divbuf_3/a_32640_n1600# divbuf_3/OUT4 0.00fF
C5617 divbuf_2/a_19072_170# divbuf_2/a_19562_170# 0.07fF
C5618 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_28830_n840# 0.04fF
C5619 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/a_20532_n240# 0.04fF
C5620 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/a_39932_n240# 0.01fF
C5621 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/a_19562_n240# 0.01fF
C5622 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/a_39442_170# 0.07fF
C5623 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C5624 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5625 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_31710_n1540# 0.19fF
C5626 pll_full_0/divbuf_1/a_1470_n840# pll_full_0/divbuf_1/a_1470_n1540# 0.01fF
C5627 pll_full_0/divbuf_1/a_31710_n840# pll_full_0/divbuf_1/a_32190_n840# 0.07fF
C5628 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C5629 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C5630 divbuf_2/a_52320_n1600# divbuf_2/a_52800_n1600# 0.26fF
C5631 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C5632 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C5633 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/tspc_0/Z2 0.01fF
C5634 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C5635 divbuf_0/a_19562_170# divbuf_0/a_20042_170# 0.07fF
C5636 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C5637 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_1/A 1.21fF
C5638 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_5790_n840# 0.04fF
C5639 divbuf_2/a_44670_n1540# divbuf_2/a_45150_n1540# 0.11fF
C5640 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C5641 divbuf_0/a_17612_n240# divbuf_0/a_17310_n840# 0.00fF
C5642 divbuf_3/a_14880_n1600# divbuf_3/a_15360_n1600# 0.26fF
C5643 divbuf_3/a_5362_n240# divbuf_3/a_5310_n840# 0.04fF
C5644 divbuf_1/a_34560_n1600# divbuf_1/OUT4 0.01fF
C5645 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_11040_n1600# 0.26fF
C5646 pd_div_0/divbuf_0/a_18270_n840# pd_div_0/divbuf_0/a_18750_n840# 0.07fF
C5647 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18270_n1540# 0.19fF
C5648 divbuf_3/a_7230_n1540# divbuf_3/a_7710_n1540# 0.11fF
C5649 divbuf_3/a_37950_n840# divbuf_3/a_37950_n1540# 0.01fF
C5650 ro_div_0/divbuf_0/a_33630_n840# ro_div_0/divbuf_0/a_33630_n1540# 0.01fF
C5651 ro_div_0/divbuf_0/a_2910_n1540# ro_div_0/divbuf_0/a_3390_n1540# 0.11fF
C5652 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/a_22952_170# 0.07fF
C5653 divbuf_2/a_42240_n1600# divbuf_2/a_42270_n840# 0.04fF
C5654 divbuf_2/a_40412_170# divbuf_2/OUT4 0.19fF
C5655 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.44fF
C5656 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C5657 divbuf_0/a_12772_170# divbuf_0/a_13252_170# 0.07fF
C5658 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_56160_n1600# 0.26fF
C5659 divbuf_1/a_15840_n1600# divbuf_1/a_16320_n1600# 0.26fF
C5660 divbuf_1/a_6332_n240# divbuf_1/a_6270_n840# 0.04fF
C5661 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C5662 divbuf_0/a_10212_170# divbuf_0/OUT4 0.07fF
C5663 divbuf_0/a_46560_n1600# divbuf_0/a_47040_n1600# 0.26fF
C5664 divbuf_0/a_37502_n240# divbuf_0/a_37470_n840# 0.05fF
C5665 pll_full_0/divbuf_0/a_48030_n1540# pll_full_0/divbuf_0/a_48510_n1540# 0.11fF
C5666 divbuf_3/a_4800_n1600# divbuf_3/a_4830_n840# 0.04fF
C5667 divbuf_1/a_8190_n1540# divbuf_1/a_8670_n1540# 0.11fF
C5668 divbuf_1/a_38910_n840# divbuf_1/a_38910_n1540# 0.01fF
C5669 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_510_n840# 0.04fF
C5670 divbuf_0/a_38910_n1540# divbuf_0/a_39390_n1540# 0.11fF
C5671 divbuf_2/a_20042_n240# divbuf_2/a_20532_n240# 0.04fF
C5672 divbuf_2/a_39932_170# divbuf_2/a_39932_n240# 0.01fF
C5673 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5674 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18720_n1600# 0.26fF
C5675 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/a_8670_n840# 0.03fF
C5676 pll_full_0/divbuf_1/a_10590_n1540# pll_full_0/divbuf_1/a_11070_n1540# 0.11fF
C5677 pll_full_0/divbuf_1/a_41310_n840# pll_full_0/divbuf_1/a_41310_n1540# 0.01fF
C5678 divbuf_2/a_41382_n240# divbuf_2/OUT4 0.04fF
C5679 divbuf_2/a_31680_n1600# divbuf_2/a_31710_n1540# 0.19fF
C5680 divbuf_2/a_1470_n840# divbuf_2/a_1470_n1540# 0.01fF
C5681 divbuf_2/a_31710_n840# divbuf_2/a_32190_n840# 0.07fF
C5682 divbuf_1/a_5852_170# divbuf_1/a_5362_170# 0.07fF
C5683 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C5684 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/and_0/OUT 0.06fF
C5685 divbuf_0/a_13742_170# divbuf_0/a_13742_n240# 0.01fF
C5686 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C5687 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_45630_n840# 0.04fF
C5688 divbuf_3/a_21502_170# divbuf_3/a_21982_170# 0.07fF
C5689 divbuf_1/a_5760_n1600# divbuf_1/a_5790_n840# 0.04fF
C5690 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/OUT3 0.19fF
C5691 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/a_19072_170# 0.07fF
C5692 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n840# 0.04fF
C5693 divbuf_0/a_28772_170# divbuf_0/OUT4 0.19fF
C5694 divbuf_3/a_4882_170# divbuf_3/OUT3 0.19fF
C5695 divbuf_3/a_54720_n1600# divbuf_3/a_55200_n1600# 0.26fF
C5696 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_5280_n1600# 0.26fF
C5697 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/a_41310_n840# 0.03fF
C5698 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50880_n1600# 0.26fF
C5699 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/OUT3 0.19fF
C5700 pd_div_0/divbuf_0/a_27870_n840# pd_div_0/divbuf_0/a_27870_n1540# 0.01fF
C5701 pd_div_0/divbuf_0/a_58110_n840# pd_div_0/divbuf_0/a_58590_n840# 0.07fF
C5702 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58110_n1540# 0.19fF
C5703 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8190_n840# 0.04fF
C5704 divbuf_3/a_47070_n1540# divbuf_3/a_47550_n1540# 0.11fF
C5705 ro_div_0/divbuf_0/a_42750_n1540# ro_div_0/divbuf_0/a_43230_n1540# 0.11fF
C5706 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/a_23922_n240# 0.05fF
C5707 divbuf_1/a_19072_170# divbuf_1/a_19562_170# 0.07fF
C5708 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/a_25862_n240# 0.01fF
C5709 divbuf_0/a_34112_170# divbuf_0/a_34112_n240# 0.01fF
C5710 divbuf_0/a_14222_n240# divbuf_0/a_14702_n240# 0.05fF
C5711 pll_full_0/divbuf_0/a_4830_n840# pll_full_0/divbuf_0/a_4830_n1540# 0.01fF
C5712 pll_full_0/divbuf_0/a_35070_n840# pll_full_0/divbuf_0/a_35550_n840# 0.07fF
C5713 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35070_n1540# 0.19fF
C5714 divbuf_3/a_492_n240# divbuf_3/a_480_n1600# 0.00fF
C5715 divbuf_1/a_55680_n1600# divbuf_1/a_56160_n1600# 0.26fF
C5716 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5717 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/a_18582_n240# 0.01fF
C5718 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n1540# 0.19fF
C5719 divbuf_0/a_29742_n240# divbuf_0/OUT4 0.04fF
C5720 divbuf_0/a_25950_n840# divbuf_0/a_26430_n840# 0.07fF
C5721 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/a_4882_n240# 0.01fF
C5722 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/a_25382_170# 0.07fF
C5723 divbuf_3/a_5852_n240# divbuf_3/OUT3 0.04fF
C5724 divbuf_3/a_44640_n1600# divbuf_3/a_44670_n840# 0.04fF
C5725 divbuf_1/a_48030_n1540# divbuf_1/a_48510_n1540# 0.11fF
C5726 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5727 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40350_n840# 0.04fF
C5728 pd_div_0/pd_0/tspc_r_1/Z4 pd_div_0/pd_0/tspc_r_1/z5 0.04fF
C5729 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58560_n1600# 0.26fF
C5730 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5731 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C5732 divbuf_2/a_18240_n1600# divbuf_2/a_18720_n1600# 0.26fF
C5733 divbuf_2/a_8762_n240# divbuf_2/a_8670_n840# 0.03fF
C5734 pll_full_0/divbuf_1/a_50430_n1540# pll_full_0/divbuf_1/a_50910_n1540# 0.11fF
C5735 divbuf_2/a_10590_n1540# divbuf_2/a_11070_n1540# 0.11fF
C5736 divbuf_2/a_41310_n840# divbuf_2/a_41310_n1540# 0.01fF
C5737 divbuf_1/a_21502_170# divbuf_1/a_21502_n240# 0.01fF
C5738 divbuf_3/a_22472_n240# divbuf_3/a_22952_n240# 0.05fF
C5739 divbuf_1/a_7792_n240# divbuf_1/OUT3 0.04fF
C5740 divbuf_1/a_45600_n1600# divbuf_1/a_45630_n840# 0.04fF
C5741 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/a_37992_n240# 0.01fF
C5742 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_18582_n240# 0.04fF
C5743 divbuf_3/a_34080_n1600# divbuf_3/a_34110_n1540# 0.19fF
C5744 divbuf_3/a_3870_n840# divbuf_3/a_3870_n1540# 0.01fF
C5745 divbuf_3/a_34110_n840# divbuf_3/a_34590_n840# 0.07fF
C5746 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/a_35550_n840# 0.05fF
C5747 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_45120_n1600# 0.26fF
C5748 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_29790_n1540# 0.19fF
C5749 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5750 ro_div_0/divbuf_0/a_29790_n840# ro_div_0/divbuf_0/a_30270_n840# 0.07fF
C5751 pd_div_0/divbuf_0/a_36990_n1540# pd_div_0/divbuf_0/a_37470_n1540# 0.11fF
C5752 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5753 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48030_n840# 0.04fF
C5754 divbuf_2/a_8160_n1600# divbuf_2/a_8190_n840# 0.04fF
C5755 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C5756 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C5757 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12510_n840# 0.02fF
C5758 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_22080_n1600# 0.26fF
C5759 divbuf_1/a_23442_n240# divbuf_1/a_23922_n240# 0.05fF
C5760 divbuf_0/a_12480_n1600# divbuf_0/a_12960_n1600# 0.26fF
C5761 pll_full_0/divbuf_0/a_13950_n1540# pll_full_0/divbuf_0/a_14430_n1540# 0.11fF
C5762 pll_full_0/divbuf_0/a_44670_n840# pll_full_0/divbuf_0/a_44670_n1540# 0.01fF
C5763 divbuf_1/a_4830_n840# divbuf_1/a_4830_n1540# 0.01fF
C5764 divbuf_1/a_35070_n840# divbuf_1/a_35550_n840# 0.07fF
C5765 divbuf_1/a_35040_n1600# divbuf_1/a_35070_n1540# 0.19fF
C5766 divbuf_0/a_35550_n840# divbuf_0/a_35550_n1540# 0.01fF
C5767 divbuf_0/a_4830_n1540# divbuf_0/a_5310_n1540# 0.11fF
C5768 divbuf_2/a_4882_170# divbuf_2/a_4882_n240# 0.01fF
C5769 divbuf_2/a_24892_170# divbuf_2/a_25382_170# 0.07fF
C5770 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_34590_n840# 0.04fF
C5771 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/a_26352_n240# 0.04fF
C5772 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C5773 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/a_5362_n240# 0.05fF
C5774 pll_full_0/divbuf_1/a_7230_n840# pll_full_0/divbuf_1/a_7230_n1540# 0.01fF
C5775 pll_full_0/divbuf_1/a_37470_n840# pll_full_0/divbuf_1/a_37950_n840# 0.07fF
C5776 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5777 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37470_n1540# 0.19fF
C5778 divbuf_2/a_58080_n1600# divbuf_2/a_58560_n1600# 0.26fF
C5779 divbuf_2/a_11802_170# divbuf_2/OUT4 0.19fF
C5780 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z4 0.00fF
C5781 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z3 0.65fF
C5782 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_11550_n840# 0.04fF
C5783 divbuf_2/a_50430_n1540# divbuf_2/a_50910_n1540# 0.11fF
C5784 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_14910_n840# 0.01fF
C5785 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n840# 0.04fF
C5786 divbuf_3/a_11312_n240# divbuf_3/a_11550_n840# 0.02fF
C5787 divbuf_3/a_20640_n1600# divbuf_3/a_21120_n1600# 0.26fF
C5788 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/a_6750_n840# 0.03fF
C5789 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16800_n1600# 0.26fF
C5790 divbuf_3/a_12990_n1540# divbuf_3/a_13470_n1540# 0.11fF
C5791 divbuf_3/a_43710_n840# divbuf_3/a_43710_n1540# 0.01fF
C5792 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5793 pd_div_0/divbuf_0/a_24030_n840# pd_div_0/divbuf_0/a_24510_n840# 0.07fF
C5794 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24030_n1540# 0.19fF
C5795 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C5796 ro_div_0/divbuf_0/a_39390_n840# ro_div_0/divbuf_0/a_39390_n1540# 0.01fF
C5797 ro_div_0/divbuf_0/a_8670_n1540# ro_div_0/divbuf_0/a_9150_n1540# 0.11fF
C5798 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/a_28772_170# 0.07fF
C5799 divbuf_2/a_12772_n240# divbuf_2/OUT4 0.04fF
C5800 divbuf_2/a_48000_n1600# divbuf_2/a_48030_n840# 0.04fF
C5801 divbuf_0/a_10212_170# divbuf_0/a_10212_n240# 0.01fF
C5802 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_990_n1540# 0.19fF
C5803 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/a_1470_n840# 0.07fF
C5804 divbuf_1/a_12282_n240# divbuf_1/a_12510_n840# 0.02fF
C5805 divbuf_1/a_21600_n1600# divbuf_1/a_22080_n1600# 0.26fF
C5806 divbuf_0/a_52320_n1600# divbuf_0/a_52800_n1600# 0.26fF
C5807 divbuf_0/a_7792_170# divbuf_0/OUT3 0.19fF
C5808 pll_full_0/divbuf_0/a_53790_n1540# pll_full_0/divbuf_0/a_54270_n1540# 0.11fF
C5809 divbuf_3/a_10560_n1600# divbuf_3/a_10590_n840# 0.04fF
C5810 divbuf_1/a_13950_n1540# divbuf_1/a_14430_n1540# 0.11fF
C5811 divbuf_1/a_44670_n840# divbuf_1/a_44670_n1540# 0.01fF
C5812 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6270_n840# 0.04fF
C5813 divbuf_0/a_44670_n1540# divbuf_0/a_45150_n1540# 0.11fF
C5814 divbuf_2/a_25862_n240# divbuf_2/a_26352_n240# 0.04fF
C5815 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5816 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24480_n1600# 0.26fF
C5817 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_14910_n840# 0.02fF
C5818 pll_full_0/divbuf_1/a_16350_n1540# pll_full_0/divbuf_1/a_16830_n1540# 0.11fF
C5819 pll_full_0/divbuf_1/a_47070_n840# pll_full_0/divbuf_1/a_47070_n1540# 0.01fF
C5820 divbuf_2/a_7230_n840# divbuf_2/a_7230_n1540# 0.01fF
C5821 divbuf_2/a_37470_n840# divbuf_2/a_37950_n840# 0.07fF
C5822 divbuf_2/a_11040_n1600# divbuf_2/OUT4 0.00fF
C5823 divbuf_2/a_37440_n1600# divbuf_2/a_37470_n1540# 0.19fF
C5824 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/tspc_0/Z2 0.01fF
C5825 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C5826 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C5827 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51390_n840# 0.04fF
C5828 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5829 divbuf_3/a_7302_170# divbuf_3/a_7302_n240# 0.01fF
C5830 divbuf_3/a_27322_170# divbuf_3/a_27802_170# 0.07fF
C5831 divbuf_1/a_18582_170# divbuf_1/OUT4 0.19fF
C5832 divbuf_1/a_11520_n1600# divbuf_1/a_11550_n840# 0.04fF
C5833 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5834 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/a_23442_170# 0.07fF
C5835 divbuf_0/a_40412_170# divbuf_0/OUT4 0.19fF
C5836 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n840# 0.04fF
C5837 divbuf_3/a_16642_170# divbuf_3/OUT4 0.19fF
C5838 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_11040_n1600# 0.26fF
C5839 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56640_n1600# 0.26fF
C5840 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/OUT3 0.19fF
C5841 pd_div_0/divbuf_0/a_2910_n1540# pd_div_0/divbuf_0/a_3390_n1540# 0.11fF
C5842 pd_div_0/divbuf_0/a_33630_n840# pd_div_0/divbuf_0/a_33630_n1540# 0.01fF
C5843 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_13950_n840# 0.04fF
C5844 divbuf_3/a_52830_n1540# divbuf_3/a_53310_n1540# 0.11fF
C5845 ro_div_0/divbuf_0/a_48510_n1540# ro_div_0/divbuf_0/a_48990_n1540# 0.11fF
C5846 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/a_29742_n240# 0.05fF
C5847 divbuf_1/a_24892_170# divbuf_1/a_25382_170# 0.07fF
C5848 divbuf_1/a_14702_170# divbuf_1/a_14702_n240# 0.01fF
C5849 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/a_31682_n240# 0.01fF
C5850 divbuf_0/a_39932_170# divbuf_0/a_39932_n240# 0.01fF
C5851 divbuf_0/a_20042_n240# divbuf_0/a_20532_n240# 0.04fF
C5852 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/a_10590_n1540# 0.01fF
C5853 pll_full_0/divbuf_0/a_40830_n840# pll_full_0/divbuf_0/a_41310_n840# 0.07fF
C5854 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_40830_n1540# 0.19fF
C5855 divbuf_1/a_960_n1600# divbuf_1/a_990_n1540# 0.19fF
C5856 divbuf_1/a_990_n840# divbuf_1/a_1470_n840# 0.07fF
C5857 divbuf_0/a_31710_n840# divbuf_0/a_32190_n840# 0.07fF
C5858 divbuf_0/a_1470_n840# divbuf_0/a_1470_n1540# 0.01fF
C5859 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n1540# 0.19fF
C5860 divbuf_0/a_41382_n240# divbuf_0/OUT4 0.04fF
C5861 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/a_11312_n240# 0.01fF
C5862 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/a_31202_170# 0.07fF
C5863 divbuf_3/a_50400_n1600# divbuf_3/a_50430_n840# 0.04fF
C5864 divbuf_3/a_17612_n240# divbuf_3/OUT4 0.04fF
C5865 divbuf_1/a_53790_n1540# divbuf_1/a_54270_n1540# 0.11fF
C5866 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_510_n840# 0.04fF
C5867 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/a_7792_170# 0.07fF
C5868 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46110_n840# 0.04fF
C5869 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C5870 divbuf_2/a_24000_n1600# divbuf_2/a_24480_n1600# 0.26fF
C5871 divbuf_2/a_14702_n240# divbuf_2/a_14910_n840# 0.02fF
C5872 pll_full_0/divbuf_1/a_3390_n840# pll_full_0/divbuf_1/a_3870_n840# 0.07fF
C5873 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5874 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3390_n1540# 0.19fF
C5875 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C5876 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/switch_3/vin 0.20fF
C5877 pll_full_0/divbuf_1/a_56190_n1540# pll_full_0/divbuf_1/a_56670_n1540# 0.11fF
C5878 divbuf_2/a_16350_n1540# divbuf_2/a_16830_n1540# 0.11fF
C5879 divbuf_2/a_47070_n840# divbuf_2/a_47070_n1540# 0.01fF
C5880 divbuf_1/a_27322_170# divbuf_1/a_27322_n240# 0.01fF
C5881 divbuf_3/a_28292_n240# divbuf_3/a_28772_n240# 0.05fF
C5882 divbuf_1/a_51360_n1600# divbuf_1/a_51390_n840# 0.04fF
C5883 divbuf_1/a_19562_n240# divbuf_1/OUT4 0.04fF
C5884 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/a_24412_n240# 0.04fF
C5885 divbuf_3/a_9630_n840# divbuf_3/a_9630_n1540# 0.01fF
C5886 divbuf_3/a_39870_n840# divbuf_3/a_40350_n840# 0.07fF
C5887 divbuf_3/a_39840_n1600# divbuf_3/a_39870_n1540# 0.19fF
C5888 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50880_n1600# 0.26fF
C5889 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/a_41310_n840# 0.03fF
C5890 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_35550_n1540# 0.19fF
C5891 ro_div_0/divbuf_0/a_35550_n840# ro_div_0/divbuf_0/a_36030_n840# 0.07fF
C5892 ro_div_0/divbuf_0/a_5310_n840# ro_div_0/divbuf_0/a_5310_n1540# 0.01fF
C5893 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/a_14702_n240# 0.01fF
C5894 pd_div_0/divbuf_0/a_42750_n1540# pd_div_0/divbuf_0/a_43230_n1540# 0.11fF
C5895 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/a_9242_n240# 0.01fF
C5896 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_53790_n840# 0.04fF
C5897 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5898 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C5899 divbuf_2/a_13920_n1600# divbuf_2/a_13950_n840# 0.04fF
C5900 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C5901 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C5902 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C5903 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/nor_1/A 0.35fF
C5904 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/nor_0/B 0.00fF
C5905 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C5906 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27840_n1600# 0.26fF
C5907 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_18270_n840# 0.02fF
C5908 divbuf_1/a_29262_n240# divbuf_1/a_29742_n240# 0.05fF
C5909 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C5910 divbuf_0/a_8762_n240# divbuf_0/a_8670_n840# 0.03fF
C5911 divbuf_0/a_18240_n1600# divbuf_0/a_18720_n1600# 0.26fF
C5912 pll_full_0/divbuf_0/a_19710_n1540# pll_full_0/divbuf_0/a_20190_n1540# 0.11fF
C5913 pll_full_0/divbuf_0/a_50430_n840# pll_full_0/divbuf_0/a_50430_n1540# 0.01fF
C5914 divbuf_1/a_10590_n840# divbuf_1/a_10590_n1540# 0.01fF
C5915 divbuf_1/a_40830_n840# divbuf_1/a_41310_n840# 0.07fF
C5916 divbuf_1/a_40800_n1600# divbuf_1/a_40830_n1540# 0.19fF
C5917 divbuf_0/a_41310_n840# divbuf_0/a_41310_n1540# 0.01fF
C5918 divbuf_0/a_10590_n1540# divbuf_0/a_11070_n1540# 0.11fF
C5919 divbuf_2/a_11312_170# divbuf_2/a_11312_n240# 0.01fF
C5920 divbuf_2/a_30712_170# divbuf_2/a_31202_170# 0.07fF
C5921 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40350_n840# 0.04fF
C5922 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/a_32172_n240# 0.04fF
C5923 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11802_n240# 0.04fF
C5924 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C5925 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43230_n1540# 0.19fF
C5926 pll_full_0/divbuf_1/a_12990_n840# pll_full_0/divbuf_1/a_12990_n1540# 0.01fF
C5927 pll_full_0/divbuf_1/a_43230_n840# pll_full_0/divbuf_1/a_43710_n840# 0.07fF
C5928 divbuf_2/a_3390_n840# divbuf_2/a_3870_n840# 0.07fF
C5929 divbuf_2/a_23442_170# divbuf_2/OUT4 0.19fF
C5930 divbuf_2/a_3360_n1600# divbuf_2/a_3390_n1540# 0.19fF
C5931 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C5932 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/OUT3 0.19fF
C5933 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17310_n840# 0.04fF
C5934 divbuf_2/a_56190_n1540# divbuf_2/a_56670_n1540# 0.11fF
C5935 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n840# 0.04fF
C5936 divbuf_3/a_26400_n1600# divbuf_3/a_26880_n1600# 0.26fF
C5937 divbuf_3/a_17122_n240# divbuf_3/a_17310_n840# 0.02fF
C5938 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22560_n1600# 0.26fF
C5939 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_12990_n840# 0.02fF
C5940 divbuf_3/a_18750_n1540# divbuf_3/a_19230_n1540# 0.11fF
C5941 divbuf_3/a_49470_n840# divbuf_3/a_49470_n1540# 0.01fF
C5942 pd_div_0/divbuf_0/a_29790_n840# pd_div_0/divbuf_0/a_30270_n840# 0.07fF
C5943 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5944 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_29790_n1540# 0.19fF
C5945 ro_div_0/divbuf_0/a_45150_n840# ro_div_0/divbuf_0/a_45150_n1540# 0.01fF
C5946 ro_div_0/divbuf_0/a_14430_n1540# ro_div_0/divbuf_0/a_14910_n1540# 0.11fF
C5947 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C5948 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C5949 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/a_34592_170# 0.07fF
C5950 divbuf_2/a_53760_n1600# divbuf_2/a_53790_n840# 0.04fF
C5951 divbuf_2/a_24412_n240# divbuf_2/OUT4 0.04fF
C5952 divbuf_0/a_24892_170# divbuf_0/a_25382_170# 0.07fF
C5953 pll_full_0/divbuf_0/a_6750_n840# pll_full_0/divbuf_0/a_7230_n840# 0.07fF
C5954 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5955 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_6750_n1540# 0.19fF
C5956 divbuf_1/a_27360_n1600# divbuf_1/a_27840_n1600# 0.26fF
C5957 divbuf_1/a_18092_n240# divbuf_1/a_18270_n840# 0.02fF
C5958 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/a_1842_170# 0.07fF
C5959 divbuf_0/a_11802_170# divbuf_0/OUT4 0.19fF
C5960 divbuf_0/a_58080_n1600# divbuf_0/a_58560_n1600# 0.26fF
C5961 pll_full_0/divbuf_0/a_59550_n1540# pll_full_0/divbuf_0/a_60030_n1540# 0.11fF
C5962 divbuf_3/a_16320_n1600# divbuf_3/a_16350_n840# 0.04fF
C5963 divbuf_1/a_19710_n1540# divbuf_1/a_20190_n1540# 0.11fF
C5964 divbuf_1/a_50430_n840# divbuf_1/a_50430_n1540# 0.01fF
C5965 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12030_n840# 0.04fF
C5966 divbuf_0/a_50430_n1540# divbuf_0/a_50910_n1540# 0.11fF
C5967 divbuf_2/a_31682_n240# divbuf_2/a_32172_n240# 0.04fF
C5968 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5969 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_30240_n1600# 0.26fF
C5970 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/a_20670_n840# 0.03fF
C5971 pll_full_0/divbuf_1/a_22110_n1540# pll_full_0/divbuf_1/a_22590_n1540# 0.11fF
C5972 pll_full_0/divbuf_1/a_52830_n840# pll_full_0/divbuf_1/a_52830_n1540# 0.01fF
C5973 divbuf_2/a_22560_n1600# divbuf_2/OUT4 0.01fF
C5974 divbuf_2/a_43200_n1600# divbuf_2/a_43230_n1540# 0.19fF
C5975 divbuf_2/a_12990_n840# divbuf_2/a_12990_n1540# 0.01fF
C5976 divbuf_2/a_43230_n840# divbuf_2/a_43710_n840# 0.07fF
C5977 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z4 0.00fF
C5978 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5979 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57150_n840# 0.04fF
C5980 divbuf_3/a_13742_170# divbuf_3/a_13742_n240# 0.01fF
C5981 divbuf_3/a_33142_170# divbuf_3/a_33622_170# 0.07fF
C5982 divbuf_1/a_17280_n1600# divbuf_1/a_17310_n840# 0.04fF
C5983 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5984 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/a_29262_170# 0.07fF
C5985 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n840# 0.04fF
C5986 divbuf_0/a_12772_n240# divbuf_0/OUT4 0.04fF
C5987 divbuf_3/a_5790_n840# divbuf_3/a_6270_n840# 0.07fF
C5988 divbuf_3/a_28292_170# divbuf_3/OUT4 0.19fF
C5989 divbuf_3/a_5760_n1600# divbuf_3/a_5790_n1540# 0.19fF
C5990 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16800_n1600# 0.26fF
C5991 pd_div_0/pd_0/tspc_r_0/Z2 pd_div_0/pd_0/tspc_r_0/Z4 0.14fF
C5992 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1470_n1540# 0.19fF
C5993 ro_div_0/divbuf_0/a_1470_n840# ro_div_0/divbuf_0/a_1950_n840# 0.07fF
C5994 pd_div_0/divbuf_0/a_8670_n1540# pd_div_0/divbuf_0/a_9150_n1540# 0.11fF
C5995 pd_div_0/divbuf_0/a_39390_n840# pd_div_0/divbuf_0/a_39390_n1540# 0.01fF
C5996 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_19710_n840# 0.04fF
C5997 divbuf_3/a_58590_n1540# divbuf_3/a_59070_n1540# 0.11fF
C5998 ro_div_0/divbuf_0/a_54270_n1540# ro_div_0/divbuf_0/a_54750_n1540# 0.11fF
C5999 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/a_35562_n240# 0.05fF
C6000 divbuf_1/a_34112_170# divbuf_1/a_34592_170# 0.07fF
C6001 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/a_37502_n240# 0.01fF
C6002 divbuf_0/a_25862_n240# divbuf_0/a_26352_n240# 0.04fF
C6003 pll_full_0/divbuf_0/a_16350_n840# pll_full_0/divbuf_0/a_16350_n1540# 0.01fF
C6004 pll_full_0/divbuf_0/a_46590_n840# pll_full_0/divbuf_0/a_47070_n840# 0.07fF
C6005 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_46590_n1540# 0.19fF
C6006 divbuf_1/a_6750_n840# divbuf_1/a_7230_n840# 0.07fF
C6007 divbuf_1/a_26832_170# divbuf_1/OUT4 0.19fF
C6008 divbuf_1/a_6720_n1600# divbuf_1/a_6750_n1540# 0.19fF
C6009 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n1540# 0.19fF
C6010 divbuf_0/a_11040_n1600# divbuf_0/OUT4 0.00fF
C6011 divbuf_0/a_37470_n840# divbuf_0/a_37950_n840# 0.07fF
C6012 divbuf_0/a_7230_n840# divbuf_0/a_7230_n1540# 0.01fF
C6013 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/a_17122_n240# 0.01fF
C6014 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/a_37022_170# 0.07fF
C6015 divbuf_3/a_29262_n240# divbuf_3/OUT4 0.04fF
C6016 divbuf_3/a_56160_n1600# divbuf_3/a_56190_n840# 0.04fF
C6017 divbuf_1/a_59550_n1540# divbuf_1/a_60030_n1540# 0.11fF
C6018 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6270_n840# 0.04fF
C6019 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/a_16642_170# 0.07fF
C6020 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6021 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_51870_n840# 0.04fF
C6022 divbuf_2/a_29760_n1600# divbuf_2/a_30240_n1600# 0.26fF
C6023 divbuf_2/a_20532_n240# divbuf_2/a_20670_n840# 0.03fF
C6024 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9150_n1540# 0.19fF
C6025 pll_full_0/divbuf_1/a_9150_n840# pll_full_0/divbuf_1/a_9630_n840# 0.07fF
C6026 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6027 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C6028 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C6029 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/a_630_n680# 0.01fF
C6030 divbuf_2/a_22110_n1540# divbuf_2/a_22590_n1540# 0.11fF
C6031 divbuf_2/a_52830_n840# divbuf_2/a_52830_n1540# 0.01fF
C6032 divbuf_3/a_34112_n240# divbuf_3/a_34592_n240# 0.05fF
C6033 divbuf_1/a_31202_n240# divbuf_1/OUT4 0.04fF
C6034 divbuf_1/a_57120_n1600# divbuf_1/a_57150_n840# 0.04fF
C6035 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/a_30232_n240# 0.04fF
C6036 divbuf_3/a_45600_n1600# divbuf_3/a_45630_n1540# 0.19fF
C6037 divbuf_3/a_15390_n840# divbuf_3/a_15390_n1540# 0.01fF
C6038 divbuf_3/a_45630_n840# divbuf_3/a_46110_n840# 0.07fF
C6039 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56640_n1600# 0.26fF
C6040 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41310_n1540# 0.19fF
C6041 ro_div_0/divbuf_0/a_41310_n840# ro_div_0/divbuf_0/a_41790_n840# 0.07fF
C6042 ro_div_0/divbuf_0/a_11070_n840# ro_div_0/divbuf_0/a_11070_n1540# 0.01fF
C6043 divbuf_2/a_19680_n1600# divbuf_2/a_19710_n840# 0.04fF
C6044 pd_div_0/divbuf_0/a_48510_n1540# pd_div_0/divbuf_0/a_48990_n1540# 0.11fF
C6045 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6046 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_59550_n840# 0.04fF
C6047 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/Out 0.08fF
C6048 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C6049 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z3 0.45fF
C6050 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C6051 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C6052 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C6053 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/a_24030_n840# 0.03fF
C6054 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33600_n1600# 0.26fF
C6055 divbuf_1/a_35082_n240# divbuf_1/a_35562_n240# 0.05fF
C6056 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/a_6270_n840# 0.04fF
C6057 divbuf_0/a_14702_n240# divbuf_0/a_14910_n840# 0.02fF
C6058 divbuf_0/a_24000_n1600# divbuf_0/a_24480_n1600# 0.26fF
C6059 pll_full_0/divbuf_0/a_25470_n1540# pll_full_0/divbuf_0/a_25950_n1540# 0.11fF
C6060 pll_full_0/divbuf_0/a_56190_n840# pll_full_0/divbuf_0/a_56190_n1540# 0.01fF
C6061 divbuf_3/a_2322_n240# divbuf_3/a_2430_n840# 0.03fF
C6062 divbuf_1/a_16350_n840# divbuf_1/a_16350_n1540# 0.01fF
C6063 divbuf_1/a_46590_n840# divbuf_1/a_47070_n840# 0.07fF
C6064 divbuf_1/a_46560_n1600# divbuf_1/a_46590_n1540# 0.19fF
C6065 divbuf_0/a_47070_n840# divbuf_0/a_47070_n1540# 0.01fF
C6066 divbuf_0/a_16350_n1540# divbuf_0/a_16830_n1540# 0.11fF
C6067 divbuf_2/a_17122_170# divbuf_2/a_17122_n240# 0.01fF
C6068 divbuf_2/a_36532_170# divbuf_2/a_37022_170# 0.07fF
C6069 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46110_n840# 0.04fF
C6070 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/a_37992_n240# 0.04fF
C6071 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_17612_n240# 0.04fF
C6072 pll_full_0/divbuf_1/a_18750_n840# pll_full_0/divbuf_1/a_18750_n1540# 0.01fF
C6073 pll_full_0/divbuf_1/a_48990_n840# pll_full_0/divbuf_1/a_49470_n840# 0.07fF
C6074 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C6075 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_48990_n1540# 0.19fF
C6076 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/a_9732_n240# 0.01fF
C6077 divbuf_2/a_9120_n1600# divbuf_2/a_9150_n1540# 0.19fF
C6078 divbuf_2/a_9150_n840# divbuf_2/a_9630_n840# 0.07fF
C6079 divbuf_2/a_35082_170# divbuf_2/OUT4 0.19fF
C6080 divbuf_0/a_17612_170# divbuf_0/a_17612_n240# 0.01fF
C6081 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C6082 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C6083 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z3 0.38fF
C6084 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23070_n840# 0.04fF
C6085 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6086 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C6087 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/a4 0.12fF
C6088 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n840# 0.04fF
C6089 divbuf_3/a_22952_n240# divbuf_3/a_23070_n840# 0.03fF
C6090 divbuf_3/a_32160_n1600# divbuf_3/a_32640_n1600# 0.26fF
C6091 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/a_24412_n240# 0.04fF
C6092 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/a_18750_n840# 0.02fF
C6093 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_28320_n1600# 0.26fF
C6094 divbuf_3/a_24510_n1540# divbuf_3/a_24990_n1540# 0.11fF
C6095 divbuf_3/a_55230_n840# divbuf_3/a_55230_n1540# 0.01fF
C6096 pd_div_0/divbuf_0/a_5310_n840# pd_div_0/divbuf_0/a_5310_n1540# 0.01fF
C6097 pd_div_0/divbuf_0/a_35550_n840# pd_div_0/divbuf_0/a_36030_n840# 0.07fF
C6098 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_35550_n1540# 0.19fF
C6099 ro_div_0/divbuf_0/a_50910_n840# ro_div_0/divbuf_0/a_50910_n1540# 0.01fF
C6100 ro_div_0/divbuf_0/a_20190_n1540# ro_div_0/divbuf_0/a_20670_n1540# 0.11fF
C6101 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/nor_0/B 0.00fF
C6102 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/nor_1/A 0.35fF
C6103 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C6104 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C6105 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C6106 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/a_20532_n240# 0.01fF
C6107 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/a_40412_170# 0.07fF
C6108 divbuf_2/a_36052_n240# divbuf_2/OUT4 0.04fF
C6109 divbuf_2/a_59520_n1600# divbuf_2/a_59550_n840# 0.04fF
C6110 divbuf_0/a_30712_170# divbuf_0/a_31202_170# 0.07fF
C6111 divbuf_0/a_11312_170# divbuf_0/a_11312_n240# 0.01fF
C6112 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/OUT2 0.04fF
C6113 pll_full_0/divbuf_0/a_12510_n840# pll_full_0/divbuf_0/a_12990_n840# 0.07fF
C6114 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/OUT5 0.07fF
C6115 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12510_n1540# 0.19fF
C6116 divbuf_1/a_23922_n240# divbuf_1/a_24030_n840# 0.03fF
C6117 divbuf_1/a_33120_n1600# divbuf_1/a_33600_n1600# 0.26fF
C6118 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6119 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n1540# 0.19fF
C6120 divbuf_0/a_23442_170# divbuf_0/OUT4 0.19fF
C6121 divbuf_0/a_3390_n840# divbuf_0/a_3870_n840# 0.07fF
C6122 divbuf_3/a_22080_n1600# divbuf_3/a_22110_n840# 0.04fF
C6123 divbuf_1/a_25470_n1540# divbuf_1/a_25950_n1540# 0.11fF
C6124 divbuf_1/a_56190_n840# divbuf_1/a_56190_n1540# 0.01fF
C6125 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/OUT4 0.07fF
C6126 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_17790_n840# 0.04fF
C6127 divbuf_0/a_56190_n1540# divbuf_0/a_56670_n1540# 0.11fF
C6128 divbuf_2/a_37502_n240# divbuf_2/a_37992_n240# 0.04fF
C6129 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_36000_n1600# 0.26fF
C6130 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/a_26430_n840# 0.04fF
C6131 pll_full_0/divbuf_1/a_27870_n1540# pll_full_0/divbuf_1/a_28350_n1540# 0.11fF
C6132 pll_full_0/divbuf_1/a_58590_n840# pll_full_0/divbuf_1/a_58590_n1540# 0.01fF
C6133 divbuf_2/a_18750_n840# divbuf_2/a_18750_n1540# 0.01fF
C6134 divbuf_2/a_48990_n840# divbuf_2/a_49470_n840# 0.07fF
C6135 divbuf_2/a_34080_n1600# divbuf_2/OUT4 0.01fF
C6136 divbuf_2/a_48960_n1600# divbuf_2/a_48990_n1540# 0.19fF
C6137 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C6138 divbuf_3/a_19562_170# divbuf_3/a_19562_n240# 0.01fF
C6139 divbuf_3/a_38962_170# divbuf_3/a_39442_170# 0.07fF
C6140 divbuf_1/a_23040_n1600# divbuf_1/a_23070_n840# 0.04fF
C6141 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C6142 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/a_35082_170# 0.07fF
C6143 divbuf_0/a_24412_n240# divbuf_0/OUT4 0.04fF
C6144 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n840# 0.04fF
C6145 divbuf_3/a_11520_n1600# divbuf_3/a_11550_n1540# 0.19fF
C6146 divbuf_3/a_11550_n840# divbuf_3/a_12030_n840# 0.07fF
C6147 divbuf_3/a_39932_170# divbuf_3/OUT4 0.19fF
C6148 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22560_n1600# 0.26fF
C6149 pd_div_0/pd_0/R pd_div_0/pd_0/and_pd_0/Out1 0.33fF
C6150 pd_div_0/pd_0/UP pd_div_0/pd_0/tspc_r_1/Qbar 0.21fF
C6151 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z4 0.02fF
C6152 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7230_n1540# 0.19fF
C6153 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6154 ro_div_0/divbuf_0/a_7230_n840# ro_div_0/divbuf_0/a_7710_n840# 0.07fF
C6155 pd_div_0/divbuf_0/a_14430_n1540# pd_div_0/divbuf_0/a_14910_n1540# 0.11fF
C6156 pd_div_0/divbuf_0/a_45150_n840# pd_div_0/divbuf_0/a_45150_n1540# 0.01fF
C6157 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/OUT3 0.19fF
C6158 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25470_n840# 0.04fF
C6159 ro_div_0/divbuf_0/a_60030_n1540# ro_div_0/divbuf_0/a_60510_n1540# 0.11fF
C6160 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/a_41382_n240# 0.05fF
C6161 divbuf_1/a_39932_170# divbuf_1/a_40412_170# 0.07fF
C6162 divbuf_0/a_31682_n240# divbuf_0/a_32172_n240# 0.04fF
C6163 pll_full_0/divbuf_0/a_22110_n840# pll_full_0/divbuf_0/a_22110_n1540# 0.01fF
C6164 pll_full_0/divbuf_0/a_52350_n840# pll_full_0/divbuf_0/a_52830_n840# 0.07fF
C6165 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52350_n1540# 0.19fF
C6166 divbuf_1/a_2322_n240# divbuf_1/OUT2 0.04fF
C6167 divbuf_1/a_12510_n840# divbuf_1/a_12990_n840# 0.07fF
C6168 divbuf_1/a_41382_170# divbuf_1/OUT5 0.07fF
C6169 divbuf_1/a_12480_n1600# divbuf_1/a_12510_n1540# 0.19fF
C6170 divbuf_0/a_43230_n840# divbuf_0/a_43710_n840# 0.07fF
C6171 divbuf_0/a_12990_n840# divbuf_0/a_12990_n1540# 0.01fF
C6172 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n1540# 0.19fF
C6173 divbuf_0/a_22560_n1600# divbuf_0/OUT4 0.01fF
C6174 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/a_2322_n240# 0.05fF
C6175 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/a_22952_n240# 0.01fF
C6176 divbuf_3/a_40902_n240# divbuf_3/OUT4 0.04fF
C6177 divbuf_3/a_480_n1600# divbuf_3/IN 0.00fF
C6178 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12030_n840# 0.04fF
C6179 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/a_22472_170# 0.07fF
C6180 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/a_5852_n240# 0.01fF
C6181 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_57630_n840# 0.04fF
C6182 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6183 divbuf_2/a_35520_n1600# divbuf_2/a_36000_n1600# 0.26fF
C6184 divbuf_2/a_26352_n240# divbuf_2/a_26430_n840# 0.04fF
C6185 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C6186 pll_full_0/divbuf_1/a_14910_n840# pll_full_0/divbuf_1/a_15390_n840# 0.07fF
C6187 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_14910_n1540# 0.19fF
C6188 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/a_630_n680# 0.12fF
C6189 divbuf_2/a_27870_n1540# divbuf_2/a_28350_n1540# 0.11fF
C6190 divbuf_2/a_58590_n840# divbuf_2/a_58590_n1540# 0.01fF
C6191 divbuf_3/a_39932_n240# divbuf_3/a_40412_n240# 0.05fF
C6192 divbuf_1/a_0_n1600# divbuf_1/OUT 0.26fF
C6193 divbuf_1/a_1920_n1600# divbuf_1/OUT2 0.00fF
C6194 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/a_36052_n240# 0.04fF
C6195 divbuf_3/a_21150_n840# divbuf_3/a_21150_n1540# 0.01fF
C6196 divbuf_3/a_51390_n840# divbuf_3/a_51870_n840# 0.07fF
C6197 divbuf_3/a_51360_n1600# divbuf_3/a_51390_n1540# 0.19fF
C6198 pd_div_0/divbuf_0/a_1470_n840# pd_div_0/divbuf_0/a_1950_n840# 0.07fF
C6199 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1470_n1540# 0.19fF
C6200 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47070_n1540# 0.19fF
C6201 ro_div_0/divbuf_0/a_47070_n840# ro_div_0/divbuf_0/a_47550_n840# 0.07fF
C6202 ro_div_0/divbuf_0/a_16830_n840# ro_div_0/divbuf_0/a_16830_n1540# 0.01fF
C6203 divbuf_2/a_6332_170# divbuf_2/OUT3 0.19fF
C6204 divbuf_2/a_25440_n1600# divbuf_2/a_25470_n840# 0.04fF
C6205 pd_div_0/divbuf_0/a_54270_n1540# pd_div_0/divbuf_0/a_54750_n1540# 0.11fF
C6206 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C6207 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.45fF
C6208 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/a_29790_n840# 0.04fF
C6209 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_39360_n1600# 0.26fF
C6210 divbuf_1/a_40902_n240# divbuf_1/a_41382_n240# 0.05fF
C6211 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12510_n840# 0.02fF
C6212 cp_0/upbar cp_0/down 0.02fF
C6213 divbuf_0/a_20532_n240# divbuf_0/a_20670_n840# 0.03fF
C6214 divbuf_0/a_29760_n1600# divbuf_0/a_30240_n1600# 0.26fF
C6215 pll_full_0/divbuf_0/a_31230_n1540# pll_full_0/divbuf_0/a_31710_n1540# 0.11fF
C6216 divbuf_1/a_22110_n840# divbuf_1/a_22110_n1540# 0.01fF
C6217 divbuf_1/a_52350_n840# divbuf_1/a_52830_n840# 0.07fF
C6218 divbuf_1/a_52320_n1600# divbuf_1/a_52350_n1540# 0.19fF
C6219 divbuf_0/a_52830_n840# divbuf_0/a_52830_n1540# 0.01fF
C6220 divbuf_0/a_22110_n1540# divbuf_0/a_22590_n1540# 0.11fF
C6221 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1920_n1600# 0.26fF
C6222 divbuf_2/a_1842_n240# divbuf_2/a_2322_n240# 0.05fF
C6223 divbuf_2/a_22952_170# divbuf_2/a_22952_n240# 0.01fF
C6224 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_51870_n840# 0.04fF
C6225 divbuf_2/a_7302_n240# divbuf_2/OUT3 0.04fF
C6226 divbuf_2/a_14910_n840# divbuf_2/a_15390_n840# 0.07fF
C6227 divbuf_2/a_14880_n1600# divbuf_2/a_14910_n1540# 0.19fF
C6228 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/a_630_n680# 0.01fF
C6229 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C6230 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_54750_n1540# 0.19fF
C6231 pll_full_0/divbuf_1/a_24510_n840# pll_full_0/divbuf_1/a_24510_n1540# 0.01fF
C6232 pll_full_0/divbuf_1/a_54750_n840# pll_full_0/divbuf_1/a_55230_n840# 0.07fF
C6233 divbuf_0/a_9242_170# divbuf_0/a_9242_n240# 0.01fF
C6234 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_28830_n840# 0.04fF
C6235 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6236 divbuf_3/a_3912_170# divbuf_3/a_4392_170# 0.07fF
C6237 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C6238 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/a_6332_170# 0.07fF
C6239 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_13252_170# 0.07fF
C6240 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n840# 0.04fF
C6241 divbuf_3/a_28772_n240# divbuf_3/a_28830_n840# 0.04fF
C6242 divbuf_3/a_37920_n1600# divbuf_3/a_38400_n1600# 0.26fF
C6243 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/a_30232_n240# 0.04fF
C6244 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_34080_n1600# 0.26fF
C6245 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/a_24510_n840# 0.03fF
C6246 divbuf_3/a_30270_n1540# divbuf_3/a_30750_n1540# 0.11fF
C6247 divbuf_3/a_60990_n840# divbuf_3/a_60990_n1540# 0.01fF
C6248 pd_div_0/divbuf_0/a_11070_n840# pd_div_0/divbuf_0/a_11070_n1540# 0.01fF
C6249 pd_div_0/divbuf_0/a_41310_n840# pd_div_0/divbuf_0/a_41790_n840# 0.07fF
C6250 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41310_n1540# 0.19fF
C6251 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12030_n840# 0.02fF
C6252 ro_div_0/divbuf_0/a_56670_n840# ro_div_0/divbuf_0/a_56670_n1540# 0.01fF
C6253 ro_div_0/divbuf_0/a_25950_n1540# ro_div_0/divbuf_0/a_26430_n1540# 0.11fF
C6254 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z3 0.45fF
C6255 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C6256 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/Out 0.08fF
C6257 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/a_6332_n240# 0.05fF
C6258 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/a_26352_n240# 0.01fF
C6259 divbuf_0/a_36532_170# divbuf_0/a_37022_170# 0.07fF
C6260 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6261 pll_full_0/divbuf_0/a_18270_n840# pll_full_0/divbuf_0/a_18750_n840# 0.07fF
C6262 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18270_n1540# 0.19fF
C6263 divbuf_1/a_29742_n240# divbuf_1/a_29790_n840# 0.04fF
C6264 divbuf_1/a_4392_170# divbuf_1/OUT3 0.19fF
C6265 divbuf_1/a_38880_n1600# divbuf_1/a_39360_n1600# 0.26fF
C6266 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6267 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/a_10212_n240# 0.01fF
C6268 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/a_4392_n240# 0.01fF
C6269 divbuf_0/a_35082_170# divbuf_0/OUT4 0.19fF
C6270 divbuf_0/a_9150_n840# divbuf_0/a_9630_n840# 0.07fF
C6271 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n1540# 0.19fF
C6272 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/a_7792_170# 0.07fF
C6273 divbuf_3/a_27840_n1600# divbuf_3/a_27870_n840# 0.04fF
C6274 divbuf_3/a_11312_170# divbuf_3/OUT4 0.23fF
C6275 divbuf_1/a_31230_n1540# divbuf_1/a_31710_n1540# 0.11fF
C6276 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_23550_n840# 0.04fF
C6277 divbuf_2/a_1440_n1600# divbuf_2/a_1920_n1600# 0.26fF
C6278 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41760_n1600# 0.26fF
C6279 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/a_32190_n840# 0.06fF
C6280 pll_full_0/divbuf_1/a_33630_n1540# pll_full_0/divbuf_1/a_34110_n1540# 0.11fF
C6281 divbuf_2/a_54720_n1600# divbuf_2/a_54750_n1540# 0.19fF
C6282 divbuf_2/a_24510_n840# divbuf_2/a_24510_n1540# 0.01fF
C6283 divbuf_2/a_54750_n840# divbuf_2/a_55230_n840# 0.07fF
C6284 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C6285 divbuf_3/a_4882_n240# divbuf_3/a_5362_n240# 0.05fF
C6286 divbuf_3/a_25382_170# divbuf_3/a_25382_n240# 0.01fF
C6287 divbuf_1/a_28800_n1600# divbuf_1/a_28830_n840# 0.04fF
C6288 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6289 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/a_40902_170# 0.07fF
C6290 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/a_21012_n240# 0.01fF
C6291 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n840# 0.04fF
C6292 divbuf_0/a_36052_n240# divbuf_0/OUT4 0.04fF
C6293 divbuf_3/a_12282_n240# divbuf_3/OUT4 0.04fF
C6294 divbuf_3/a_17310_n840# divbuf_3/a_17790_n840# 0.07fF
C6295 divbuf_3/a_17280_n1600# divbuf_3/a_17310_n1540# 0.19fF
C6296 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_28320_n1600# 0.26fF
C6297 ro_div_0/ro_complete_0/a5 ro_div_0/divider_0/clk 0.10fF
C6298 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_12990_n1540# 0.19fF
C6299 ro_div_0/divbuf_0/a_12990_n840# ro_div_0/divbuf_0/a_13470_n840# 0.07fF
C6300 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/OUT3 0.07fF
C6301 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/IN 0.13fF
C6302 divbuf_2/a_12282_n240# divbuf_2/a_12030_n840# 0.02fF
C6303 pd_div_0/divbuf_0/a_20190_n1540# pd_div_0/divbuf_0/a_20670_n1540# 0.11fF
C6304 pd_div_0/divbuf_0/a_50910_n840# pd_div_0/divbuf_0/a_50910_n1540# 0.01fF
C6305 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31230_n840# 0.04fF
C6306 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6307 divbuf_1/a_5852_n240# divbuf_1/a_6332_n240# 0.05fF
C6308 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_5280_n1600# 0.26fF
C6309 divbuf_0/a_37502_n240# divbuf_0/a_37992_n240# 0.04fF
C6310 pll_full_0/divbuf_0/a_27870_n840# pll_full_0/divbuf_0/a_27870_n1540# 0.01fF
C6311 pll_full_0/divbuf_0/a_58110_n840# pll_full_0/divbuf_0/a_58590_n840# 0.07fF
C6312 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58110_n1540# 0.19fF
C6313 divbuf_1/a_14222_n240# divbuf_1/OUT4 0.04fF
C6314 divbuf_1/a_18270_n840# divbuf_1/a_18750_n840# 0.07fF
C6315 divbuf_1/a_18240_n1600# divbuf_1/a_18270_n1540# 0.19fF
C6316 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n1540# 0.19fF
C6317 divbuf_0/a_34080_n1600# divbuf_0/OUT4 0.01fF
C6318 divbuf_0/a_48990_n840# divbuf_0/a_49470_n840# 0.07fF
C6319 divbuf_0/a_18750_n840# divbuf_0/a_18750_n1540# 0.01fF
C6320 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/a_8762_n240# 0.04fF
C6321 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/a_28772_n240# 0.01fF
C6322 divbuf_3/a_11040_n1600# divbuf_3/OUT3 0.00fF
C6323 divbuf_2/a_7302_170# divbuf_2/a_7792_170# 0.07fF
C6324 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_17790_n840# 0.04fF
C6325 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/a_28292_170# 0.07fF
C6326 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C6327 divbuf_2/a_41280_n1600# divbuf_2/a_41760_n1600# 0.26fF
C6328 divbuf_2/a_32172_n240# divbuf_2/a_32190_n840# 0.06fF
C6329 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_20670_n1540# 0.19fF
C6330 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6331 pll_full_0/divbuf_1/a_20670_n840# pll_full_0/divbuf_1/a_21150_n840# 0.07fF
C6332 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C6333 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_15390_n840# 0.01fF
C6334 divbuf_2/a_33630_n1540# divbuf_2/a_34110_n1540# 0.11fF
C6335 divbuf_3/a_3840_n1600# divbuf_3/a_4320_n1600# 0.26fF
C6336 divbuf_1/a_12480_n1600# divbuf_1/OUT4 0.00fF
C6337 divbuf_3/a_57120_n1600# divbuf_3/a_57150_n1540# 0.19fF
C6338 divbuf_3/a_26910_n840# divbuf_3/a_26910_n1540# 0.01fF
C6339 divbuf_3/a_57150_n840# divbuf_3/a_57630_n840# 0.07fF
C6340 pd_div_0/divbuf_0/a_7230_n840# pd_div_0/divbuf_0/a_7710_n840# 0.07fF
C6341 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7230_n1540# 0.19fF
C6342 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_52830_n1540# 0.19fF
C6343 ro_div_0/divbuf_0/a_52830_n840# ro_div_0/divbuf_0/a_53310_n840# 0.07fF
C6344 ro_div_0/divbuf_0/a_22590_n840# ro_div_0/divbuf_0/a_22590_n1540# 0.01fF
C6345 divbuf_2/a_31200_n1600# divbuf_2/a_31230_n840# 0.04fF
C6346 divbuf_2/a_18092_170# divbuf_2/OUT4 0.19fF
C6347 pd_div_0/divbuf_0/a_60030_n1540# pd_div_0/divbuf_0/a_60510_n1540# 0.11fF
C6348 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C6349 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.22fF
C6350 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C6351 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C6352 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/a_35550_n840# 0.05fF
C6353 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_45120_n1600# 0.26fF
C6354 divbuf_1/a_4800_n1600# divbuf_1/a_5280_n1600# 0.26fF
C6355 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_18270_n840# 0.02fF
C6356 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/a_9242_170# 0.07fF
C6357 divbuf_0/a_26352_n240# divbuf_0/a_26430_n840# 0.04fF
C6358 divbuf_0/a_35520_n1600# divbuf_0/a_36000_n1600# 0.26fF
C6359 divbuf_0/a_19072_170# divbuf_0/OUT4 0.19fF
C6360 pll_full_0/divbuf_0/a_36990_n1540# pll_full_0/divbuf_0/a_37470_n1540# 0.11fF
C6361 divbuf_3/a_14702_n240# divbuf_3/a_14430_n840# 0.01fF
C6362 divbuf_1/a_27870_n840# divbuf_1/a_27870_n1540# 0.01fF
C6363 divbuf_1/a_58110_n840# divbuf_1/a_58590_n840# 0.07fF
C6364 divbuf_1/a_58080_n1600# divbuf_1/a_58110_n1540# 0.19fF
C6365 divbuf_0/a_58590_n840# divbuf_0/a_58590_n1540# 0.01fF
C6366 divbuf_0/a_27870_n1540# divbuf_0/a_28350_n1540# 0.11fF
C6367 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7680_n1600# 0.26fF
C6368 divbuf_2/a_8272_n240# divbuf_2/a_8762_n240# 0.04fF
C6369 divbuf_2/a_28772_170# divbuf_2/a_28772_n240# 0.01fF
C6370 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6371 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_57630_n840# 0.04fF
C6372 divbuf_2/a_20640_n1600# divbuf_2/a_20670_n1540# 0.19fF
C6373 divbuf_2/a_19072_n240# divbuf_2/OUT4 0.04fF
C6374 divbuf_2/a_20670_n840# divbuf_2/a_21150_n840# 0.07fF
C6375 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/a_630_n680# 0.12fF
C6376 pll_full_0/divbuf_1/a_30270_n840# pll_full_0/divbuf_1/a_30270_n1540# 0.01fF
C6377 pll_full_0/divbuf_1/a_60510_n840# pll_full_0/divbuf_1/a_60990_n840# 0.07fF
C6378 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/a_60510_n1540# 0.19fF
C6379 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6380 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_34590_n840# 0.04fF
C6381 divbuf_3/a_9732_170# divbuf_3/a_10212_170# 0.07fF
C6382 divbuf_1/a_15672_n240# divbuf_1/a_15390_n840# 0.01fF
C6383 ro_div_0/ro_complete_0/cbank_0/switch_5/vin ro_div_0/ro_complete_0/a0 0.09fF
C6384 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n840# 0.04fF
C6385 divbuf_3/a_34592_n240# divbuf_3/a_34590_n840# 0.06fF
C6386 divbuf_3/a_43680_n1600# divbuf_3/a_44160_n1600# 0.26fF
C6387 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/a_36052_n240# 0.04fF
C6388 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/a_30270_n840# 0.05fF
C6389 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39840_n1600# 0.26fF
C6390 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_17790_n840# 0.00fF
C6391 divbuf_3/a_36030_n1540# divbuf_3/a_36510_n1540# 0.11fF
C6392 pd_div_0/divbuf_0/a_16830_n840# pd_div_0/divbuf_0/a_16830_n1540# 0.01fF
C6393 pd_div_0/divbuf_0/a_47070_n840# pd_div_0/divbuf_0/a_47550_n840# 0.07fF
C6394 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47070_n1540# 0.19fF
C6395 ro_div_0/divbuf_0/a_31710_n1540# ro_div_0/divbuf_0/a_32190_n1540# 0.11fF
C6396 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/a_32172_n240# 0.01fF
C6397 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12772_n240# 0.04fF
C6398 divbuf_0/a_22952_170# divbuf_0/a_22952_n240# 0.01fF
C6399 divbuf_0/a_1842_n240# divbuf_0/a_2322_n240# 0.05fF
C6400 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6401 pll_full_0/divbuf_0/a_24030_n840# pll_full_0/divbuf_0/a_24510_n840# 0.07fF
C6402 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24030_n1540# 0.19fF
C6403 divbuf_1/a_35562_n240# divbuf_1/a_35550_n840# 0.05fF
C6404 divbuf_1/a_44640_n1600# divbuf_1/a_45120_n1600# 0.26fF
C6405 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6406 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n1540# 0.19fF
C6407 divbuf_0/a_14910_n840# divbuf_0/a_15390_n840# 0.07fF
C6408 divbuf_0/a_7302_n240# divbuf_0/OUT3 0.04fF
C6409 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/a_14222_170# 0.07fF
C6410 divbuf_3/a_22952_170# divbuf_3/OUT4 0.19fF
C6411 divbuf_3/a_33600_n1600# divbuf_3/a_33630_n840# 0.04fF
C6412 divbuf_1/a_36990_n1540# divbuf_1/a_37470_n1540# 0.11fF
C6413 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/DOWN 0.11fF
C6414 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z1 0.17fF
C6415 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6416 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29310_n840# 0.04fF
C6417 divbuf_2/a_7200_n1600# divbuf_2/a_7680_n1600# 0.26fF
C6418 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/a_37950_n840# 0.04fF
C6419 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47520_n1600# 0.26fF
C6420 divbuf_1/a_12772_170# divbuf_1/a_12772_n240# 0.01fF
C6421 pll_full_0/divbuf_1/a_39390_n1540# pll_full_0/divbuf_1/a_39870_n1540# 0.11fF
C6422 divbuf_2/a_30270_n840# divbuf_2/a_30270_n1540# 0.01fF
C6423 divbuf_2/a_60510_n840# divbuf_2/a_60990_n840# 0.07fF
C6424 divbuf_2/a_60480_n1600# divbuf_2/a_60510_n1540# 0.19fF
C6425 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C6426 divbuf_3/a_31202_170# divbuf_3/a_31202_n240# 0.01fF
C6427 divbuf_3/a_11312_n240# divbuf_3/a_11802_n240# 0.04fF
C6428 divbuf_1/a_21502_170# divbuf_1/OUT4 0.19fF
C6429 divbuf_1/a_34560_n1600# divbuf_1/a_34590_n840# 0.04fF
C6430 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/a_26832_n240# 0.01fF
C6431 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/a_6822_n240# 0.04fF
C6432 vdda1 vssa1 27.51fF
C6433 divbuf_3/a_23040_n1600# divbuf_3/a_23070_n1540# 0.19fF
C6434 divbuf_3/a_23922_n240# divbuf_3/OUT4 0.04fF
C6435 divbuf_3/a_23070_n840# divbuf_3/a_23550_n840# 0.07fF
C6436 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/a_24510_n840# 0.03fF
C6437 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_34080_n1600# 0.26fF
C6438 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_18750_n1540# 0.19fF
C6439 ro_div_0/divbuf_0/a_18750_n840# ro_div_0/divbuf_0/a_19230_n840# 0.07fF
C6440 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6441 divbuf_0/a_1842_170# divbuf_0/a_2322_170# 0.07fF
C6442 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C6443 divbuf_2/a_18092_n240# divbuf_2/a_17790_n840# 0.00fF
C6444 pd_div_0/divbuf_0/a_25950_n1540# pd_div_0/divbuf_0/a_26430_n1540# 0.11fF
C6445 pd_div_0/divbuf_0/a_56670_n840# pd_div_0/divbuf_0/a_56670_n1540# 0.01fF
C6446 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6447 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_36990_n840# 0.04fF
C6448 divbuf_1/a_12282_n240# divbuf_1/a_12772_n240# 0.04fF
C6449 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_11040_n1600# 0.26fF
C6450 divbuf_0/a_1440_n1600# divbuf_0/a_1920_n1600# 0.26fF
C6451 pll_full_0/divbuf_0/a_2910_n1540# pll_full_0/divbuf_0/a_3390_n1540# 0.11fF
C6452 pll_full_0/divbuf_0/a_33630_n840# pll_full_0/divbuf_0/a_33630_n1540# 0.01fF
C6453 divbuf_1/a_25862_n240# divbuf_1/OUT4 0.04fF
C6454 divbuf_1/a_24030_n840# divbuf_1/a_24510_n840# 0.07fF
C6455 divbuf_1/a_24000_n1600# divbuf_1/a_24030_n1540# 0.19fF
C6456 divbuf_0/a_54750_n840# divbuf_0/a_55230_n840# 0.07fF
C6457 divbuf_0/a_24510_n840# divbuf_0/a_24510_n1540# 0.01fF
C6458 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n1540# 0.19fF
C6459 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_15182_n240# 0.05fF
C6460 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/a_34592_n240# 0.01fF
C6461 divbuf_3/a_22080_n1600# divbuf_3/OUT4 0.01fF
C6462 divbuf_2/a_13742_170# divbuf_2/a_14222_170# 0.07fF
C6463 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_23550_n840# 0.04fF
C6464 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/a_34112_170# 0.07fF
C6465 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C6466 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C6467 divbuf_2/a_37992_n240# divbuf_2/a_37950_n840# 0.04fF
C6468 divbuf_2/a_47040_n1600# divbuf_2/a_47520_n1600# 0.26fF
C6469 pll_full_0/divbuf_1/a_26430_n840# pll_full_0/divbuf_1/a_26910_n840# 0.07fF
C6470 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6471 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26430_n1540# 0.19fF
C6472 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/clk 0.11fF
C6473 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C6474 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_510_n840# 0.04fF
C6475 divbuf_2/a_39390_n1540# divbuf_2/a_39870_n1540# 0.11fF
C6476 divbuf_0/a_12282_n240# divbuf_0/a_12030_n840# 0.02fF
C6477 divbuf_3/a_9600_n1600# divbuf_3/a_10080_n1600# 0.26fF
C6478 divbuf_1/a_24000_n1600# divbuf_1/OUT4 0.00fF
C6479 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5760_n1600# 0.26fF
C6480 divbuf_3/a_1950_n1540# divbuf_3/a_2430_n1540# 0.11fF
C6481 divbuf_3/a_32670_n840# divbuf_3/a_32670_n1540# 0.01fF
C6482 divbuf_3/a_510_n840# divbuf_3/OUT 0.07fF
C6483 pd_div_0/divbuf_0/a_12990_n840# pd_div_0/divbuf_0/a_13470_n840# 0.07fF
C6484 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_12990_n1540# 0.19fF
C6485 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_58590_n1540# 0.19fF
C6486 ro_div_0/divbuf_0/a_58590_n840# ro_div_0/divbuf_0/a_59070_n840# 0.07fF
C6487 ro_div_0/divbuf_0/a_28350_n840# ro_div_0/divbuf_0/a_28350_n1540# 0.01fF
C6488 divbuf_2/a_29742_170# divbuf_2/OUT4 0.19fF
C6489 divbuf_2/a_36960_n1600# divbuf_2/a_36990_n840# 0.04fF
C6490 divbuf_1/a_17122_170# divbuf_1/a_17612_170# 0.07fF
C6491 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/a_19072_170# 0.07fF
C6492 divbuf_0/a_7792_170# divbuf_0/a_7302_170# 0.07fF
C6493 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C6494 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/A 0.01fF
C6495 pll_full_0/divbuf_0/a_4392_170# pll_full_0/divbuf_0/OUT3 0.19fF
C6496 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50880_n1600# 0.26fF
C6497 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/a_41310_n840# 0.03fF
C6498 divbuf_1/a_10560_n1600# divbuf_1/a_11040_n1600# 0.26fF
C6499 divbuf_0/a_32172_n240# divbuf_0/a_32190_n840# 0.06fF
C6500 divbuf_0/a_41280_n1600# divbuf_0/a_41760_n1600# 0.26fF
C6501 pll_full_0/divbuf_0/a_42750_n1540# pll_full_0/divbuf_0/a_43230_n1540# 0.11fF
C6502 divbuf_1/a_2910_n1540# divbuf_1/a_3390_n1540# 0.11fF
C6503 divbuf_1/a_33630_n840# divbuf_1/a_33630_n1540# 0.01fF
C6504 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_15870_n840# 0.01fF
C6505 divbuf_0/a_33630_n1540# divbuf_0/a_34110_n1540# 0.11fF
C6506 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_13440_n1600# 0.26fF
C6507 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/a_3390_n840# 0.05fF
C6508 divbuf_2/a_14702_n240# divbuf_2/a_15182_n240# 0.05fF
C6509 divbuf_2/a_34592_170# divbuf_2/a_34592_n240# 0.01fF
C6510 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C6511 divbuf_2/a_26430_n840# divbuf_2/a_26910_n840# 0.07fF
C6512 divbuf_2/a_30712_n240# divbuf_2/OUT4 0.04fF
C6513 divbuf_2/a_26400_n1600# divbuf_2/a_26430_n1540# 0.19fF
C6514 divbuf_1/a_7302_170# divbuf_1/a_6822_170# 0.07fF
C6515 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C6516 pll_full_0/divbuf_1/a_5310_n1540# pll_full_0/divbuf_1/a_5790_n1540# 0.11fF
C6517 pll_full_0/divbuf_1/a_36030_n840# pll_full_0/divbuf_1/a_36030_n1540# 0.01fF
C6518 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/a_18582_n240# 0.01fF
C6519 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40350_n840# 0.04fF
C6520 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6521 divbuf_3/a_16152_170# divbuf_3/a_16642_170# 0.07fF
C6522 divbuf_1/a_480_n1600# divbuf_1/a_510_n840# 0.04fF
C6523 divbuf_0/a_15672_170# divbuf_0/OUT4 0.19fF
C6524 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n840# 0.04fF
C6525 divbuf_3/a_40412_n240# divbuf_3/a_40350_n840# 0.04fF
C6526 divbuf_3/a_49440_n1600# divbuf_3/a_49920_n1600# 0.26fF
C6527 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45600_n1600# 0.26fF
C6528 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/a_36030_n840# 0.05fF
C6529 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_2910_n840# 0.04fF
C6530 divbuf_3/a_41790_n1540# divbuf_3/a_42270_n1540# 0.11fF
C6531 pd_div_0/divbuf_0/a_22590_n840# pd_div_0/divbuf_0/a_22590_n1540# 0.01fF
C6532 pd_div_0/divbuf_0/a_52830_n840# pd_div_0/divbuf_0/a_53310_n840# 0.07fF
C6533 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_52830_n1540# 0.19fF
C6534 ro_div_0/divbuf_0/a_37470_n1540# ro_div_0/divbuf_0/a_37950_n1540# 0.11fF
C6535 divbuf_1/a_2322_170# divbuf_1/a_2322_n240# 0.01fF
C6536 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_18582_n240# 0.04fF
C6537 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/a_37992_n240# 0.01fF
C6538 divbuf_0/a_28772_170# divbuf_0/a_28772_n240# 0.01fF
C6539 divbuf_0/a_8272_n240# divbuf_0/a_8762_n240# 0.04fF
C6540 pll_full_0/divbuf_0/a_29790_n840# pll_full_0/divbuf_0/a_30270_n840# 0.07fF
C6541 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6542 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_29790_n1540# 0.19fF
C6543 divbuf_1/a_50400_n1600# divbuf_1/a_50880_n1600# 0.26fF
C6544 divbuf_1/a_41382_n240# divbuf_1/a_41310_n840# 0.03fF
C6545 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/OUT2 0.04fF
C6546 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/OUT5 0.07fF
C6547 divbuf_0/a_20670_n840# divbuf_0/a_21150_n840# 0.07fF
C6548 divbuf_0/a_19072_n240# divbuf_0/OUT4 0.04fF
C6549 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n1540# 0.19fF
C6550 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/a_20042_170# 0.07fF
C6551 divbuf_3/a_39360_n1600# divbuf_3/a_39390_n840# 0.04fF
C6552 divbuf_3/a_34592_170# divbuf_3/OUT4 0.19fF
C6553 divbuf_1/a_42750_n1540# divbuf_1/a_43230_n1540# 0.11fF
C6554 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Z2 0.21fF
C6555 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35070_n840# 0.04fF
C6556 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6557 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C6558 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_53280_n1600# 0.26fF
C6559 divbuf_2/a_12960_n1600# divbuf_2/a_13440_n1600# 0.26fF
C6560 divbuf_2/a_3422_n240# divbuf_2/a_3390_n840# 0.05fF
C6561 pll_full_0/divbuf_1/a_45150_n1540# pll_full_0/divbuf_1/a_45630_n1540# 0.11fF
C6562 divbuf_2/a_5310_n1540# divbuf_2/a_5790_n1540# 0.11fF
C6563 divbuf_2/a_36030_n840# divbuf_2/a_36030_n1540# 0.01fF
C6564 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C6565 divbuf_3/a_17122_n240# divbuf_3/a_17612_n240# 0.04fF
C6566 divbuf_3/a_37022_170# divbuf_3/a_37022_n240# 0.01fF
C6567 divbuf_1/a_40320_n1600# divbuf_1/a_40350_n840# 0.04fF
C6568 divbuf_1/a_36532_170# divbuf_1/OUT4 0.19fF
C6569 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_13252_n240# 0.05fF
C6570 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/a_32652_n240# 0.01fF
C6571 divbuf_3/a_28830_n840# divbuf_3/a_29310_n840# 0.07fF
C6572 divbuf_3/a_35562_n240# divbuf_3/OUT4 0.04fF
C6573 divbuf_3/a_28800_n1600# divbuf_3/a_28830_n1540# 0.19fF
C6574 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39840_n1600# 0.26fF
C6575 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/a_30270_n840# 0.05fF
C6576 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24510_n1540# 0.19fF
C6577 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6578 ro_div_0/divbuf_0/a_24510_n840# ro_div_0/divbuf_0/a_24990_n840# 0.07fF
C6579 divbuf_2/a_2880_n1600# divbuf_2/a_2910_n840# 0.04fF
C6580 pd_div_0/divbuf_0/a_31710_n1540# pd_div_0/divbuf_0/a_32190_n1540# 0.11fF
C6581 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_42750_n840# 0.04fF
C6582 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/OUT2 0.04fF
C6583 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6584 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C6585 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/nor_1/B 0.35fF
C6586 divbuf_1/a_18092_n240# divbuf_1/a_18582_n240# 0.04fF
C6587 divbuf_1/a_37992_170# divbuf_1/a_37992_n240# 0.01fF
C6588 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16800_n1600# 0.26fF
C6589 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/a_6750_n840# 0.03fF
C6590 divbuf_0/a_7200_n1600# divbuf_0/a_7680_n1600# 0.26fF
C6591 pll_full_0/divbuf_0/a_8670_n1540# pll_full_0/divbuf_0/a_9150_n1540# 0.11fF
C6592 pll_full_0/divbuf_0/a_39390_n840# pll_full_0/divbuf_0/a_39390_n1540# 0.01fF
C6593 divbuf_1/a_29790_n840# divbuf_1/a_30270_n840# 0.07fF
C6594 divbuf_1/a_37502_n240# divbuf_1/OUT4 0.04fF
C6595 divbuf_1/a_29760_n1600# divbuf_1/a_29790_n1540# 0.19fF
C6596 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n1540# 0.19fF
C6597 divbuf_0/a_60510_n840# divbuf_0/a_60990_n840# 0.07fF
C6598 divbuf_0/a_30270_n840# divbuf_0/a_30270_n1540# 0.01fF
C6599 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/a_21012_n240# 0.05fF
C6600 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/a_40412_n240# 0.01fF
C6601 divbuf_3/a_33600_n1600# divbuf_3/OUT4 0.01fF
C6602 divbuf_2/a_19562_170# divbuf_2/a_20042_170# 0.07fF
C6603 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29310_n840# 0.04fF
C6604 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/a_20042_n240# 0.01fF
C6605 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/a_39932_170# 0.07fF
C6606 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C6607 divbuf_2/a_492_n240# divbuf_2/OUT2 0.42fF
C6608 divbuf_2/a_52800_n1600# divbuf_2/a_53280_n1600# 0.26fF
C6609 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/OUT2 0.01fF
C6610 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32190_n1540# 0.19fF
C6611 pll_full_0/divbuf_1/a_1950_n840# pll_full_0/divbuf_1/a_1950_n1540# 0.01fF
C6612 pll_full_0/divbuf_1/a_32190_n840# pll_full_0/divbuf_1/a_32670_n840# 0.07fF
C6613 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C6614 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C6615 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_1/A 0.01fF
C6616 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C6617 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C6618 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C6619 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6270_n840# 0.04fF
C6620 divbuf_2/a_45150_n1540# divbuf_2/a_45630_n1540# 0.11fF
C6621 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C6622 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C6623 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C6624 divbuf_0/a_18092_n240# divbuf_0/a_17790_n840# 0.00fF
C6625 divbuf_3/a_15360_n1600# divbuf_3/a_15840_n1600# 0.26fF
C6626 divbuf_3/a_5852_n240# divbuf_3/a_5790_n840# 0.04fF
C6627 divbuf_1/a_35520_n1600# divbuf_1/OUT4 0.00fF
C6628 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11520_n1600# 0.26fF
C6629 divbuf_3/a_7710_n1540# divbuf_3/a_8190_n1540# 0.11fF
C6630 divbuf_3/a_38430_n840# divbuf_3/a_38430_n1540# 0.01fF
C6631 pd_div_0/divbuf_0/a_18750_n840# pd_div_0/divbuf_0/a_19230_n840# 0.07fF
C6632 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_18750_n1540# 0.19fF
C6633 ro_div_0/divbuf_0/a_34110_n840# ro_div_0/divbuf_0/a_34110_n1540# 0.01fF
C6634 ro_div_0/divbuf_0/a_3390_n1540# ro_div_0/divbuf_0/a_3870_n1540# 0.11fF
C6635 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/a_23442_170# 0.07fF
C6636 divbuf_2/a_42720_n1600# divbuf_2/a_42750_n840# 0.04fF
C6637 divbuf_2/a_1842_n240# divbuf_2/OUT2 0.04fF
C6638 divbuf_2/a_41382_170# divbuf_2/OUT4 0.19fF
C6639 divbuf_1/a_16320_n1600# divbuf_1/a_16800_n1600# 0.26fF
C6640 divbuf_1/a_6822_n240# divbuf_1/a_6750_n840# 0.03fF
C6641 divbuf_0/a_13252_170# divbuf_0/a_13742_170# 0.07fF
C6642 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.29fF
C6643 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/OUT3 0.19fF
C6644 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56640_n1600# 0.26fF
C6645 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/a3 0.13fF
C6646 divbuf_0/a_47040_n1600# divbuf_0/a_47520_n1600# 0.26fF
C6647 divbuf_0/a_37992_n240# divbuf_0/a_37950_n840# 0.04fF
C6648 pll_full_0/divbuf_0/a_48510_n1540# pll_full_0/divbuf_0/a_48990_n1540# 0.11fF
C6649 divbuf_3/a_5280_n1600# divbuf_3/a_5310_n840# 0.04fF
C6650 divbuf_1/a_8670_n1540# divbuf_1/a_9150_n1540# 0.11fF
C6651 divbuf_1/a_39390_n840# divbuf_1/a_39390_n1540# 0.01fF
C6652 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_990_n840# 0.04fF
C6653 divbuf_0/a_39390_n1540# divbuf_0/a_39870_n1540# 0.11fF
C6654 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_19200_n1600# 0.26fF
C6655 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/a_9150_n840# 0.03fF
C6656 divbuf_2/a_20532_n240# divbuf_2/a_21012_n240# 0.05fF
C6657 divbuf_2/a_40412_170# divbuf_2/a_40412_n240# 0.01fF
C6658 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6659 divbuf_2/a_1440_n1600# divbuf_2/OUT2 0.01fF
C6660 divbuf_2/a_32160_n1600# divbuf_2/a_32190_n1540# 0.19fF
C6661 divbuf_2/a_1950_n840# divbuf_2/a_1950_n1540# 0.01fF
C6662 divbuf_2/a_32190_n840# divbuf_2/a_32670_n840# 0.07fF
C6663 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/clk 0.11fF
C6664 pll_full_0/divbuf_1/a_11070_n1540# pll_full_0/divbuf_1/a_11550_n1540# 0.11fF
C6665 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/a_41790_n1540# 0.01fF
C6666 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C6667 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46110_n840# 0.04fF
C6668 divbuf_3/a_21982_170# divbuf_3/a_22472_170# 0.07fF
C6669 divbuf_3/a_1352_170# divbuf_3/a_1352_n240# 0.01fF
C6670 divbuf_1/a_6240_n1600# divbuf_1/a_6270_n840# 0.04fF
C6671 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/OUT4 0.07fF
C6672 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/a_19562_170# 0.07fF
C6673 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n840# 0.04fF
C6674 divbuf_0/a_29742_170# divbuf_0/OUT4 0.19fF
C6675 divbuf_3/a_5852_170# divbuf_3/OUT3 0.19fF
C6676 divbuf_3/a_55200_n1600# divbuf_3/a_55680_n1600# 0.26fF
C6677 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5760_n1600# 0.26fF
C6678 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_51360_n1600# 0.26fF
C6679 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_8670_n840# 0.04fF
C6680 divbuf_3/a_47550_n1540# divbuf_3/a_48030_n1540# 0.11fF
C6681 pd_div_0/divbuf_0/a_28350_n840# pd_div_0/divbuf_0/a_28350_n1540# 0.01fF
C6682 pd_div_0/divbuf_0/a_58590_n840# pd_div_0/divbuf_0/a_59070_n840# 0.07fF
C6683 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_58590_n1540# 0.19fF
C6684 ro_div_0/divbuf_0/a_43230_n1540# ro_div_0/divbuf_0/a_43710_n1540# 0.11fF
C6685 divbuf_1/a_19562_170# divbuf_1/a_20042_170# 0.07fF
C6686 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/a_24412_n240# 0.04fF
C6687 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/a_26352_n240# 0.01fF
C6688 divbuf_0/a_34592_170# divbuf_0/a_34592_n240# 0.01fF
C6689 divbuf_0/a_14702_n240# divbuf_0/a_15182_n240# 0.05fF
C6690 pll_full_0/divbuf_0/a_5310_n840# pll_full_0/divbuf_0/a_5310_n1540# 0.01fF
C6691 pll_full_0/divbuf_0/a_35550_n840# pll_full_0/divbuf_0/a_36030_n840# 0.07fF
C6692 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_35550_n1540# 0.19fF
C6693 divbuf_1/a_56160_n1600# divbuf_1/a_56640_n1600# 0.26fF
C6694 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6695 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/a_19072_n240# 0.01fF
C6696 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n1540# 0.19fF
C6697 divbuf_0/a_30712_n240# divbuf_0/OUT4 0.04fF
C6698 divbuf_0/a_26430_n840# divbuf_0/a_26910_n840# 0.07fF
C6699 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/a_5362_n240# 0.01fF
C6700 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/a_25862_170# 0.07fF
C6701 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.01fF
C6702 divbuf_3/a_6822_n240# divbuf_3/OUT3 0.04fF
C6703 divbuf_3/a_45120_n1600# divbuf_3/a_45150_n840# 0.04fF
C6704 divbuf_1/a_48510_n1540# divbuf_1/a_48990_n1540# 0.11fF
C6705 divbuf_1/a_492_n240# divbuf_1/OUT2 0.42fF
C6706 pd_div_0/pd_0/UP pd_div_0/pd_0/and_pd_0/Z1 0.06fF
C6707 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/divider_0/clk 1.30fF
C6708 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6709 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_40830_n840# 0.04fF
C6710 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_59040_n1600# 0.26fF
C6711 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6712 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C6713 divbuf_2/a_18720_n1600# divbuf_2/a_19200_n1600# 0.26fF
C6714 divbuf_2/a_9242_n240# divbuf_2/a_9150_n840# 0.03fF
C6715 divbuf_2/a_11070_n1540# divbuf_2/a_11550_n1540# 0.11fF
C6716 divbuf_2/a_41790_n840# divbuf_2/a_41790_n1540# 0.01fF
C6717 divbuf_1/a_21982_170# divbuf_1/a_21982_n240# 0.01fF
C6718 pll_full_0/divbuf_1/a_50910_n1540# pll_full_0/divbuf_1/a_51390_n1540# 0.11fF
C6719 divbuf_3/a_22952_n240# divbuf_3/a_23442_n240# 0.04fF
C6720 divbuf_1/a_8762_n240# divbuf_1/OUT3 0.04fF
C6721 divbuf_1/a_46080_n1600# divbuf_1/a_46110_n840# 0.04fF
C6722 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/a_38472_n240# 0.01fF
C6723 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/a_19072_n240# 0.04fF
C6724 divbuf_3/a_34560_n1600# divbuf_3/a_34590_n1540# 0.19fF
C6725 divbuf_3/a_4350_n840# divbuf_3/a_4350_n1540# 0.01fF
C6726 divbuf_3/a_34590_n840# divbuf_3/a_35070_n840# 0.07fF
C6727 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/a_36030_n840# 0.05fF
C6728 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45600_n1600# 0.26fF
C6729 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30270_n1540# 0.19fF
C6730 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6731 ro_div_0/divbuf_0/a_30270_n840# ro_div_0/divbuf_0/a_30750_n840# 0.07fF
C6732 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6733 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48510_n840# 0.04fF
C6734 divbuf_2/a_8640_n1600# divbuf_2/a_8670_n840# 0.04fF
C6735 pd_div_0/divbuf_0/a_37470_n1540# pd_div_0/divbuf_0/a_37950_n1540# 0.11fF
C6736 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C6737 divbuf_1/a_23922_n240# divbuf_1/a_24412_n240# 0.04fF
C6738 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_12990_n840# 0.02fF
C6739 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22560_n1600# 0.26fF
C6740 divbuf_0/a_3422_n240# divbuf_0/a_3390_n840# 0.05fF
C6741 divbuf_0/a_12960_n1600# divbuf_0/a_13440_n1600# 0.26fF
C6742 pll_full_0/divbuf_0/a_14430_n1540# pll_full_0/divbuf_0/a_14910_n1540# 0.11fF
C6743 pll_full_0/divbuf_0/a_45150_n840# pll_full_0/divbuf_0/a_45150_n1540# 0.01fF
C6744 divbuf_1/a_5310_n840# divbuf_1/a_5310_n1540# 0.01fF
C6745 divbuf_1/a_35550_n840# divbuf_1/a_36030_n840# 0.07fF
C6746 divbuf_1/a_35520_n1600# divbuf_1/a_35550_n1540# 0.19fF
C6747 divbuf_0/a_36030_n840# divbuf_0/a_36030_n1540# 0.01fF
C6748 divbuf_0/a_5310_n1540# divbuf_0/a_5790_n1540# 0.11fF
C6749 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/a_26832_n240# 0.05fF
C6750 divbuf_2/a_5362_170# divbuf_2/a_5362_n240# 0.01fF
C6751 divbuf_2/a_25382_170# divbuf_2/a_25862_170# 0.07fF
C6752 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35070_n840# 0.04fF
C6753 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/a_5852_n240# 0.04fF
C6754 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C6755 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/a_1842_170# 0.07fF
C6756 divbuf_2/a_58560_n1600# divbuf_2/a_59040_n1600# 0.26fF
C6757 divbuf_2/a_12772_170# divbuf_2/OUT4 0.19fF
C6758 pll_full_0/divbuf_1/a_7710_n840# pll_full_0/divbuf_1/a_7710_n1540# 0.01fF
C6759 pll_full_0/divbuf_1/a_37950_n840# pll_full_0/divbuf_1/a_38430_n840# 0.07fF
C6760 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6761 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_37950_n1540# 0.19fF
C6762 ro_div_0/divider_0/tspc_2/Z3 ro_div_0/divider_0/tspc_2/Z4 0.65fF
C6763 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12030_n840# 0.04fF
C6764 divbuf_2/a_50910_n1540# divbuf_2/a_51390_n1540# 0.11fF
C6765 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_15390_n840# 0.01fF
C6766 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n840# 0.04fF
C6767 divbuf_3/a_11802_n240# divbuf_3/a_12030_n840# 0.02fF
C6768 divbuf_3/a_21120_n1600# divbuf_3/a_21600_n1600# 0.26fF
C6769 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/a_7230_n840# 0.03fF
C6770 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_17280_n1600# 0.26fF
C6771 divbuf_3/a_13470_n1540# divbuf_3/a_13950_n1540# 0.11fF
C6772 divbuf_3/a_44190_n840# divbuf_3/a_44190_n1540# 0.01fF
C6773 pd_div_0/divbuf_0/a_24510_n840# pd_div_0/divbuf_0/a_24990_n840# 0.07fF
C6774 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6775 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24510_n1540# 0.19fF
C6776 ro_div_0/divbuf_0/a_39870_n840# ro_div_0/divbuf_0/a_39870_n1540# 0.01fF
C6777 ro_div_0/divbuf_0/a_9150_n1540# ro_div_0/divbuf_0/a_9630_n1540# 0.11fF
C6778 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/a_29262_170# 0.07fF
C6779 divbuf_2/a_13742_n240# divbuf_2/OUT4 0.04fF
C6780 divbuf_2/a_48480_n1600# divbuf_2/a_48510_n840# 0.04fF
C6781 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/nor_1/B 0.35fF
C6782 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C6783 divbuf_1/a_12772_n240# divbuf_1/a_12990_n840# 0.02fF
C6784 divbuf_1/a_22080_n1600# divbuf_1/a_22560_n1600# 0.26fF
C6785 pll_full_0/divbuf_0/a_1470_n840# pll_full_0/divbuf_0/a_1950_n840# 0.07fF
C6786 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1470_n1540# 0.19fF
C6787 divbuf_0/a_2322_170# divbuf_0/OUT3 0.07fF
C6788 divbuf_0/a_52800_n1600# divbuf_0/a_53280_n1600# 0.26fF
C6789 pll_full_0/divbuf_0/a_54270_n1540# pll_full_0/divbuf_0/a_54750_n1540# 0.11fF
C6790 divbuf_3/a_11040_n1600# divbuf_3/a_11070_n840# 0.04fF
C6791 divbuf_1/a_14430_n1540# divbuf_1/a_14910_n1540# 0.11fF
C6792 divbuf_1/a_45150_n840# divbuf_1/a_45150_n1540# 0.01fF
C6793 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_6750_n840# 0.04fF
C6794 divbuf_0/a_45150_n1540# divbuf_0/a_45630_n1540# 0.11fF
C6795 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24960_n1600# 0.26fF
C6796 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_15390_n840# 0.02fF
C6797 divbuf_2/a_26352_n240# divbuf_2/a_26832_n240# 0.05fF
C6798 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6799 divbuf_2/a_7710_n840# divbuf_2/a_7710_n1540# 0.01fF
C6800 divbuf_2/a_37950_n840# divbuf_2/a_38430_n840# 0.07fF
C6801 divbuf_2/a_12000_n1600# divbuf_2/OUT4 0.00fF
C6802 divbuf_2/a_37920_n1600# divbuf_2/a_37950_n1540# 0.19fF
C6803 divbuf_1/a_4392_170# divbuf_1/a_4392_n240# 0.01fF
C6804 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C6805 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C6806 pll_full_0/divbuf_1/a_16830_n1540# pll_full_0/divbuf_1/a_17310_n1540# 0.11fF
C6807 pll_full_0/divbuf_1/a_47550_n840# pll_full_0/divbuf_1/a_47550_n1540# 0.01fF
C6808 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_51870_n840# 0.04fF
C6809 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6810 divbuf_3/a_7792_170# divbuf_3/a_7792_n240# 0.01fF
C6811 divbuf_3/a_27802_170# divbuf_3/a_28292_170# 0.07fF
C6812 divbuf_1/a_30712_170# divbuf_1/OUT4 0.19fF
C6813 divbuf_1/a_12000_n1600# divbuf_1/a_12030_n840# 0.04fF
C6814 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6815 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/a_23922_170# 0.07fF
C6816 divbuf_0/a_41382_170# divbuf_0/OUT4 0.19fF
C6817 divbuf_0/a_1842_n240# divbuf_0/OUT2 0.04fF
C6818 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n840# 0.04fF
C6819 divbuf_3/a_510_n840# divbuf_3/a_990_n840# 0.07fF
C6820 divbuf_3/a_480_n1600# divbuf_3/a_510_n1540# 0.19fF
C6821 divbuf_3/a_17612_170# divbuf_3/OUT4 0.19fF
C6822 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11520_n1600# 0.26fF
C6823 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_57120_n1600# 0.26fF
C6824 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14430_n840# 0.04fF
C6825 divbuf_3/a_53310_n1540# divbuf_3/a_53790_n1540# 0.11fF
C6826 pd_div_0/divbuf_0/a_3390_n1540# pd_div_0/divbuf_0/a_3870_n1540# 0.11fF
C6827 pd_div_0/divbuf_0/a_34110_n840# pd_div_0/divbuf_0/a_34110_n1540# 0.01fF
C6828 ro_div_0/divbuf_0/a_48990_n1540# ro_div_0/divbuf_0/a_49470_n1540# 0.11fF
C6829 divbuf_1/a_25382_170# divbuf_1/a_25862_170# 0.07fF
C6830 divbuf_1/a_15182_170# divbuf_1/a_15182_n240# 0.01fF
C6831 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/a_30232_n240# 0.04fF
C6832 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/a_32172_n240# 0.01fF
C6833 divbuf_0/a_40412_170# divbuf_0/a_40412_n240# 0.01fF
C6834 divbuf_0/a_20532_n240# divbuf_0/a_21012_n240# 0.05fF
C6835 pll_full_0/divbuf_0/a_11070_n840# pll_full_0/divbuf_0/a_11070_n1540# 0.01fF
C6836 pll_full_0/divbuf_0/a_41310_n840# pll_full_0/divbuf_0/a_41790_n840# 0.07fF
C6837 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41310_n1540# 0.19fF
C6838 divbuf_1/a_1470_n840# divbuf_1/a_1950_n840# 0.07fF
C6839 divbuf_1/a_1440_n1600# divbuf_1/a_1470_n1540# 0.19fF
C6840 divbuf_0/a_32190_n840# divbuf_0/a_32670_n840# 0.07fF
C6841 divbuf_0/a_1950_n840# divbuf_0/a_1950_n1540# 0.01fF
C6842 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n1540# 0.19fF
C6843 divbuf_0/a_1440_n1600# divbuf_0/OUT2 0.01fF
C6844 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/a_11802_n240# 0.01fF
C6845 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/a_31682_170# 0.07fF
C6846 divbuf_3/a_50880_n1600# divbuf_3/a_50910_n840# 0.04fF
C6847 divbuf_3/a_18582_n240# divbuf_3/OUT4 0.04fF
C6848 divbuf_1/a_54270_n1540# divbuf_1/a_54750_n1540# 0.11fF
C6849 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_990_n840# 0.04fF
C6850 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/a_8272_170# 0.07fF
C6851 ro_div_0/ro_complete_0/cbank_0/v ro_div_0/divider_0/clk 1.27fF
C6852 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_46590_n840# 0.04fF
C6853 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C6854 pll_full_0/divbuf_1/a_3870_n840# pll_full_0/divbuf_1/a_4350_n840# 0.07fF
C6855 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6856 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_3870_n1540# 0.19fF
C6857 divbuf_2/a_24480_n1600# divbuf_2/a_24960_n1600# 0.26fF
C6858 divbuf_2/a_15182_n240# divbuf_2/a_15390_n840# 0.02fF
C6859 divbuf_2/a_16830_n1540# divbuf_2/a_17310_n1540# 0.11fF
C6860 divbuf_2/a_47550_n840# divbuf_2/a_47550_n1540# 0.01fF
C6861 divbuf_1/a_27802_170# divbuf_1/a_27802_n240# 0.01fF
C6862 pll_full_0/divbuf_1/a_56670_n1540# pll_full_0/divbuf_1/a_57150_n1540# 0.11fF
C6863 divbuf_3/a_28772_n240# divbuf_3/a_29262_n240# 0.04fF
C6864 divbuf_1/a_51840_n1600# divbuf_1/a_51870_n840# 0.04fF
C6865 divbuf_1/a_20532_n240# divbuf_1/OUT4 0.04fF
C6866 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/a_24892_n240# 0.05fF
C6867 divbuf_3/a_10110_n840# divbuf_3/a_10110_n1540# 0.01fF
C6868 divbuf_3/a_40350_n840# divbuf_3/a_40830_n840# 0.07fF
C6869 divbuf_3/a_40320_n1600# divbuf_3/a_40350_n1540# 0.19fF
C6870 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_51360_n1600# 0.26fF
C6871 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/a_9732_n240# 0.01fF
C6872 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36030_n1540# 0.19fF
C6873 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C6874 ro_div_0/divbuf_0/a_36030_n840# ro_div_0/divbuf_0/a_36510_n840# 0.07fF
C6875 ro_div_0/divbuf_0/a_5790_n840# ro_div_0/divbuf_0/a_5790_n1540# 0.01fF
C6876 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6877 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54270_n840# 0.04fF
C6878 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C6879 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C6880 divbuf_2/a_14400_n1600# divbuf_2/a_14430_n840# 0.04fF
C6881 pd_div_0/divbuf_0/a_43230_n1540# pd_div_0/divbuf_0/a_43710_n1540# 0.11fF
C6882 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C6883 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C6884 divbuf_1/a_29742_n240# divbuf_1/a_30232_n240# 0.04fF
C6885 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C6886 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_28320_n1600# 0.26fF
C6887 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/a_18750_n840# 0.02fF
C6888 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C6889 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C6890 divbuf_0/a_9242_n240# divbuf_0/a_9150_n840# 0.03fF
C6891 divbuf_0/a_18720_n1600# divbuf_0/a_19200_n1600# 0.26fF
C6892 pll_full_0/divbuf_0/a_20190_n1540# pll_full_0/divbuf_0/a_20670_n1540# 0.11fF
C6893 pll_full_0/divbuf_0/a_50910_n840# pll_full_0/divbuf_0/a_50910_n1540# 0.01fF
C6894 divbuf_1/a_11070_n840# divbuf_1/a_11070_n1540# 0.01fF
C6895 divbuf_1/a_41310_n840# divbuf_1/a_41790_n840# 0.07fF
C6896 divbuf_1/a_41280_n1600# divbuf_1/a_41310_n1540# 0.19fF
C6897 divbuf_0/a_41790_n840# divbuf_0/a_41790_n1540# 0.01fF
C6898 divbuf_0/a_11070_n1540# divbuf_0/a_11550_n1540# 0.11fF
C6899 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/a_32652_n240# 0.05fF
C6900 divbuf_2/a_11802_170# divbuf_2/a_11802_n240# 0.01fF
C6901 divbuf_2/a_31202_170# divbuf_2/a_31682_170# 0.07fF
C6902 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_40830_n840# 0.04fF
C6903 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_12282_n240# 0.05fF
C6904 divbuf_2/a_3870_n840# divbuf_2/a_4350_n840# 0.07fF
C6905 divbuf_2/a_24412_170# divbuf_2/OUT4 0.19fF
C6906 divbuf_2/a_3840_n1600# divbuf_2/a_3870_n1540# 0.19fF
C6907 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6908 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_43710_n1540# 0.19fF
C6909 pll_full_0/divbuf_1/a_13470_n840# pll_full_0/divbuf_1/a_13470_n1540# 0.01fF
C6910 pll_full_0/divbuf_1/a_43710_n840# pll_full_0/divbuf_1/a_44190_n840# 0.07fF
C6911 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C6912 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_17790_n840# 0.04fF
C6913 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/OUT4 0.07fF
C6914 divbuf_2/a_56670_n1540# divbuf_2/a_57150_n1540# 0.11fF
C6915 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n840# 0.04fF
C6916 divbuf_3/a_26880_n1600# divbuf_3/a_27360_n1600# 0.26fF
C6917 divbuf_3/a_17612_n240# divbuf_3/a_17790_n840# 0.02fF
C6918 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_23040_n1600# 0.26fF
C6919 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_13470_n840# 0.02fF
C6920 divbuf_3/a_19230_n1540# divbuf_3/a_19710_n1540# 0.11fF
C6921 divbuf_3/a_49950_n840# divbuf_3/a_49950_n1540# 0.01fF
C6922 pd_div_0/divbuf_0/a_30270_n840# pd_div_0/divbuf_0/a_30750_n840# 0.07fF
C6923 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6924 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30270_n1540# 0.19fF
C6925 ro_div_0/divbuf_0/a_45630_n840# ro_div_0/divbuf_0/a_45630_n1540# 0.01fF
C6926 ro_div_0/divbuf_0/a_14910_n1540# ro_div_0/divbuf_0/a_15390_n1540# 0.11fF
C6927 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/a_35082_170# 0.07fF
C6928 divbuf_2/a_25382_n240# divbuf_2/OUT4 0.04fF
C6929 divbuf_2/a_54240_n1600# divbuf_2/a_54270_n840# 0.04fF
C6930 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C6931 divbuf_0/a_25382_170# divbuf_0/a_25862_170# 0.07fF
C6932 divbuf_1/a_27840_n1600# divbuf_1/a_28320_n1600# 0.26fF
C6933 divbuf_1/a_18582_n240# divbuf_1/a_18750_n840# 0.02fF
C6934 pll_full_0/divbuf_0/a_7230_n840# pll_full_0/divbuf_0/a_7710_n840# 0.07fF
C6935 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6936 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7230_n1540# 0.19fF
C6937 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C6938 divbuf_0/a_58560_n1600# divbuf_0/a_59040_n1600# 0.26fF
C6939 pll_full_0/divbuf_0/a_60030_n1540# pll_full_0/divbuf_0/a_60510_n1540# 0.11fF
C6940 divbuf_3/a_16800_n1600# divbuf_3/a_16830_n840# 0.04fF
C6941 divbuf_1/a_20190_n1540# divbuf_1/a_20670_n1540# 0.11fF
C6942 divbuf_1/a_50910_n840# divbuf_1/a_50910_n1540# 0.01fF
C6943 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12510_n840# 0.04fF
C6944 divbuf_0/a_50910_n1540# divbuf_0/a_51390_n1540# 0.11fF
C6945 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30720_n1600# 0.26fF
C6946 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/a_21150_n840# 0.03fF
C6947 divbuf_2/a_32172_n240# divbuf_2/a_32652_n240# 0.05fF
C6948 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6949 divbuf_2/a_23520_n1600# divbuf_2/OUT4 0.00fF
C6950 divbuf_2/a_43680_n1600# divbuf_2/a_43710_n1540# 0.19fF
C6951 divbuf_2/a_13470_n840# divbuf_2/a_13470_n1540# 0.01fF
C6952 divbuf_2/a_43710_n840# divbuf_2/a_44190_n840# 0.07fF
C6953 pd_div_0/divider_0/tspc_2/Z3 pd_div_0/divider_0/tspc_2/Z4 0.65fF
C6954 pll_full_0/divbuf_1/a_22590_n1540# pll_full_0/divbuf_1/a_23070_n1540# 0.11fF
C6955 pll_full_0/divbuf_1/a_53310_n840# pll_full_0/divbuf_1/a_53310_n1540# 0.01fF
C6956 divbuf_1/a_17760_n1600# divbuf_1/a_17790_n840# 0.04fF
C6957 divbuf_1/a_2322_170# divbuf_1/OUT2 0.19fF
C6958 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6959 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_57630_n840# 0.04fF
C6960 divbuf_3/a_14222_170# divbuf_3/a_14222_n240# 0.01fF
C6961 divbuf_3/a_33622_170# divbuf_3/a_34112_170# 0.07fF
C6962 pd_div_0/divbuf_0/a_492_n240# pd_div_0/bufin 0.13fF
C6963 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6964 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/a_29742_170# 0.07fF
C6965 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n840# 0.04fF
C6966 divbuf_0/a_13742_n240# divbuf_0/OUT4 0.04fF
C6967 divbuf_3/a_6270_n840# divbuf_3/a_6750_n840# 0.07fF
C6968 divbuf_3/a_29262_170# divbuf_3/OUT4 0.19fF
C6969 divbuf_3/a_6240_n1600# divbuf_3/a_6270_n1540# 0.19fF
C6970 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_17280_n1600# 0.26fF
C6971 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_1950_n1540# 0.19fF
C6972 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6973 ro_div_0/divbuf_0/a_1950_n840# ro_div_0/divbuf_0/a_2430_n840# 0.07fF
C6974 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20190_n840# 0.04fF
C6975 divbuf_3/a_59070_n1540# divbuf_3/a_59550_n1540# 0.11fF
C6976 pd_div_0/divbuf_0/a_9150_n1540# pd_div_0/divbuf_0/a_9630_n1540# 0.11fF
C6977 pd_div_0/divbuf_0/a_39870_n840# pd_div_0/divbuf_0/a_39870_n1540# 0.01fF
C6978 ro_div_0/divbuf_0/a_54750_n1540# ro_div_0/divbuf_0/a_55230_n1540# 0.11fF
C6979 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/a_36052_n240# 0.04fF
C6980 divbuf_1/a_34592_170# divbuf_1/a_35082_170# 0.07fF
C6981 divbuf_1/a_8762_170# divbuf_1/a_8762_n240# 0.01fF
C6982 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/a_37992_n240# 0.01fF
C6983 divbuf_0/a_26352_n240# divbuf_0/a_26832_n240# 0.05fF
C6984 pll_full_0/divbuf_0/a_16830_n840# pll_full_0/divbuf_0/a_16830_n1540# 0.01fF
C6985 pll_full_0/divbuf_0/a_47070_n840# pll_full_0/divbuf_0/a_47550_n840# 0.07fF
C6986 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47070_n1540# 0.19fF
C6987 divbuf_1/a_7230_n840# divbuf_1/a_7710_n840# 0.07fF
C6988 divbuf_1/a_27802_170# divbuf_1/OUT4 0.19fF
C6989 divbuf_1/a_7200_n1600# divbuf_1/a_7230_n1540# 0.19fF
C6990 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n1540# 0.19fF
C6991 divbuf_0/a_12000_n1600# divbuf_0/OUT4 0.00fF
C6992 divbuf_0/a_37950_n840# divbuf_0/a_38430_n840# 0.07fF
C6993 divbuf_0/a_7710_n840# divbuf_0/a_7710_n1540# 0.01fF
C6994 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/a_17612_n240# 0.01fF
C6995 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/a_37502_170# 0.07fF
C6996 divbuf_3/a_30232_n240# divbuf_3/OUT4 0.04fF
C6997 divbuf_3/a_56640_n1600# divbuf_3/a_56670_n840# 0.04fF
C6998 divbuf_1/a_60030_n1540# divbuf_1/a_60510_n1540# 0.11fF
C6999 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_6750_n840# 0.04fF
C7000 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/a_17122_170# 0.07fF
C7001 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7002 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52350_n840# 0.04fF
C7003 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_9630_n1540# 0.19fF
C7004 pll_full_0/divbuf_1/a_9630_n840# pll_full_0/divbuf_1/a_10110_n840# 0.07fF
C7005 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7006 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C7007 divbuf_2/a_30240_n1600# divbuf_2/a_30720_n1600# 0.26fF
C7008 divbuf_2/a_21012_n240# divbuf_2/a_21150_n840# 0.03fF
C7009 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C7010 divbuf_2/a_22590_n1540# divbuf_2/a_23070_n1540# 0.11fF
C7011 divbuf_2/a_53310_n840# divbuf_2/a_53310_n1540# 0.01fF
C7012 pll_full_0/divbuf_1/a_60990_n1540# pll_full_0/divbuf_1/OUT5 0.19fF
C7013 divbuf_3/a_34592_n240# divbuf_3/a_35082_n240# 0.04fF
C7014 divbuf_1/a_32172_n240# divbuf_1/OUT4 0.04fF
C7015 divbuf_1/a_57600_n1600# divbuf_1/a_57630_n840# 0.04fF
C7016 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/a_30712_n240# 0.05fF
C7017 divbuf_3/a_46080_n1600# divbuf_3/a_46110_n1540# 0.19fF
C7018 divbuf_3/a_15870_n840# divbuf_3/a_15870_n1540# 0.01fF
C7019 divbuf_3/a_46110_n840# divbuf_3/a_46590_n840# 0.07fF
C7020 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_57120_n1600# 0.26fF
C7021 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_41790_n1540# 0.19fF
C7022 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C7023 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/a_42270_n840# 0.07fF
C7024 ro_div_0/divbuf_0/a_11550_n840# ro_div_0/divbuf_0/a_11550_n1540# 0.01fF
C7025 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7026 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60030_n840# 0.04fF
C7027 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_13252_170# 0.07fF
C7028 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/a_6332_170# 0.07fF
C7029 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C7030 divbuf_2/a_20160_n1600# divbuf_2/a_20190_n840# 0.04fF
C7031 pd_div_0/divbuf_0/a_48990_n1540# pd_div_0/divbuf_0/a_49470_n1540# 0.11fF
C7032 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/clk 0.11fF
C7033 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/Out 0.11fF
C7034 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z4 0.15fF
C7035 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C7036 divbuf_1/a_35562_n240# divbuf_1/a_36052_n240# 0.04fF
C7037 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C7038 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C7039 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/a_24510_n840# 0.03fF
C7040 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_34080_n1600# 0.26fF
C7041 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/a_6750_n840# 0.03fF
C7042 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C7043 divbuf_0/a_15182_n240# divbuf_0/a_15390_n840# 0.02fF
C7044 divbuf_0/a_24480_n1600# divbuf_0/a_24960_n1600# 0.26fF
C7045 pll_full_0/divbuf_0/a_25950_n1540# pll_full_0/divbuf_0/a_26430_n1540# 0.11fF
C7046 pll_full_0/divbuf_0/a_56670_n840# pll_full_0/divbuf_0/a_56670_n1540# 0.01fF
C7047 divbuf_1/a_16830_n840# divbuf_1/a_16830_n1540# 0.01fF
C7048 divbuf_1/a_47070_n840# divbuf_1/a_47550_n840# 0.07fF
C7049 divbuf_1/a_47040_n1600# divbuf_1/a_47070_n1540# 0.19fF
C7050 divbuf_0/a_47550_n840# divbuf_0/a_47550_n1540# 0.01fF
C7051 divbuf_0/a_16830_n1540# divbuf_0/a_17310_n1540# 0.11fF
C7052 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/a_38472_n240# 0.05fF
C7053 divbuf_2/a_17612_170# divbuf_2/a_17612_n240# 0.01fF
C7054 divbuf_2/a_37022_170# divbuf_2/a_37502_170# 0.07fF
C7055 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_46590_n840# 0.04fF
C7056 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_18092_n240# 0.05fF
C7057 pll_full_0/divbuf_1/a_19230_n840# pll_full_0/divbuf_1/a_19230_n1540# 0.01fF
C7058 pll_full_0/divbuf_1/a_49470_n840# pll_full_0/divbuf_1/a_49950_n840# 0.07fF
C7059 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C7060 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49470_n1540# 0.19fF
C7061 pll_full_0/divbuf_0/a_4392_170# pll_full_0/divbuf_0/a_4392_n240# 0.01fF
C7062 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/a_10212_n240# 0.01fF
C7063 divbuf_2/a_9600_n1600# divbuf_2/a_9630_n1540# 0.19fF
C7064 divbuf_2/a_9630_n840# divbuf_2/a_10110_n840# 0.07fF
C7065 divbuf_2/a_36052_170# divbuf_2/OUT4 0.19fF
C7066 divbuf_0/a_18092_170# divbuf_0/a_18092_n240# 0.01fF
C7067 divbuf_2/a_60990_n1540# divbuf_2/OUT5 0.19fF
C7068 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C7069 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z4 0.22fF
C7070 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_23550_n840# 0.04fF
C7071 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/a_24892_n240# 0.05fF
C7072 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C7073 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_7302_170# 0.07fF
C7074 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n840# 0.04fF
C7075 divbuf_3/a_23442_n240# divbuf_3/a_23550_n840# 0.03fF
C7076 divbuf_3/a_32640_n1600# divbuf_3/a_33120_n1600# 0.26fF
C7077 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/a_19230_n840# 0.02fF
C7078 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28800_n1600# 0.26fF
C7079 divbuf_3/a_24990_n1540# divbuf_3/a_25470_n1540# 0.11fF
C7080 divbuf_3/a_55710_n840# divbuf_3/a_55710_n1540# 0.01fF
C7081 pd_div_0/divbuf_0/a_5790_n840# pd_div_0/divbuf_0/a_5790_n1540# 0.01fF
C7082 pd_div_0/divbuf_0/a_36030_n840# pd_div_0/divbuf_0/a_36510_n840# 0.07fF
C7083 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C7084 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36030_n1540# 0.19fF
C7085 ro_div_0/divbuf_0/a_51390_n840# ro_div_0/divbuf_0/a_51390_n1540# 0.01fF
C7086 ro_div_0/divbuf_0/a_20670_n1540# ro_div_0/divbuf_0/a_21150_n1540# 0.11fF
C7087 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/a_21012_n240# 0.01fF
C7088 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/a_40902_170# 0.07fF
C7089 divbuf_2/a_37022_n240# divbuf_2/OUT4 0.04fF
C7090 divbuf_2/a_60000_n1600# divbuf_2/a_60030_n840# 0.04fF
C7091 divbuf_1/a_18582_170# divbuf_1/a_19072_170# 0.07fF
C7092 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C7093 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C7094 divbuf_0/a_7302_170# divbuf_0/a_7302_n240# 0.01fF
C7095 divbuf_0/a_31202_170# divbuf_0/a_31682_170# 0.07fF
C7096 divbuf_0/a_11802_170# divbuf_0/a_11802_n240# 0.01fF
C7097 divbuf_1/a_24412_n240# divbuf_1/a_24510_n840# 0.03fF
C7098 divbuf_1/a_33600_n1600# divbuf_1/a_34080_n1600# 0.26fF
C7099 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/OUT3 0.07fF
C7100 pll_full_0/divbuf_0/a_12990_n840# pll_full_0/divbuf_0/a_13470_n840# 0.07fF
C7101 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_12990_n1540# 0.19fF
C7102 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/OUT3 0.23fF
C7103 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n1540# 0.19fF
C7104 divbuf_0/a_24412_170# divbuf_0/OUT4 0.19fF
C7105 divbuf_0/a_3870_n840# divbuf_0/a_4350_n840# 0.07fF
C7106 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/a_1842_170# 0.07fF
C7107 divbuf_3/a_492_n240# divbuf_3/IN 0.13fF
C7108 divbuf_3/a_22560_n1600# divbuf_3/a_22590_n840# 0.04fF
C7109 divbuf_1/a_25950_n1540# divbuf_1/a_26430_n1540# 0.11fF
C7110 divbuf_1/a_56670_n840# divbuf_1/a_56670_n1540# 0.01fF
C7111 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/OUT3 0.19fF
C7112 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18270_n840# 0.04fF
C7113 divbuf_0/a_56670_n1540# divbuf_0/a_57150_n1540# 0.11fF
C7114 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/a_26910_n840# 0.04fF
C7115 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36480_n1600# 0.26fF
C7116 divbuf_2/a_37992_n240# divbuf_2/a_38472_n240# 0.05fF
C7117 divbuf_2/a_19230_n840# divbuf_2/a_19230_n1540# 0.01fF
C7118 divbuf_2/a_49470_n840# divbuf_2/a_49950_n840# 0.07fF
C7119 divbuf_2/a_35040_n1600# divbuf_2/OUT4 0.00fF
C7120 divbuf_2/a_49440_n1600# divbuf_2/a_49470_n1540# 0.19fF
C7121 pll_full_0/divbuf_1/a_28350_n1540# pll_full_0/divbuf_1/a_28830_n1540# 0.11fF
C7122 pll_full_0/divbuf_1/a_59070_n840# pll_full_0/divbuf_1/a_59070_n1540# 0.01fF
C7123 divbuf_1/a_23520_n1600# divbuf_1/a_23550_n840# 0.04fF
C7124 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C7125 divbuf_3/a_20042_170# divbuf_3/a_20042_n240# 0.01fF
C7126 divbuf_3/a_39442_170# divbuf_3/a_39932_170# 0.07fF
C7127 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C7128 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/a_35562_170# 0.07fF
C7129 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n840# 0.04fF
C7130 divbuf_0/a_25382_n240# divbuf_0/OUT4 0.04fF
C7131 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C7132 divbuf_3/a_12000_n1600# divbuf_3/a_12030_n1540# 0.19fF
C7133 divbuf_3/a_1352_n240# divbuf_3/OUT2 0.07fF
C7134 divbuf_3/a_12030_n840# divbuf_3/a_12510_n840# 0.07fF
C7135 divbuf_3/a_40902_170# divbuf_3/OUT4 0.19fF
C7136 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_23040_n1600# 0.26fF
C7137 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/z5 0.11fF
C7138 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_7710_n1540# 0.19fF
C7139 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7140 ro_div_0/divbuf_0/a_7710_n840# ro_div_0/divbuf_0/a_8190_n840# 0.07fF
C7141 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/OUT3 0.19fF
C7142 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_25950_n840# 0.04fF
C7143 pd_div_0/divbuf_0/a_14910_n1540# pd_div_0/divbuf_0/a_15390_n1540# 0.11fF
C7144 pd_div_0/divbuf_0/a_45630_n840# pd_div_0/divbuf_0/a_45630_n1540# 0.01fF
C7145 ro_div_0/divbuf_0/a_60510_n1540# ro_div_0/divbuf_0/a_60990_n1540# 0.11fF
C7146 divbuf_1/a_40412_170# divbuf_1/a_40902_170# 0.07fF
C7147 divbuf_0/a_32172_n240# divbuf_0/a_32652_n240# 0.05fF
C7148 divbuf_1/a_3422_n240# divbuf_1/OUT3 0.07fF
C7149 divbuf_1/a_12990_n840# divbuf_1/a_13470_n840# 0.07fF
C7150 divbuf_1/a_12960_n1600# divbuf_1/a_12990_n1540# 0.19fF
C7151 pll_full_0/divbuf_0/a_22590_n840# pll_full_0/divbuf_0/a_22590_n1540# 0.01fF
C7152 pll_full_0/divbuf_0/a_52830_n840# pll_full_0/divbuf_0/a_53310_n840# 0.07fF
C7153 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_52830_n1540# 0.19fF
C7154 divbuf_0/a_43710_n840# divbuf_0/a_44190_n840# 0.07fF
C7155 divbuf_0/a_13470_n840# divbuf_0/a_13470_n1540# 0.01fF
C7156 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n1540# 0.19fF
C7157 divbuf_0/a_23520_n1600# divbuf_0/OUT4 0.00fF
C7158 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/a_23442_n240# 0.01fF
C7159 divbuf_3/a_960_n1600# divbuf_3/OUT2 0.00fF
C7160 divbuf_3/a_41382_n240# divbuf_3/OUT5 0.04fF
C7161 divbuf_2/a_1352_170# divbuf_2/a_1842_170# 0.07fF
C7162 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12510_n840# 0.04fF
C7163 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/a_22952_170# 0.07fF
C7164 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/a_6332_n240# 0.01fF
C7165 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58110_n840# 0.04fF
C7166 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7167 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C7168 pll_full_0/divbuf_1/a_15390_n840# pll_full_0/divbuf_1/a_15870_n840# 0.07fF
C7169 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15390_n1540# 0.19fF
C7170 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/a_9242_170# 0.07fF
C7171 divbuf_2/a_26832_n240# divbuf_2/a_26910_n840# 0.04fF
C7172 divbuf_2/a_36000_n1600# divbuf_2/a_36480_n1600# 0.26fF
C7173 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C7174 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z3 0.05fF
C7175 divbuf_0/a_6332_170# divbuf_0/a_6822_170# 0.07fF
C7176 divbuf_2/a_28350_n1540# divbuf_2/a_28830_n1540# 0.11fF
C7177 divbuf_2/a_59070_n840# divbuf_2/a_59070_n1540# 0.01fF
C7178 divbuf_3/a_40412_n240# divbuf_3/a_40902_n240# 0.04fF
C7179 divbuf_1/a_2880_n1600# divbuf_1/OUT2 0.00fF
C7180 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/a_36532_n240# 0.05fF
C7181 divbuf_3/a_21630_n840# divbuf_3/a_21630_n1540# 0.01fF
C7182 divbuf_3/a_51870_n840# divbuf_3/a_52350_n840# 0.07fF
C7183 divbuf_3/a_51840_n1600# divbuf_3/a_51870_n1540# 0.19fF
C7184 pd_div_0/divbuf_0/a_1950_n840# pd_div_0/divbuf_0/a_2430_n840# 0.07fF
C7185 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_1950_n1540# 0.19fF
C7186 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_47550_n1540# 0.19fF
C7187 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C7188 ro_div_0/divbuf_0/a_47550_n840# ro_div_0/divbuf_0/a_48030_n840# 0.07fF
C7189 ro_div_0/divbuf_0/a_17310_n840# ro_div_0/divbuf_0/a_17310_n1540# 0.01fF
C7190 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C7191 divbuf_2/a_7302_170# divbuf_2/OUT3 0.19fF
C7192 divbuf_2/a_25920_n1600# divbuf_2/a_25950_n840# 0.04fF
C7193 pd_div_0/divbuf_0/a_54750_n1540# pd_div_0/divbuf_0/a_55230_n1540# 0.11fF
C7194 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C7195 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C7196 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C7197 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C7198 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39840_n1600# 0.26fF
C7199 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/a_30270_n840# 0.05fF
C7200 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_12990_n840# 0.02fF
C7201 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C7202 divbuf_0/a_21012_n240# divbuf_0/a_21150_n840# 0.03fF
C7203 divbuf_0/a_30240_n1600# divbuf_0/a_30720_n1600# 0.26fF
C7204 pll_full_0/divbuf_0/a_31710_n1540# pll_full_0/divbuf_0/a_32190_n1540# 0.11fF
C7205 divbuf_1/a_22590_n840# divbuf_1/a_22590_n1540# 0.01fF
C7206 divbuf_1/a_52830_n840# divbuf_1/a_53310_n840# 0.07fF
C7207 divbuf_1/a_52800_n1600# divbuf_1/a_52830_n1540# 0.19fF
C7208 divbuf_0/a_53310_n840# divbuf_0/a_53310_n1540# 0.01fF
C7209 divbuf_0/a_22590_n1540# divbuf_0/a_23070_n1540# 0.11fF
C7210 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_2400_n1600# 0.26fF
C7211 divbuf_2/a_23442_170# divbuf_2/a_23442_n240# 0.01fF
C7212 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52350_n840# 0.04fF
C7213 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7214 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/OUT4 0.03fF
C7215 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55230_n1540# 0.19fF
C7216 pll_full_0/divbuf_1/a_24990_n840# pll_full_0/divbuf_1/a_24990_n1540# 0.01fF
C7217 pll_full_0/divbuf_1/a_55230_n840# pll_full_0/divbuf_1/a_55710_n840# 0.07fF
C7218 divbuf_2/a_8272_n240# divbuf_2/OUT3 0.04fF
C7219 divbuf_2/a_15390_n840# divbuf_2/a_15870_n840# 0.07fF
C7220 divbuf_2/a_15360_n1600# divbuf_2/a_15390_n1540# 0.19fF
C7221 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C7222 divbuf_3/a_4392_170# divbuf_3/a_4882_170# 0.07fF
C7223 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29310_n840# 0.04fF
C7224 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7225 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/a_13742_170# 0.07fF
C7226 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/a_30712_n240# 0.05fF
C7227 divbuf_0/a_6822_170# divbuf_0/OUT3 0.19fF
C7228 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n840# 0.04fF
C7229 divbuf_3/a_29262_n240# divbuf_3/a_29310_n840# 0.04fF
C7230 divbuf_3/a_38400_n1600# divbuf_3/a_38880_n1600# 0.26fF
C7231 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34560_n1600# 0.26fF
C7232 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/a_24990_n840# 0.03fF
C7233 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_12510_n840# 0.01fF
C7234 divbuf_3/a_30750_n1540# divbuf_3/a_31230_n1540# 0.11fF
C7235 pd_div_0/divbuf_0/a_11550_n840# pd_div_0/divbuf_0/a_11550_n1540# 0.01fF
C7236 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/a_42270_n840# 0.07fF
C7237 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7238 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_41790_n1540# 0.19fF
C7239 ro_div_0/divbuf_0/a_57150_n840# ro_div_0/divbuf_0/a_57150_n1540# 0.01fF
C7240 ro_div_0/divbuf_0/a_26430_n1540# ro_div_0/divbuf_0/a_26910_n1540# 0.11fF
C7241 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/a_6822_n240# 0.04fF
C7242 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/a_26832_n240# 0.01fF
C7243 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z4 0.15fF
C7244 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/Out 0.11fF
C7245 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/clk 0.11fF
C7246 divbuf_0/a_492_n240# divbuf_0/a_480_n1600# 0.00fF
C7247 divbuf_0/a_37022_170# divbuf_0/a_37502_170# 0.07fF
C7248 divbuf_1/a_39360_n1600# divbuf_1/a_39840_n1600# 0.26fF
C7249 divbuf_1/a_30232_n240# divbuf_1/a_30270_n840# 0.05fF
C7250 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7251 pll_full_0/divbuf_0/a_18750_n840# pll_full_0/divbuf_0/a_19230_n840# 0.07fF
C7252 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_18750_n1540# 0.19fF
C7253 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7254 divbuf_0/a_36052_170# divbuf_0/OUT4 0.19fF
C7255 divbuf_0/a_9630_n840# divbuf_0/a_10110_n840# 0.07fF
C7256 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n1540# 0.19fF
C7257 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/a_8272_170# 0.07fF
C7258 divbuf_3/a_28320_n1600# divbuf_3/a_28350_n840# 0.04fF
C7259 divbuf_3/a_12282_170# divbuf_3/OUT4 0.19fF
C7260 divbuf_1/a_31710_n1540# divbuf_1/a_32190_n1540# 0.11fF
C7261 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24030_n840# 0.04fF
C7262 divbuf_0/a_60990_n1540# divbuf_0/OUT5 0.19fF
C7263 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_42240_n1600# 0.26fF
C7264 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/a_32670_n840# 0.06fF
C7265 divbuf_2/a_1920_n1600# divbuf_2/a_2400_n1600# 0.26fF
C7266 divbuf_2/a_55200_n1600# divbuf_2/a_55230_n1540# 0.19fF
C7267 divbuf_2/a_24990_n840# divbuf_2/a_24990_n1540# 0.01fF
C7268 divbuf_2/a_55230_n840# divbuf_2/a_55710_n840# 0.07fF
C7269 pll_full_0/divbuf_1/a_34110_n1540# pll_full_0/divbuf_1/a_34590_n1540# 0.11fF
C7270 divbuf_1/a_29280_n1600# divbuf_1/a_29310_n840# 0.04fF
C7271 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7272 divbuf_3/a_5362_n240# divbuf_3/a_5852_n240# 0.04fF
C7273 divbuf_3/a_25862_170# divbuf_3/a_25862_n240# 0.01fF
C7274 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7275 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/a_41382_170# 0.07fF
C7276 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/a_21502_n240# 0.01fF
C7277 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n840# 0.04fF
C7278 divbuf_0/a_37022_n240# divbuf_0/OUT4 0.04fF
C7279 divbuf_3/a_13252_n240# divbuf_3/OUT4 0.04fF
C7280 divbuf_3/a_17790_n840# divbuf_3/a_18270_n840# 0.07fF
C7281 divbuf_3/a_17760_n1600# divbuf_3/a_17790_n1540# 0.19fF
C7282 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28800_n1600# 0.26fF
C7283 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13470_n1540# 0.19fF
C7284 ro_div_0/divbuf_0/a_13470_n840# ro_div_0/divbuf_0/a_13950_n840# 0.07fF
C7285 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C7286 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7287 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_31710_n840# 0.04fF
C7288 divbuf_2/a_12772_n240# divbuf_2/a_12510_n840# 0.01fF
C7289 pd_div_0/divbuf_0/a_20670_n1540# pd_div_0/divbuf_0/a_21150_n1540# 0.11fF
C7290 pd_div_0/divbuf_0/a_51390_n840# pd_div_0/divbuf_0/a_51390_n1540# 0.01fF
C7291 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C7292 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5760_n1600# 0.26fF
C7293 divbuf_1/a_6332_n240# divbuf_1/a_6822_n240# 0.04fF
C7294 divbuf_0/a_37992_n240# divbuf_0/a_38472_n240# 0.05fF
C7295 divbuf_1/a_15182_n240# divbuf_1/OUT4 0.04fF
C7296 divbuf_1/a_18750_n840# divbuf_1/a_19230_n840# 0.07fF
C7297 divbuf_1/a_18720_n1600# divbuf_1/a_18750_n1540# 0.19fF
C7298 pll_full_0/divbuf_0/a_28350_n840# pll_full_0/divbuf_0/a_28350_n1540# 0.01fF
C7299 pll_full_0/divbuf_0/a_58590_n840# pll_full_0/divbuf_0/a_59070_n840# 0.07fF
C7300 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_58590_n1540# 0.19fF
C7301 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n1540# 0.19fF
C7302 divbuf_0/a_35040_n1600# divbuf_0/OUT4 0.00fF
C7303 divbuf_0/a_49470_n840# divbuf_0/a_49950_n840# 0.07fF
C7304 divbuf_0/a_19230_n840# divbuf_0/a_19230_n1540# 0.01fF
C7305 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/a_29262_n240# 0.01fF
C7306 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/a_9242_n240# 0.05fF
C7307 divbuf_3/a_11520_n1600# divbuf_3/OUT4 0.01fF
C7308 divbuf_2/a_7792_170# divbuf_2/a_8272_170# 0.07fF
C7309 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18270_n840# 0.04fF
C7310 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/a_28772_170# 0.07fF
C7311 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21150_n1540# 0.19fF
C7312 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7313 pll_full_0/divbuf_1/a_21150_n840# pll_full_0/divbuf_1/a_21630_n840# 0.07fF
C7314 divbuf_2/a_41760_n1600# divbuf_2/a_42240_n1600# 0.26fF
C7315 divbuf_2/a_32652_n240# divbuf_2/a_32670_n840# 0.06fF
C7316 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_15870_n840# 0.01fF
C7317 divbuf_2/a_34110_n1540# divbuf_2/a_34590_n1540# 0.11fF
C7318 divbuf_1/a_13440_n1600# divbuf_1/OUT4 0.00fF
C7319 divbuf_3/a_4320_n1600# divbuf_3/a_4800_n1600# 0.26fF
C7320 ro_div_0/divbuf_0/a_0_n1600# ro_div_0/divbuf_0/a_480_n1600# 0.26fF
C7321 divbuf_3/a_57600_n1600# divbuf_3/a_57630_n1540# 0.19fF
C7322 divbuf_3/a_27390_n840# divbuf_3/a_27390_n1540# 0.01fF
C7323 divbuf_3/a_57630_n840# divbuf_3/a_58110_n840# 0.07fF
C7324 pd_div_0/divbuf_0/a_7710_n840# pd_div_0/divbuf_0/a_8190_n840# 0.07fF
C7325 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_7710_n1540# 0.19fF
C7326 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53310_n1540# 0.19fF
C7327 ro_div_0/divbuf_0/a_53310_n840# ro_div_0/divbuf_0/a_53790_n840# 0.07fF
C7328 ro_div_0/divbuf_0/a_23070_n840# ro_div_0/divbuf_0/a_23070_n1540# 0.01fF
C7329 divbuf_2/a_19072_170# divbuf_2/OUT4 0.19fF
C7330 divbuf_2/a_31680_n1600# divbuf_2/a_31710_n840# 0.04fF
C7331 pd_div_0/divbuf_0/a_60510_n1540# pd_div_0/divbuf_0/a_60990_n1540# 0.11fF
C7332 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/clk 0.51fF
C7333 divbuf_1/a_5280_n1600# divbuf_1/a_5760_n1600# 0.26fF
C7334 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.31fF
C7335 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z2 0.14fF
C7336 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C7337 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/a_36030_n840# 0.05fF
C7338 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45600_n1600# 0.26fF
C7339 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/a_18750_n840# 0.02fF
C7340 divbuf_0/a_36000_n1600# divbuf_0/a_36480_n1600# 0.26fF
C7341 divbuf_0/a_26832_n240# divbuf_0/a_26910_n840# 0.04fF
C7342 pll_full_0/divbuf_0/a_37470_n1540# pll_full_0/divbuf_0/a_37950_n1540# 0.11fF
C7343 divbuf_3/a_15182_n240# divbuf_3/a_14910_n840# 0.01fF
C7344 divbuf_1/a_28350_n840# divbuf_1/a_28350_n1540# 0.01fF
C7345 divbuf_1/a_58590_n840# divbuf_1/a_59070_n840# 0.07fF
C7346 divbuf_1/a_58560_n1600# divbuf_1/a_58590_n1540# 0.19fF
C7347 divbuf_0/a_59070_n840# divbuf_0/a_59070_n1540# 0.01fF
C7348 divbuf_0/a_28350_n1540# divbuf_0/a_28830_n1540# 0.11fF
C7349 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_8160_n1600# 0.26fF
C7350 divbuf_2/a_29262_170# divbuf_2/a_29262_n240# 0.01fF
C7351 divbuf_2/a_8762_n240# divbuf_2/a_9242_n240# 0.05fF
C7352 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7353 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58110_n840# 0.04fF
C7354 pll_full_0/divbuf_1/a_30750_n840# pll_full_0/divbuf_1/a_30750_n1540# 0.01fF
C7355 divbuf_2/a_21120_n1600# divbuf_2/a_21150_n1540# 0.19fF
C7356 divbuf_2/a_20042_n240# divbuf_2/OUT4 0.04fF
C7357 divbuf_2/a_21150_n840# divbuf_2/a_21630_n840# 0.07fF
C7358 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z3 0.05fF
C7359 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C7360 divbuf_1/a_16152_n240# divbuf_1/a_15870_n840# 0.01fF
C7361 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7362 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35070_n840# 0.04fF
C7363 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/OUT3 0.07fF
C7364 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C7365 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/a_36532_n240# 0.05fF
C7366 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n840# 0.04fF
C7367 divbuf_3/a_35082_n240# divbuf_3/a_35070_n840# 0.05fF
C7368 divbuf_3/a_44160_n1600# divbuf_3/a_44640_n1600# 0.26fF
C7369 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/a_30750_n840# 0.05fF
C7370 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_40320_n1600# 0.26fF
C7371 divbuf_3/a_36510_n1540# divbuf_3/a_36990_n1540# 0.11fF
C7372 pd_div_0/divbuf_0/a_17310_n840# pd_div_0/divbuf_0/a_17310_n1540# 0.01fF
C7373 pd_div_0/divbuf_0/a_47550_n840# pd_div_0/divbuf_0/a_48030_n840# 0.07fF
C7374 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7375 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_47550_n1540# 0.19fF
C7376 ro_div_0/divbuf_0/a_32190_n1540# ro_div_0/divbuf_0/a_32670_n1540# 0.11fF
C7377 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/a_32652_n240# 0.01fF
C7378 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_13252_n240# 0.05fF
C7379 divbuf_0/a_23442_170# divbuf_0/a_23442_n240# 0.01fF
C7380 divbuf_1/a_36052_n240# divbuf_1/a_36030_n840# 0.05fF
C7381 divbuf_1/a_45120_n1600# divbuf_1/a_45600_n1600# 0.26fF
C7382 pll_full_0/divbuf_0/a_24510_n840# pll_full_0/divbuf_0/a_24990_n840# 0.07fF
C7383 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7384 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24510_n1540# 0.19fF
C7385 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7386 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n1540# 0.19fF
C7387 divbuf_0/a_15390_n840# divbuf_0/a_15870_n840# 0.07fF
C7388 divbuf_0/a_8272_n240# divbuf_0/OUT3 0.04fF
C7389 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/a_14702_170# 0.07fF
C7390 divbuf_3/a_23922_170# divbuf_3/OUT4 0.19fF
C7391 divbuf_3/a_34080_n1600# divbuf_3/a_34110_n840# 0.04fF
C7392 divbuf_1/a_37470_n1540# divbuf_1/a_37950_n1540# 0.11fF
C7393 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z2 0.25fF
C7394 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7395 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_29790_n840# 0.04fF
C7396 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/a_38430_n840# 0.04fF
C7397 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_48000_n1600# 0.26fF
C7398 divbuf_2/a_7680_n1600# divbuf_2/a_8160_n1600# 0.26fF
C7399 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/OUT4 0.03fF
C7400 pll_full_0/divbuf_1/a_39870_n1540# pll_full_0/divbuf_1/a_40350_n1540# 0.11fF
C7401 divbuf_2/a_30750_n840# divbuf_2/a_30750_n1540# 0.01fF
C7402 divbuf_3/a_31682_170# divbuf_3/a_31682_n240# 0.01fF
C7403 divbuf_3/a_11802_n240# divbuf_3/a_12282_n240# 0.05fF
C7404 divbuf_1/a_22472_170# divbuf_1/OUT4 0.19fF
C7405 divbuf_1/a_35040_n1600# divbuf_1/a_35070_n840# 0.04fF
C7406 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7407 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/a_27322_n240# 0.01fF
C7408 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/a_7302_n240# 0.05fF
C7409 divbuf_3/a_23520_n1600# divbuf_3/a_23550_n1540# 0.19fF
C7410 divbuf_3/a_24892_n240# divbuf_3/OUT4 0.04fF
C7411 divbuf_3/a_23550_n840# divbuf_3/a_24030_n840# 0.07fF
C7412 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/a_24990_n840# 0.03fF
C7413 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34560_n1600# 0.26fF
C7414 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19230_n1540# 0.19fF
C7415 ro_div_0/divbuf_0/a_19230_n840# ro_div_0/divbuf_0/a_19710_n840# 0.07fF
C7416 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7417 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7418 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37470_n840# 0.04fF
C7419 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C7420 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C7421 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C7422 pd_div_0/divbuf_0/a_26430_n1540# pd_div_0/divbuf_0/a_26910_n1540# 0.11fF
C7423 pd_div_0/divbuf_0/a_57150_n840# pd_div_0/divbuf_0/a_57150_n1540# 0.01fF
C7424 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11520_n1600# 0.26fF
C7425 divbuf_1/a_12772_n240# divbuf_1/a_13252_n240# 0.05fF
C7426 divbuf_0/a_1920_n1600# divbuf_0/a_2400_n1600# 0.26fF
C7427 divbuf_1/a_24510_n840# divbuf_1/a_24990_n840# 0.07fF
C7428 divbuf_1/a_26832_n240# divbuf_1/OUT4 0.04fF
C7429 divbuf_1/a_24480_n1600# divbuf_1/a_24510_n1540# 0.19fF
C7430 pll_full_0/divbuf_0/a_3390_n1540# pll_full_0/divbuf_0/a_3870_n1540# 0.11fF
C7431 pll_full_0/divbuf_0/a_34110_n840# pll_full_0/divbuf_0/a_34110_n1540# 0.01fF
C7432 divbuf_0/a_55230_n840# divbuf_0/a_55710_n840# 0.07fF
C7433 divbuf_0/a_24990_n840# divbuf_0/a_24990_n1540# 0.01fF
C7434 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n1540# 0.19fF
C7435 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_15672_n240# 0.04fF
C7436 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/a_35082_n240# 0.01fF
C7437 divbuf_3/a_23040_n1600# divbuf_3/OUT4 0.01fF
C7438 divbuf_2/a_14222_170# divbuf_2/a_14702_170# 0.07fF
C7439 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24030_n840# 0.04fF
C7440 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/a_34592_170# 0.07fF
C7441 pll_full_0/divbuf_1/a_26910_n840# pll_full_0/divbuf_1/a_27390_n840# 0.07fF
C7442 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7443 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_26910_n1540# 0.19fF
C7444 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C7445 divbuf_2/a_38472_n240# divbuf_2/a_38430_n840# 0.04fF
C7446 divbuf_2/a_47520_n1600# divbuf_2/a_48000_n1600# 0.26fF
C7447 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C7448 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_990_n840# 0.04fF
C7449 divbuf_2/a_39870_n1540# divbuf_2/a_40350_n1540# 0.11fF
C7450 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C7451 divbuf_0/a_12772_n240# divbuf_0/a_12510_n840# 0.01fF
C7452 divbuf_1/a_24960_n1600# divbuf_1/OUT4 0.00fF
C7453 divbuf_3/a_10080_n1600# divbuf_3/a_10560_n1600# 0.26fF
C7454 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_6240_n1600# 0.26fF
C7455 divbuf_3/a_2910_n840# divbuf_3/OUT3 0.03fF
C7456 divbuf_3/a_2430_n1540# divbuf_3/a_2910_n1540# 0.11fF
C7457 divbuf_3/a_33150_n840# divbuf_3/a_33150_n1540# 0.01fF
C7458 pd_div_0/divbuf_0/a_13470_n840# pd_div_0/divbuf_0/a_13950_n840# 0.07fF
C7459 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13470_n1540# 0.19fF
C7460 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59070_n1540# 0.19fF
C7461 ro_div_0/divbuf_0/a_59070_n840# ro_div_0/divbuf_0/a_59550_n840# 0.07fF
C7462 ro_div_0/divbuf_0/a_28830_n840# ro_div_0/divbuf_0/a_28830_n1540# 0.01fF
C7463 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/a_19562_170# 0.07fF
C7464 divbuf_2/a_30712_170# divbuf_2/OUT4 0.19fF
C7465 divbuf_2/a_37440_n1600# divbuf_2/a_37470_n840# 0.04fF
C7466 divbuf_1/a_17612_170# divbuf_1/a_18092_170# 0.07fF
C7467 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_51360_n1600# 0.26fF
C7468 divbuf_1/a_11040_n1600# divbuf_1/a_11520_n1600# 0.26fF
C7469 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.05fF
C7470 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C7471 io_clamp_low[0] io_clamp_high[0] 0.53fF
C7472 divbuf_1/a_3390_n1540# divbuf_1/a_3870_n1540# 0.11fF
C7473 divbuf_1/a_34110_n840# divbuf_1/a_34110_n1540# 0.01fF
C7474 divbuf_0/a_32652_n240# divbuf_0/a_32670_n840# 0.06fF
C7475 divbuf_0/a_41760_n1600# divbuf_0/a_42240_n1600# 0.26fF
C7476 pll_full_0/divbuf_0/a_43230_n1540# pll_full_0/divbuf_0/a_43710_n1540# 0.11fF
C7477 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_16350_n840# 0.00fF
C7478 divbuf_0/a_34110_n1540# divbuf_0/a_34590_n1540# 0.11fF
C7479 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13920_n1600# 0.26fF
C7480 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/a_3870_n840# 0.04fF
C7481 divbuf_3/a_41790_n840# divbuf_3/OUT5 0.03fF
C7482 divbuf_2/a_15182_n240# divbuf_2/a_15672_n240# 0.04fF
C7483 divbuf_2/a_35082_170# divbuf_2/a_35082_n240# 0.01fF
C7484 pll_full_0/divbuf_1/a_5790_n1540# pll_full_0/divbuf_1/a_6270_n1540# 0.11fF
C7485 pll_full_0/divbuf_1/a_36510_n840# pll_full_0/divbuf_1/a_36510_n1540# 0.01fF
C7486 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/a_19072_n240# 0.01fF
C7487 divbuf_2/a_26910_n840# divbuf_2/a_27390_n840# 0.07fF
C7488 divbuf_2/a_31682_n240# divbuf_2/OUT4 0.04fF
C7489 divbuf_2/a_26880_n1600# divbuf_2/a_26910_n1540# 0.19fF
C7490 divbuf_3/a_16642_170# divbuf_3/a_17122_170# 0.07fF
C7491 divbuf_1/a_960_n1600# divbuf_1/a_990_n840# 0.04fF
C7492 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_40830_n840# 0.04fF
C7493 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7494 pd_div_0/divbuf_0/a_0_n1600# pd_div_0/divbuf_0/a_480_n1600# 0.26fF
C7495 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n840# 0.04fF
C7496 divbuf_0/a_16642_170# divbuf_0/OUT4 0.19fF
C7497 divbuf_3/a_40902_n240# divbuf_3/a_40830_n840# 0.03fF
C7498 divbuf_3/a_49920_n1600# divbuf_3/a_50400_n1600# 0.26fF
C7499 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_46080_n1600# 0.26fF
C7500 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/a_36510_n840# 0.05fF
C7501 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3390_n840# 0.04fF
C7502 divbuf_3/a_42270_n1540# divbuf_3/a_42750_n1540# 0.11fF
C7503 pd_div_0/divbuf_0/a_23070_n840# pd_div_0/divbuf_0/a_23070_n1540# 0.01fF
C7504 pd_div_0/divbuf_0/a_53310_n840# pd_div_0/divbuf_0/a_53790_n840# 0.07fF
C7505 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53310_n1540# 0.19fF
C7506 ro_div_0/divbuf_0/a_37950_n1540# ro_div_0/divbuf_0/a_38430_n1540# 0.11fF
C7507 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/a_19072_n240# 0.04fF
C7508 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/a_38472_n240# 0.01fF
C7509 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/clk 0.51fF
C7510 divbuf_0/a_8762_n240# divbuf_0/a_9242_n240# 0.05fF
C7511 divbuf_0/a_29262_170# divbuf_0/a_29262_n240# 0.01fF
C7512 divbuf_1/a_50880_n1600# divbuf_1/a_51360_n1600# 0.26fF
C7513 pll_full_0/divbuf_0/a_30270_n840# pll_full_0/divbuf_0/a_30750_n840# 0.07fF
C7514 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7515 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30270_n1540# 0.19fF
C7516 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/OUT3 0.07fF
C7517 divbuf_0/a_21150_n840# divbuf_0/a_21630_n840# 0.07fF
C7518 divbuf_0/a_20042_n240# divbuf_0/OUT4 0.04fF
C7519 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n1540# 0.19fF
C7520 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/a_20532_170# 0.07fF
C7521 divbuf_3/a_39840_n1600# divbuf_3/a_39870_n840# 0.04fF
C7522 divbuf_3/a_35562_170# divbuf_3/OUT4 0.19fF
C7523 divbuf_1/a_43230_n1540# divbuf_1/a_43710_n1540# 0.11fF
C7524 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z3 0.65fF
C7525 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_35550_n840# 0.04fF
C7526 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7527 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53760_n1600# 0.26fF
C7528 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/OUT2 0.19fF
C7529 divbuf_2/a_13440_n1600# divbuf_2/a_13920_n1600# 0.26fF
C7530 divbuf_2/a_3912_n240# divbuf_2/a_3870_n840# 0.04fF
C7531 pll_full_0/divbuf_1/a_45630_n1540# pll_full_0/divbuf_1/a_46110_n1540# 0.11fF
C7532 divbuf_2/a_5790_n1540# divbuf_2/a_6270_n1540# 0.11fF
C7533 divbuf_2/a_36510_n840# divbuf_2/a_36510_n1540# 0.01fF
C7534 divbuf_3/a_17612_n240# divbuf_3/a_18092_n240# 0.05fF
C7535 divbuf_3/a_37502_170# divbuf_3/a_37502_n240# 0.01fF
C7536 divbuf_1/a_40800_n1600# divbuf_1/a_40830_n840# 0.04fF
C7537 divbuf_1/a_37502_170# divbuf_1/OUT4 0.19fF
C7538 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7539 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_40320_n1600# 0.26fF
C7540 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/a_30750_n840# 0.05fF
C7541 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/a_33142_n240# 0.01fF
C7542 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_13742_n240# 0.04fF
C7543 divbuf_3/a_29310_n840# divbuf_3/a_29790_n840# 0.07fF
C7544 divbuf_3/a_36532_n240# divbuf_3/OUT4 0.04fF
C7545 divbuf_3/a_29280_n1600# divbuf_3/a_29310_n1540# 0.19fF
C7546 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_24990_n1540# 0.19fF
C7547 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7548 ro_div_0/divbuf_0/a_24990_n840# ro_div_0/divbuf_0/a_25470_n840# 0.07fF
C7549 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C7550 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43230_n840# 0.04fF
C7551 divbuf_2/a_3360_n1600# divbuf_2/a_3390_n840# 0.04fF
C7552 pd_div_0/divbuf_0/a_32190_n1540# pd_div_0/divbuf_0/a_32670_n1540# 0.11fF
C7553 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_17280_n1600# 0.26fF
C7554 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/a_7230_n840# 0.03fF
C7555 divbuf_1/a_18582_n240# divbuf_1/a_19072_n240# 0.04fF
C7556 divbuf_1/a_38472_170# divbuf_1/a_38472_n240# 0.01fF
C7557 divbuf_0/a_7680_n1600# divbuf_0/a_8160_n1600# 0.26fF
C7558 divbuf_1/a_30270_n840# divbuf_1/a_30750_n840# 0.07fF
C7559 divbuf_1/a_38472_n240# divbuf_1/OUT4 0.04fF
C7560 divbuf_1/a_30240_n1600# divbuf_1/a_30270_n1540# 0.19fF
C7561 pll_full_0/divbuf_0/a_9150_n1540# pll_full_0/divbuf_0/a_9630_n1540# 0.11fF
C7562 pll_full_0/divbuf_0/a_39870_n840# pll_full_0/divbuf_0/a_39870_n1540# 0.01fF
C7563 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_510_n840# 0.00fF
C7564 divbuf_0/a_30750_n840# divbuf_0/a_30750_n1540# 0.01fF
C7565 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/a_40902_n240# 0.01fF
C7566 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/a_21502_n240# 0.04fF
C7567 divbuf_3/a_34560_n1600# divbuf_3/OUT4 0.01fF
C7568 divbuf_2/a_20042_170# divbuf_2/a_20532_170# 0.07fF
C7569 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_29790_n840# 0.04fF
C7570 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/a_20532_n240# 0.01fF
C7571 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/a_40412_170# 0.07fF
C7572 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C7573 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_32670_n1540# 0.19fF
C7574 pll_full_0/divbuf_1/a_2430_n840# pll_full_0/divbuf_1/a_2430_n1540# 0.01fF
C7575 pll_full_0/divbuf_1/a_32670_n840# pll_full_0/divbuf_1/a_33150_n840# 0.07fF
C7576 divbuf_2/a_53280_n1600# divbuf_2/a_53760_n1600# 0.26fF
C7577 divbuf_2/a_1842_170# divbuf_2/OUT2 0.19fF
C7578 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/clk 0.11fF
C7579 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/Out 0.05fF
C7580 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C7581 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_6750_n840# 0.04fF
C7582 divbuf_2/a_45630_n1540# divbuf_2/a_46110_n1540# 0.11fF
C7583 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C7584 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C7585 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C7586 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C7587 divbuf_1/a_36480_n1600# divbuf_1/OUT4 0.00fF
C7588 divbuf_3/a_15840_n1600# divbuf_3/a_16320_n1600# 0.26fF
C7589 divbuf_3/a_6332_n240# divbuf_3/a_6270_n840# 0.04fF
C7590 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_12000_n1600# 0.26fF
C7591 divbuf_3/a_8190_n1540# divbuf_3/a_8670_n1540# 0.11fF
C7592 divbuf_3/a_38910_n840# divbuf_3/a_38910_n1540# 0.01fF
C7593 pd_div_0/divbuf_0/a_19230_n840# pd_div_0/divbuf_0/a_19710_n840# 0.07fF
C7594 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19230_n1540# 0.19fF
C7595 ro_div_0/divbuf_0/a_34590_n840# ro_div_0/divbuf_0/a_34590_n1540# 0.01fF
C7596 ro_div_0/divbuf_0/a_3870_n1540# ro_div_0/divbuf_0/a_4350_n1540# 0.11fF
C7597 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/a_23922_170# 0.07fF
C7598 divbuf_2/a_2322_n240# divbuf_2/OUT3 0.04fF
C7599 divbuf_2/a_43200_n1600# divbuf_2/a_43230_n840# 0.04fF
C7600 divbuf_1/a_7792_170# divbuf_1/a_8272_170# 0.07fF
C7601 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C7602 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_57120_n1600# 0.26fF
C7603 divbuf_1/a_16800_n1600# divbuf_1/a_17280_n1600# 0.26fF
C7604 divbuf_1/a_7302_n240# divbuf_1/a_7230_n840# 0.03fF
C7605 divbuf_0/a_3912_170# divbuf_0/OUT3 0.19fF
C7606 divbuf_0/a_47520_n1600# divbuf_0/a_48000_n1600# 0.26fF
C7607 divbuf_0/a_38472_n240# divbuf_0/a_38430_n840# 0.04fF
C7608 divbuf_1/a_9150_n1540# divbuf_1/a_9630_n1540# 0.11fF
C7609 divbuf_1/a_39870_n840# divbuf_1/a_39870_n1540# 0.01fF
C7610 pll_full_0/divbuf_0/a_48990_n1540# pll_full_0/divbuf_0/a_49470_n1540# 0.11fF
C7611 divbuf_3/a_5760_n1600# divbuf_3/a_5790_n840# 0.04fF
C7612 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1470_n840# 0.04fF
C7613 divbuf_0/a_39870_n1540# divbuf_0/a_40350_n1540# 0.11fF
C7614 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19680_n1600# 0.26fF
C7615 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/a_9630_n840# 0.03fF
C7616 divbuf_2/a_40902_170# divbuf_2/a_40902_n240# 0.01fF
C7617 divbuf_2/a_21012_n240# divbuf_2/a_21502_n240# 0.04fF
C7618 pll_full_0/divbuf_1/a_11550_n1540# pll_full_0/divbuf_1/a_12030_n1540# 0.11fF
C7619 pll_full_0/divbuf_1/a_42270_n840# pll_full_0/divbuf_1/a_42270_n1540# 0.01fF
C7620 divbuf_2/a_2400_n1600# divbuf_2/OUT2 0.00fF
C7621 divbuf_2/a_32640_n1600# divbuf_2/a_32670_n1540# 0.19fF
C7622 divbuf_2/a_2430_n840# divbuf_2/a_2430_n1540# 0.01fF
C7623 divbuf_2/a_32670_n840# divbuf_2/a_33150_n840# 0.07fF
C7624 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C7625 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_46590_n840# 0.04fF
C7626 divbuf_3/a_22472_170# divbuf_3/a_22952_170# 0.07fF
C7627 divbuf_3/a_1842_170# divbuf_3/a_1842_n240# 0.01fF
C7628 divbuf_1/a_6720_n1600# divbuf_1/a_6750_n840# 0.04fF
C7629 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7630 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_4882_n240# 0.01fF
C7631 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_6240_n1600# 0.26fF
C7632 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n840# 0.04fF
C7633 divbuf_0/a_30712_170# divbuf_0/OUT4 0.19fF
C7634 divbuf_3/a_6822_170# divbuf_3/OUT3 0.19fF
C7635 divbuf_3/a_55680_n1600# divbuf_3/a_56160_n1600# 0.26fF
C7636 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/OUT3 0.07fF
C7637 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51840_n1600# 0.26fF
C7638 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9150_n840# 0.04fF
C7639 divbuf_3/a_48030_n1540# divbuf_3/a_48510_n1540# 0.11fF
C7640 pd_div_0/divbuf_0/a_28830_n840# pd_div_0/divbuf_0/a_28830_n1540# 0.01fF
C7641 pd_div_0/divbuf_0/a_59070_n840# pd_div_0/divbuf_0/a_59550_n840# 0.07fF
C7642 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59070_n1540# 0.19fF
C7643 ro_div_0/divbuf_0/a_43710_n1540# ro_div_0/divbuf_0/a_44190_n1540# 0.11fF
C7644 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/a_24892_n240# 0.05fF
C7645 divbuf_1/a_20042_170# divbuf_1/a_20532_170# 0.07fF
C7646 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/a_26832_n240# 0.01fF
C7647 divbuf_0/a_35082_170# divbuf_0/a_35082_n240# 0.01fF
C7648 divbuf_0/a_15182_n240# divbuf_0/a_15672_n240# 0.04fF
C7649 divbuf_1/a_56640_n1600# divbuf_1/a_57120_n1600# 0.26fF
C7650 pll_full_0/divbuf_0/a_5790_n840# pll_full_0/divbuf_0/a_5790_n1540# 0.01fF
C7651 pll_full_0/divbuf_0/a_36030_n840# pll_full_0/divbuf_0/a_36510_n840# 0.07fF
C7652 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C7653 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36030_n1540# 0.19fF
C7654 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7655 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/a_19562_n240# 0.01fF
C7656 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n1540# 0.19fF
C7657 divbuf_0/a_31682_n240# divbuf_0/OUT4 0.04fF
C7658 divbuf_0/a_26910_n840# divbuf_0/a_27390_n840# 0.07fF
C7659 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/a_26352_170# 0.07fF
C7660 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/a_5852_n240# 0.01fF
C7661 divbuf_3/a_7792_n240# divbuf_3/OUT3 0.04fF
C7662 divbuf_3/a_45600_n1600# divbuf_3/a_45630_n840# 0.04fF
C7663 divbuf_1/a_48990_n1540# divbuf_1/a_49470_n1540# 0.11fF
C7664 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_13252_170# 0.07fF
C7665 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7666 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41310_n840# 0.04fF
C7667 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59520_n1600# 0.26fF
C7668 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7669 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C7670 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C7671 divbuf_2/a_19200_n1600# divbuf_2/a_19680_n1600# 0.26fF
C7672 divbuf_2/a_9732_n240# divbuf_2/a_9630_n840# 0.03fF
C7673 pll_full_0/divbuf_1/a_51390_n1540# pll_full_0/divbuf_1/a_51870_n1540# 0.11fF
C7674 divbuf_2/a_11550_n1540# divbuf_2/a_12030_n1540# 0.11fF
C7675 divbuf_2/a_42270_n840# divbuf_2/a_42270_n1540# 0.01fF
C7676 divbuf_1/a_22472_170# divbuf_1/a_22472_n240# 0.01fF
C7677 divbuf_3/a_23442_n240# divbuf_3/a_23922_n240# 0.05fF
C7678 divbuf_1/a_9732_n240# divbuf_1/OUT3 0.04fF
C7679 divbuf_1/a_46560_n1600# divbuf_1/a_46590_n840# 0.04fF
C7680 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/a_38962_n240# 0.01fF
C7681 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/a_19562_n240# 0.04fF
C7682 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/a_36510_n840# 0.05fF
C7683 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_46080_n1600# 0.26fF
C7684 divbuf_3/a_4830_n840# divbuf_3/a_4830_n1540# 0.01fF
C7685 divbuf_3/a_35070_n840# divbuf_3/a_35550_n840# 0.07fF
C7686 divbuf_3/a_35040_n1600# divbuf_3/a_35070_n1540# 0.19fF
C7687 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/a_3422_n240# 0.01fF
C7688 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_30750_n1540# 0.19fF
C7689 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/a_510_n1540# 0.01fF
C7690 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7691 ro_div_0/divbuf_0/a_30750_n840# ro_div_0/divbuf_0/a_31230_n840# 0.07fF
C7692 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7693 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_48990_n840# 0.04fF
C7694 divbuf_2/a_9120_n1600# divbuf_2/a_9150_n840# 0.04fF
C7695 pd_div_0/divbuf_0/a_37950_n1540# pd_div_0/divbuf_0/a_38430_n1540# 0.11fF
C7696 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C7697 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_13470_n840# 0.02fF
C7698 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_23040_n1600# 0.26fF
C7699 divbuf_1/a_24412_n240# divbuf_1/a_24892_n240# 0.05fF
C7700 divbuf_0/a_3912_n240# divbuf_0/a_3870_n840# 0.04fF
C7701 divbuf_0/a_13440_n1600# divbuf_0/a_13920_n1600# 0.26fF
C7702 divbuf_1/a_5790_n840# divbuf_1/a_5790_n1540# 0.01fF
C7703 divbuf_1/a_36030_n840# divbuf_1/a_36510_n840# 0.07fF
C7704 divbuf_1/a_8640_n1600# divbuf_1/OUT3 0.00fF
C7705 divbuf_1/a_36000_n1600# divbuf_1/a_36030_n1540# 0.19fF
C7706 pll_full_0/divbuf_0/a_14910_n1540# pll_full_0/divbuf_0/a_15390_n1540# 0.11fF
C7707 pll_full_0/divbuf_0/a_45630_n840# pll_full_0/divbuf_0/a_45630_n1540# 0.01fF
C7708 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_35550_n840# 0.04fF
C7709 divbuf_0/a_36510_n840# divbuf_0/a_36510_n1540# 0.01fF
C7710 divbuf_0/a_5790_n1540# divbuf_0/a_6270_n1540# 0.11fF
C7711 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/a_27322_n240# 0.04fF
C7712 divbuf_2/a_25862_170# divbuf_2/a_26352_170# 0.07fF
C7713 divbuf_2/a_5852_170# divbuf_2/a_5852_n240# 0.01fF
C7714 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/a_6332_n240# 0.05fF
C7715 pll_full_0/divbuf_1/a_8190_n840# pll_full_0/divbuf_1/a_8190_n1540# 0.01fF
C7716 pll_full_0/divbuf_1/a_38430_n840# pll_full_0/divbuf_1/a_38910_n840# 0.07fF
C7717 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C7718 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38430_n1540# 0.19fF
C7719 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C7720 divbuf_2/a_59040_n1600# divbuf_2/a_59520_n1600# 0.26fF
C7721 divbuf_2/a_13742_170# divbuf_2/OUT4 0.19fF
C7722 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12510_n840# 0.04fF
C7723 divbuf_2/a_51390_n1540# divbuf_2/a_51870_n1540# 0.11fF
C7724 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z4 0.02fF
C7725 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_15870_n840# 0.01fF
C7726 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C7727 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n840# 0.04fF
C7728 divbuf_3/a_12282_n240# divbuf_3/a_12510_n840# 0.02fF
C7729 divbuf_3/a_21600_n1600# divbuf_3/a_22080_n1600# 0.26fF
C7730 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/a_7710_n840# 0.03fF
C7731 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17760_n1600# 0.26fF
C7732 divbuf_3/a_13950_n1540# divbuf_3/a_14430_n1540# 0.11fF
C7733 divbuf_3/a_44670_n840# divbuf_3/a_44670_n1540# 0.01fF
C7734 pd_div_0/divbuf_0/a_24990_n840# pd_div_0/divbuf_0/a_25470_n840# 0.07fF
C7735 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7736 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_24990_n1540# 0.19fF
C7737 ro_div_0/divbuf_0/a_40350_n840# ro_div_0/divbuf_0/a_40350_n1540# 0.01fF
C7738 ro_div_0/divbuf_0/a_9630_n1540# ro_div_0/divbuf_0/a_10110_n1540# 0.11fF
C7739 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/a_29742_170# 0.07fF
C7740 divbuf_2/a_14702_n240# divbuf_2/OUT4 0.04fF
C7741 divbuf_2/a_48960_n1600# divbuf_2/a_48990_n840# 0.04fF
C7742 divbuf_1/a_4392_170# divbuf_1/a_3912_170# 0.07fF
C7743 divbuf_0/a_20042_170# divbuf_0/a_20532_170# 0.07fF
C7744 pll_full_0/divbuf_0/a_1950_n840# pll_full_0/divbuf_0/a_2430_n840# 0.07fF
C7745 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7746 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_1950_n1540# 0.19fF
C7747 divbuf_1/a_13252_n240# divbuf_1/a_13470_n840# 0.02fF
C7748 divbuf_1/a_22560_n1600# divbuf_1/a_23040_n1600# 0.26fF
C7749 divbuf_0/a_53280_n1600# divbuf_0/a_53760_n1600# 0.26fF
C7750 divbuf_1/a_14910_n1540# divbuf_1/a_15390_n1540# 0.11fF
C7751 divbuf_1/a_45630_n840# divbuf_1/a_45630_n1540# 0.01fF
C7752 pll_full_0/divbuf_0/a_54750_n1540# pll_full_0/divbuf_0/a_55230_n1540# 0.11fF
C7753 divbuf_3/a_11520_n1600# divbuf_3/a_11550_n840# 0.04fF
C7754 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7230_n840# 0.04fF
C7755 divbuf_0/a_45630_n1540# divbuf_0/a_46110_n1540# 0.11fF
C7756 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_25440_n1600# 0.26fF
C7757 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_15870_n840# 0.02fF
C7758 divbuf_2/a_26832_n240# divbuf_2/a_27322_n240# 0.04fF
C7759 pll_full_0/divbuf_1/a_17310_n1540# pll_full_0/divbuf_1/a_17790_n1540# 0.11fF
C7760 pll_full_0/divbuf_1/a_48030_n840# pll_full_0/divbuf_1/a_48030_n1540# 0.01fF
C7761 divbuf_2/a_8190_n840# divbuf_2/a_8190_n1540# 0.01fF
C7762 divbuf_2/a_38430_n840# divbuf_2/a_38910_n840# 0.07fF
C7763 divbuf_2/a_12960_n1600# divbuf_2/OUT4 0.00fF
C7764 divbuf_2/a_38400_n1600# divbuf_2/a_38430_n1540# 0.19fF
C7765 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C7766 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/Out 0.05fF
C7767 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/clk 0.11fF
C7768 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52350_n840# 0.04fF
C7769 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7770 divbuf_3/a_8272_170# divbuf_3/a_8272_n240# 0.01fF
C7771 divbuf_3/a_28292_170# divbuf_3/a_28772_170# 0.07fF
C7772 divbuf_1/a_31682_170# divbuf_1/OUT4 0.19fF
C7773 divbuf_1/a_12480_n1600# divbuf_1/a_12510_n840# 0.04fF
C7774 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7775 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/a_1352_n240# 0.01fF
C7776 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/a_24412_170# 0.07fF
C7777 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n840# 0.04fF
C7778 divbuf_0/a_2322_n240# divbuf_0/OUT3 0.04fF
C7779 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_12000_n1600# 0.26fF
C7780 divbuf_3/a_960_n1600# divbuf_3/a_990_n1540# 0.19fF
C7781 divbuf_3/a_990_n840# divbuf_3/a_1470_n840# 0.07fF
C7782 divbuf_3/a_18582_170# divbuf_3/OUT4 0.19fF
C7783 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/OUT4 0.23fF
C7784 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57600_n1600# 0.26fF
C7785 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_14910_n840# 0.04fF
C7786 divbuf_3/a_53790_n1540# divbuf_3/a_54270_n1540# 0.11fF
C7787 pd_div_0/divbuf_0/a_3870_n1540# pd_div_0/divbuf_0/a_4350_n1540# 0.11fF
C7788 pd_div_0/divbuf_0/a_34590_n840# pd_div_0/divbuf_0/a_34590_n1540# 0.01fF
C7789 ro_div_0/divbuf_0/a_49470_n1540# ro_div_0/divbuf_0/a_49950_n1540# 0.11fF
C7790 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/a_30712_n240# 0.05fF
C7791 divbuf_1/a_25862_170# divbuf_1/a_26352_170# 0.07fF
C7792 divbuf_1/a_15672_170# divbuf_1/a_15672_n240# 0.01fF
C7793 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/a_32652_n240# 0.01fF
C7794 divbuf_0/a_21012_n240# divbuf_0/a_21502_n240# 0.04fF
C7795 divbuf_0/a_40902_170# divbuf_0/a_40902_n240# 0.01fF
C7796 pll_full_0/divbuf_0/a_11550_n840# pll_full_0/divbuf_0/a_11550_n1540# 0.01fF
C7797 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/a_42270_n840# 0.07fF
C7798 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7799 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_41790_n1540# 0.19fF
C7800 divbuf_1/a_8762_170# divbuf_1/OUT3 0.19fF
C7801 divbuf_1/a_1950_n840# divbuf_1/a_2430_n840# 0.07fF
C7802 divbuf_1/a_1920_n1600# divbuf_1/a_1950_n1540# 0.19fF
C7803 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1470_n840# 0.04fF
C7804 divbuf_0/a_32670_n840# divbuf_0/a_33150_n840# 0.07fF
C7805 divbuf_0/a_2430_n840# divbuf_0/a_2430_n1540# 0.01fF
C7806 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n1540# 0.19fF
C7807 divbuf_0/a_2400_n1600# divbuf_0/OUT2 0.00fF
C7808 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/a_12282_n240# 0.01fF
C7809 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/a_32172_170# 0.07fF
C7810 divbuf_3/a_51360_n1600# divbuf_3/a_51390_n840# 0.04fF
C7811 divbuf_3/a_19562_n240# divbuf_3/OUT4 0.04fF
C7812 divbuf_1/a_54750_n1540# divbuf_1/a_55230_n1540# 0.11fF
C7813 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/a_8762_170# 0.07fF
C7814 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47070_n840# 0.04fF
C7815 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7816 pll_full_0/divbuf_1/a_4350_n840# pll_full_0/divbuf_1/a_4830_n840# 0.07fF
C7817 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7818 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4350_n1540# 0.19fF
C7819 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C7820 divbuf_2/a_24960_n1600# divbuf_2/a_25440_n1600# 0.26fF
C7821 divbuf_2/a_15672_n240# divbuf_2/a_15870_n840# 0.02fF
C7822 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_3/vin 0.20fF
C7823 pll_full_0/divbuf_1/a_57150_n1540# pll_full_0/divbuf_1/a_57630_n1540# 0.11fF
C7824 divbuf_2/a_17310_n1540# divbuf_2/a_17790_n1540# 0.11fF
C7825 divbuf_2/a_48030_n840# divbuf_2/a_48030_n1540# 0.01fF
C7826 divbuf_1/a_28292_170# divbuf_1/a_28292_n240# 0.01fF
C7827 divbuf_3/a_29262_n240# divbuf_3/a_29742_n240# 0.05fF
C7828 divbuf_1/a_52320_n1600# divbuf_1/a_52350_n840# 0.04fF
C7829 divbuf_1/a_21502_n240# divbuf_1/OUT4 0.04fF
C7830 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/a_25382_n240# 0.04fF
C7831 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51840_n1600# 0.26fF
C7832 divbuf_3/a_10590_n840# divbuf_3/a_10590_n1540# 0.01fF
C7833 divbuf_3/a_40830_n840# divbuf_3/a_41310_n840# 0.07fF
C7834 divbuf_3/a_40800_n1600# divbuf_3/a_40830_n1540# 0.19fF
C7835 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/a_10212_n240# 0.01fF
C7836 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36510_n1540# 0.19fF
C7837 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C7838 ro_div_0/divbuf_0/a_36510_n840# ro_div_0/divbuf_0/a_36990_n840# 0.07fF
C7839 ro_div_0/divbuf_0/a_6270_n840# ro_div_0/divbuf_0/a_6270_n1540# 0.01fF
C7840 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7841 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_54750_n840# 0.04fF
C7842 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_7302_170# 0.07fF
C7843 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C7844 divbuf_2/a_14880_n1600# divbuf_2/a_14910_n840# 0.04fF
C7845 pd_div_0/divbuf_0/a_43710_n1540# pd_div_0/divbuf_0/a_44190_n1540# 0.11fF
C7846 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C7847 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C7848 divbuf_0/a_1842_170# divbuf_0/OUT2 0.19fF
C7849 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C7850 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28800_n1600# 0.26fF
C7851 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/a_19230_n840# 0.02fF
C7852 divbuf_1/a_30232_n240# divbuf_1/a_30712_n240# 0.05fF
C7853 pd_0/DIV pd_0/R 0.51fF
C7854 divbuf_0/a_9732_n240# divbuf_0/a_9630_n840# 0.03fF
C7855 divbuf_0/a_19200_n1600# divbuf_0/a_19680_n1600# 0.26fF
C7856 divbuf_1/a_11550_n840# divbuf_1/a_11550_n1540# 0.01fF
C7857 divbuf_1/a_41790_n840# divbuf_1/a_42270_n840# 0.07fF
C7858 divbuf_1/a_19680_n1600# divbuf_1/OUT4 0.00fF
C7859 divbuf_1/a_41760_n1600# divbuf_1/a_41790_n1540# 0.19fF
C7860 pll_full_0/divbuf_0/a_20670_n1540# pll_full_0/divbuf_0/a_21150_n1540# 0.11fF
C7861 pll_full_0/divbuf_0/a_51390_n840# pll_full_0/divbuf_0/a_51390_n1540# 0.01fF
C7862 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41310_n840# 0.04fF
C7863 divbuf_0/a_42270_n840# divbuf_0/a_42270_n1540# 0.01fF
C7864 divbuf_0/a_11550_n1540# divbuf_0/a_12030_n1540# 0.11fF
C7865 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/a_33142_n240# 0.04fF
C7866 divbuf_2/a_12282_170# divbuf_2/a_12282_n240# 0.01fF
C7867 divbuf_2/a_31682_170# divbuf_2/a_32172_170# 0.07fF
C7868 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12772_n240# 0.04fF
C7869 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C7870 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44190_n1540# 0.19fF
C7871 pll_full_0/divbuf_1/a_13950_n840# pll_full_0/divbuf_1/a_13950_n1540# 0.01fF
C7872 pll_full_0/divbuf_1/a_44190_n840# pll_full_0/divbuf_1/a_44670_n840# 0.07fF
C7873 divbuf_2/a_4350_n840# divbuf_2/a_4830_n840# 0.07fF
C7874 divbuf_2/a_25382_170# divbuf_2/OUT4 0.19fF
C7875 divbuf_2/a_4320_n1600# divbuf_2/a_4350_n1540# 0.19fF
C7876 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C7877 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C7878 divbuf_0/a_6822_170# divbuf_0/a_7302_170# 0.07fF
C7879 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C7880 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18270_n840# 0.04fF
C7881 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/OUT3 0.19fF
C7882 divbuf_2/a_57150_n1540# divbuf_2/a_57630_n1540# 0.11fF
C7883 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n840# 0.04fF
C7884 divbuf_3/a_27360_n1600# divbuf_3/a_27840_n1600# 0.26fF
C7885 divbuf_3/a_18092_n240# divbuf_3/a_18270_n840# 0.02fF
C7886 pd_div_0/divbuf_0/a_30750_n840# pd_div_0/divbuf_0/a_31230_n840# 0.07fF
C7887 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7888 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/a_510_n1540# 0.01fF
C7889 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_30750_n1540# 0.19fF
C7890 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23520_n1600# 0.26fF
C7891 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_13950_n840# 0.02fF
C7892 divbuf_3/a_19710_n1540# divbuf_3/a_20190_n1540# 0.11fF
C7893 divbuf_3/a_50430_n840# divbuf_3/a_50430_n1540# 0.01fF
C7894 ro_div_0/divbuf_0/a_46110_n840# ro_div_0/divbuf_0/a_46110_n1540# 0.01fF
C7895 ro_div_0/divbuf_0/a_15390_n1540# ro_div_0/divbuf_0/a_15870_n1540# 0.11fF
C7896 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/a_35562_170# 0.07fF
C7897 divbuf_2/a_26352_n240# divbuf_2/OUT4 0.04fF
C7898 divbuf_2/a_54720_n1600# divbuf_2/a_54750_n840# 0.04fF
C7899 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C7900 divbuf_0/a_25862_170# divbuf_0/a_26352_170# 0.07fF
C7901 pll_full_0/divbuf_0/a_7710_n840# pll_full_0/divbuf_0/a_8190_n840# 0.07fF
C7902 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7903 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_7710_n1540# 0.19fF
C7904 divbuf_1/a_28320_n1600# divbuf_1/a_28800_n1600# 0.26fF
C7905 divbuf_1/a_19072_n240# divbuf_1/a_19230_n840# 0.02fF
C7906 divbuf_0/a_13252_170# divbuf_0/OUT4 0.19fF
C7907 divbuf_0/a_59040_n1600# divbuf_0/a_59520_n1600# 0.26fF
C7908 divbuf_1/a_20670_n1540# divbuf_1/a_21150_n1540# 0.11fF
C7909 divbuf_1/a_51390_n840# divbuf_1/a_51390_n1540# 0.01fF
C7910 pll_full_0/divbuf_0/a_60510_n1540# pll_full_0/divbuf_0/a_60990_n1540# 0.11fF
C7911 divbuf_3/a_17280_n1600# divbuf_3/a_17310_n840# 0.04fF
C7912 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_12990_n840# 0.04fF
C7913 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/OUT3 0.19fF
C7914 divbuf_0/a_51390_n1540# divbuf_0/a_51870_n1540# 0.11fF
C7915 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_31200_n1600# 0.26fF
C7916 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/a_21630_n840# 0.03fF
C7917 divbuf_2/a_32652_n240# divbuf_2/a_33142_n240# 0.04fF
C7918 pll_full_0/divbuf_1/a_23070_n1540# pll_full_0/divbuf_1/a_23550_n1540# 0.11fF
C7919 pll_full_0/divbuf_1/a_53790_n840# pll_full_0/divbuf_1/a_53790_n1540# 0.01fF
C7920 divbuf_2/a_24480_n1600# divbuf_2/OUT4 0.00fF
C7921 divbuf_2/a_44160_n1600# divbuf_2/a_44190_n1540# 0.19fF
C7922 divbuf_2/a_13950_n840# divbuf_2/a_13950_n1540# 0.01fF
C7923 divbuf_2/a_44190_n840# divbuf_2/a_44670_n840# 0.07fF
C7924 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7925 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58110_n840# 0.04fF
C7926 divbuf_3/a_14702_170# divbuf_3/a_14702_n240# 0.01fF
C7927 divbuf_3/a_34112_170# divbuf_3/a_34592_170# 0.07fF
C7928 divbuf_1/a_18240_n1600# divbuf_1/a_18270_n840# 0.04fF
C7929 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7930 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/a_30232_170# 0.07fF
C7931 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n840# 0.04fF
C7932 divbuf_0/a_14702_n240# divbuf_0/OUT4 0.04fF
C7933 io_clamp_high[2] io_analog[6] 0.53fF
C7934 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17760_n1600# 0.26fF
C7935 divbuf_3/a_6750_n840# divbuf_3/a_7230_n840# 0.07fF
C7936 divbuf_3/a_30232_170# divbuf_3/OUT4 0.19fF
C7937 divbuf_3/a_6720_n1600# divbuf_3/a_6750_n1540# 0.19fF
C7938 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2430_n1540# 0.19fF
C7939 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7940 ro_div_0/divbuf_0/a_2430_n840# ro_div_0/divbuf_0/a_2910_n840# 0.07fF
C7941 divbuf_0/a_1842_170# divbuf_0/a_1352_170# 0.07fF
C7942 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_20670_n840# 0.04fF
C7943 divbuf_3/a_59550_n1540# divbuf_3/a_60030_n1540# 0.11fF
C7944 pd_div_0/divbuf_0/a_9630_n1540# pd_div_0/divbuf_0/a_10110_n1540# 0.11fF
C7945 pd_div_0/divbuf_0/a_40350_n840# pd_div_0/divbuf_0/a_40350_n1540# 0.01fF
C7946 ro_div_0/divbuf_0/a_55230_n1540# ro_div_0/divbuf_0/a_55710_n1540# 0.11fF
C7947 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/a_36532_n240# 0.05fF
C7948 divbuf_1/a_35082_170# divbuf_1/a_35562_170# 0.07fF
C7949 divbuf_1/a_9242_170# divbuf_1/a_9242_n240# 0.01fF
C7950 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/a_38472_n240# 0.01fF
C7951 divbuf_0/a_26832_n240# divbuf_0/a_27322_n240# 0.04fF
C7952 pll_full_0/divbuf_0/a_17310_n840# pll_full_0/divbuf_0/a_17310_n1540# 0.01fF
C7953 pll_full_0/divbuf_0/a_47550_n840# pll_full_0/divbuf_0/a_48030_n840# 0.07fF
C7954 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7955 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_47550_n1540# 0.19fF
C7956 divbuf_1/a_7710_n840# divbuf_1/a_8190_n840# 0.07fF
C7957 divbuf_1/a_28772_170# divbuf_1/OUT4 0.19fF
C7958 divbuf_1/a_7680_n1600# divbuf_1/a_7710_n1540# 0.19fF
C7959 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n1540# 0.19fF
C7960 divbuf_0/a_12960_n1600# divbuf_0/OUT4 0.00fF
C7961 divbuf_0/a_38430_n840# divbuf_0/a_38910_n840# 0.07fF
C7962 divbuf_0/a_8190_n840# divbuf_0/a_8190_n1540# 0.01fF
C7963 divbuf_1/a_60510_n1540# divbuf_1/a_60990_n1540# 0.11fF
C7964 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7230_n840# 0.04fF
C7965 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/a_37992_170# 0.07fF
C7966 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/a_18092_n240# 0.01fF
C7967 divbuf_3/a_31202_n240# divbuf_3/OUT4 0.04fF
C7968 divbuf_3/a_57120_n1600# divbuf_3/a_57150_n840# 0.04fF
C7969 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/a_17612_170# 0.07fF
C7970 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7971 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_52830_n840# 0.04fF
C7972 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10110_n1540# 0.19fF
C7973 pll_full_0/divbuf_1/a_10110_n840# pll_full_0/divbuf_1/a_10590_n840# 0.07fF
C7974 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7975 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C7976 divbuf_2/a_30720_n1600# divbuf_2/a_31200_n1600# 0.26fF
C7977 divbuf_2/a_21502_n240# divbuf_2/a_21630_n840# 0.03fF
C7978 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/nor_1/B 0.06fF
C7979 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 0.36fF
C7980 divbuf_2/a_23070_n1540# divbuf_2/a_23550_n1540# 0.11fF
C7981 divbuf_2/a_53790_n840# divbuf_2/a_53790_n1540# 0.01fF
C7982 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/OUT4 0.03fF
C7983 divbuf_3/a_35082_n240# divbuf_3/a_35562_n240# 0.05fF
C7984 divbuf_1/a_33142_n240# divbuf_1/OUT4 0.04fF
C7985 divbuf_1/a_58080_n1600# divbuf_1/a_58110_n840# 0.04fF
C7986 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/a_31202_n240# 0.04fF
C7987 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57600_n1600# 0.26fF
C7988 divbuf_3/a_16350_n840# divbuf_3/a_16350_n1540# 0.01fF
C7989 divbuf_3/a_46590_n840# divbuf_3/a_47070_n840# 0.07fF
C7990 divbuf_3/a_46560_n1600# divbuf_3/a_46590_n1540# 0.19fF
C7991 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42270_n1540# 0.19fF
C7992 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C7993 ro_div_0/divbuf_0/a_42270_n840# ro_div_0/divbuf_0/a_42750_n840# 0.07fF
C7994 ro_div_0/divbuf_0/a_12030_n840# ro_div_0/divbuf_0/a_12030_n1540# 0.01fF
C7995 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7996 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/a_60510_n840# 0.04fF
C7997 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/a_13742_170# 0.07fF
C7998 divbuf_2/a_20640_n1600# divbuf_2/a_20670_n840# 0.04fF
C7999 pd_div_0/divbuf_0/a_49470_n1540# pd_div_0/divbuf_0/a_49950_n1540# 0.11fF
C8000 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/prescaler_0/Out 0.28fF
C8001 divbuf_0/a_17122_170# divbuf_0/a_16642_170# 0.07fF
C8002 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C8003 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C8004 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/a_24990_n840# 0.03fF
C8005 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34560_n1600# 0.26fF
C8006 divbuf_1/a_36052_n240# divbuf_1/a_36532_n240# 0.05fF
C8007 pd_div_0/div pd_div_0/divbuf_0/a_510_n1540# 0.11fF
C8008 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/a_7230_n840# 0.03fF
C8009 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C8010 divbuf_0/a_15672_n240# divbuf_0/a_15870_n840# 0.02fF
C8011 divbuf_0/a_24960_n1600# divbuf_0/a_25440_n1600# 0.26fF
C8012 divbuf_1/a_17310_n840# divbuf_1/a_17310_n1540# 0.01fF
C8013 divbuf_1/a_47550_n840# divbuf_1/a_48030_n840# 0.07fF
C8014 divbuf_1/a_31200_n1600# divbuf_1/OUT4 0.00fF
C8015 divbuf_1/a_47520_n1600# divbuf_1/a_47550_n1540# 0.19fF
C8016 pll_full_0/divbuf_0/a_26430_n1540# pll_full_0/divbuf_0/a_26910_n1540# 0.11fF
C8017 pll_full_0/divbuf_0/a_57150_n840# pll_full_0/divbuf_0/a_57150_n1540# 0.01fF
C8018 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47070_n840# 0.04fF
C8019 divbuf_0/a_48030_n840# divbuf_0/a_48030_n1540# 0.01fF
C8020 divbuf_0/a_17310_n1540# divbuf_0/a_17790_n1540# 0.11fF
C8021 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/a_38962_n240# 0.04fF
C8022 divbuf_2/a_37502_170# divbuf_2/a_37992_170# 0.07fF
C8023 divbuf_2/a_18092_170# divbuf_2/a_18092_n240# 0.01fF
C8024 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_18582_n240# 0.04fF
C8025 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/OUT2 0.02fF
C8026 pll_full_0/divbuf_1/a_19710_n840# pll_full_0/divbuf_1/a_19710_n1540# 0.01fF
C8027 pll_full_0/divbuf_1/a_49950_n840# pll_full_0/divbuf_1/a_50430_n840# 0.07fF
C8028 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C8029 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_49950_n1540# 0.19fF
C8030 divbuf_2/a_10080_n1600# divbuf_2/a_10110_n1540# 0.19fF
C8031 divbuf_2/a_10110_n840# divbuf_2/a_10590_n840# 0.07fF
C8032 divbuf_2/a_37022_170# divbuf_2/OUT4 0.19fF
C8033 divbuf_0/a_18582_170# divbuf_0/a_18582_n240# 0.01fF
C8034 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C8035 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divbuf_0/IN 0.05fF
C8036 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24030_n840# 0.04fF
C8037 divbuf_2/OUT2 divbuf_2/OUT3 0.36fF
C8038 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/a5 0.09fF
C8039 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/a4 0.09fF
C8040 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C8041 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n840# 0.04fF
C8042 divbuf_3/a_23922_n240# divbuf_3/a_24030_n840# 0.03fF
C8043 divbuf_3/a_33120_n1600# divbuf_3/a_33600_n1600# 0.26fF
C8044 divbuf_1/a_10590_n840# divbuf_1/OUT4 0.03fF
C8045 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/a_25382_n240# 0.04fF
C8046 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/a_19710_n840# 0.03fF
C8047 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_29280_n1600# 0.26fF
C8048 pd_div_0/divbuf_0/a_6270_n840# pd_div_0/divbuf_0/a_6270_n1540# 0.01fF
C8049 pd_div_0/divbuf_0/a_36510_n840# pd_div_0/divbuf_0/a_36990_n840# 0.07fF
C8050 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C8051 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36510_n1540# 0.19fF
C8052 divbuf_3/a_25470_n1540# divbuf_3/a_25950_n1540# 0.11fF
C8053 divbuf_3/a_56190_n840# divbuf_3/a_56190_n1540# 0.01fF
C8054 ro_div_0/divbuf_0/a_51870_n840# ro_div_0/divbuf_0/a_51870_n1540# 0.01fF
C8055 ro_div_0/divbuf_0/a_21150_n1540# ro_div_0/divbuf_0/a_21630_n1540# 0.11fF
C8056 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/a_21502_n240# 0.01fF
C8057 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/a_41382_170# 0.07fF
C8058 divbuf_2/a_37992_n240# divbuf_2/OUT4 0.04fF
C8059 divbuf_2/a_60480_n1600# divbuf_2/a_60510_n840# 0.04fF
C8060 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C8061 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C8062 divbuf_0/a_31682_170# divbuf_0/a_32172_170# 0.07fF
C8063 divbuf_0/a_12282_170# divbuf_0/a_12282_n240# 0.01fF
C8064 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C8065 pll_full_0/divbuf_0/a_13470_n840# pll_full_0/divbuf_0/a_13950_n840# 0.07fF
C8066 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13470_n1540# 0.19fF
C8067 divbuf_1/a_24892_n240# divbuf_1/a_24990_n840# 0.03fF
C8068 divbuf_1/a_34080_n1600# divbuf_1/a_34560_n1600# 0.26fF
C8069 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n1540# 0.19fF
C8070 divbuf_0/a_25382_170# divbuf_0/OUT4 0.19fF
C8071 divbuf_0/a_4350_n840# divbuf_0/a_4830_n840# 0.07fF
C8072 divbuf_3/a_1352_170# divbuf_3/OUT2 0.23fF
C8073 divbuf_3/a_23040_n1600# divbuf_3/a_23070_n840# 0.04fF
C8074 divbuf_1/a_26430_n1540# divbuf_1/a_26910_n1540# 0.11fF
C8075 divbuf_1/a_57150_n840# divbuf_1/a_57150_n1540# 0.01fF
C8076 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/a_2322_170# 0.07fF
C8077 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_18750_n840# 0.04fF
C8078 divbuf_0/a_57150_n1540# divbuf_0/a_57630_n1540# 0.11fF
C8079 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/a_27390_n840# 0.04fF
C8080 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36960_n1600# 0.26fF
C8081 divbuf_2/a_38472_n240# divbuf_2/a_38962_n240# 0.04fF
C8082 pll_full_0/divbuf_1/a_28830_n1540# pll_full_0/divbuf_1/a_29310_n1540# 0.11fF
C8083 pll_full_0/divbuf_1/a_59550_n840# pll_full_0/divbuf_1/a_59550_n1540# 0.01fF
C8084 divbuf_2/a_19710_n840# divbuf_2/a_19710_n1540# 0.01fF
C8085 divbuf_2/a_49950_n840# divbuf_2/a_50430_n840# 0.07fF
C8086 divbuf_2/a_36000_n1600# divbuf_2/OUT4 0.00fF
C8087 divbuf_2/a_49920_n1600# divbuf_2/a_49950_n1540# 0.19fF
C8088 divbuf_3/a_20532_170# divbuf_3/a_20532_n240# 0.01fF
C8089 divbuf_3/a_39932_170# divbuf_3/a_40412_170# 0.07fF
C8090 divbuf_1/a_24000_n1600# divbuf_1/a_24030_n840# 0.04fF
C8091 divbuf_1/a_15182_170# divbuf_1/OUT4 0.19fF
C8092 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C8093 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/a_36052_170# 0.07fF
C8094 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n840# 0.04fF
C8095 divbuf_0/a_26352_n240# divbuf_0/OUT4 0.04fF
C8096 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23520_n1600# 0.26fF
C8097 divbuf_3/a_2322_n240# divbuf_3/OUT2 0.04fF
C8098 divbuf_3/a_12510_n840# divbuf_3/a_12990_n840# 0.07fF
C8099 divbuf_3/a_41382_170# divbuf_3/OUT5 0.07fF
C8100 divbuf_3/a_12480_n1600# divbuf_3/a_12510_n1540# 0.19fF
C8101 pd_div_0/pd_0/UP pd_div_0/pd_0/tspc_r_1/z5 0.03fF
C8102 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8190_n1540# 0.19fF
C8103 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8104 ro_div_0/divbuf_0/a_8190_n840# ro_div_0/divbuf_0/a_8670_n840# 0.07fF
C8105 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/OUT3 0.19fF
C8106 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26430_n840# 0.04fF
C8107 pd_div_0/divbuf_0/a_15390_n1540# pd_div_0/divbuf_0/a_15870_n1540# 0.11fF
C8108 pd_div_0/divbuf_0/a_46110_n840# pd_div_0/divbuf_0/a_46110_n1540# 0.01fF
C8109 pll_full_0/divbuf_0/a_0_n1600# pll_full_0/divbuf_0/a_480_n1600# 0.26fF
C8110 divbuf_1/a_40902_170# divbuf_1/a_41382_170# 0.07fF
C8111 divbuf_0/a_32652_n240# divbuf_0/a_33142_n240# 0.04fF
C8112 pll_full_0/divbuf_0/a_23070_n840# pll_full_0/divbuf_0/a_23070_n1540# 0.01fF
C8113 pll_full_0/divbuf_0/a_53310_n840# pll_full_0/divbuf_0/a_53790_n840# 0.07fF
C8114 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53310_n1540# 0.19fF
C8115 divbuf_1/a_4392_n240# divbuf_1/OUT3 0.04fF
C8116 divbuf_1/a_13470_n840# divbuf_1/a_13950_n840# 0.07fF
C8117 divbuf_1/a_13440_n1600# divbuf_1/a_13470_n1540# 0.19fF
C8118 divbuf_0/a_44190_n840# divbuf_0/a_44670_n840# 0.07fF
C8119 divbuf_0/a_13950_n840# divbuf_0/a_13950_n1540# 0.01fF
C8120 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n1540# 0.19fF
C8121 divbuf_0/a_24480_n1600# divbuf_0/OUT4 0.00fF
C8122 divbuf_2/a_1842_170# divbuf_2/a_2322_170# 0.07fF
C8123 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_12990_n840# 0.04fF
C8124 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/a_3912_n240# 0.04fF
C8125 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/a_23922_n240# 0.01fF
C8126 divbuf_3/a_0_n1600# divbuf_3/OUT 0.26fF
C8127 divbuf_3/a_1920_n1600# divbuf_3/OUT2 0.00fF
C8128 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/a_23442_170# 0.07fF
C8129 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_58590_n840# 0.04fF
C8130 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8131 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C8132 pll_full_0/divbuf_1/a_15870_n840# pll_full_0/divbuf_1/a_16350_n840# 0.07fF
C8133 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_15870_n1540# 0.19fF
C8134 divbuf_2/a_27322_n240# divbuf_2/a_27390_n840# 0.04fF
C8135 divbuf_2/a_36480_n1600# divbuf_2/a_36960_n1600# 0.26fF
C8136 divbuf_2/a_28830_n1540# divbuf_2/a_29310_n1540# 0.11fF
C8137 divbuf_2/a_59550_n840# divbuf_2/a_59550_n1540# 0.01fF
C8138 divbuf_3/a_40902_n240# divbuf_3/a_41382_n240# 0.05fF
C8139 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/a_37022_n240# 0.04fF
C8140 pd_div_0/divbuf_0/a_2430_n840# pd_div_0/divbuf_0/a_2910_n840# 0.07fF
C8141 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2430_n1540# 0.19fF
C8142 divbuf_3/a_22110_n840# divbuf_3/a_22110_n1540# 0.01fF
C8143 divbuf_3/a_52350_n840# divbuf_3/a_52830_n840# 0.07fF
C8144 divbuf_3/a_52320_n1600# divbuf_3/a_52350_n1540# 0.19fF
C8145 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48030_n1540# 0.19fF
C8146 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C8147 ro_div_0/divbuf_0/a_48030_n840# ro_div_0/divbuf_0/a_48510_n840# 0.07fF
C8148 ro_div_0/divbuf_0/a_17790_n840# ro_div_0/divbuf_0/a_17790_n1540# 0.01fF
C8149 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C8150 divbuf_2/a_8272_170# divbuf_2/OUT3 0.19fF
C8151 divbuf_2/a_26400_n1600# divbuf_2/a_26430_n840# 0.04fF
C8152 pd_div_0/divbuf_0/a_55230_n1540# pd_div_0/divbuf_0/a_55710_n1540# 0.11fF
C8153 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/Out 0.91fF
C8154 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/B 0.01fF
C8155 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_40320_n1600# 0.26fF
C8156 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/a_30750_n840# 0.05fF
C8157 divbuf_1/a_0_n1600# divbuf_1/a_480_n1600# 0.26fF
C8158 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_13470_n840# 0.02fF
C8159 divbuf_0/a_21502_n240# divbuf_0/a_21630_n840# 0.03fF
C8160 divbuf_0/a_30720_n1600# divbuf_0/a_31200_n1600# 0.26fF
C8161 divbuf_1/a_23070_n840# divbuf_1/a_23070_n1540# 0.01fF
C8162 divbuf_1/a_53310_n840# divbuf_1/a_53790_n840# 0.07fF
C8163 divbuf_1/a_53280_n1600# divbuf_1/a_53310_n1540# 0.19fF
C8164 pll_full_0/divbuf_0/a_32190_n1540# pll_full_0/divbuf_0/a_32670_n1540# 0.11fF
C8165 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_52830_n840# 0.04fF
C8166 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8167 divbuf_0/a_53790_n840# divbuf_0/a_53790_n1540# 0.01fF
C8168 divbuf_0/a_23070_n1540# divbuf_0/a_23550_n1540# 0.11fF
C8169 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2880_n1600# 0.26fF
C8170 divbuf_2/a_3422_n240# divbuf_2/a_3912_n240# 0.04fF
C8171 divbuf_2/a_23922_170# divbuf_2/a_23922_n240# 0.01fF
C8172 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_55710_n1540# 0.19fF
C8173 pll_full_0/divbuf_1/a_25470_n840# pll_full_0/divbuf_1/a_25470_n1540# 0.01fF
C8174 pll_full_0/divbuf_1/a_55710_n840# pll_full_0/divbuf_1/a_56190_n840# 0.07fF
C8175 divbuf_2/a_9242_n240# divbuf_2/OUT3 0.04fF
C8176 divbuf_2/a_15870_n840# divbuf_2/a_16350_n840# 0.07fF
C8177 divbuf_2/a_15840_n1600# divbuf_2/a_15870_n1540# 0.19fF
C8178 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/nor_1/B 0.06fF
C8179 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C8180 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_29790_n840# 0.04fF
C8181 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8182 divbuf_3/a_4882_170# divbuf_3/a_5362_170# 0.07fF
C8183 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/a_14222_170# 0.07fF
C8184 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n840# 0.04fF
C8185 divbuf_0/a_4392_170# divbuf_0/OUT3 0.19fF
C8186 divbuf_3/a_29742_n240# divbuf_3/a_29790_n840# 0.04fF
C8187 divbuf_3/a_38880_n1600# divbuf_3/a_39360_n1600# 0.26fF
C8188 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/a_31202_n240# 0.04fF
C8189 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_35040_n1600# 0.26fF
C8190 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/a_25470_n840# 0.03fF
C8191 pd_div_0/divbuf_0/a_12030_n840# pd_div_0/divbuf_0/a_12030_n1540# 0.01fF
C8192 pd_div_0/divbuf_0/a_42270_n840# pd_div_0/divbuf_0/a_42750_n840# 0.07fF
C8193 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C8194 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42270_n1540# 0.19fF
C8195 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_12990_n840# 0.01fF
C8196 divbuf_3/a_31230_n1540# divbuf_3/a_31710_n1540# 0.11fF
C8197 ro_div_0/divbuf_0/a_57630_n840# ro_div_0/divbuf_0/a_57630_n1540# 0.01fF
C8198 ro_div_0/divbuf_0/a_26910_n1540# ro_div_0/divbuf_0/a_27390_n1540# 0.11fF
C8199 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/a_7302_n240# 0.05fF
C8200 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/a_27322_n240# 0.01fF
C8201 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/prescaler_0/Out 0.28fF
C8202 divbuf_0/a_37502_170# divbuf_0/a_37992_170# 0.07fF
C8203 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8204 pll_full_0/divbuf_0/a_19230_n840# pll_full_0/divbuf_0/a_19710_n840# 0.07fF
C8205 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19230_n1540# 0.19fF
C8206 divbuf_1/a_39840_n1600# divbuf_1/a_40320_n1600# 0.26fF
C8207 divbuf_1/a_30712_n240# divbuf_1/a_30750_n840# 0.05fF
C8208 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8209 divbuf_0/a_37022_170# divbuf_0/OUT4 0.19fF
C8210 divbuf_0/a_10110_n840# divbuf_0/a_10590_n840# 0.07fF
C8211 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n1540# 0.19fF
C8212 divbuf_3/a_28800_n1600# divbuf_3/a_28830_n840# 0.04fF
C8213 divbuf_3/a_13252_170# divbuf_3/OUT4 0.19fF
C8214 divbuf_1/a_32190_n1540# divbuf_1/a_32670_n1540# 0.11fF
C8215 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/a_8762_170# 0.07fF
C8216 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24510_n840# 0.04fF
C8217 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/OUT2 0.02fF
C8218 divbuf_0/OUT2 divbuf_0/OUT3 0.36fF
C8219 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42720_n1600# 0.26fF
C8220 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/a_33150_n840# 0.06fF
C8221 divbuf_2/a_2400_n1600# divbuf_2/a_2880_n1600# 0.26fF
C8222 pll_full_0/divbuf_1/a_34590_n1540# pll_full_0/divbuf_1/a_35070_n1540# 0.11fF
C8223 divbuf_2/a_55680_n1600# divbuf_2/a_55710_n1540# 0.19fF
C8224 divbuf_2/a_25470_n840# divbuf_2/a_25470_n1540# 0.01fF
C8225 divbuf_2/a_55710_n840# divbuf_2/a_56190_n840# 0.07fF
C8226 divbuf_3/a_5852_n240# divbuf_3/a_6332_n240# 0.05fF
C8227 divbuf_3/a_26352_170# divbuf_3/a_26352_n240# 0.01fF
C8228 divbuf_1/a_29760_n1600# divbuf_1/a_29790_n840# 0.04fF
C8229 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/a_21982_n240# 0.01fF
C8230 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n840# 0.04fF
C8231 divbuf_0/a_37992_n240# divbuf_0/OUT4 0.04fF
C8232 divbuf_3/a_14222_n240# divbuf_3/OUT4 0.04fF
C8233 divbuf_3/a_18270_n840# divbuf_3/a_18750_n840# 0.07fF
C8234 divbuf_3/a_18240_n1600# divbuf_3/a_18270_n1540# 0.19fF
C8235 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_29280_n1600# 0.26fF
C8236 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_13950_n1540# 0.19fF
C8237 ro_div_0/divbuf_0/a_13950_n840# ro_div_0/divbuf_0/a_14430_n840# 0.07fF
C8238 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C8239 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8240 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32190_n840# 0.04fF
C8241 divbuf_2/a_13252_n240# divbuf_2/a_12990_n840# 0.01fF
C8242 pd_div_0/divbuf_0/a_21150_n1540# pd_div_0/divbuf_0/a_21630_n1540# 0.11fF
C8243 pd_div_0/divbuf_0/a_51870_n840# pd_div_0/divbuf_0/a_51870_n1540# 0.01fF
C8244 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_6240_n1600# 0.26fF
C8245 divbuf_1/a_6822_n240# divbuf_1/a_7302_n240# 0.05fF
C8246 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_510_n840# 0.00fF
C8247 divbuf_0/a_38472_n240# divbuf_0/a_38962_n240# 0.04fF
C8248 pll_full_0/divbuf_0/a_28830_n840# pll_full_0/divbuf_0/a_28830_n1540# 0.01fF
C8249 pll_full_0/divbuf_0/a_59070_n840# pll_full_0/divbuf_0/a_59550_n840# 0.07fF
C8250 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59070_n1540# 0.19fF
C8251 divbuf_1/a_16152_n240# divbuf_1/OUT4 0.04fF
C8252 divbuf_1/a_19230_n840# divbuf_1/a_19710_n840# 0.07fF
C8253 divbuf_1/a_19200_n1600# divbuf_1/a_19230_n1540# 0.19fF
C8254 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n1540# 0.19fF
C8255 divbuf_0/a_36000_n1600# divbuf_0/OUT4 0.00fF
C8256 divbuf_0/a_49950_n840# divbuf_0/a_50430_n840# 0.07fF
C8257 divbuf_0/a_19710_n840# divbuf_0/a_19710_n1540# 0.01fF
C8258 divbuf_2/a_8272_170# divbuf_2/a_8762_170# 0.07fF
C8259 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_18750_n840# 0.04fF
C8260 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/a_29742_n240# 0.01fF
C8261 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/a_9732_n240# 0.04fF
C8262 divbuf_3/a_12480_n1600# divbuf_3/OUT4 0.00fF
C8263 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/a_29262_170# 0.07fF
C8264 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_21630_n1540# 0.19fF
C8265 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8266 pll_full_0/divbuf_1/a_21630_n840# pll_full_0/divbuf_1/a_22110_n840# 0.07fF
C8267 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C8268 divbuf_2/a_42240_n1600# divbuf_2/a_42720_n1600# 0.26fF
C8269 divbuf_2/a_33142_n240# divbuf_2/a_33150_n840# 0.06fF
C8270 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C8271 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_16350_n840# 0.00fF
C8272 divbuf_2/a_34590_n1540# divbuf_2/a_35070_n1540# 0.11fF
C8273 divbuf_3/a_4800_n1600# divbuf_3/a_5280_n1600# 0.26fF
C8274 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_960_n1600# 0.26fF
C8275 pd_div_0/divbuf_0/a_8190_n840# pd_div_0/divbuf_0/a_8670_n840# 0.07fF
C8276 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8190_n1540# 0.19fF
C8277 divbuf_3/a_27870_n840# divbuf_3/a_27870_n1540# 0.01fF
C8278 divbuf_3/a_58110_n840# divbuf_3/a_58590_n840# 0.07fF
C8279 divbuf_3/a_58080_n1600# divbuf_3/a_58110_n1540# 0.19fF
C8280 ro_div_0/divbuf_0/a_53790_n840# ro_div_0/divbuf_0/a_54270_n840# 0.07fF
C8281 ro_div_0/divbuf_0/a_23550_n840# ro_div_0/divbuf_0/a_23550_n1540# 0.01fF
C8282 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_53790_n1540# 0.19fF
C8283 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C8284 divbuf_2/a_20042_170# divbuf_2/OUT4 0.19fF
C8285 divbuf_2/a_32160_n1600# divbuf_2/a_32190_n840# 0.04fF
C8286 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/tspc_0/Z3 0.45fF
C8287 divbuf_0/a_7792_170# divbuf_0/a_8272_170# 0.07fF
C8288 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C8289 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/Out 0.19fF
C8290 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/a_36510_n840# 0.05fF
C8291 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_46080_n1600# 0.26fF
C8292 divbuf_1/a_5760_n1600# divbuf_1/a_6240_n1600# 0.26fF
C8293 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/a_19230_n840# 0.02fF
C8294 divbuf_0/a_36480_n1600# divbuf_0/a_36960_n1600# 0.26fF
C8295 divbuf_0/a_27322_n240# divbuf_0/a_27390_n840# 0.04fF
C8296 pll_full_0/divbuf_0/a_37950_n1540# pll_full_0/divbuf_0/a_38430_n1540# 0.11fF
C8297 divbuf_3/a_15672_n240# divbuf_3/a_15390_n840# 0.01fF
C8298 divbuf_1/a_28830_n840# divbuf_1/a_28830_n1540# 0.01fF
C8299 divbuf_1/a_59070_n840# divbuf_1/a_59550_n840# 0.07fF
C8300 divbuf_1/a_59040_n1600# divbuf_1/a_59070_n1540# 0.19fF
C8301 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11070_n840# 0.02fF
C8302 divbuf_2/a_29742_170# divbuf_2/a_29742_n240# 0.01fF
C8303 divbuf_2/a_9242_n240# divbuf_2/a_9732_n240# 0.04fF
C8304 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8305 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_58590_n840# 0.04fF
C8306 divbuf_0/a_59550_n840# divbuf_0/a_59550_n1540# 0.01fF
C8307 divbuf_0/a_28830_n1540# divbuf_0/a_29310_n1540# 0.11fF
C8308 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8640_n1600# 0.26fF
C8309 pll_full_0/divbuf_1/a_510_n1540# pll_full_0/divbuf_1/a_990_n1540# 0.11fF
C8310 pll_full_0/divbuf_1/a_31230_n840# pll_full_0/divbuf_1/a_31230_n1540# 0.01fF
C8311 divbuf_2/a_21600_n1600# divbuf_2/a_21630_n1540# 0.19fF
C8312 divbuf_2/a_21012_n240# divbuf_2/OUT4 0.04fF
C8313 divbuf_2/a_21630_n840# divbuf_2/a_22110_n840# 0.07fF
C8314 divbuf_1/a_1352_170# divbuf_1/a_1842_170# 0.07fF
C8315 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8316 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_35550_n840# 0.04fF
C8317 divbuf_3/a_11312_170# divbuf_3/a_11802_170# 0.07fF
C8318 divbuf_1/a_16642_n240# divbuf_1/a_16350_n840# 0.00fF
C8319 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n840# 0.04fF
C8320 divbuf_0/a_4882_170# divbuf_0/OUT3 0.19fF
C8321 divbuf_3/a_35562_n240# divbuf_3/a_35550_n840# 0.05fF
C8322 divbuf_3/a_44640_n1600# divbuf_3/a_45120_n1600# 0.26fF
C8323 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/a_37022_n240# 0.04fF
C8324 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/a_31230_n840# 0.05fF
C8325 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40800_n1600# 0.26fF
C8326 pd_div_0/divbuf_0/a_17790_n840# pd_div_0/divbuf_0/a_17790_n1540# 0.01fF
C8327 pd_div_0/divbuf_0/a_48030_n840# pd_div_0/divbuf_0/a_48510_n840# 0.07fF
C8328 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C8329 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48030_n1540# 0.19fF
C8330 divbuf_3/a_36990_n1540# divbuf_3/a_37470_n1540# 0.11fF
C8331 ro_div_0/divbuf_0/a_32670_n1540# ro_div_0/divbuf_0/a_33150_n1540# 0.11fF
C8332 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_13742_n240# 0.04fF
C8333 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/a_33142_n240# 0.01fF
C8334 divbuf_2/a_19200_n1600# divbuf_2/OUT4 0.00fF
C8335 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/B 0.01fF
C8336 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/Out 0.91fF
C8337 divbuf_0/a_23922_170# divbuf_0/a_23922_n240# 0.01fF
C8338 divbuf_0/a_3422_n240# divbuf_0/a_3912_n240# 0.04fF
C8339 pll_full_0/divbuf_0/a_24990_n840# pll_full_0/divbuf_0/a_25470_n840# 0.07fF
C8340 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8341 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_24990_n1540# 0.19fF
C8342 divbuf_1/a_36532_n240# divbuf_1/a_36510_n840# 0.05fF
C8343 divbuf_1/a_45600_n1600# divbuf_1/a_46080_n1600# 0.26fF
C8344 pd_div_0/div pd_div_0/bufin 0.26fF
C8345 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8346 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n1540# 0.19fF
C8347 divbuf_0/a_15870_n840# divbuf_0/a_16350_n840# 0.07fF
C8348 divbuf_0/a_9242_n240# divbuf_0/OUT3 0.04fF
C8349 divbuf_3/a_24892_170# divbuf_3/OUT4 0.19fF
C8350 divbuf_3/a_34560_n1600# divbuf_3/a_34590_n840# 0.04fF
C8351 divbuf_1/a_37950_n1540# divbuf_1/a_38430_n1540# 0.11fF
C8352 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/a_15182_170# 0.07fF
C8353 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8354 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30270_n840# 0.04fF
C8355 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/tspc_r_0/Qbar 0.01fF
C8356 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/R 0.27fF
C8357 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/a_38910_n840# 0.04fF
C8358 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48480_n1600# 0.26fF
C8359 divbuf_2/a_8160_n1600# divbuf_2/a_8640_n1600# 0.26fF
C8360 pll_full_0/divbuf_1/a_40350_n1540# pll_full_0/divbuf_1/a_40830_n1540# 0.11fF
C8361 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_510_n840# 0.00fF
C8362 divbuf_2/a_510_n1540# divbuf_2/a_990_n1540# 0.11fF
C8363 divbuf_2/a_31230_n840# divbuf_2/a_31230_n1540# 0.01fF
C8364 divbuf_3/a_32172_170# divbuf_3/a_32172_n240# 0.01fF
C8365 divbuf_3/a_12282_n240# divbuf_3/a_12772_n240# 0.04fF
C8366 divbuf_1/a_23442_170# divbuf_1/OUT4 0.19fF
C8367 divbuf_1/a_35520_n1600# divbuf_1/a_35550_n840# 0.04fF
C8368 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/a_27802_n240# 0.01fF
C8369 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/a_7792_n240# 0.04fF
C8370 divbuf_3/a_25862_n240# divbuf_3/OUT4 0.04fF
C8371 divbuf_3/a_24030_n840# divbuf_3/a_24510_n840# 0.07fF
C8372 divbuf_3/a_24000_n1600# divbuf_3/a_24030_n1540# 0.19fF
C8373 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/a_25470_n840# 0.03fF
C8374 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_35040_n1600# 0.26fF
C8375 ro_div_0/divbuf_0/a_19710_n840# ro_div_0/divbuf_0/a_20190_n840# 0.07fF
C8376 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8377 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_19710_n1540# 0.19fF
C8378 pd_div_0/divbuf_0/a_26910_n1540# pd_div_0/divbuf_0/a_27390_n1540# 0.11fF
C8379 pd_div_0/divbuf_0/a_57630_n840# pd_div_0/divbuf_0/a_57630_n1540# 0.01fF
C8380 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8381 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_37950_n840# 0.04fF
C8382 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C8383 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C8384 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_12000_n1600# 0.26fF
C8385 divbuf_1/a_13252_n240# divbuf_1/a_13742_n240# 0.04fF
C8386 divbuf_0/a_2400_n1600# divbuf_0/a_2880_n1600# 0.26fF
C8387 pll_full_0/divbuf_0/a_3870_n1540# pll_full_0/divbuf_0/a_4350_n1540# 0.11fF
C8388 pll_full_0/divbuf_0/a_34590_n840# pll_full_0/divbuf_0/a_34590_n1540# 0.01fF
C8389 divbuf_1/a_24990_n840# divbuf_1/a_25470_n840# 0.07fF
C8390 divbuf_1/a_27802_n240# divbuf_1/OUT4 0.04fF
C8391 divbuf_1/a_24960_n1600# divbuf_1/a_24990_n1540# 0.19fF
C8392 divbuf_0/a_55710_n840# divbuf_0/a_56190_n840# 0.07fF
C8393 divbuf_0/a_25470_n840# divbuf_0/a_25470_n1540# 0.01fF
C8394 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n1540# 0.19fF
C8395 divbuf_2/a_14702_170# divbuf_2/a_15182_170# 0.07fF
C8396 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24510_n840# 0.04fF
C8397 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_16152_n240# 0.05fF
C8398 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/a_35562_n240# 0.01fF
C8399 divbuf_3/a_24000_n1600# divbuf_3/OUT4 0.00fF
C8400 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/a_15182_n240# 0.01fF
C8401 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/a_35082_170# 0.07fF
C8402 pll_full_0/divbuf_1/a_27390_n840# pll_full_0/divbuf_1/a_27870_n840# 0.07fF
C8403 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8404 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27390_n1540# 0.19fF
C8405 divbuf_2/a_38962_n240# divbuf_2/a_38910_n840# 0.04fF
C8406 divbuf_2/a_48000_n1600# divbuf_2/a_48480_n1600# 0.26fF
C8407 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C8408 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/tspc_0/Z3 0.06fF
C8409 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/a0 0.09fF
C8410 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C8411 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C8412 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1470_n840# 0.04fF
C8413 divbuf_2/a_40350_n1540# divbuf_2/a_40830_n1540# 0.11fF
C8414 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C8415 pd_0/DOWN pd_0/UP 0.46fF
C8416 divbuf_0/a_13252_n240# divbuf_0/a_12990_n840# 0.01fF
C8417 divbuf_3/a_10560_n1600# divbuf_3/a_11040_n1600# 0.26fF
C8418 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6720_n1600# 0.26fF
C8419 pd_div_0/divbuf_0/a_13950_n840# pd_div_0/divbuf_0/a_14430_n840# 0.07fF
C8420 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_13950_n1540# 0.19fF
C8421 divbuf_3/a_2910_n1540# divbuf_3/a_3390_n1540# 0.11fF
C8422 divbuf_3/a_33630_n840# divbuf_3/a_33630_n1540# 0.01fF
C8423 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_59550_n1540# 0.19fF
C8424 ro_div_0/divbuf_0/a_59550_n840# ro_div_0/divbuf_0/a_60030_n840# 0.07fF
C8425 ro_div_0/divbuf_0/a_29310_n840# ro_div_0/divbuf_0/a_29310_n1540# 0.01fF
C8426 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_4882_n240# 0.01fF
C8427 divbuf_2/a_31682_170# divbuf_2/OUT4 0.19fF
C8428 divbuf_2/a_37920_n1600# divbuf_2/a_37950_n840# 0.04fF
C8429 divbuf_1/a_18092_170# divbuf_1/a_18582_170# 0.07fF
C8430 divbuf_0/a_3422_170# divbuf_0/a_3422_n240# 0.01fF
C8431 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.26fF
C8432 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51840_n1600# 0.26fF
C8433 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/OUT3 0.07fF
C8434 divbuf_1/a_11520_n1600# divbuf_1/a_12000_n1600# 0.26fF
C8435 divbuf_0/a_33142_n240# divbuf_0/a_33150_n840# 0.06fF
C8436 divbuf_0/a_5362_170# divbuf_0/OUT3 0.19fF
C8437 divbuf_0/a_42240_n1600# divbuf_0/a_42720_n1600# 0.26fF
C8438 pll_full_0/divbuf_0/a_43710_n1540# pll_full_0/divbuf_0/a_44190_n1540# 0.11fF
C8439 divbuf_3/a_480_n1600# divbuf_3/a_510_n840# 0.04fF
C8440 divbuf_1/a_3870_n1540# divbuf_1/a_4350_n1540# 0.11fF
C8441 divbuf_1/a_34590_n840# divbuf_1/a_34590_n1540# 0.01fF
C8442 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_16830_n840# 0.00fF
C8443 divbuf_0/a_34590_n1540# divbuf_0/a_35070_n1540# 0.11fF
C8444 divbuf_2/a_15672_n240# divbuf_2/a_16152_n240# 0.05fF
C8445 divbuf_2/a_35562_170# divbuf_2/a_35562_n240# 0.01fF
C8446 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_14400_n1600# 0.26fF
C8447 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/a_4350_n840# 0.04fF
C8448 pll_full_0/divbuf_1/a_6270_n1540# pll_full_0/divbuf_1/a_6750_n1540# 0.11fF
C8449 pll_full_0/divbuf_1/a_36990_n840# pll_full_0/divbuf_1/a_36990_n1540# 0.01fF
C8450 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/a_19562_n240# 0.01fF
C8451 divbuf_2/a_27390_n840# divbuf_2/a_27870_n840# 0.07fF
C8452 divbuf_2/a_32652_n240# divbuf_2/OUT4 0.04fF
C8453 divbuf_2/a_27360_n1600# divbuf_2/a_27390_n1540# 0.19fF
C8454 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C8455 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41310_n840# 0.04fF
C8456 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8457 divbuf_3/a_17122_170# divbuf_3/a_17612_170# 0.07fF
C8458 divbuf_1/a_1440_n1600# divbuf_1/a_1470_n840# 0.04fF
C8459 pd_div_0/divbuf_0/a_4882_170# pd_div_0/divbuf_0/OUT3 0.19fF
C8460 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C8461 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n840# 0.04fF
C8462 divbuf_0/a_20042_170# divbuf_0/OUT4 0.19fF
C8463 divbuf_3/a_50400_n1600# divbuf_3/a_50880_n1600# 0.26fF
C8464 divbuf_3/a_41382_n240# divbuf_3/a_41310_n840# 0.03fF
C8465 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_960_n1600# 0.26fF
C8466 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46560_n1600# 0.26fF
C8467 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/a_36990_n840# 0.05fF
C8468 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_53790_n1540# 0.19fF
C8469 pd_div_0/divbuf_0/a_23550_n840# pd_div_0/divbuf_0/a_23550_n1540# 0.01fF
C8470 pd_div_0/divbuf_0/a_53790_n840# pd_div_0/divbuf_0/a_54270_n840# 0.07fF
C8471 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_3870_n840# 0.04fF
C8472 divbuf_3/a_42750_n1540# divbuf_3/a_43230_n1540# 0.11fF
C8473 ro_div_0/divbuf_0/a_38430_n1540# ro_div_0/divbuf_0/a_38910_n1540# 0.11fF
C8474 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/a_19562_n240# 0.04fF
C8475 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/a_38962_n240# 0.01fF
C8476 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/tspc_0/Z3 0.45fF
C8477 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/a_21502_n240# 0.01fF
C8478 divbuf_0/a_9242_n240# divbuf_0/a_9732_n240# 0.04fF
C8479 divbuf_0/a_29742_170# divbuf_0/a_29742_n240# 0.01fF
C8480 pll_full_0/divbuf_0/a_30750_n840# pll_full_0/divbuf_0/a_31230_n840# 0.07fF
C8481 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8482 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/a_510_n1540# 0.01fF
C8483 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_30750_n1540# 0.19fF
C8484 divbuf_1/a_51360_n1600# divbuf_1/a_51840_n1600# 0.26fF
C8485 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C8486 divbuf_0/a_21630_n840# divbuf_0/a_22110_n840# 0.07fF
C8487 divbuf_0/a_21012_n240# divbuf_0/OUT4 0.04fF
C8488 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n1540# 0.19fF
C8489 divbuf_3/a_40320_n1600# divbuf_3/a_40350_n840# 0.04fF
C8490 divbuf_3/a_36532_170# divbuf_3/OUT4 0.19fF
C8491 divbuf_1/a_43710_n1540# divbuf_1/a_44190_n1540# 0.11fF
C8492 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/a_21012_170# 0.07fF
C8493 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.11fF
C8494 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36030_n840# 0.04fF
C8495 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8496 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Qbar1 0.38fF
C8497 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_54240_n1600# 0.26fF
C8498 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/OUT3 0.07fF
C8499 divbuf_2/a_13920_n1600# divbuf_2/a_14400_n1600# 0.26fF
C8500 divbuf_2/a_4392_n240# divbuf_2/a_4350_n840# 0.04fF
C8501 pll_full_0/divbuf_1/a_46110_n1540# pll_full_0/divbuf_1/a_46590_n1540# 0.11fF
C8502 divbuf_2/a_6270_n1540# divbuf_2/a_6750_n1540# 0.11fF
C8503 divbuf_2/a_36990_n840# divbuf_2/a_36990_n1540# 0.01fF
C8504 divbuf_3/a_18092_n240# divbuf_3/a_18582_n240# 0.04fF
C8505 divbuf_3/a_37992_170# divbuf_3/a_37992_n240# 0.01fF
C8506 divbuf_1/a_41280_n1600# divbuf_1/a_41310_n840# 0.04fF
C8507 divbuf_1/a_38472_170# divbuf_1/OUT4 0.19fF
C8508 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/a_33622_n240# 0.01fF
C8509 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_14222_n240# 0.05fF
C8510 divbuf_0/a_19200_n1600# divbuf_0/OUT4 0.00fF
C8511 divbuf_3/a_29790_n840# divbuf_3/a_30270_n840# 0.07fF
C8512 divbuf_3/a_37502_n240# divbuf_3/OUT4 0.04fF
C8513 divbuf_3/a_29760_n1600# divbuf_3/a_29790_n1540# 0.19fF
C8514 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40800_n1600# 0.26fF
C8515 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/a_31230_n840# 0.05fF
C8516 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25470_n1540# 0.19fF
C8517 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8518 ro_div_0/divbuf_0/a_25470_n840# ro_div_0/divbuf_0/a_25950_n840# 0.07fF
C8519 pd_div_0/divbuf_0/a_32670_n1540# pd_div_0/divbuf_0/a_33150_n1540# 0.11fF
C8520 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C8521 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_43710_n840# 0.04fF
C8522 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C8523 divbuf_2/a_3840_n1600# divbuf_2/a_3870_n840# 0.04fF
C8524 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17760_n1600# 0.26fF
C8525 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/a_7710_n840# 0.03fF
C8526 divbuf_1/a_19072_n240# divbuf_1/a_19562_n240# 0.04fF
C8527 divbuf_1/a_38962_170# divbuf_1/a_38962_n240# 0.01fF
C8528 divbuf_0/a_8160_n1600# divbuf_0/a_8640_n1600# 0.26fF
C8529 pll_full_0/divbuf_0/a_9630_n1540# pll_full_0/divbuf_0/a_10110_n1540# 0.11fF
C8530 pll_full_0/divbuf_0/a_40350_n840# pll_full_0/divbuf_0/a_40350_n1540# 0.01fF
C8531 divbuf_1/a_30750_n840# divbuf_1/a_31230_n840# 0.07fF
C8532 divbuf_1/a_39442_n240# divbuf_1/OUT4 0.04fF
C8533 divbuf_1/a_510_n840# divbuf_1/a_510_n1540# 0.01fF
C8534 divbuf_1/a_30720_n1600# divbuf_1/a_30750_n1540# 0.19fF
C8535 divbuf_0/a_31230_n840# divbuf_0/a_31230_n1540# 0.01fF
C8536 divbuf_0/a_510_n1540# divbuf_0/a_990_n1540# 0.11fF
C8537 divbuf_3/a_35520_n1600# divbuf_3/OUT4 0.00fF
C8538 divbuf_2/a_20532_170# divbuf_2/a_21012_170# 0.07fF
C8539 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30270_n840# 0.04fF
C8540 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/a_41382_n240# 0.01fF
C8541 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/a_21982_n240# 0.05fF
C8542 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/IN 0.00fF
C8543 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/a_21012_n240# 0.01fF
C8544 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/a_40902_170# 0.07fF
C8545 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33150_n1540# 0.19fF
C8546 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/a_2910_n1540# 0.01fF
C8547 pll_full_0/divbuf_1/a_33150_n840# pll_full_0/divbuf_1/a_33630_n840# 0.07fF
C8548 divbuf_2/a_53760_n1600# divbuf_2/a_54240_n1600# 0.26fF
C8549 divbuf_2/a_2322_170# divbuf_2/OUT3 0.07fF
C8550 ro_div_0/divider_0/prescaler_0/tspc_2/D ro_div_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C8551 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C8552 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7230_n840# 0.04fF
C8553 divbuf_2/a_46110_n1540# divbuf_2/a_46590_n1540# 0.11fF
C8554 divbuf_3/a_16320_n1600# divbuf_3/a_16800_n1600# 0.26fF
C8555 divbuf_3/a_6822_n240# divbuf_3/a_6750_n840# 0.03fF
C8556 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12480_n1600# 0.26fF
C8557 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_19710_n1540# 0.19fF
C8558 pd_div_0/divbuf_0/a_19710_n840# pd_div_0/divbuf_0/a_20190_n840# 0.07fF
C8559 divbuf_3/a_8670_n1540# divbuf_3/a_9150_n1540# 0.11fF
C8560 divbuf_3/a_39390_n840# divbuf_3/a_39390_n1540# 0.01fF
C8561 ro_div_0/divbuf_0/a_35070_n840# ro_div_0/divbuf_0/a_35070_n1540# 0.01fF
C8562 ro_div_0/divbuf_0/a_4350_n1540# ro_div_0/divbuf_0/a_4830_n1540# 0.11fF
C8563 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/a_24412_170# 0.07fF
C8564 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/a_1352_n240# 0.01fF
C8565 divbuf_2/a_3912_n240# divbuf_2/OUT3 0.04fF
C8566 divbuf_2/a_43680_n1600# divbuf_2/a_43710_n840# 0.04fF
C8567 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57600_n1600# 0.26fF
C8568 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/OUT4 0.23fF
C8569 divbuf_1/a_17280_n1600# divbuf_1/a_17760_n1600# 0.26fF
C8570 divbuf_1/a_7792_n240# divbuf_1/a_7710_n840# 0.03fF
C8571 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C8572 divbuf_0/a_48000_n1600# divbuf_0/a_48480_n1600# 0.26fF
C8573 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C8574 divbuf_0/a_38962_n240# divbuf_0/a_38910_n840# 0.04fF
C8575 pll_full_0/divbuf_0/a_49470_n1540# pll_full_0/divbuf_0/a_49950_n1540# 0.11fF
C8576 divbuf_3/a_6240_n1600# divbuf_3/a_6270_n840# 0.04fF
C8577 divbuf_1/a_9630_n1540# divbuf_1/a_10110_n1540# 0.11fF
C8578 divbuf_1/a_40350_n840# divbuf_1/a_40350_n1540# 0.01fF
C8579 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_1950_n840# 0.04fF
C8580 divbuf_0/a_40350_n1540# divbuf_0/a_40830_n1540# 0.11fF
C8581 divbuf_2/a_41382_170# divbuf_2/a_41382_n240# 0.01fF
C8582 divbuf_2/a_21502_n240# divbuf_2/a_21982_n240# 0.05fF
C8583 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_20160_n1600# 0.26fF
C8584 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/a_10110_n840# 0.03fF
C8585 pll_full_0/divbuf_1/a_12030_n1540# pll_full_0/divbuf_1/a_12510_n1540# 0.11fF
C8586 pll_full_0/divbuf_1/a_42750_n840# pll_full_0/divbuf_1/a_42750_n1540# 0.01fF
C8587 divbuf_2/a_33120_n1600# divbuf_2/a_33150_n1540# 0.19fF
C8588 divbuf_2/a_2910_n840# divbuf_2/a_2910_n1540# 0.01fF
C8589 divbuf_2/a_33150_n840# divbuf_2/a_33630_n840# 0.07fF
C8590 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/tspc_0/Z3 0.06fF
C8591 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C8592 divbuf_0/a_14222_170# divbuf_0/a_14222_n240# 0.01fF
C8593 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8594 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47070_n840# 0.04fF
C8595 divbuf_3/a_22952_170# divbuf_3/a_23442_170# 0.07fF
C8596 divbuf_3/a_2322_170# divbuf_3/a_2322_n240# 0.01fF
C8597 divbuf_1/a_7200_n1600# divbuf_1/a_7230_n840# 0.04fF
C8598 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8599 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_5362_n240# 0.01fF
C8600 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n840# 0.04fF
C8601 divbuf_0/a_31682_170# divbuf_0/OUT4 0.19fF
C8602 divbuf_3/a_7792_170# divbuf_3/OUT3 0.19fF
C8603 divbuf_3/a_56160_n1600# divbuf_3/a_56640_n1600# 0.26fF
C8604 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6720_n1600# 0.26fF
C8605 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_52320_n1600# 0.26fF
C8606 pd_div_0/divbuf_0/a_29310_n840# pd_div_0/divbuf_0/a_29310_n1540# 0.01fF
C8607 pd_div_0/divbuf_0/a_59550_n840# pd_div_0/divbuf_0/a_60030_n840# 0.07fF
C8608 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_59550_n1540# 0.19fF
C8609 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_9630_n840# 0.04fF
C8610 divbuf_3/a_48510_n1540# divbuf_3/a_48990_n1540# 0.11fF
C8611 ro_div_0/divbuf_0/a_44190_n1540# ro_div_0/divbuf_0/a_44670_n1540# 0.11fF
C8612 pll_full_0/divbuf_1/a_60990_n840# pll_full_0/divbuf_1/OUT5 0.04fF
C8613 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/a_25382_n240# 0.04fF
C8614 divbuf_1/a_20532_170# divbuf_1/a_21012_170# 0.07fF
C8615 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/a_27322_n240# 0.01fF
C8616 divbuf_0/a_35562_170# divbuf_0/a_35562_n240# 0.01fF
C8617 divbuf_0/a_15672_n240# divbuf_0/a_16152_n240# 0.05fF
C8618 pll_full_0/divbuf_0/a_6270_n840# pll_full_0/divbuf_0/a_6270_n1540# 0.01fF
C8619 pll_full_0/divbuf_0/a_36510_n840# pll_full_0/divbuf_0/a_36990_n840# 0.07fF
C8620 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C8621 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36510_n1540# 0.19fF
C8622 divbuf_1/a_57120_n1600# divbuf_1/a_57600_n1600# 0.26fF
C8623 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8624 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n1540# 0.19fF
C8625 divbuf_0/a_32652_n240# divbuf_0/OUT4 0.04fF
C8626 divbuf_0/a_27390_n840# divbuf_0/a_27870_n840# 0.07fF
C8627 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/a_6332_n240# 0.01fF
C8628 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/a_26832_170# 0.07fF
C8629 divbuf_3/a_8762_n240# divbuf_3/OUT3 0.04fF
C8630 divbuf_3/a_46080_n1600# divbuf_3/a_46110_n840# 0.04fF
C8631 divbuf_1/a_49470_n1540# divbuf_1/a_49950_n1540# 0.11fF
C8632 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8633 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_41790_n840# 0.04fF
C8634 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/a_13742_170# 0.07fF
C8635 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_3912_170# 0.07fF
C8636 pd_div_0/pd_0/tspc_r_1/Qbar pd_div_0/pd_0/and_pd_0/Z1 0.02fF
C8637 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_60000_n1600# 0.26fF
C8638 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8639 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C8640 divbuf_2/a_19680_n1600# divbuf_2/a_20160_n1600# 0.26fF
C8641 divbuf_2/a_10212_n240# divbuf_2/a_10110_n840# 0.03fF
C8642 pll_full_0/divbuf_1/a_51870_n1540# pll_full_0/divbuf_1/a_52350_n1540# 0.11fF
C8643 divbuf_2/a_12030_n1540# divbuf_2/a_12510_n1540# 0.11fF
C8644 divbuf_2/a_42750_n840# divbuf_2/a_42750_n1540# 0.01fF
C8645 divbuf_1/a_22952_170# divbuf_1/a_22952_n240# 0.01fF
C8646 divbuf_3/a_23922_n240# divbuf_3/a_24412_n240# 0.04fF
C8647 divbuf_1/a_10212_n240# divbuf_1/OUT4 0.04fF
C8648 divbuf_1/a_47040_n1600# divbuf_1/a_47070_n840# 0.04fF
C8649 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/a_39442_n240# 0.01fF
C8650 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/a_20042_n240# 0.05fF
C8651 divbuf_3/a_5310_n840# divbuf_3/a_5310_n1540# 0.01fF
C8652 divbuf_3/a_35550_n840# divbuf_3/a_36030_n840# 0.07fF
C8653 divbuf_3/a_35520_n1600# divbuf_3/a_35550_n1540# 0.19fF
C8654 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/a_36990_n840# 0.05fF
C8655 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46560_n1600# 0.26fF
C8656 ro_div_0/divbuf_0/a_31230_n840# ro_div_0/divbuf_0/a_31710_n840# 0.07fF
C8657 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/a_990_n1540# 0.01fF
C8658 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31230_n1540# 0.19fF
C8659 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8660 pd_div_0/divbuf_0/a_3912_170# pd_div_0/divbuf_0/a_3912_n240# 0.01fF
C8661 pd_div_0/divbuf_0/a_38430_n1540# pd_div_0/divbuf_0/a_38910_n1540# 0.11fF
C8662 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8663 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49470_n840# 0.04fF
C8664 divbuf_2/a_9600_n1600# divbuf_2/a_9630_n840# 0.04fF
C8665 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_13950_n840# 0.02fF
C8666 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23520_n1600# 0.26fF
C8667 divbuf_2/a_60990_n840# divbuf_2/OUT5 0.04fF
C8668 divbuf_1/a_24892_n240# divbuf_1/a_25382_n240# 0.04fF
C8669 ashish_0/a_150_0# ashish_0/von 9.14fF
C8670 divbuf_0/a_4392_n240# divbuf_0/a_4350_n840# 0.04fF
C8671 divbuf_0/a_13920_n1600# divbuf_0/a_14400_n1600# 0.26fF
C8672 pll_full_0/divbuf_0/a_15390_n1540# pll_full_0/divbuf_0/a_15870_n1540# 0.11fF
C8673 pll_full_0/divbuf_0/a_46110_n840# pll_full_0/divbuf_0/a_46110_n1540# 0.01fF
C8674 divbuf_1/a_6270_n840# divbuf_1/a_6270_n1540# 0.01fF
C8675 divbuf_1/a_36510_n840# divbuf_1/a_36990_n840# 0.07fF
C8676 divbuf_1/a_9600_n1600# divbuf_1/OUT3 0.00fF
C8677 divbuf_1/a_36480_n1600# divbuf_1/a_36510_n1540# 0.19fF
C8678 divbuf_0/a_36990_n840# divbuf_0/a_36990_n1540# 0.01fF
C8679 divbuf_0/a_6270_n1540# divbuf_0/a_6750_n1540# 0.11fF
C8680 divbuf_2/a_6332_170# divbuf_2/a_6332_n240# 0.01fF
C8681 divbuf_2/a_26352_170# divbuf_2/a_26832_170# 0.07fF
C8682 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36030_n840# 0.04fF
C8683 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/a_27802_n240# 0.05fF
C8684 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/a_6822_n240# 0.04fF
C8685 pll_full_0/divbuf_1/a_8670_n840# pll_full_0/divbuf_1/a_8670_n1540# 0.01fF
C8686 pll_full_0/divbuf_1/a_38910_n840# pll_full_0/divbuf_1/a_39390_n840# 0.07fF
C8687 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_38910_n1540# 0.19fF
C8688 divbuf_2/a_59520_n1600# divbuf_2/a_60000_n1600# 0.26fF
C8689 divbuf_2/a_14702_170# divbuf_2/OUT4 0.19fF
C8690 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.45fF
C8691 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/OUT3 0.19fF
C8692 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_12990_n840# 0.04fF
C8693 divbuf_2/a_51870_n1540# divbuf_2/a_52350_n1540# 0.11fF
C8694 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_16350_n840# 0.00fF
C8695 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n840# 0.04fF
C8696 divbuf_3/a_12772_n240# divbuf_3/a_12990_n840# 0.02fF
C8697 divbuf_3/a_22080_n1600# divbuf_3/a_22560_n1600# 0.26fF
C8698 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/a_8190_n840# 0.03fF
C8699 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_18240_n1600# 0.26fF
C8700 divbuf_3/a_14430_n1540# divbuf_3/a_14910_n1540# 0.11fF
C8701 divbuf_3/a_45150_n840# divbuf_3/a_45150_n1540# 0.01fF
C8702 pd_div_0/divbuf_0/a_25470_n840# pd_div_0/divbuf_0/a_25950_n840# 0.07fF
C8703 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8704 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25470_n1540# 0.19fF
C8705 divbuf_1/a_4392_170# divbuf_1/a_4882_170# 0.07fF
C8706 ro_div_0/divbuf_0/a_40830_n840# ro_div_0/divbuf_0/a_40830_n1540# 0.01fF
C8707 ro_div_0/divbuf_0/a_10110_n1540# ro_div_0/divbuf_0/a_10590_n1540# 0.11fF
C8708 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/a_30232_170# 0.07fF
C8709 divbuf_2/a_15672_n240# divbuf_2/OUT4 0.04fF
C8710 divbuf_2/a_49440_n1600# divbuf_2/a_49470_n840# 0.04fF
C8711 divbuf_0/a_20532_170# divbuf_0/a_21012_170# 0.07fF
C8712 divbuf_0/a_4392_170# divbuf_0/a_4392_n240# 0.01fF
C8713 pll_full_0/divbuf_0/a_2430_n840# pll_full_0/divbuf_0/a_2910_n840# 0.07fF
C8714 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8715 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2430_n1540# 0.19fF
C8716 divbuf_1/a_13742_n240# divbuf_1/a_13950_n840# 0.02fF
C8717 divbuf_1/a_23040_n1600# divbuf_1/a_23520_n1600# 0.26fF
C8718 divbuf_0/a_53760_n1600# divbuf_0/a_54240_n1600# 0.26fF
C8719 pll_full_0/divbuf_0/a_55230_n1540# pll_full_0/divbuf_0/a_55710_n1540# 0.11fF
C8720 divbuf_3/a_12000_n1600# divbuf_3/a_12030_n840# 0.04fF
C8721 divbuf_1/a_15390_n1540# divbuf_1/a_15870_n1540# 0.11fF
C8722 divbuf_1/a_46110_n840# divbuf_1/a_46110_n1540# 0.01fF
C8723 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_7710_n840# 0.04fF
C8724 divbuf_0/a_46110_n1540# divbuf_0/a_46590_n1540# 0.11fF
C8725 divbuf_2/a_27322_n240# divbuf_2/a_27802_n240# 0.05fF
C8726 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25920_n1600# 0.26fF
C8727 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_16350_n840# 0.02fF
C8728 pll_full_0/divbuf_1/a_17790_n1540# pll_full_0/divbuf_1/a_18270_n1540# 0.11fF
C8729 pll_full_0/divbuf_1/a_48510_n840# pll_full_0/divbuf_1/a_48510_n1540# 0.01fF
C8730 divbuf_2/a_8670_n840# divbuf_2/a_8670_n1540# 0.01fF
C8731 divbuf_2/a_38910_n840# divbuf_2/a_39390_n840# 0.07fF
C8732 divbuf_2/a_38880_n1600# divbuf_2/a_38910_n1540# 0.19fF
C8733 divbuf_1/a_14702_170# divbuf_1/a_14222_170# 0.07fF
C8734 pd_div_0/divider_0/prescaler_0/tspc_2/D pd_div_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C8735 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_52830_n840# 0.04fF
C8736 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8737 divbuf_3/a_8762_170# divbuf_3/a_8762_n240# 0.01fF
C8738 divbuf_3/a_28772_170# divbuf_3/a_29262_170# 0.07fF
C8739 divbuf_1/a_32652_170# divbuf_1/OUT4 0.19fF
C8740 divbuf_1/a_12960_n1600# divbuf_1/a_12990_n840# 0.04fF
C8741 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8742 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/a_24892_170# 0.07fF
C8743 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n840# 0.04fF
C8744 divbuf_0/a_3912_n240# divbuf_0/OUT3 0.04fF
C8745 divbuf_3/a_1470_n840# divbuf_3/a_1950_n840# 0.07fF
C8746 divbuf_3/a_19562_170# divbuf_3/OUT4 0.19fF
C8747 divbuf_3/a_1440_n1600# divbuf_3/a_1470_n1540# 0.19fF
C8748 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12480_n1600# 0.26fF
C8749 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8750 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_58080_n1600# 0.26fF
C8751 pd_div_0/divbuf_0/a_4350_n1540# pd_div_0/divbuf_0/a_4830_n1540# 0.11fF
C8752 pd_div_0/divbuf_0/a_35070_n840# pd_div_0/divbuf_0/a_35070_n1540# 0.01fF
C8753 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15390_n840# 0.04fF
C8754 divbuf_3/a_54270_n1540# divbuf_3/a_54750_n1540# 0.11fF
C8755 ro_div_0/divbuf_0/a_49950_n1540# ro_div_0/divbuf_0/a_50430_n1540# 0.11fF
C8756 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/a_31202_n240# 0.04fF
C8757 divbuf_1/a_26352_170# divbuf_1/a_26832_170# 0.07fF
C8758 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/a_33142_n240# 0.01fF
C8759 divbuf_0/a_21502_n240# divbuf_0/a_21982_n240# 0.05fF
C8760 divbuf_0/a_41382_170# divbuf_0/a_41382_n240# 0.01fF
C8761 pll_full_0/divbuf_0/a_12030_n840# pll_full_0/divbuf_0/a_12030_n1540# 0.01fF
C8762 pll_full_0/divbuf_0/a_42270_n840# pll_full_0/divbuf_0/a_42750_n840# 0.07fF
C8763 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C8764 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42270_n1540# 0.19fF
C8765 divbuf_1/a_2430_n840# divbuf_1/a_2910_n840# 0.07fF
C8766 divbuf_1/a_2400_n1600# divbuf_1/a_2430_n1540# 0.19fF
C8767 divbuf_0/a_33150_n840# divbuf_0/a_33630_n840# 0.07fF
C8768 divbuf_0/a_2910_n840# divbuf_0/a_2910_n1540# 0.01fF
C8769 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n1540# 0.19fF
C8770 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/a_12772_n240# 0.01fF
C8771 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/a_32652_170# 0.07fF
C8772 divbuf_3/a_51840_n1600# divbuf_3/a_51870_n840# 0.04fF
C8773 divbuf_3/a_20532_n240# divbuf_3/OUT4 0.04fF
C8774 divbuf_1/a_55230_n1540# divbuf_1/a_55710_n1540# 0.11fF
C8775 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_1950_n840# 0.04fF
C8776 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/a_9242_170# 0.07fF
C8777 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_47550_n840# 0.04fF
C8778 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8779 divbuf_2/a_25440_n1600# divbuf_2/a_25920_n1600# 0.26fF
C8780 divbuf_2/a_16152_n240# divbuf_2/a_16350_n840# 0.02fF
C8781 pll_full_0/divbuf_1/a_4830_n840# pll_full_0/divbuf_1/a_5310_n840# 0.07fF
C8782 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8783 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_4830_n1540# 0.19fF
C8784 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C8785 pll_full_0/divbuf_1/a_57630_n1540# pll_full_0/divbuf_1/a_58110_n1540# 0.11fF
C8786 divbuf_2/a_17790_n1540# divbuf_2/a_18270_n1540# 0.11fF
C8787 divbuf_2/a_48510_n840# divbuf_2/a_48510_n1540# 0.01fF
C8788 divbuf_1/a_28772_170# divbuf_1/a_28772_n240# 0.01fF
C8789 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/OUT2 0.02fF
C8790 divbuf_3/a_29742_n240# divbuf_3/a_30232_n240# 0.04fF
C8791 divbuf_1/a_52800_n1600# divbuf_1/a_52830_n840# 0.04fF
C8792 divbuf_1/a_22472_n240# divbuf_1/OUT4 0.04fF
C8793 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/a_25862_n240# 0.05fF
C8794 divbuf_3/a_11070_n840# divbuf_3/a_11070_n1540# 0.01fF
C8795 divbuf_3/a_41310_n840# divbuf_3/a_41790_n840# 0.07fF
C8796 divbuf_3/a_41280_n1600# divbuf_3/a_41310_n1540# 0.19fF
C8797 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_52320_n1600# 0.26fF
C8798 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_36990_n1540# 0.19fF
C8799 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/OUT3 0.01fF
C8800 ro_div_0/divbuf_0/a_36990_n840# ro_div_0/divbuf_0/a_37470_n840# 0.07fF
C8801 ro_div_0/divbuf_0/a_6750_n840# ro_div_0/divbuf_0/a_6750_n1540# 0.01fF
C8802 pd_div_0/divbuf_0/a_44190_n1540# pd_div_0/divbuf_0/a_44670_n1540# 0.11fF
C8803 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/a_11312_n240# 0.01fF
C8804 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8805 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55230_n840# 0.04fF
C8806 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C8807 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C8808 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C8809 divbuf_2/a_15360_n1600# divbuf_2/a_15390_n840# 0.04fF
C8810 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/and_0/A 0.80fF
C8811 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C8812 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/switch_1/vin 0.19fF
C8813 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C8814 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_29280_n1600# 0.26fF
C8815 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/a_19710_n840# 0.03fF
C8816 divbuf_1/a_30712_n240# divbuf_1/a_31202_n240# 0.04fF
C8817 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C8818 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C8819 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C8820 divbuf_0/a_10212_n240# divbuf_0/a_10110_n840# 0.03fF
C8821 divbuf_0/a_19680_n1600# divbuf_0/a_20160_n1600# 0.26fF
C8822 pll_full_0/divbuf_0/a_21150_n1540# pll_full_0/divbuf_0/a_21630_n1540# 0.11fF
C8823 pll_full_0/divbuf_0/a_51870_n840# pll_full_0/divbuf_0/a_51870_n1540# 0.01fF
C8824 divbuf_1/a_12030_n840# divbuf_1/a_12030_n1540# 0.01fF
C8825 divbuf_1/a_42270_n840# divbuf_1/a_42750_n840# 0.07fF
C8826 divbuf_1/a_20640_n1600# divbuf_1/OUT4 0.00fF
C8827 divbuf_1/a_42240_n1600# divbuf_1/a_42270_n1540# 0.19fF
C8828 divbuf_0/a_42750_n840# divbuf_0/a_42750_n1540# 0.01fF
C8829 divbuf_0/a_12030_n1540# divbuf_0/a_12510_n1540# 0.11fF
C8830 divbuf_2/a_12772_170# divbuf_2/a_12772_n240# 0.01fF
C8831 divbuf_2/a_32172_170# divbuf_2/a_32652_170# 0.07fF
C8832 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_41790_n840# 0.04fF
C8833 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/a_33622_n240# 0.05fF
C8834 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_13252_n240# 0.05fF
C8835 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_44670_n1540# 0.19fF
C8836 pll_full_0/divbuf_1/a_14430_n840# pll_full_0/divbuf_1/a_14430_n1540# 0.01fF
C8837 pll_full_0/divbuf_1/a_44670_n840# pll_full_0/divbuf_1/a_45150_n840# 0.07fF
C8838 divbuf_2/a_4830_n840# divbuf_2/a_5310_n840# 0.07fF
C8839 divbuf_2/a_26352_170# divbuf_2/OUT4 0.19fF
C8840 divbuf_2/a_4800_n1600# divbuf_2/a_4830_n1540# 0.19fF
C8841 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_18750_n840# 0.04fF
C8842 divbuf_2/a_57630_n1540# divbuf_2/a_58110_n1540# 0.11fF
C8843 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/a_9732_170# 0.07fF
C8844 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n840# 0.04fF
C8845 divbuf_0/a_3422_170# divbuf_0/OUT3 0.23fF
C8846 divbuf_3/a_27840_n1600# divbuf_3/a_28320_n1600# 0.26fF
C8847 divbuf_3/a_18582_n240# divbuf_3/a_18750_n840# 0.02fF
C8848 divbuf_1/a_990_n840# divbuf_1/OUT2 0.02fF
C8849 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_24000_n1600# 0.26fF
C8850 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_14430_n840# 0.02fF
C8851 divbuf_0/a_60990_n840# divbuf_0/OUT5 0.04fF
C8852 divbuf_3/a_20190_n1540# divbuf_3/a_20670_n1540# 0.11fF
C8853 divbuf_3/a_50910_n840# divbuf_3/a_50910_n1540# 0.01fF
C8854 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8855 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31230_n1540# 0.19fF
C8856 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/a_990_n1540# 0.01fF
C8857 pd_div_0/divbuf_0/a_31230_n840# pd_div_0/divbuf_0/a_31710_n840# 0.07fF
C8858 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/a_1470_n840# 0.03fF
C8859 ro_div_0/divbuf_0/a_46590_n840# ro_div_0/divbuf_0/a_46590_n1540# 0.01fF
C8860 ro_div_0/divbuf_0/a_15870_n1540# ro_div_0/divbuf_0/a_16350_n1540# 0.11fF
C8861 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/a_36052_170# 0.07fF
C8862 divbuf_2/a_27322_n240# divbuf_2/OUT4 0.04fF
C8863 divbuf_2/a_55200_n1600# divbuf_2/a_55230_n840# 0.04fF
C8864 divbuf_0/a_26352_170# divbuf_0/a_26832_170# 0.07fF
C8865 pll_full_0/divbuf_0/a_8190_n840# pll_full_0/divbuf_0/a_8670_n840# 0.07fF
C8866 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8867 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8190_n1540# 0.19fF
C8868 divbuf_1/a_28800_n1600# divbuf_1/a_29280_n1600# 0.26fF
C8869 divbuf_1/a_19562_n240# divbuf_1/a_19710_n840# 0.03fF
C8870 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/OUT3 0.19fF
C8871 divbuf_0/a_59520_n1600# divbuf_0/a_60000_n1600# 0.26fF
C8872 divbuf_3/a_17760_n1600# divbuf_3/a_17790_n840# 0.04fF
C8873 divbuf_1/a_21150_n1540# divbuf_1/a_21630_n1540# 0.11fF
C8874 divbuf_1/a_51870_n840# divbuf_1/a_51870_n1540# 0.01fF
C8875 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13470_n840# 0.04fF
C8876 divbuf_0/a_51870_n1540# divbuf_0/a_52350_n1540# 0.11fF
C8877 divbuf_2/a_33142_n240# divbuf_2/a_33622_n240# 0.05fF
C8878 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31680_n1600# 0.26fF
C8879 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/a_22110_n840# 0.03fF
C8880 divbuf_1/a_16152_170# divbuf_1/a_16152_n240# 0.01fF
C8881 divbuf_1/a_5852_170# divbuf_1/a_5852_n240# 0.01fF
C8882 pll_full_0/divbuf_1/a_23550_n1540# pll_full_0/divbuf_1/a_24030_n1540# 0.11fF
C8883 pll_full_0/divbuf_1/a_54270_n840# pll_full_0/divbuf_1/a_54270_n1540# 0.01fF
C8884 divbuf_2/a_44640_n1600# divbuf_2/a_44670_n1540# 0.19fF
C8885 divbuf_2/a_14430_n840# divbuf_2/a_14430_n1540# 0.01fF
C8886 divbuf_2/a_44670_n840# divbuf_2/a_45150_n840# 0.07fF
C8887 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8888 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_58590_n840# 0.04fF
C8889 divbuf_3/a_15182_170# divbuf_3/a_15182_n240# 0.01fF
C8890 divbuf_3/a_34592_170# divbuf_3/a_35082_170# 0.07fF
C8891 divbuf_1/a_10212_170# divbuf_1/OUT3 0.19fF
C8892 divbuf_1/a_18720_n1600# divbuf_1/a_18750_n840# 0.04fF
C8893 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8894 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/a_30712_170# 0.07fF
C8895 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n840# 0.04fF
C8896 divbuf_0/a_15672_n240# divbuf_0/OUT4 0.04fF
C8897 io_clamp_low[1] io_analog[5] 0.53fF
C8898 divbuf_3/a_7230_n840# divbuf_3/a_7710_n840# 0.07fF
C8899 divbuf_3/a_31202_170# divbuf_3/OUT4 0.19fF
C8900 divbuf_3/a_7200_n1600# divbuf_3/a_7230_n1540# 0.19fF
C8901 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_18240_n1600# 0.26fF
C8902 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_2910_n1540# 0.19fF
C8903 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8904 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/a_3390_n840# 0.07fF
C8905 divbuf_2/a_1352_n240# divbuf_2/a_1470_n840# 0.03fF
C8906 pd_div_0/divbuf_0/a_10110_n1540# pd_div_0/divbuf_0/a_10590_n1540# 0.11fF
C8907 pd_div_0/divbuf_0/a_40830_n840# pd_div_0/divbuf_0/a_40830_n1540# 0.01fF
C8908 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21150_n840# 0.04fF
C8909 divbuf_3/a_60030_n1540# divbuf_3/a_60510_n1540# 0.11fF
C8910 ro_div_0/divbuf_0/a_55710_n1540# ro_div_0/divbuf_0/a_56190_n1540# 0.11fF
C8911 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/a_37022_n240# 0.04fF
C8912 divbuf_1/a_35562_170# divbuf_1/a_36052_170# 0.07fF
C8913 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/a_38962_n240# 0.01fF
C8914 divbuf_0/a_27322_n240# divbuf_0/a_27802_n240# 0.05fF
C8915 pll_full_0/divbuf_0/a_17790_n840# pll_full_0/divbuf_0/a_17790_n1540# 0.01fF
C8916 pll_full_0/divbuf_0/a_48030_n840# pll_full_0/divbuf_0/a_48510_n840# 0.07fF
C8917 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C8918 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48030_n1540# 0.19fF
C8919 divbuf_1/a_8190_n840# divbuf_1/a_8670_n840# 0.07fF
C8920 divbuf_1/a_29742_170# divbuf_1/OUT4 0.19fF
C8921 divbuf_1/a_8160_n1600# divbuf_1/a_8190_n1540# 0.19fF
C8922 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n1540# 0.19fF
C8923 divbuf_0/a_38910_n840# divbuf_0/a_39390_n840# 0.07fF
C8924 divbuf_0/a_8670_n840# divbuf_0/a_8670_n1540# 0.01fF
C8925 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/a_18582_n240# 0.01fF
C8926 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/a_38472_170# 0.07fF
C8927 divbuf_3/a_32172_n240# divbuf_3/OUT4 0.04fF
C8928 divbuf_3/a_57600_n1600# divbuf_3/a_57630_n840# 0.04fF
C8929 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_7710_n840# 0.04fF
C8930 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/a_18092_170# 0.07fF
C8931 ro_div_0/ro_complete_0/cbank_2/v ro_div_0/divider_0/clk 1.36fF
C8932 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8933 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53310_n840# 0.04fF
C8934 divbuf_2/a_31200_n1600# divbuf_2/a_31680_n1600# 0.26fF
C8935 divbuf_2/a_21982_n240# divbuf_2/a_22110_n840# 0.03fF
C8936 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_10590_n1540# 0.19fF
C8937 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/a_11070_n840# 0.07fF
C8938 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8939 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C8940 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 0.36fF
C8941 divbuf_2/a_23550_n1540# divbuf_2/a_24030_n1540# 0.11fF
C8942 divbuf_2/a_54270_n840# divbuf_2/a_54270_n1540# 0.01fF
C8943 divbuf_3/a_35562_n240# divbuf_3/a_36052_n240# 0.04fF
C8944 divbuf_1/a_34112_n240# divbuf_1/OUT4 0.04fF
C8945 divbuf_1/a_58560_n1600# divbuf_1/a_58590_n840# 0.04fF
C8946 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/a_31682_n240# 0.05fF
C8947 divbuf_3/a_16830_n840# divbuf_3/a_16830_n1540# 0.01fF
C8948 divbuf_3/a_47070_n840# divbuf_3/a_47550_n840# 0.07fF
C8949 divbuf_3/a_47040_n1600# divbuf_3/a_47070_n1540# 0.19fF
C8950 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_58080_n1600# 0.26fF
C8951 ro_div_0/divbuf_0/a_42750_n840# ro_div_0/divbuf_0/a_43230_n840# 0.07fF
C8952 ro_div_0/divbuf_0/a_12510_n840# ro_div_0/divbuf_0/a_12510_n1540# 0.01fF
C8953 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_42750_n1540# 0.19fF
C8954 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C8955 divbuf_2/a_21120_n1600# divbuf_2/a_21150_n840# 0.04fF
C8956 pd_div_0/divbuf_0/a_49950_n1540# pd_div_0/divbuf_0/a_50430_n1540# 0.11fF
C8957 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8958 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/a_14222_170# 0.07fF
C8959 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C8960 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C8961 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C8962 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/a_25470_n840# 0.03fF
C8963 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_35040_n1600# 0.26fF
C8964 divbuf_1/a_36532_n240# divbuf_1/a_37022_n240# 0.04fF
C8965 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/a_7710_n840# 0.03fF
C8966 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C8967 divbuf_0/a_16152_n240# divbuf_0/a_16350_n840# 0.02fF
C8968 divbuf_0/a_25440_n1600# divbuf_0/a_25920_n1600# 0.26fF
C8969 pll_full_0/divbuf_0/a_26910_n1540# pll_full_0/divbuf_0/a_27390_n1540# 0.11fF
C8970 pll_full_0/divbuf_0/a_57630_n840# pll_full_0/divbuf_0/a_57630_n1540# 0.01fF
C8971 divbuf_1/a_17790_n840# divbuf_1/a_17790_n1540# 0.01fF
C8972 divbuf_1/a_48030_n840# divbuf_1/a_48510_n840# 0.07fF
C8973 divbuf_1/a_32160_n1600# divbuf_1/OUT4 0.00fF
C8974 divbuf_1/a_48000_n1600# divbuf_1/a_48030_n1540# 0.19fF
C8975 divbuf_0/a_48510_n840# divbuf_0/a_48510_n1540# 0.01fF
C8976 divbuf_0/a_17790_n1540# divbuf_0/a_18270_n1540# 0.11fF
C8977 divbuf_2/a_18582_170# divbuf_2/a_18582_n240# 0.01fF
C8978 divbuf_2/a_37992_170# divbuf_2/a_38472_170# 0.07fF
C8979 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_47550_n840# 0.04fF
C8980 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/a_39442_n240# 0.05fF
C8981 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/a_19072_n240# 0.04fF
C8982 pll_full_0/divbuf_1/a_20190_n840# pll_full_0/divbuf_1/a_20190_n1540# 0.01fF
C8983 pll_full_0/divbuf_1/a_50430_n840# pll_full_0/divbuf_1/a_50910_n840# 0.07fF
C8984 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50430_n1540# 0.19fF
C8985 divbuf_2/a_10560_n1600# divbuf_2/a_10590_n1540# 0.19fF
C8986 divbuf_2/a_10590_n840# divbuf_2/a_11070_n840# 0.07fF
C8987 divbuf_2/a_37992_170# divbuf_2/OUT4 0.19fF
C8988 divbuf_0/a_19072_170# divbuf_0/a_19072_n240# 0.01fF
C8989 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24510_n840# 0.04fF
C8990 divbuf_2/OUT3 divbuf_2/OUT4 0.36fF
C8991 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n840# 0.04fF
C8992 divbuf_3/a_24412_n240# divbuf_3/a_24510_n840# 0.03fF
C8993 divbuf_3/a_33600_n1600# divbuf_3/a_34080_n1600# 0.26fF
C8994 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/a_25862_n240# 0.05fF
C8995 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/a_20190_n840# 0.03fF
C8996 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29760_n1600# 0.26fF
C8997 divbuf_3/a_25950_n1540# divbuf_3/a_26430_n1540# 0.11fF
C8998 divbuf_3/a_56670_n840# divbuf_3/a_56670_n1540# 0.01fF
C8999 pd_div_0/divbuf_0/a_6750_n840# pd_div_0/divbuf_0/a_6750_n1540# 0.01fF
C9000 pd_div_0/divbuf_0/a_36990_n840# pd_div_0/divbuf_0/a_37470_n840# 0.07fF
C9001 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/OUT3 0.01fF
C9002 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_36990_n1540# 0.19fF
C9003 ro_div_0/divbuf_0/a_52350_n840# ro_div_0/divbuf_0/a_52350_n1540# 0.01fF
C9004 ro_div_0/divbuf_0/a_21630_n1540# ro_div_0/divbuf_0/a_22110_n1540# 0.11fF
C9005 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C9006 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/and_0/A 0.80fF
C9007 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/a_21982_n240# 0.01fF
C9008 divbuf_2/a_38962_n240# divbuf_2/OUT4 0.04fF
C9009 divbuf_0/a_32172_170# divbuf_0/a_32652_170# 0.07fF
C9010 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C9011 pll_full_0/divbuf_0/a_13950_n840# pll_full_0/divbuf_0/a_14430_n840# 0.07fF
C9012 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_13950_n1540# 0.19fF
C9013 divbuf_1/a_25382_n240# divbuf_1/a_25470_n840# 0.03fF
C9014 divbuf_1/a_34560_n1600# divbuf_1/a_35040_n1600# 0.26fF
C9015 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/OUT3 0.19fF
C9016 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n1540# 0.19fF
C9017 divbuf_0/a_26352_170# divbuf_0/OUT4 0.19fF
C9018 divbuf_0/a_4830_n840# divbuf_0/a_5310_n840# 0.07fF
C9019 divbuf_3/a_23520_n1600# divbuf_3/a_23550_n840# 0.04fF
C9020 divbuf_3/a_2322_170# divbuf_3/OUT2 0.19fF
C9021 divbuf_1/a_26910_n1540# divbuf_1/a_27390_n1540# 0.11fF
C9022 divbuf_1/a_57630_n840# divbuf_1/a_57630_n1540# 0.01fF
C9023 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19230_n840# 0.04fF
C9024 divbuf_0/a_57630_n1540# divbuf_0/a_58110_n1540# 0.11fF
C9025 divbuf_2/a_38962_n240# divbuf_2/a_39442_n240# 0.05fF
C9026 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/a_27870_n840# 0.04fF
C9027 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_37440_n1600# 0.26fF
C9028 pll_full_0/divbuf_1/a_29310_n1540# pll_full_0/divbuf_1/a_29790_n1540# 0.11fF
C9029 pll_full_0/divbuf_1/a_60030_n840# pll_full_0/divbuf_1/a_60030_n1540# 0.01fF
C9030 divbuf_2/a_20190_n840# divbuf_2/a_20190_n1540# 0.01fF
C9031 divbuf_2/a_50430_n840# divbuf_2/a_50910_n840# 0.07fF
C9032 divbuf_2/a_50400_n1600# divbuf_2/a_50430_n1540# 0.19fF
C9033 divbuf_3/a_21012_170# divbuf_3/a_21012_n240# 0.01fF
C9034 divbuf_3/a_40412_170# divbuf_3/a_40902_170# 0.07fF
C9035 divbuf_1/a_24480_n1600# divbuf_1/a_24510_n840# 0.04fF
C9036 divbuf_1/a_3912_170# divbuf_1/OUT3 0.19fF
C9037 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9038 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/a_36532_170# 0.07fF
C9039 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n840# 0.04fF
C9040 divbuf_0/a_27322_n240# divbuf_0/OUT4 0.04fF
C9041 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C9042 divbuf_3/a_3422_n240# divbuf_3/OUT3 0.07fF
C9043 divbuf_3/a_12990_n840# divbuf_3/a_13470_n840# 0.07fF
C9044 divbuf_3/a_12960_n1600# divbuf_3/a_12990_n1540# 0.19fF
C9045 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_24000_n1600# 0.26fF
C9046 pd_div_0/pd_0/tspc_r_1/Z2 pd_div_0/pd_0/tspc_r_1/Z4 0.14fF
C9047 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9048 ro_div_0/divbuf_0/a_8670_n840# ro_div_0/divbuf_0/a_9150_n840# 0.07fF
C9049 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_8670_n1540# 0.19fF
C9050 pd_div_0/divbuf_0/a_15870_n1540# pd_div_0/divbuf_0/a_16350_n1540# 0.11fF
C9051 pd_div_0/divbuf_0/a_46590_n840# pd_div_0/divbuf_0/a_46590_n1540# 0.01fF
C9052 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/OUT3 0.19fF
C9053 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_26910_n840# 0.04fF
C9054 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_960_n1600# 0.26fF
C9055 divbuf_0/a_33142_n240# divbuf_0/a_33622_n240# 0.05fF
C9056 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_53790_n1540# 0.19fF
C9057 pll_full_0/divbuf_0/a_23550_n840# pll_full_0/divbuf_0/a_23550_n1540# 0.01fF
C9058 pll_full_0/divbuf_0/a_53790_n840# pll_full_0/divbuf_0/a_54270_n840# 0.07fF
C9059 divbuf_1/a_5362_n240# divbuf_1/OUT3 0.04fF
C9060 divbuf_1/a_13950_n840# divbuf_1/a_14430_n840# 0.07fF
C9061 divbuf_1/a_13920_n1600# divbuf_1/a_13950_n1540# 0.19fF
C9062 divbuf_0/a_44670_n840# divbuf_0/a_45150_n840# 0.07fF
C9063 divbuf_0/a_14430_n840# divbuf_0/a_14430_n1540# 0.01fF
C9064 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n1540# 0.19fF
C9065 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/a_4392_n240# 0.05fF
C9066 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/a_24412_n240# 0.01fF
C9067 divbuf_3/a_2880_n1600# divbuf_3/OUT2 0.00fF
C9068 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13470_n840# 0.04fF
C9069 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/a_23922_170# 0.07fF
C9070 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59070_n840# 0.04fF
C9071 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9072 divbuf_2/a_27802_n240# divbuf_2/a_27870_n840# 0.04fF
C9073 divbuf_2/a_36960_n1600# divbuf_2/a_37440_n1600# 0.26fF
C9074 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C9075 pll_full_0/divbuf_1/a_16350_n840# pll_full_0/divbuf_1/a_16830_n840# 0.07fF
C9076 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16350_n1540# 0.19fF
C9077 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/nor_1/A 0.55fF
C9078 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11070_n840# 0.02fF
C9079 divbuf_2/a_29310_n1540# divbuf_2/a_29790_n1540# 0.11fF
C9080 divbuf_2/a_60030_n840# divbuf_2/a_60030_n1540# 0.01fF
C9081 divbuf_0/a_1352_n240# divbuf_0/a_1470_n840# 0.03fF
C9082 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/a_37502_n240# 0.05fF
C9083 divbuf_3/a_22590_n840# divbuf_3/a_22590_n1540# 0.01fF
C9084 divbuf_3/a_52830_n840# divbuf_3/a_53310_n840# 0.07fF
C9085 divbuf_3/a_52800_n1600# divbuf_3/a_52830_n1540# 0.19fF
C9086 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/a_3390_n840# 0.07fF
C9087 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_2910_n1540# 0.19fF
C9088 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48510_n1540# 0.19fF
C9089 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C9090 ro_div_0/divbuf_0/a_48510_n840# ro_div_0/divbuf_0/a_48990_n840# 0.07fF
C9091 ro_div_0/divbuf_0/a_18270_n840# ro_div_0/divbuf_0/a_18270_n1540# 0.01fF
C9092 divbuf_2/a_9242_170# divbuf_2/OUT3 0.19fF
C9093 divbuf_2/a_26880_n1600# divbuf_2/a_26910_n840# 0.04fF
C9094 pd_div_0/divbuf_0/a_55710_n1540# pd_div_0/divbuf_0/a_56190_n1540# 0.11fF
C9095 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C9096 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z3 0.05fF
C9097 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z1 0.03fF
C9098 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C9099 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40800_n1600# 0.26fF
C9100 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/a_31230_n840# 0.05fF
C9101 divbuf_1/a_480_n1600# divbuf_1/a_960_n1600# 0.26fF
C9102 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_13950_n840# 0.02fF
C9103 divbuf_0/a_21982_n240# divbuf_0/a_22110_n840# 0.03fF
C9104 divbuf_0/a_31200_n1600# divbuf_0/a_31680_n1600# 0.26fF
C9105 pll_full_0/divbuf_0/a_32670_n1540# pll_full_0/divbuf_0/a_33150_n1540# 0.11fF
C9106 divbuf_1/a_53760_n1600# divbuf_1/a_53790_n1540# 0.19fF
C9107 divbuf_1/a_23550_n840# divbuf_1/a_23550_n1540# 0.01fF
C9108 divbuf_1/a_53790_n840# divbuf_1/a_54270_n840# 0.07fF
C9109 divbuf_0/a_54270_n840# divbuf_0/a_54270_n1540# 0.01fF
C9110 divbuf_0/a_23550_n1540# divbuf_0/a_24030_n1540# 0.11fF
C9111 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_3360_n1600# 0.26fF
C9112 divbuf_2/a_3912_n240# divbuf_2/a_4392_n240# 0.05fF
C9113 divbuf_2/a_24412_170# divbuf_2/a_24412_n240# 0.01fF
C9114 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53310_n840# 0.04fF
C9115 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9116 divbuf_2/a_10212_n240# divbuf_2/OUT3 0.04fF
C9117 divbuf_2/a_16350_n840# divbuf_2/a_16830_n840# 0.07fF
C9118 divbuf_2/a_16320_n1600# divbuf_2/a_16350_n1540# 0.19fF
C9119 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C9120 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56190_n1540# 0.19fF
C9121 pll_full_0/divbuf_1/a_25950_n840# pll_full_0/divbuf_1/a_25950_n1540# 0.01fF
C9122 pll_full_0/divbuf_1/a_56190_n840# pll_full_0/divbuf_1/a_56670_n840# 0.07fF
C9123 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30270_n840# 0.04fF
C9124 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9125 divbuf_3/a_5362_170# divbuf_3/a_5852_170# 0.07fF
C9126 divbuf_1/a_11312_n240# divbuf_1/a_11070_n840# 0.02fF
C9127 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C9128 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n840# 0.04fF
C9129 divbuf_3/a_39360_n1600# divbuf_3/a_39840_n1600# 0.26fF
C9130 divbuf_3/a_30232_n240# divbuf_3/a_30270_n840# 0.05fF
C9131 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/a_31682_n240# 0.05fF
C9132 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35520_n1600# 0.26fF
C9133 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/a_25950_n840# 0.03fF
C9134 divbuf_3/a_31710_n1540# divbuf_3/a_32190_n1540# 0.11fF
C9135 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C9136 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_42750_n1540# 0.19fF
C9137 pd_div_0/divbuf_0/a_12510_n840# pd_div_0/divbuf_0/a_12510_n1540# 0.01fF
C9138 pd_div_0/divbuf_0/a_42750_n840# pd_div_0/divbuf_0/a_43230_n840# 0.07fF
C9139 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_13470_n840# 0.01fF
C9140 ro_div_0/divbuf_0/a_58110_n840# ro_div_0/divbuf_0/a_58110_n1540# 0.01fF
C9141 ro_div_0/divbuf_0/a_27390_n1540# ro_div_0/divbuf_0/a_27870_n1540# 0.11fF
C9142 divbuf_1/a_9732_170# divbuf_1/a_9242_170# 0.07fF
C9143 divbuf_1/a_1352_170# divbuf_1/a_1352_n240# 0.01fF
C9144 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/a_7792_n240# 0.04fF
C9145 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/a_27802_n240# 0.01fF
C9146 divbuf_2/a_9120_n1600# divbuf_2/OUT3 0.00fF
C9147 divbuf_0/a_37992_170# divbuf_0/a_38472_170# 0.07fF
C9148 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_19710_n1540# 0.19fF
C9149 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9150 pll_full_0/divbuf_0/a_19710_n840# pll_full_0/divbuf_0/a_20190_n840# 0.07fF
C9151 divbuf_1/a_40320_n1600# divbuf_1/a_40800_n1600# 0.26fF
C9152 divbuf_1/a_16152_170# divbuf_1/OUT4 0.19fF
C9153 divbuf_1/a_31202_n240# divbuf_1/a_31230_n840# 0.05fF
C9154 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9155 divbuf_0/a_37992_170# divbuf_0/OUT4 0.19fF
C9156 divbuf_0/a_10590_n840# divbuf_0/a_11070_n840# 0.07fF
C9157 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n1540# 0.19fF
C9158 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/a_9242_170# 0.07fF
C9159 divbuf_3/a_29280_n1600# divbuf_3/a_29310_n840# 0.04fF
C9160 divbuf_3/a_14222_170# divbuf_3/OUT4 0.19fF
C9161 divbuf_1/a_32670_n1540# divbuf_1/a_33150_n1540# 0.11fF
C9162 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/OUT2 0.23fF
C9163 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_24990_n840# 0.04fF
C9164 divbuf_0/OUT3 divbuf_0/OUT4 0.36fF
C9165 divbuf_2/a_2880_n1600# divbuf_2/a_3360_n1600# 0.26fF
C9166 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_43200_n1600# 0.26fF
C9167 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/a_33630_n840# 0.06fF
C9168 divbuf_1/a_1842_170# divbuf_1/a_1842_n240# 0.01fF
C9169 divbuf_1/a_6822_170# divbuf_1/a_6822_n240# 0.01fF
C9170 pll_full_0/divbuf_1/a_35070_n1540# pll_full_0/divbuf_1/a_35550_n1540# 0.11fF
C9171 divbuf_2/a_56160_n1600# divbuf_2/a_56190_n1540# 0.19fF
C9172 divbuf_2/a_25950_n840# divbuf_2/a_25950_n1540# 0.01fF
C9173 divbuf_2/a_56190_n840# divbuf_2/a_56670_n840# 0.07fF
C9174 divbuf_3/a_6332_n240# divbuf_3/a_6822_n240# 0.04fF
C9175 divbuf_3/a_26832_170# divbuf_3/a_26832_n240# 0.01fF
C9176 divbuf_1/a_30240_n1600# divbuf_1/a_30270_n840# 0.04fF
C9177 divbuf_1/a_13742_170# divbuf_1/OUT4 0.19fF
C9178 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/a_22472_n240# 0.01fF
C9179 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/a_1842_n240# 0.04fF
C9180 divbuf_0/a_38962_n240# divbuf_0/OUT4 0.04fF
C9181 divbuf_3/a_15182_n240# divbuf_3/OUT4 0.04fF
C9182 divbuf_3/a_18750_n840# divbuf_3/a_19230_n840# 0.07fF
C9183 divbuf_3/a_18720_n1600# divbuf_3/a_18750_n1540# 0.19fF
C9184 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29760_n1600# 0.26fF
C9185 ro_div_0/ro_complete_0/cbank_1/switch_2/vin ro_div_0/divider_0/clk 1.30fF
C9186 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14430_n1540# 0.19fF
C9187 ro_div_0/divbuf_0/a_14430_n840# ro_div_0/divbuf_0/a_14910_n840# 0.07fF
C9188 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C9189 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C9190 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C9191 divbuf_2/a_13742_n240# divbuf_2/a_13470_n840# 0.01fF
C9192 pd_div_0/divbuf_0/a_21630_n1540# pd_div_0/divbuf_0/a_22110_n1540# 0.11fF
C9193 pd_div_0/divbuf_0/a_52350_n840# pd_div_0/divbuf_0/a_52350_n1540# 0.01fF
C9194 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9195 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_32670_n840# 0.04fF
C9196 divbuf_1/a_7302_n240# divbuf_1/a_7792_n240# 0.04fF
C9197 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6720_n1600# 0.26fF
C9198 divbuf_0/a_38962_n240# divbuf_0/a_39442_n240# 0.05fF
C9199 pll_full_0/divbuf_0/a_29310_n840# pll_full_0/divbuf_0/a_29310_n1540# 0.01fF
C9200 pll_full_0/divbuf_0/a_59550_n840# pll_full_0/divbuf_0/a_60030_n840# 0.07fF
C9201 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_59550_n1540# 0.19fF
C9202 divbuf_1/a_19680_n1600# divbuf_1/a_19710_n1540# 0.19fF
C9203 divbuf_1/a_17122_n240# divbuf_1/OUT4 0.04fF
C9204 divbuf_1/a_19710_n840# divbuf_1/a_20190_n840# 0.07fF
C9205 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n1540# 0.19fF
C9206 divbuf_0/a_50430_n840# divbuf_0/a_50910_n840# 0.07fF
C9207 divbuf_0/a_20190_n840# divbuf_0/a_20190_n1540# 0.01fF
C9208 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/a_30232_n240# 0.01fF
C9209 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/a_10212_n240# 0.05fF
C9210 divbuf_3/a_13440_n1600# divbuf_3/OUT4 0.00fF
C9211 divbuf_2/a_8762_170# divbuf_2/a_9242_170# 0.07fF
C9212 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19230_n840# 0.04fF
C9213 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/a_29742_170# 0.07fF
C9214 divbuf_2/a_42720_n1600# divbuf_2/a_43200_n1600# 0.26fF
C9215 divbuf_2/a_33622_n240# divbuf_2/a_33630_n840# 0.06fF
C9216 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22110_n1540# 0.19fF
C9217 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9218 pll_full_0/divbuf_1/a_22110_n840# pll_full_0/divbuf_1/a_22590_n840# 0.07fF
C9219 divbuf_0/a_6332_170# divbuf_0/a_5852_170# 0.07fF
C9220 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_16830_n840# 0.00fF
C9221 divbuf_2/a_35070_n1540# divbuf_2/a_35550_n1540# 0.11fF
C9222 divbuf_3/a_5280_n1600# divbuf_3/a_5760_n1600# 0.26fF
C9223 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_1440_n1600# 0.26fF
C9224 divbuf_3/a_28350_n840# divbuf_3/a_28350_n1540# 0.01fF
C9225 divbuf_3/a_58590_n840# divbuf_3/a_59070_n840# 0.07fF
C9226 divbuf_3/a_58560_n1600# divbuf_3/a_58590_n1540# 0.19fF
C9227 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_8670_n1540# 0.19fF
C9228 pd_div_0/divbuf_0/a_8670_n840# pd_div_0/divbuf_0/a_9150_n840# 0.07fF
C9229 ro_div_0/divbuf_0/a_54270_n840# ro_div_0/divbuf_0/a_54750_n840# 0.07fF
C9230 ro_div_0/divbuf_0/a_24030_n840# ro_div_0/divbuf_0/a_24030_n1540# 0.01fF
C9231 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54270_n1540# 0.19fF
C9232 divbuf_2/a_21012_170# divbuf_2/OUT4 0.19fF
C9233 divbuf_2/a_32640_n1600# divbuf_2/a_32670_n840# 0.04fF
C9234 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C9235 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C9236 ro_div_0/divider_0/tspc_0/Z2 ro_div_0/divider_0/tspc_0/Z3 0.16fF
C9237 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/B 0.18fF
C9238 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_3/vin 0.20fF
C9239 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C9240 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C9241 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/a_36990_n840# 0.05fF
C9242 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46560_n1600# 0.26fF
C9243 divbuf_1/a_6240_n1600# divbuf_1/a_6720_n1600# 0.26fF
C9244 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/a_19710_n840# 0.03fF
C9245 divbuf_0/a_36960_n1600# divbuf_0/a_37440_n1600# 0.26fF
C9246 divbuf_0/a_27802_n240# divbuf_0/a_27870_n840# 0.04fF
C9247 pll_full_0/divbuf_0/a_38430_n1540# pll_full_0/divbuf_0/a_38910_n1540# 0.11fF
C9248 divbuf_3/a_16152_n240# divbuf_3/a_15870_n840# 0.01fF
C9249 divbuf_1/a_29310_n840# divbuf_1/a_29310_n1540# 0.01fF
C9250 divbuf_1/a_59550_n840# divbuf_1/a_60030_n840# 0.07fF
C9251 divbuf_1/a_59520_n1600# divbuf_1/a_59550_n1540# 0.19fF
C9252 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_11550_n840# 0.02fF
C9253 divbuf_0/a_60030_n840# divbuf_0/a_60030_n1540# 0.01fF
C9254 divbuf_0/a_29310_n1540# divbuf_0/a_29790_n1540# 0.11fF
C9255 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_9120_n1600# 0.26fF
C9256 divbuf_2/a_30232_170# divbuf_2/a_30232_n240# 0.01fF
C9257 divbuf_2/a_9732_n240# divbuf_2/a_10212_n240# 0.05fF
C9258 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9259 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59070_n840# 0.04fF
C9260 divbuf_2/a_22080_n1600# divbuf_2/a_22110_n1540# 0.19fF
C9261 divbuf_2/a_21982_n240# divbuf_2/OUT4 0.04fF
C9262 divbuf_2/a_22110_n840# divbuf_2/a_22590_n840# 0.07fF
C9263 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/nor_1/A 0.55fF
C9264 pll_full_0/divbuf_1/a_990_n1540# pll_full_0/divbuf_1/a_1470_n1540# 0.11fF
C9265 pll_full_0/divbuf_1/a_31710_n840# pll_full_0/divbuf_1/a_31710_n1540# 0.01fF
C9266 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/OUT2 0.02fF
C9267 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9268 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36030_n840# 0.04fF
C9269 divbuf_3/a_11802_170# divbuf_3/a_12282_170# 0.07fF
C9270 divbuf_1/a_17122_n240# divbuf_1/a_16830_n840# 0.00fF
C9271 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n840# 0.04fF
C9272 divbuf_0/a_5852_170# divbuf_0/OUT3 0.19fF
C9273 divbuf_3/a_36052_n240# divbuf_3/a_36030_n840# 0.05fF
C9274 divbuf_3/a_45120_n1600# divbuf_3/a_45600_n1600# 0.26fF
C9275 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/a_37502_n240# 0.05fF
C9276 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/a_31710_n840# 0.05fF
C9277 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_41280_n1600# 0.26fF
C9278 divbuf_3/a_37470_n1540# divbuf_3/a_37950_n1540# 0.11fF
C9279 pd_div_0/divbuf_0/a_18270_n840# pd_div_0/divbuf_0/a_18270_n1540# 0.01fF
C9280 pd_div_0/divbuf_0/a_48510_n840# pd_div_0/divbuf_0/a_48990_n840# 0.07fF
C9281 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C9282 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48510_n1540# 0.19fF
C9283 ro_div_0/divbuf_0/a_33150_n1540# ro_div_0/divbuf_0/a_33630_n1540# 0.11fF
C9284 divbuf_2/a_20160_n1600# divbuf_2/OUT4 0.00fF
C9285 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z1 0.03fF
C9286 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z3 0.05fF
C9287 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_14222_n240# 0.05fF
C9288 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/a_33622_n240# 0.01fF
C9289 divbuf_0/a_24412_170# divbuf_0/a_24412_n240# 0.01fF
C9290 divbuf_0/a_3912_n240# divbuf_0/a_4392_n240# 0.05fF
C9291 pll_full_0/divbuf_0/a_25470_n840# pll_full_0/divbuf_0/a_25950_n840# 0.07fF
C9292 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9293 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25470_n1540# 0.19fF
C9294 divbuf_1/a_37022_n240# divbuf_1/a_36990_n840# 0.05fF
C9295 divbuf_1/a_46080_n1600# divbuf_1/a_46560_n1600# 0.26fF
C9296 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9297 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n1540# 0.19fF
C9298 divbuf_0/a_16350_n840# divbuf_0/a_16830_n840# 0.07fF
C9299 divbuf_0/a_10212_n240# divbuf_0/OUT3 0.04fF
C9300 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/a_15672_170# 0.07fF
C9301 divbuf_3/a_25862_170# divbuf_3/OUT4 0.19fF
C9302 divbuf_3/a_35040_n1600# divbuf_3/a_35070_n840# 0.04fF
C9303 divbuf_1/a_38430_n1540# divbuf_1/a_38910_n1540# 0.11fF
C9304 pd_div_0/pd_0/DOWN pd_div_0/pd_0/R 0.36fF
C9305 pd_div_0/pd_0/tspc_r_0/Z1 pd_div_0/pd_0/tspc_r_0/Z2 0.71fF
C9306 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z4 0.20fF
C9307 pd_div_0/div pd_div_0/pd_0/tspc_r_0/z5 0.04fF
C9308 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9309 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_30750_n840# 0.04fF
C9310 divbuf_2/a_8640_n1600# divbuf_2/a_9120_n1600# 0.26fF
C9311 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/a_39390_n840# 0.04fF
C9312 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48960_n1600# 0.26fF
C9313 pll_full_0/divbuf_1/a_40830_n1540# pll_full_0/divbuf_1/a_41310_n1540# 0.11fF
C9314 divbuf_2/a_990_n1540# divbuf_2/a_1470_n1540# 0.11fF
C9315 divbuf_2/a_31710_n840# divbuf_2/a_31710_n1540# 0.01fF
C9316 divbuf_2/a_510_n840# divbuf_2/OUT2 0.02fF
C9317 divbuf_3/a_32652_170# divbuf_3/a_32652_n240# 0.01fF
C9318 divbuf_3/a_12772_n240# divbuf_3/a_13252_n240# 0.05fF
C9319 divbuf_1/a_24412_170# divbuf_1/OUT4 0.19fF
C9320 divbuf_1/a_36000_n1600# divbuf_1/a_36030_n840# 0.04fF
C9321 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/a_28292_n240# 0.01fF
C9322 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/a_8272_n240# 0.05fF
C9323 divbuf_0/a_9120_n1600# divbuf_0/OUT3 0.00fF
C9324 divbuf_3/a_24510_n840# divbuf_3/a_24990_n840# 0.07fF
C9325 divbuf_3/a_26832_n240# divbuf_3/OUT4 0.04fF
C9326 divbuf_3/a_24480_n1600# divbuf_3/a_24510_n1540# 0.19fF
C9327 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/a_25950_n840# 0.03fF
C9328 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35520_n1600# 0.26fF
C9329 ro_div_0/divbuf_0/a_20190_n840# ro_div_0/divbuf_0/a_20670_n840# 0.07fF
C9330 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9331 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20190_n1540# 0.19fF
C9332 pd_div_0/divbuf_0/a_27390_n1540# pd_div_0/divbuf_0/a_27870_n1540# 0.11fF
C9333 pd_div_0/divbuf_0/a_58110_n840# pd_div_0/divbuf_0/a_58110_n1540# 0.01fF
C9334 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9335 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38430_n840# 0.04fF
C9336 divbuf_1/a_13742_n240# divbuf_1/a_14222_n240# 0.05fF
C9337 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12480_n1600# 0.26fF
C9338 divbuf_0/a_2880_n1600# divbuf_0/a_3360_n1600# 0.26fF
C9339 pll_full_0/divbuf_0/a_4350_n1540# pll_full_0/divbuf_0/a_4830_n1540# 0.11fF
C9340 pll_full_0/divbuf_0/a_35070_n840# pll_full_0/divbuf_0/a_35070_n1540# 0.01fF
C9341 divbuf_3/a_492_n240# divbuf_3/a_510_n840# 0.00fF
C9342 divbuf_1/a_25470_n840# divbuf_1/a_25950_n840# 0.07fF
C9343 divbuf_1/a_28772_n240# divbuf_1/OUT4 0.04fF
C9344 divbuf_1/a_25440_n1600# divbuf_1/a_25470_n1540# 0.19fF
C9345 divbuf_0/a_56190_n840# divbuf_0/a_56670_n840# 0.07fF
C9346 divbuf_0/a_25950_n840# divbuf_0/a_25950_n1540# 0.01fF
C9347 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n1540# 0.19fF
C9348 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_16642_n240# 0.04fF
C9349 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/a_36052_n240# 0.01fF
C9350 divbuf_3/a_24960_n1600# divbuf_3/OUT4 0.00fF
C9351 divbuf_2/a_15182_170# divbuf_2/a_15672_170# 0.07fF
C9352 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_24990_n840# 0.04fF
C9353 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/a_15672_n240# 0.01fF
C9354 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/a_35562_170# 0.07fF
C9355 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C9356 divbuf_2/a_39442_n240# divbuf_2/a_39390_n840# 0.04fF
C9357 divbuf_2/a_48480_n1600# divbuf_2/a_48960_n1600# 0.26fF
C9358 pll_full_0/divbuf_1/a_27870_n840# pll_full_0/divbuf_1/a_28350_n840# 0.07fF
C9359 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9360 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_27870_n1540# 0.19fF
C9361 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/Out 0.11fF
C9362 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/a_630_n680# 0.01fF
C9363 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C9364 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C9365 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.04fF
C9366 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_1950_n840# 0.04fF
C9367 divbuf_2/a_40830_n1540# divbuf_2/a_41310_n1540# 0.11fF
C9368 pd_0/R pd_0/REF 0.61fF
C9369 divbuf_0/a_13742_n240# divbuf_0/a_13470_n840# 0.01fF
C9370 divbuf_3/a_11040_n1600# divbuf_3/a_11520_n1600# 0.26fF
C9371 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_7200_n1600# 0.26fF
C9372 divbuf_3/a_3390_n1540# divbuf_3/a_3870_n1540# 0.11fF
C9373 divbuf_3/a_34110_n840# divbuf_3/a_34110_n1540# 0.01fF
C9374 pd_div_0/divbuf_0/a_14430_n840# pd_div_0/divbuf_0/a_14910_n840# 0.07fF
C9375 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14430_n1540# 0.19fF
C9376 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60030_n1540# 0.19fF
C9377 ro_div_0/divbuf_0/a_60030_n840# ro_div_0/divbuf_0/a_60510_n840# 0.07fF
C9378 ro_div_0/divbuf_0/a_29790_n840# ro_div_0/divbuf_0/a_29790_n1540# 0.01fF
C9379 divbuf_2/a_32652_170# divbuf_2/OUT4 0.19fF
C9380 divbuf_2/a_38400_n1600# divbuf_2/a_38430_n840# 0.04fF
C9381 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C9382 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/a_5362_n240# 0.01fF
C9383 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C9384 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C9385 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_52320_n1600# 0.26fF
C9386 divbuf_1/a_12000_n1600# divbuf_1/a_12480_n1600# 0.26fF
C9387 divbuf_0/a_33622_n240# divbuf_0/a_33630_n840# 0.06fF
C9388 divbuf_0/a_42720_n1600# divbuf_0/a_43200_n1600# 0.26fF
C9389 pll_full_0/divbuf_0/a_44190_n1540# pll_full_0/divbuf_0/a_44670_n1540# 0.11fF
C9390 divbuf_3/a_960_n1600# divbuf_3/a_990_n840# 0.04fF
C9391 divbuf_1/a_4350_n1540# divbuf_1/a_4830_n1540# 0.11fF
C9392 divbuf_1/a_35070_n840# divbuf_1/a_35070_n1540# 0.01fF
C9393 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_17310_n840# 0.00fF
C9394 divbuf_0/a_35070_n1540# divbuf_0/a_35550_n1540# 0.11fF
C9395 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14880_n1600# 0.26fF
C9396 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/a_4830_n840# 0.04fF
C9397 divbuf_2/a_16152_n240# divbuf_2/a_16642_n240# 0.04fF
C9398 divbuf_2/a_36052_170# divbuf_2/a_36052_n240# 0.01fF
C9399 divbuf_2/a_27870_n840# divbuf_2/a_28350_n840# 0.07fF
C9400 divbuf_2/a_33622_n240# divbuf_2/OUT4 0.04fF
C9401 divbuf_2/a_27840_n1600# divbuf_2/a_27870_n1540# 0.19fF
C9402 pll_full_0/divbuf_1/a_6750_n1540# pll_full_0/divbuf_1/a_7230_n1540# 0.11fF
C9403 pll_full_0/divbuf_1/a_37470_n840# pll_full_0/divbuf_1/a_37470_n1540# 0.01fF
C9404 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_41790_n840# 0.04fF
C9405 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9406 divbuf_3/a_17612_170# divbuf_3/a_18092_170# 0.07fF
C9407 divbuf_1/a_1920_n1600# divbuf_1/a_1950_n840# 0.04fF
C9408 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C9409 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/a_15182_170# 0.07fF
C9410 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n840# 0.04fF
C9411 divbuf_0/a_21012_170# divbuf_0/OUT4 0.19fF
C9412 divbuf_3/a_50880_n1600# divbuf_3/a_51360_n1600# 0.26fF
C9413 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_1440_n1600# 0.26fF
C9414 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_47040_n1600# 0.26fF
C9415 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/a_37470_n840# 0.05fF
C9416 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4350_n840# 0.04fF
C9417 divbuf_3/a_43230_n1540# divbuf_3/a_43710_n1540# 0.11fF
C9418 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54270_n1540# 0.19fF
C9419 pd_div_0/divbuf_0/a_24030_n840# pd_div_0/divbuf_0/a_24030_n1540# 0.01fF
C9420 pd_div_0/divbuf_0/a_54270_n840# pd_div_0/divbuf_0/a_54750_n840# 0.07fF
C9421 ro_div_0/divbuf_0/a_38910_n1540# ro_div_0/divbuf_0/a_39390_n1540# 0.11fF
C9422 divbuf_2/a_31680_n1600# divbuf_2/OUT4 0.00fF
C9423 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/B 0.18fF
C9424 pd_div_0/divider_0/tspc_0/Z2 pd_div_0/divider_0/tspc_0/Z3 0.16fF
C9425 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/a_20042_n240# 0.05fF
C9426 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/a_39442_n240# 0.01fF
C9427 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/a_21982_n240# 0.01fF
C9428 divbuf_0/a_9732_n240# divbuf_0/a_10212_n240# 0.05fF
C9429 divbuf_0/a_30232_170# divbuf_0/a_30232_n240# 0.01fF
C9430 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9431 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31230_n1540# 0.19fF
C9432 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/a_990_n1540# 0.01fF
C9433 pll_full_0/divbuf_0/a_31230_n840# pll_full_0/divbuf_0/a_31710_n840# 0.07fF
C9434 divbuf_1/a_51840_n1600# divbuf_1/a_52320_n1600# 0.26fF
C9435 divbuf_1/a_11312_170# divbuf_1/OUT4 0.23fF
C9436 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C9437 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/a_14702_n240# 0.01fF
C9438 divbuf_0/a_22110_n840# divbuf_0/a_22590_n840# 0.07fF
C9439 divbuf_0/a_21982_n240# divbuf_0/OUT4 0.04fF
C9440 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n1540# 0.19fF
C9441 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/a_21502_170# 0.07fF
C9442 divbuf_3/a_40800_n1600# divbuf_3/a_40830_n840# 0.04fF
C9443 divbuf_3/a_37502_170# divbuf_3/OUT4 0.19fF
C9444 divbuf_1/a_44190_n1540# divbuf_1/a_44670_n1540# 0.11fF
C9445 pd_div_0/pd_0/tspc_r_0/Z4 pd_div_0/pd_0/tspc_r_1/Z4 0.02fF
C9446 pd_div_0/pd_0/DOWN pd_div_0/pd_0/and_pd_0/Out1 0.12fF
C9447 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/UP 0.11fF
C9448 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z1 0.17fF
C9449 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36510_n840# 0.04fF
C9450 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9451 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54720_n1600# 0.26fF
C9452 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/OUT3 0.19fF
C9453 divbuf_2/a_14400_n1600# divbuf_2/a_14880_n1600# 0.26fF
C9454 divbuf_2/a_4882_n240# divbuf_2/a_4830_n840# 0.04fF
C9455 divbuf_2/a_6750_n1540# divbuf_2/a_7230_n1540# 0.11fF
C9456 divbuf_2/a_37470_n840# divbuf_2/a_37470_n1540# 0.01fF
C9457 pll_full_0/divbuf_1/a_46590_n1540# pll_full_0/divbuf_1/a_47070_n1540# 0.11fF
C9458 divbuf_3/a_18582_n240# divbuf_3/a_19072_n240# 0.04fF
C9459 divbuf_3/a_38472_170# divbuf_3/a_38472_n240# 0.01fF
C9460 divbuf_1/a_41760_n1600# divbuf_1/a_41790_n840# 0.04fF
C9461 divbuf_1/a_39442_170# divbuf_1/OUT4 0.19fF
C9462 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/a_34112_n240# 0.01fF
C9463 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_14702_n240# 0.05fF
C9464 divbuf_0/a_20160_n1600# divbuf_0/OUT4 0.00fF
C9465 divbuf_3/a_30270_n840# divbuf_3/a_30750_n840# 0.07fF
C9466 divbuf_3/a_38472_n240# divbuf_3/OUT4 0.04fF
C9467 divbuf_3/a_30240_n1600# divbuf_3/a_30270_n1540# 0.19fF
C9468 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_41280_n1600# 0.26fF
C9469 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/a_31710_n840# 0.05fF
C9470 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_25950_n1540# 0.19fF
C9471 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9472 ro_div_0/divbuf_0/a_25950_n840# ro_div_0/divbuf_0/a_26430_n840# 0.07fF
C9473 divbuf_2/a_4320_n1600# divbuf_2/a_4350_n840# 0.04fF
C9474 pd_div_0/divbuf_0/a_33150_n1540# pd_div_0/divbuf_0/a_33630_n1540# 0.11fF
C9475 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C9476 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44190_n840# 0.04fF
C9477 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z2 0.14fF
C9478 divbuf_1/a_19562_n240# divbuf_1/a_20042_n240# 0.05fF
C9479 divbuf_1/a_39442_170# divbuf_1/a_39442_n240# 0.01fF
C9480 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_18240_n1600# 0.26fF
C9481 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/a_8190_n840# 0.03fF
C9482 divbuf_0/a_8640_n1600# divbuf_0/a_9120_n1600# 0.26fF
C9483 pll_full_0/divbuf_0/a_10110_n1540# pll_full_0/divbuf_0/a_10590_n1540# 0.11fF
C9484 pll_full_0/divbuf_0/a_40830_n840# pll_full_0/divbuf_0/a_40830_n1540# 0.01fF
C9485 divbuf_1/a_40412_n240# divbuf_1/OUT4 0.04fF
C9486 divbuf_1/a_31200_n1600# divbuf_1/a_31230_n1540# 0.19fF
C9487 divbuf_1/a_990_n840# divbuf_1/a_990_n1540# 0.01fF
C9488 divbuf_1/a_31230_n840# divbuf_1/a_31710_n840# 0.07fF
C9489 divbuf_0/a_510_n840# divbuf_0/OUT2 0.02fF
C9490 divbuf_0/a_31710_n840# divbuf_0/a_31710_n1540# 0.01fF
C9491 divbuf_0/a_990_n1540# divbuf_0/a_1470_n1540# 0.11fF
C9492 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/a_22472_n240# 0.04fF
C9493 divbuf_3/a_36480_n1600# divbuf_3/OUT4 0.00fF
C9494 divbuf_2/a_21012_170# divbuf_2/a_21502_170# 0.07fF
C9495 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_30750_n840# 0.04fF
C9496 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/a_41382_170# 0.07fF
C9497 divbuf_2/a_54240_n1600# divbuf_2/a_54720_n1600# 0.26fF
C9498 divbuf_2/a_3912_170# divbuf_2/OUT3 0.19fF
C9499 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_33630_n1540# 0.19fF
C9500 pll_full_0/divbuf_1/a_3390_n840# pll_full_0/divbuf_1/a_3390_n1540# 0.01fF
C9501 pll_full_0/divbuf_1/a_33630_n840# pll_full_0/divbuf_1/a_34110_n840# 0.07fF
C9502 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_0/Z3 0.38fF
C9503 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C9504 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C9505 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_7710_n840# 0.04fF
C9506 divbuf_2/a_46590_n1540# divbuf_2/a_47070_n1540# 0.11fF
C9507 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11070_n840# 0.02fF
C9508 divbuf_3/a_16800_n1600# divbuf_3/a_17280_n1600# 0.26fF
C9509 divbuf_3/a_7302_n240# divbuf_3/a_7230_n840# 0.03fF
C9510 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12960_n1600# 0.26fF
C9511 divbuf_3/a_9150_n1540# divbuf_3/a_9630_n1540# 0.11fF
C9512 divbuf_3/a_39870_n840# divbuf_3/a_39870_n1540# 0.01fF
C9513 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20190_n1540# 0.19fF
C9514 pd_div_0/divbuf_0/a_20190_n840# pd_div_0/divbuf_0/a_20670_n840# 0.07fF
C9515 ro_div_0/divbuf_0/a_35550_n840# ro_div_0/divbuf_0/a_35550_n1540# 0.01fF
C9516 ro_div_0/divbuf_0/a_4830_n1540# ro_div_0/divbuf_0/a_5310_n1540# 0.11fF
C9517 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/a_24892_170# 0.07fF
C9518 divbuf_2/a_4882_n240# divbuf_2/OUT3 0.04fF
C9519 divbuf_2/a_44160_n1600# divbuf_2/a_44190_n840# 0.04fF
C9520 divbuf_1/a_17760_n1600# divbuf_1/a_18240_n1600# 0.26fF
C9521 divbuf_1/a_8272_n240# divbuf_1/a_8190_n840# 0.03fF
C9522 divbuf_0/a_13742_170# divbuf_0/a_14222_170# 0.07fF
C9523 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z2 0.11fF
C9524 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_58080_n1600# 0.26fF
C9525 pll_full_0/divbuf_0/a_12282_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9526 divbuf_0/a_48480_n1600# divbuf_0/a_48960_n1600# 0.26fF
C9527 divbuf_0/a_39442_n240# divbuf_0/a_39390_n840# 0.04fF
C9528 pll_full_0/divbuf_0/a_49950_n1540# pll_full_0/divbuf_0/a_50430_n1540# 0.11fF
C9529 divbuf_3/a_6720_n1600# divbuf_3/a_6750_n840# 0.04fF
C9530 divbuf_1/a_10110_n1540# divbuf_1/a_10590_n1540# 0.11fF
C9531 divbuf_1/a_40830_n840# divbuf_1/a_40830_n1540# 0.01fF
C9532 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2430_n840# 0.04fF
C9533 divbuf_0/a_40830_n1540# divbuf_0/a_41310_n1540# 0.11fF
C9534 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20640_n1600# 0.26fF
C9535 divbuf_2/a_21982_n240# divbuf_2/a_22472_n240# 0.04fF
C9536 divbuf_2/a_33600_n1600# divbuf_2/a_33630_n1540# 0.19fF
C9537 divbuf_2/a_3390_n840# divbuf_2/a_3390_n1540# 0.01fF
C9538 divbuf_2/a_33630_n840# divbuf_2/a_34110_n840# 0.07fF
C9539 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C9540 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/a_630_n680# 0.01fF
C9541 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/Out 0.11fF
C9542 pll_full_0/divbuf_1/a_12510_n1540# pll_full_0/divbuf_1/a_12990_n1540# 0.11fF
C9543 pll_full_0/divbuf_1/a_43230_n840# pll_full_0/divbuf_1/a_43230_n1540# 0.01fF
C9544 divbuf_0/a_14702_170# divbuf_0/a_14702_n240# 0.01fF
C9545 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9546 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_47550_n840# 0.04fF
C9547 divbuf_3/a_23442_170# divbuf_3/a_23922_170# 0.07fF
C9548 divbuf_3/a_3422_170# divbuf_3/a_3422_n240# 0.01fF
C9549 divbuf_1/a_7680_n1600# divbuf_1/a_7710_n840# 0.04fF
C9550 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9551 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/a_5852_n240# 0.01fF
C9552 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n840# 0.04fF
C9553 divbuf_0/a_32652_170# divbuf_0/OUT4 0.19fF
C9554 divbuf_3/a_8762_170# divbuf_3/OUT3 0.19fF
C9555 divbuf_3/a_56640_n1600# divbuf_3/a_57120_n1600# 0.26fF
C9556 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_7200_n1600# 0.26fF
C9557 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9558 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52800_n1600# 0.26fF
C9559 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10110_n840# 0.04fF
C9560 divbuf_3/a_48990_n1540# divbuf_3/a_49470_n1540# 0.11fF
C9561 pd_div_0/divbuf_0/a_29790_n840# pd_div_0/divbuf_0/a_29790_n1540# 0.01fF
C9562 pd_div_0/divbuf_0/a_60030_n840# pd_div_0/divbuf_0/a_60510_n840# 0.07fF
C9563 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60030_n1540# 0.19fF
C9564 ro_div_0/divbuf_0/a_44670_n1540# ro_div_0/divbuf_0/a_45150_n1540# 0.11fF
C9565 divbuf_1/a_30712_170# divbuf_1/a_30712_n240# 0.01fF
C9566 divbuf_1/a_21012_170# divbuf_1/a_21502_170# 0.07fF
C9567 pll_full_0/divbuf_1/a_510_n1540# pll_full_0/divbuf_1/OUT 0.11fF
C9568 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/a_25862_n240# 0.05fF
C9569 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/a_27802_n240# 0.01fF
C9570 divbuf_0/a_36052_170# divbuf_0/a_36052_n240# 0.01fF
C9571 divbuf_0/a_16152_n240# divbuf_0/a_16642_n240# 0.04fF
C9572 pll_full_0/divbuf_0/a_6750_n840# pll_full_0/divbuf_0/a_6750_n1540# 0.01fF
C9573 pll_full_0/divbuf_0/a_36990_n840# pll_full_0/divbuf_0/a_37470_n840# 0.07fF
C9574 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/OUT3 0.01fF
C9575 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_36990_n1540# 0.19fF
C9576 divbuf_1/a_57600_n1600# divbuf_1/a_58080_n1600# 0.26fF
C9577 divbuf_1/a_12282_170# divbuf_1/OUT4 0.19fF
C9578 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9579 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n1540# 0.19fF
C9580 divbuf_0/a_33622_n240# divbuf_0/OUT4 0.04fF
C9581 divbuf_0/a_27870_n840# divbuf_0/a_28350_n840# 0.07fF
C9582 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/a_6822_n240# 0.01fF
C9583 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/a_27322_170# 0.07fF
C9584 divbuf_3/a_9732_n240# divbuf_3/OUT3 0.04fF
C9585 divbuf_3/a_46560_n1600# divbuf_3/a_46590_n840# 0.04fF
C9586 divbuf_1/a_49950_n1540# divbuf_1/a_50430_n1540# 0.11fF
C9587 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/a_14222_170# 0.07fF
C9588 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9589 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42270_n840# 0.04fF
C9590 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60480_n1600# 0.26fF
C9591 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9592 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C9593 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C9594 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C9595 divbuf_2/a_20160_n1600# divbuf_2/a_20640_n1600# 0.26fF
C9596 divbuf_2/a_12510_n1540# divbuf_2/a_12990_n1540# 0.11fF
C9597 divbuf_2/a_43230_n840# divbuf_2/a_43230_n1540# 0.01fF
C9598 divbuf_1/a_23442_170# divbuf_1/a_23442_n240# 0.01fF
C9599 pll_full_0/divbuf_1/a_52350_n1540# pll_full_0/divbuf_1/a_52830_n1540# 0.11fF
C9600 pd_div_0/div pd_div_0/divbuf_0/a_510_n840# 0.07fF
C9601 divbuf_3/a_24412_n240# divbuf_3/a_24892_n240# 0.05fF
C9602 divbuf_1/a_11802_n240# divbuf_1/OUT4 0.04fF
C9603 divbuf_1/a_47520_n1600# divbuf_1/a_47550_n840# 0.04fF
C9604 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/a_39932_n240# 0.01fF
C9605 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/a_20532_n240# 0.04fF
C9606 divbuf_0/a_31680_n1600# divbuf_0/OUT4 0.00fF
C9607 divbuf_3/a_5790_n840# divbuf_3/a_5790_n1540# 0.01fF
C9608 divbuf_3/a_36030_n840# divbuf_3/a_36510_n840# 0.07fF
C9609 divbuf_3/a_8640_n1600# divbuf_3/OUT3 0.00fF
C9610 divbuf_3/a_36000_n1600# divbuf_3/a_36030_n1540# 0.19fF
C9611 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/a_37470_n840# 0.05fF
C9612 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_47040_n1600# 0.26fF
C9613 ro_div_0/divbuf_0/a_31710_n840# ro_div_0/divbuf_0/a_32190_n840# 0.07fF
C9614 ro_div_0/divbuf_0/a_1470_n840# ro_div_0/divbuf_0/a_1470_n1540# 0.01fF
C9615 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_31710_n1540# 0.19fF
C9616 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9617 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9618 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_49950_n840# 0.04fF
C9619 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/a_9732_170# 0.07fF
C9620 divbuf_2/a_10080_n1600# divbuf_2/a_10110_n840# 0.04fF
C9621 pd_div_0/divbuf_0/a_38910_n1540# pd_div_0/divbuf_0/a_39390_n1540# 0.11fF
C9622 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/nor_1/A 1.21fF
C9623 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C9624 divbuf_1/a_25382_n240# divbuf_1/a_25862_n240# 0.05fF
C9625 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_14430_n840# 0.02fF
C9626 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_24000_n1600# 0.26fF
C9627 divbuf_2/a_510_n1540# divbuf_2/OUT 0.11fF
C9628 ashish_0/a_150_0# ashish_0/Gnd 1.74fF
C9629 ashish_0/a_150_n710# ashish_0/vop 9.14fF
C9630 divbuf_0/a_4882_n240# divbuf_0/a_4830_n840# 0.04fF
C9631 divbuf_0/a_14400_n1600# divbuf_0/a_14880_n1600# 0.26fF
C9632 pll_full_0/divbuf_0/a_15870_n1540# pll_full_0/divbuf_0/a_16350_n1540# 0.11fF
C9633 pll_full_0/divbuf_0/a_46590_n840# pll_full_0/divbuf_0/a_46590_n1540# 0.01fF
C9634 divbuf_1/a_6750_n840# divbuf_1/a_6750_n1540# 0.01fF
C9635 divbuf_1/a_36990_n840# divbuf_1/a_37470_n840# 0.07fF
C9636 divbuf_1/a_10560_n1600# divbuf_1/OUT3 0.01fF
C9637 divbuf_1/a_36960_n1600# divbuf_1/a_36990_n1540# 0.19fF
C9638 divbuf_0/a_37470_n840# divbuf_0/a_37470_n1540# 0.01fF
C9639 divbuf_0/a_6750_n1540# divbuf_0/a_7230_n1540# 0.11fF
C9640 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/a_28292_n240# 0.04fF
C9641 divbuf_2/a_6822_170# divbuf_2/a_6822_n240# 0.01fF
C9642 divbuf_2/a_26832_170# divbuf_2/a_27322_170# 0.07fF
C9643 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36510_n840# 0.04fF
C9644 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/a_7302_n240# 0.05fF
C9645 divbuf_2/a_60000_n1600# divbuf_2/a_60480_n1600# 0.26fF
C9646 divbuf_2/a_15672_170# divbuf_2/OUT4 0.19fF
C9647 pll_full_0/divbuf_1/a_9150_n840# pll_full_0/divbuf_1/a_9150_n1540# 0.01fF
C9648 pll_full_0/divbuf_1/a_39390_n840# pll_full_0/divbuf_1/a_39870_n840# 0.07fF
C9649 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39390_n1540# 0.19fF
C9650 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C9651 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C9652 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13470_n840# 0.04fF
C9653 divbuf_2/a_52350_n1540# divbuf_2/a_52830_n1540# 0.11fF
C9654 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_16830_n840# 0.00fF
C9655 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n840# 0.04fF
C9656 divbuf_3/a_13252_n240# divbuf_3/a_13470_n840# 0.02fF
C9657 divbuf_3/a_22560_n1600# divbuf_3/a_23040_n1600# 0.26fF
C9658 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/a_8670_n840# 0.03fF
C9659 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18720_n1600# 0.26fF
C9660 divbuf_3/a_14910_n1540# divbuf_3/a_15390_n1540# 0.11fF
C9661 divbuf_3/a_45630_n840# divbuf_3/a_45630_n1540# 0.01fF
C9662 pd_div_0/divbuf_0/a_25950_n840# pd_div_0/divbuf_0/a_26430_n840# 0.07fF
C9663 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9664 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_25950_n1540# 0.19fF
C9665 ro_div_0/divbuf_0/a_41310_n840# ro_div_0/divbuf_0/a_41310_n1540# 0.01fF
C9666 ro_div_0/divbuf_0/a_10590_n1540# ro_div_0/divbuf_0/a_11070_n1540# 0.11fF
C9667 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/a_30712_170# 0.07fF
C9668 divbuf_2/a_16642_n240# divbuf_2/OUT4 0.04fF
C9669 divbuf_2/a_49920_n1600# divbuf_2/a_49950_n840# 0.04fF
C9670 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z2 0.14fF
C9671 divbuf_0/a_21012_170# divbuf_0/a_21502_170# 0.07fF
C9672 divbuf_1/a_14222_n240# divbuf_1/a_14430_n840# 0.02fF
C9673 divbuf_1/a_23520_n1600# divbuf_1/a_24000_n1600# 0.26fF
C9674 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/a_3390_n840# 0.07fF
C9675 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9676 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_2910_n1540# 0.19fF
C9677 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C9678 divbuf_0/a_54240_n1600# divbuf_0/a_54720_n1600# 0.26fF
C9679 pll_full_0/divbuf_0/a_55710_n1540# pll_full_0/divbuf_0/a_56190_n1540# 0.11fF
C9680 divbuf_3/a_12480_n1600# divbuf_3/a_12510_n840# 0.04fF
C9681 divbuf_1/a_15870_n1540# divbuf_1/a_16350_n1540# 0.11fF
C9682 divbuf_1/a_46590_n840# divbuf_1/a_46590_n1540# 0.01fF
C9683 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8190_n840# 0.04fF
C9684 divbuf_0/a_46590_n1540# divbuf_0/a_47070_n1540# 0.11fF
C9685 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_26400_n1600# 0.26fF
C9686 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_16830_n840# 0.02fF
C9687 divbuf_2/a_27802_n240# divbuf_2/a_28292_n240# 0.04fF
C9688 divbuf_2/a_9150_n840# divbuf_2/a_9150_n1540# 0.01fF
C9689 divbuf_2/a_39390_n840# divbuf_2/a_39870_n840# 0.07fF
C9690 divbuf_2/a_39360_n1600# divbuf_2/a_39390_n1540# 0.19fF
C9691 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_0/Z3 0.38fF
C9692 pll_full_0/divbuf_1/a_18270_n1540# pll_full_0/divbuf_1/a_18750_n1540# 0.11fF
C9693 pll_full_0/divbuf_1/a_48990_n840# pll_full_0/divbuf_1/a_48990_n1540# 0.01fF
C9694 divbuf_1/a_13440_n1600# divbuf_1/a_13470_n840# 0.04fF
C9695 divbuf_1/a_33622_170# divbuf_1/OUT4 0.19fF
C9696 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53310_n840# 0.04fF
C9697 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9698 divbuf_3/a_9242_170# divbuf_3/a_9242_n240# 0.01fF
C9699 divbuf_3/a_29262_170# divbuf_3/a_29742_170# 0.07fF
C9700 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9701 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/a_25382_170# 0.07fF
C9702 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n840# 0.04fF
C9703 divbuf_0/a_4882_n240# divbuf_0/OUT3 0.04fF
C9704 divbuf_3/a_1950_n840# divbuf_3/a_2430_n840# 0.07fF
C9705 divbuf_3/a_20532_170# divbuf_3/OUT4 0.19fF
C9706 divbuf_3/a_1920_n1600# divbuf_3/a_1950_n1540# 0.19fF
C9707 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12960_n1600# 0.26fF
C9708 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58560_n1600# 0.26fF
C9709 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_15870_n840# 0.04fF
C9710 divbuf_3/a_54750_n1540# divbuf_3/a_55230_n1540# 0.11fF
C9711 pd_div_0/divbuf_0/a_4830_n1540# pd_div_0/divbuf_0/a_5310_n1540# 0.11fF
C9712 pd_div_0/divbuf_0/a_35550_n840# pd_div_0/divbuf_0/a_35550_n1540# 0.01fF
C9713 ro_div_0/divbuf_0/a_50430_n1540# ro_div_0/divbuf_0/a_50910_n1540# 0.11fF
C9714 divbuf_1/a_26832_170# divbuf_1/a_27322_170# 0.07fF
C9715 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/a_31682_n240# 0.05fF
C9716 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/a_33622_n240# 0.01fF
C9717 divbuf_0/a_21982_n240# divbuf_0/a_22472_n240# 0.04fF
C9718 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C9719 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_42750_n1540# 0.19fF
C9720 pll_full_0/divbuf_0/a_12510_n840# pll_full_0/divbuf_0/a_12510_n1540# 0.01fF
C9721 pll_full_0/divbuf_0/a_42750_n840# pll_full_0/divbuf_0/a_43230_n840# 0.07fF
C9722 divbuf_1/a_2910_n840# divbuf_1/a_3390_n840# 0.07fF
C9723 divbuf_1/a_19072_170# divbuf_1/OUT4 0.19fF
C9724 divbuf_1/a_2880_n1600# divbuf_1/a_2910_n1540# 0.19fF
C9725 divbuf_0/a_33630_n840# divbuf_0/a_34110_n840# 0.07fF
C9726 divbuf_0/a_3390_n840# divbuf_0/a_3390_n1540# 0.01fF
C9727 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n1540# 0.19fF
C9728 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/a_13252_n240# 0.01fF
C9729 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/a_33142_170# 0.07fF
C9730 divbuf_3/a_52320_n1600# divbuf_3/a_52350_n840# 0.04fF
C9731 divbuf_3/a_21502_n240# divbuf_3/OUT4 0.04fF
C9732 divbuf_1/a_55710_n1540# divbuf_1/a_56190_n1540# 0.11fF
C9733 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2430_n840# 0.04fF
C9734 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/a_9732_170# 0.07fF
C9735 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48030_n840# 0.04fF
C9736 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9737 pll_full_0/divbuf_1/a_5310_n840# pll_full_0/divbuf_1/a_5790_n840# 0.07fF
C9738 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9739 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5310_n1540# 0.19fF
C9740 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C9741 divbuf_2/a_25920_n1600# divbuf_2/a_26400_n1600# 0.26fF
C9742 divbuf_2/a_16642_n240# divbuf_2/a_16830_n840# 0.02fF
C9743 divbuf_2/a_18270_n1540# divbuf_2/a_18750_n1540# 0.11fF
C9744 divbuf_2/a_48990_n840# divbuf_2/a_48990_n1540# 0.01fF
C9745 divbuf_1/a_29262_170# divbuf_1/a_29262_n240# 0.01fF
C9746 pll_full_0/divbuf_1/a_58110_n1540# pll_full_0/divbuf_1/a_58590_n1540# 0.11fF
C9747 divbuf_3/a_30232_n240# divbuf_3/a_30712_n240# 0.05fF
C9748 divbuf_1/a_53280_n1600# divbuf_1/a_53310_n840# 0.04fF
C9749 divbuf_1/a_23442_n240# divbuf_1/OUT4 0.04fF
C9750 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/a_26352_n240# 0.04fF
C9751 divbuf_3/a_11550_n840# divbuf_3/a_11550_n1540# 0.01fF
C9752 divbuf_3/a_41790_n840# divbuf_3/a_42270_n840# 0.07fF
C9753 divbuf_3/a_19680_n1600# divbuf_3/OUT4 0.00fF
C9754 divbuf_3/a_41760_n1600# divbuf_3/a_41790_n1540# 0.19fF
C9755 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52800_n1600# 0.26fF
C9756 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/a_11802_n240# 0.01fF
C9757 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37470_n1540# 0.19fF
C9758 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C9759 ro_div_0/divbuf_0/a_37470_n840# ro_div_0/divbuf_0/a_37950_n840# 0.07fF
C9760 ro_div_0/divbuf_0/a_7230_n840# ro_div_0/divbuf_0/a_7230_n1540# 0.01fF
C9761 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9762 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_55710_n840# 0.04fF
C9763 divbuf_2/a_15840_n1600# divbuf_2/a_15870_n840# 0.04fF
C9764 pd_div_0/divbuf_0/a_44670_n1540# pd_div_0/divbuf_0/a_45150_n1540# 0.11fF
C9765 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z3 0.65fF
C9766 divbuf_1/a_31202_n240# divbuf_1/a_31682_n240# 0.05fF
C9767 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29760_n1600# 0.26fF
C9768 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/a_20190_n840# 0.03fF
C9769 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C9770 divbuf_0/a_20160_n1600# divbuf_0/a_20640_n1600# 0.26fF
C9771 pll_full_0/divbuf_0/a_21630_n1540# pll_full_0/divbuf_0/a_22110_n1540# 0.11fF
C9772 pll_full_0/divbuf_0/a_52350_n840# pll_full_0/divbuf_0/a_52350_n1540# 0.01fF
C9773 divbuf_1/a_21600_n1600# divbuf_1/OUT4 0.01fF
C9774 divbuf_1/a_42720_n1600# divbuf_1/a_42750_n1540# 0.19fF
C9775 divbuf_1/a_12510_n840# divbuf_1/a_12510_n1540# 0.01fF
C9776 divbuf_1/a_42750_n840# divbuf_1/a_43230_n840# 0.07fF
C9777 divbuf_0/a_43230_n840# divbuf_0/a_43230_n1540# 0.01fF
C9778 divbuf_0/a_12510_n1540# divbuf_0/a_12990_n1540# 0.11fF
C9779 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/a_34112_n240# 0.04fF
C9780 divbuf_2/a_13252_170# divbuf_2/a_13252_n240# 0.01fF
C9781 divbuf_2/a_32652_170# divbuf_2/a_33142_170# 0.07fF
C9782 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42270_n840# 0.04fF
C9783 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_13742_n240# 0.04fF
C9784 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45150_n1540# 0.19fF
C9785 pll_full_0/divbuf_1/a_14910_n840# pll_full_0/divbuf_1/a_14910_n1540# 0.01fF
C9786 pll_full_0/divbuf_1/a_45150_n840# pll_full_0/divbuf_1/a_45630_n840# 0.07fF
C9787 divbuf_2/a_5310_n840# divbuf_2/a_5790_n840# 0.07fF
C9788 divbuf_2/a_27322_170# divbuf_2/OUT4 0.19fF
C9789 divbuf_2/a_5280_n1600# divbuf_2/a_5310_n1540# 0.19fF
C9790 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/Out 0.15fF
C9791 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.64fF
C9792 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19230_n840# 0.04fF
C9793 divbuf_2/a_58110_n1540# divbuf_2/a_58590_n1540# 0.11fF
C9794 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/a_10212_170# 0.07fF
C9795 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n840# 0.04fF
C9796 divbuf_3/a_28320_n1600# divbuf_3/a_28800_n1600# 0.26fF
C9797 divbuf_3/a_19072_n240# divbuf_3/a_19230_n840# 0.02fF
C9798 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_14910_n840# 0.02fF
C9799 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24480_n1600# 0.26fF
C9800 divbuf_0/a_510_n1540# divbuf_0/OUT 0.11fF
C9801 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/a_1950_n840# 0.03fF
C9802 divbuf_3/a_20670_n1540# divbuf_3/a_21150_n1540# 0.11fF
C9803 divbuf_3/a_51390_n840# divbuf_3/a_51390_n1540# 0.01fF
C9804 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9805 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_31710_n1540# 0.19fF
C9806 pd_div_0/divbuf_0/a_1470_n840# pd_div_0/divbuf_0/a_1470_n1540# 0.01fF
C9807 pd_div_0/divbuf_0/a_31710_n840# pd_div_0/divbuf_0/a_32190_n840# 0.07fF
C9808 ro_div_0/divbuf_0/a_47070_n840# ro_div_0/divbuf_0/a_47070_n1540# 0.01fF
C9809 ro_div_0/divbuf_0/a_16350_n1540# ro_div_0/divbuf_0/a_16830_n1540# 0.11fF
C9810 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/a_36532_170# 0.07fF
C9811 divbuf_2/a_28292_n240# divbuf_2/OUT4 0.04fF
C9812 divbuf_2/a_55680_n1600# divbuf_2/a_55710_n840# 0.04fF
C9813 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C9814 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/nor_1/A 1.21fF
C9815 divbuf_0/a_26832_170# divbuf_0/a_27322_170# 0.07fF
C9816 divbuf_0/a_8272_170# divbuf_0/a_8272_n240# 0.01fF
C9817 divbuf_1/a_29280_n1600# divbuf_1/a_29760_n1600# 0.26fF
C9818 divbuf_1/a_20042_n240# divbuf_1/a_20190_n840# 0.03fF
C9819 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_8670_n1540# 0.19fF
C9820 pll_full_0/divbuf_0/a_8670_n840# pll_full_0/divbuf_0/a_9150_n840# 0.07fF
C9821 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9822 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C9823 divbuf_0/a_60000_n1600# divbuf_0/a_60480_n1600# 0.26fF
C9824 divbuf_3/a_18240_n1600# divbuf_3/a_18270_n840# 0.04fF
C9825 divbuf_1/a_21630_n1540# divbuf_1/a_22110_n1540# 0.11fF
C9826 divbuf_1/a_52350_n840# divbuf_1/a_52350_n1540# 0.01fF
C9827 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_13950_n840# 0.04fF
C9828 divbuf_0/a_52350_n1540# divbuf_0/a_52830_n1540# 0.11fF
C9829 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_32160_n1600# 0.26fF
C9830 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/a_22590_n840# 0.03fF
C9831 divbuf_2/a_33622_n240# divbuf_2/a_34112_n240# 0.04fF
C9832 divbuf_2/a_45120_n1600# divbuf_2/a_45150_n1540# 0.19fF
C9833 divbuf_2/a_14910_n840# divbuf_2/a_14910_n1540# 0.01fF
C9834 divbuf_2/a_45150_n840# divbuf_2/a_45630_n840# 0.07fF
C9835 divbuf_1/a_16642_170# divbuf_1/a_16642_n240# 0.01fF
C9836 pll_full_0/divbuf_1/a_24030_n1540# pll_full_0/divbuf_1/a_24510_n1540# 0.11fF
C9837 pll_full_0/divbuf_1/a_54750_n840# pll_full_0/divbuf_1/a_54750_n1540# 0.01fF
C9838 divbuf_1/a_19200_n1600# divbuf_1/a_19230_n840# 0.04fF
C9839 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9840 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59070_n840# 0.04fF
C9841 divbuf_3/a_15672_170# divbuf_3/a_15672_n240# 0.01fF
C9842 divbuf_3/a_35082_170# divbuf_3/a_35562_170# 0.07fF
C9843 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9844 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/a_31202_170# 0.07fF
C9845 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n840# 0.04fF
C9846 divbuf_0/a_16642_n240# divbuf_0/OUT4 0.04fF
C9847 divbuf_3/a_7710_n840# divbuf_3/a_8190_n840# 0.07fF
C9848 divbuf_3/a_32172_170# divbuf_3/OUT4 0.19fF
C9849 divbuf_3/a_7680_n1600# divbuf_3/a_7710_n1540# 0.19fF
C9850 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18720_n1600# 0.26fF
C9851 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Z3 0.29fF
C9852 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3390_n1540# 0.19fF
C9853 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9854 ro_div_0/divbuf_0/a_3390_n840# ro_div_0/divbuf_0/a_3870_n840# 0.07fF
C9855 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_21630_n840# 0.04fF
C9856 divbuf_3/a_60510_n1540# divbuf_3/a_60990_n1540# 0.11fF
C9857 divbuf_2/a_1842_n240# divbuf_2/a_1950_n840# 0.03fF
C9858 pd_div_0/divbuf_0/a_10590_n1540# pd_div_0/divbuf_0/a_11070_n1540# 0.11fF
C9859 pd_div_0/divbuf_0/a_41310_n840# pd_div_0/divbuf_0/a_41310_n1540# 0.01fF
C9860 ro_div_0/divbuf_0/a_56190_n1540# ro_div_0/divbuf_0/a_56670_n1540# 0.11fF
C9861 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/a_37502_n240# 0.05fF
C9862 divbuf_1/a_36052_170# divbuf_1/a_36532_170# 0.07fF
C9863 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/a_39442_n240# 0.01fF
C9864 divbuf_0/a_27802_n240# divbuf_0/a_28292_n240# 0.04fF
C9865 pll_full_0/divbuf_0/a_18270_n840# pll_full_0/divbuf_0/a_18270_n1540# 0.01fF
C9866 pll_full_0/divbuf_0/a_48510_n840# pll_full_0/divbuf_0/a_48990_n840# 0.07fF
C9867 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C9868 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48510_n1540# 0.19fF
C9869 divbuf_1/a_8640_n1600# divbuf_1/a_8670_n1540# 0.19fF
C9870 divbuf_1/a_8670_n840# divbuf_1/a_9150_n840# 0.07fF
C9871 divbuf_1/a_34112_170# divbuf_1/OUT4 0.19fF
C9872 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n1540# 0.19fF
C9873 divbuf_0/a_39390_n840# divbuf_0/a_39870_n840# 0.07fF
C9874 divbuf_0/a_9150_n840# divbuf_0/a_9150_n1540# 0.01fF
C9875 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/a_19072_n240# 0.01fF
C9876 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/a_38962_170# 0.07fF
C9877 divbuf_3/a_33142_n240# divbuf_3/OUT4 0.04fF
C9878 divbuf_3/a_58080_n1600# divbuf_3/a_58110_n840# 0.04fF
C9879 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8190_n840# 0.04fF
C9880 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/a_18582_170# 0.07fF
C9881 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/a_1842_n240# 0.01fF
C9882 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9883 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_53790_n840# 0.04fF
C9884 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11070_n1540# 0.19fF
C9885 pll_full_0/divbuf_1/a_11070_n840# pll_full_0/divbuf_1/a_11550_n840# 0.07fF
C9886 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9887 divbuf_2/a_31680_n1600# divbuf_2/a_32160_n1600# 0.26fF
C9888 divbuf_2/a_22472_n240# divbuf_2/a_22590_n840# 0.03fF
C9889 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z1 0.01fF
C9890 divbuf_2/a_24030_n1540# divbuf_2/a_24510_n1540# 0.11fF
C9891 divbuf_2/a_54750_n840# divbuf_2/a_54750_n1540# 0.01fF
C9892 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 0.26fF
C9893 divbuf_3/a_36052_n240# divbuf_3/a_36532_n240# 0.05fF
C9894 divbuf_1/a_35082_n240# divbuf_1/OUT4 0.04fF
C9895 divbuf_1/a_59040_n1600# divbuf_1/a_59070_n840# 0.04fF
C9896 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/a_32172_n240# 0.04fF
C9897 divbuf_3/a_17310_n840# divbuf_3/a_17310_n1540# 0.01fF
C9898 divbuf_3/a_47550_n840# divbuf_3/a_48030_n840# 0.07fF
C9899 divbuf_3/a_31200_n1600# divbuf_3/OUT4 0.00fF
C9900 divbuf_3/a_47520_n1600# divbuf_3/a_47550_n1540# 0.19fF
C9901 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58560_n1600# 0.26fF
C9902 ro_div_0/divbuf_0/a_43230_n840# ro_div_0/divbuf_0/a_43710_n840# 0.07fF
C9903 ro_div_0/divbuf_0/a_12990_n840# ro_div_0/divbuf_0/a_12990_n1540# 0.01fF
C9904 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43230_n1540# 0.19fF
C9905 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C9906 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9907 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C9908 divbuf_2/a_21600_n1600# divbuf_2/a_21630_n840# 0.04fF
C9909 pd_div_0/divbuf_0/a_50430_n1540# pd_div_0/divbuf_0/a_50910_n1540# 0.11fF
C9910 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/Out 0.21fF
C9911 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C9912 divbuf_1/a_37022_n240# divbuf_1/a_37502_n240# 0.05fF
C9913 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/A 0.03fF
C9914 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C9915 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/a_25950_n840# 0.03fF
C9916 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35520_n1600# 0.26fF
C9917 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/a_8190_n840# 0.03fF
C9918 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C9919 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C9920 divbuf_0/a_16642_n240# divbuf_0/a_16830_n840# 0.02fF
C9921 divbuf_0/a_25920_n1600# divbuf_0/a_26400_n1600# 0.26fF
C9922 pll_full_0/divbuf_0/a_27390_n1540# pll_full_0/divbuf_0/a_27870_n1540# 0.11fF
C9923 pll_full_0/divbuf_0/a_58110_n840# pll_full_0/divbuf_0/a_58110_n1540# 0.01fF
C9924 divbuf_1/a_18270_n840# divbuf_1/a_18270_n1540# 0.01fF
C9925 divbuf_1/a_48510_n840# divbuf_1/a_48990_n840# 0.07fF
C9926 divbuf_1/a_33120_n1600# divbuf_1/OUT4 0.01fF
C9927 divbuf_1/a_48480_n1600# divbuf_1/a_48510_n1540# 0.19fF
C9928 divbuf_0/a_48990_n840# divbuf_0/a_48990_n1540# 0.01fF
C9929 divbuf_0/a_18270_n1540# divbuf_0/a_18750_n1540# 0.11fF
C9930 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/a_39932_n240# 0.04fF
C9931 divbuf_3/a_10590_n840# divbuf_3/OUT4 0.03fF
C9932 divbuf_2/a_19072_170# divbuf_2/a_19072_n240# 0.01fF
C9933 divbuf_2/a_38472_170# divbuf_2/a_38962_170# 0.07fF
C9934 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48030_n840# 0.04fF
C9935 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/a_19562_n240# 0.04fF
C9936 pll_full_0/divbuf_1/a_20670_n840# pll_full_0/divbuf_1/a_20670_n1540# 0.01fF
C9937 pll_full_0/divbuf_1/a_50910_n840# pll_full_0/divbuf_1/a_51390_n840# 0.07fF
C9938 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_50910_n1540# 0.19fF
C9939 divbuf_2/a_11040_n1600# divbuf_2/a_11070_n1540# 0.19fF
C9940 divbuf_2/a_11070_n840# divbuf_2/a_11550_n840# 0.07fF
C9941 divbuf_2/a_38962_170# divbuf_2/OUT4 0.19fF
C9942 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C9943 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C9944 divbuf_0/a_19562_170# divbuf_0/a_19562_n240# 0.01fF
C9945 divbuf_0/a_12282_170# divbuf_0/a_12772_170# 0.07fF
C9946 divbuf_0/a_5362_170# divbuf_0/a_5362_n240# 0.01fF
C9947 divbuf_2/OUT4 divbuf_2/OUT5 0.26fF
C9948 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_24990_n840# 0.04fF
C9949 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/OUT2 0.23fF
C9950 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/a_26352_n240# 0.04fF
C9951 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n840# 0.04fF
C9952 divbuf_3/a_24892_n240# divbuf_3/a_24990_n840# 0.03fF
C9953 divbuf_3/a_34080_n1600# divbuf_3/a_34560_n1600# 0.26fF
C9954 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/a_20670_n840# 0.03fF
C9955 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_30240_n1600# 0.26fF
C9956 divbuf_3/a_26430_n1540# divbuf_3/a_26910_n1540# 0.11fF
C9957 divbuf_3/a_57150_n840# divbuf_3/a_57150_n1540# 0.01fF
C9958 pd_div_0/divbuf_0/a_7230_n840# pd_div_0/divbuf_0/a_7230_n1540# 0.01fF
C9959 pd_div_0/divbuf_0/a_37470_n840# pd_div_0/divbuf_0/a_37950_n840# 0.07fF
C9960 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C9961 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37470_n1540# 0.19fF
C9962 ro_div_0/divbuf_0/a_52830_n840# ro_div_0/divbuf_0/a_52830_n1540# 0.01fF
C9963 ro_div_0/divbuf_0/a_22110_n1540# ro_div_0/divbuf_0/a_22590_n1540# 0.11fF
C9964 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/a_1842_n240# 0.04fF
C9965 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/a_22472_n240# 0.01fF
C9966 divbuf_2/a_39932_n240# divbuf_2/OUT4 0.04fF
C9967 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z3 0.65fF
C9968 divbuf_0/a_32652_170# divbuf_0/a_33142_170# 0.07fF
C9969 divbuf_1/a_25862_n240# divbuf_1/a_25950_n840# 0.03fF
C9970 divbuf_1/a_35040_n1600# divbuf_1/a_35520_n1600# 0.26fF
C9971 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C9972 pll_full_0/divbuf_0/a_14430_n840# pll_full_0/divbuf_0/a_14910_n840# 0.07fF
C9973 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14430_n1540# 0.19fF
C9974 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/OUT3 0.19fF
C9975 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n1540# 0.19fF
C9976 divbuf_0/a_27322_170# divbuf_0/OUT4 0.19fF
C9977 divbuf_0/a_5310_n840# divbuf_0/a_5790_n840# 0.07fF
C9978 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/a_3912_170# 0.07fF
C9979 divbuf_3/a_24000_n1600# divbuf_3/a_24030_n840# 0.04fF
C9980 divbuf_3/a_3422_170# divbuf_3/OUT3 0.23fF
C9981 divbuf_1/a_27390_n1540# divbuf_1/a_27870_n1540# 0.11fF
C9982 divbuf_1/a_58110_n840# divbuf_1/a_58110_n1540# 0.01fF
C9983 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_19710_n840# 0.04fF
C9984 divbuf_0/a_58110_n1540# divbuf_0/a_58590_n1540# 0.11fF
C9985 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/a_28350_n840# 0.04fF
C9986 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37920_n1600# 0.26fF
C9987 divbuf_2/a_39442_n240# divbuf_2/a_39932_n240# 0.04fF
C9988 divbuf_2/a_20670_n840# divbuf_2/a_20670_n1540# 0.01fF
C9989 divbuf_2/a_50910_n840# divbuf_2/a_51390_n840# 0.07fF
C9990 divbuf_2/a_50880_n1600# divbuf_2/a_50910_n1540# 0.19fF
C9991 pll_full_0/divbuf_1/a_29790_n1540# pll_full_0/divbuf_1/a_30270_n1540# 0.11fF
C9992 pll_full_0/divbuf_1/a_60510_n840# pll_full_0/divbuf_1/a_60510_n1540# 0.01fF
C9993 divbuf_1/a_4882_170# divbuf_1/OUT3 0.19fF
C9994 divbuf_1/a_24960_n1600# divbuf_1/a_24990_n840# 0.04fF
C9995 divbuf_3/a_21502_170# divbuf_3/a_21502_n240# 0.01fF
C9996 divbuf_3/a_40902_170# divbuf_3/a_41382_170# 0.07fF
C9997 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9998 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/a_37022_170# 0.07fF
C9999 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n840# 0.04fF
C10000 divbuf_0/a_28292_n240# divbuf_0/OUT4 0.04fF
C10001 divbuf_3/a_4392_n240# divbuf_3/OUT3 0.04fF
C10002 divbuf_3/a_13470_n840# divbuf_3/a_13950_n840# 0.07fF
C10003 divbuf_3/a_13440_n1600# divbuf_3/a_13470_n1540# 0.19fF
C10004 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24480_n1600# 0.26fF
C10005 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10006 ro_div_0/divbuf_0/a_9150_n840# ro_div_0/divbuf_0/a_9630_n840# 0.07fF
C10007 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9150_n1540# 0.19fF
C10008 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/OUT3 0.19fF
C10009 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27390_n840# 0.04fF
C10010 pd_div_0/divbuf_0/a_16350_n1540# pd_div_0/divbuf_0/a_16830_n1540# 0.11fF
C10011 pd_div_0/divbuf_0/a_47070_n840# pd_div_0/divbuf_0/a_47070_n1540# 0.01fF
C10012 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_1440_n1600# 0.26fF
C10013 divbuf_1/a_1352_n240# divbuf_1/a_1842_n240# 0.04fF
C10014 divbuf_0/a_33622_n240# divbuf_0/a_34112_n240# 0.04fF
C10015 divbuf_1/a_6332_n240# divbuf_1/OUT3 0.04fF
C10016 divbuf_1/a_14430_n840# divbuf_1/a_14910_n840# 0.07fF
C10017 divbuf_1/a_14400_n1600# divbuf_1/a_14430_n1540# 0.19fF
C10018 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54270_n1540# 0.19fF
C10019 pll_full_0/divbuf_0/a_24030_n840# pll_full_0/divbuf_0/a_24030_n1540# 0.01fF
C10020 pll_full_0/divbuf_0/a_54270_n840# pll_full_0/divbuf_0/a_54750_n840# 0.07fF
C10021 divbuf_0/a_45150_n840# divbuf_0/a_45630_n840# 0.07fF
C10022 divbuf_0/a_14910_n840# divbuf_0/a_14910_n1540# 0.01fF
C10023 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n1540# 0.19fF
C10024 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/a_4882_n240# 0.04fF
C10025 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/a_24892_n240# 0.01fF
C10026 divbuf_2/a_3422_170# divbuf_2/a_3912_170# 0.07fF
C10027 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_13950_n840# 0.04fF
C10028 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/a_24412_170# 0.07fF
C10029 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_59550_n840# 0.04fF
C10030 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10031 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/OUT4 0.07fF
C10032 pll_full_0/divbuf_1/a_16830_n840# pll_full_0/divbuf_1/a_17310_n840# 0.07fF
C10033 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_16830_n1540# 0.19fF
C10034 divbuf_2/a_28292_n240# divbuf_2/a_28350_n840# 0.04fF
C10035 divbuf_2/a_37440_n1600# divbuf_2/a_37920_n1600# 0.26fF
C10036 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C10037 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z2 0.30fF
C10038 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z4 0.15fF
C10039 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_11550_n840# 0.02fF
C10040 divbuf_2/a_29790_n1540# divbuf_2/a_30270_n1540# 0.11fF
C10041 divbuf_2/a_60510_n840# divbuf_2/a_60510_n1540# 0.01fF
C10042 divbuf_0/a_1842_n240# divbuf_0/a_1950_n840# 0.03fF
C10043 divbuf_3/a_0_n1600# divbuf_3/a_480_n1600# 0.26fF
C10044 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/a_37992_n240# 0.04fF
C10045 divbuf_3/a_23070_n840# divbuf_3/a_23070_n1540# 0.01fF
C10046 divbuf_3/a_53310_n840# divbuf_3/a_53790_n840# 0.07fF
C10047 divbuf_3/a_53280_n1600# divbuf_3/a_53310_n1540# 0.19fF
C10048 pd_div_0/divbuf_0/a_3390_n840# pd_div_0/divbuf_0/a_3870_n840# 0.07fF
C10049 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3390_n1540# 0.19fF
C10050 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_48990_n1540# 0.19fF
C10051 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C10052 ro_div_0/divbuf_0/a_48990_n840# ro_div_0/divbuf_0/a_49470_n840# 0.07fF
C10053 ro_div_0/divbuf_0/a_18750_n840# ro_div_0/divbuf_0/a_18750_n1540# 0.01fF
C10054 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C10055 divbuf_2/a_10212_170# divbuf_2/OUT3 0.19fF
C10056 divbuf_2/a_27360_n1600# divbuf_2/a_27390_n840# 0.04fF
C10057 pd_div_0/divbuf_0/a_56190_n1540# pd_div_0/divbuf_0/a_56670_n1540# 0.11fF
C10058 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z3 0.38fF
C10059 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z2 1.07fF
C10060 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z4 0.12fF
C10061 divbuf_1/a_960_n1600# divbuf_1/a_1440_n1600# 0.26fF
C10062 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/Out 0.12fF
C10063 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C10064 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C10065 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_41280_n1600# 0.26fF
C10066 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/a_31710_n840# 0.05fF
C10067 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_14430_n840# 0.02fF
C10068 divbuf_0/a_22472_n240# divbuf_0/a_22590_n840# 0.03fF
C10069 divbuf_0/a_31680_n1600# divbuf_0/a_32160_n1600# 0.26fF
C10070 pll_full_0/divbuf_0/a_33150_n1540# pll_full_0/divbuf_0/a_33630_n1540# 0.11fF
C10071 divbuf_1/a_54240_n1600# divbuf_1/a_54270_n1540# 0.19fF
C10072 divbuf_1/a_24030_n840# divbuf_1/a_24030_n1540# 0.01fF
C10073 divbuf_1/a_54270_n840# divbuf_1/a_54750_n840# 0.07fF
C10074 divbuf_0/a_54750_n840# divbuf_0/a_54750_n1540# 0.01fF
C10075 divbuf_0/a_24030_n1540# divbuf_0/a_24510_n1540# 0.11fF
C10076 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3840_n1600# 0.26fF
C10077 divbuf_2/a_4392_n240# divbuf_2/a_4882_n240# 0.04fF
C10078 divbuf_2/a_24892_170# divbuf_2/a_24892_n240# 0.01fF
C10079 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_53790_n840# 0.04fF
C10080 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10081 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_56670_n1540# 0.19fF
C10082 pll_full_0/divbuf_1/a_26430_n840# pll_full_0/divbuf_1/a_26430_n1540# 0.01fF
C10083 pll_full_0/divbuf_1/a_56670_n840# pll_full_0/divbuf_1/a_57150_n840# 0.07fF
C10084 divbuf_2/a_11312_n240# divbuf_2/OUT4 0.07fF
C10085 divbuf_2/a_16830_n840# divbuf_2/a_17310_n840# 0.07fF
C10086 divbuf_2/a_16800_n1600# divbuf_2/a_16830_n1540# 0.19fF
C10087 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z1 0.01fF
C10088 divbuf_3/a_5852_170# divbuf_3/a_6332_170# 0.07fF
C10089 divbuf_1/a_11802_n240# divbuf_1/a_11550_n840# 0.02fF
C10090 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C10091 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_30750_n840# 0.04fF
C10092 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10093 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C10094 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/a_32172_n240# 0.04fF
C10095 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n840# 0.04fF
C10096 divbuf_3/a_39840_n1600# divbuf_3/a_40320_n1600# 0.26fF
C10097 divbuf_3/a_30712_n240# divbuf_3/a_30750_n840# 0.05fF
C10098 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/a_26430_n840# 0.04fF
C10099 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_36000_n1600# 0.26fF
C10100 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_13950_n840# 0.01fF
C10101 divbuf_3/a_32190_n1540# divbuf_3/a_32670_n1540# 0.11fF
C10102 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C10103 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43230_n1540# 0.19fF
C10104 pd_div_0/divbuf_0/a_12990_n840# pd_div_0/divbuf_0/a_12990_n1540# 0.01fF
C10105 pd_div_0/divbuf_0/a_43230_n840# pd_div_0/divbuf_0/a_43710_n840# 0.07fF
C10106 ro_div_0/divbuf_0/a_58590_n840# ro_div_0/divbuf_0/a_58590_n1540# 0.01fF
C10107 ro_div_0/divbuf_0/a_27870_n1540# ro_div_0/divbuf_0/a_28350_n1540# 0.11fF
C10108 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/a_8272_n240# 0.05fF
C10109 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/a_28292_n240# 0.01fF
C10110 divbuf_2/a_10080_n1600# divbuf_2/OUT3 0.00fF
C10111 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/Out 0.21fF
C10112 divbuf_0/a_38472_170# divbuf_0/a_38962_170# 0.07fF
C10113 divbuf_1/a_40800_n1600# divbuf_1/a_41280_n1600# 0.26fF
C10114 divbuf_1/a_17122_170# divbuf_1/OUT4 0.19fF
C10115 divbuf_1/a_31682_n240# divbuf_1/a_31710_n840# 0.05fF
C10116 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20190_n1540# 0.19fF
C10117 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10118 pll_full_0/divbuf_0/a_20190_n840# pll_full_0/divbuf_0/a_20670_n840# 0.07fF
C10119 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10120 divbuf_0/a_38962_170# divbuf_0/OUT4 0.19fF
C10121 divbuf_0/a_11070_n840# divbuf_0/a_11550_n840# 0.07fF
C10122 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n1540# 0.19fF
C10123 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/a_9732_170# 0.07fF
C10124 divbuf_3/a_29760_n1600# divbuf_3/a_29790_n840# 0.04fF
C10125 divbuf_3/a_15182_170# divbuf_3/OUT4 0.19fF
C10126 divbuf_1/a_33150_n1540# divbuf_1/a_33630_n1540# 0.11fF
C10127 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25470_n840# 0.04fF
C10128 divbuf_0/OUT4 divbuf_0/OUT5 0.26fF
C10129 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/a_34110_n840# 0.06fF
C10130 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43680_n1600# 0.26fF
C10131 divbuf_2/a_3360_n1600# divbuf_2/a_3840_n1600# 0.26fF
C10132 divbuf_2/a_56640_n1600# divbuf_2/a_56670_n1540# 0.19fF
C10133 divbuf_2/a_26430_n840# divbuf_2/a_26430_n1540# 0.01fF
C10134 divbuf_2/a_56670_n840# divbuf_2/a_57150_n840# 0.07fF
C10135 pll_full_0/divbuf_1/a_35550_n1540# pll_full_0/divbuf_1/a_36030_n1540# 0.11fF
C10136 divbuf_1/a_30720_n1600# divbuf_1/a_30750_n840# 0.04fF
C10137 divbuf_3/a_6822_n240# divbuf_3/a_7302_n240# 0.05fF
C10138 divbuf_3/a_27322_170# divbuf_3/a_27322_n240# 0.01fF
C10139 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/a_22952_n240# 0.01fF
C10140 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_960_n1600# 0.00fF
C10141 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/a_2322_n240# 0.05fF
C10142 divbuf_0/a_39932_n240# divbuf_0/OUT4 0.04fF
C10143 divbuf_3/a_16152_n240# divbuf_3/OUT4 0.04fF
C10144 divbuf_3/a_19230_n840# divbuf_3/a_19710_n840# 0.07fF
C10145 divbuf_3/a_19200_n1600# divbuf_3/a_19230_n1540# 0.19fF
C10146 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_30240_n1600# 0.26fF
C10147 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_14910_n1540# 0.19fF
C10148 ro_div_0/divbuf_0/a_14910_n840# ro_div_0/divbuf_0/a_15390_n840# 0.07fF
C10149 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C10150 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10151 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33150_n840# 0.04fF
C10152 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C10153 divbuf_2/a_14222_n240# divbuf_2/a_13950_n840# 0.01fF
C10154 pd_div_0/divbuf_0/a_22110_n1540# pd_div_0/divbuf_0/a_22590_n1540# 0.11fF
C10155 pd_div_0/divbuf_0/a_52830_n840# pd_div_0/divbuf_0/a_52830_n1540# 0.01fF
C10156 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_7200_n1600# 0.26fF
C10157 divbuf_1/a_7792_n240# divbuf_1/a_8272_n240# 0.05fF
C10158 divbuf_0/a_39442_n240# divbuf_0/a_39932_n240# 0.04fF
C10159 divbuf_1/a_20160_n1600# divbuf_1/a_20190_n1540# 0.19fF
C10160 divbuf_1/a_18092_n240# divbuf_1/OUT4 0.04fF
C10161 divbuf_1/a_20190_n840# divbuf_1/a_20670_n840# 0.07fF
C10162 pll_full_0/divbuf_0/a_29790_n840# pll_full_0/divbuf_0/a_29790_n1540# 0.01fF
C10163 pll_full_0/divbuf_0/a_60030_n840# pll_full_0/divbuf_0/a_60510_n840# 0.07fF
C10164 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60030_n1540# 0.19fF
C10165 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n1540# 0.19fF
C10166 divbuf_0/a_50910_n840# divbuf_0/a_51390_n840# 0.07fF
C10167 divbuf_0/a_20670_n840# divbuf_0/a_20670_n1540# 0.01fF
C10168 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/a_30712_n240# 0.01fF
C10169 divbuf_2/a_9242_170# divbuf_2/a_9732_170# 0.07fF
C10170 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_19710_n840# 0.04fF
C10171 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/a_30232_170# 0.07fF
C10172 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_22590_n1540# 0.19fF
C10173 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10174 pll_full_0/divbuf_1/a_22590_n840# pll_full_0/divbuf_1/a_23070_n840# 0.07fF
C10175 divbuf_2/a_34112_n240# divbuf_2/a_34110_n840# 0.06fF
C10176 divbuf_2/a_43200_n1600# divbuf_2/a_43680_n1600# 0.26fF
C10177 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_17310_n840# 0.00fF
C10178 divbuf_2/a_35550_n1540# divbuf_2/a_36030_n1540# 0.11fF
C10179 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C10180 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C10181 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C10182 divbuf_3/a_5760_n1600# divbuf_3/a_6240_n1600# 0.26fF
C10183 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1920_n1600# 0.26fF
C10184 divbuf_3/a_28830_n840# divbuf_3/a_28830_n1540# 0.01fF
C10185 divbuf_3/a_59070_n840# divbuf_3/a_59550_n840# 0.07fF
C10186 divbuf_3/a_59040_n1600# divbuf_3/a_59070_n1540# 0.19fF
C10187 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9150_n1540# 0.19fF
C10188 pd_div_0/divbuf_0/a_9150_n840# pd_div_0/divbuf_0/a_9630_n840# 0.07fF
C10189 ro_div_0/divbuf_0/a_54750_n840# ro_div_0/divbuf_0/a_55230_n840# 0.07fF
C10190 ro_div_0/divbuf_0/a_24510_n840# ro_div_0/divbuf_0/a_24510_n1540# 0.01fF
C10191 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_54750_n1540# 0.19fF
C10192 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C10193 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/a_15182_170# 0.07fF
C10194 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C10195 divbuf_2/a_21982_170# divbuf_2/OUT4 0.19fF
C10196 divbuf_2/a_33120_n1600# divbuf_2/a_33150_n840# 0.04fF
C10197 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C10198 divbuf_1/a_6720_n1600# divbuf_1/a_7200_n1600# 0.26fF
C10199 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C10200 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/a_37470_n840# 0.05fF
C10201 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_47040_n1600# 0.26fF
C10202 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/a_20190_n840# 0.03fF
C10203 divbuf_0/a_37440_n1600# divbuf_0/a_37920_n1600# 0.26fF
C10204 divbuf_0/a_28292_n240# divbuf_0/a_28350_n840# 0.04fF
C10205 pll_full_0/divbuf_0/a_38910_n1540# pll_full_0/divbuf_0/a_39390_n1540# 0.11fF
C10206 divbuf_3/a_16642_n240# divbuf_3/a_16350_n840# 0.00fF
C10207 divbuf_1/a_29790_n840# divbuf_1/a_29790_n1540# 0.01fF
C10208 divbuf_1/a_60030_n840# divbuf_1/a_60510_n840# 0.07fF
C10209 divbuf_1/a_60000_n1600# divbuf_1/a_60030_n1540# 0.19fF
C10210 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12030_n840# 0.02fF
C10211 divbuf_0/a_60510_n840# divbuf_0/a_60510_n1540# 0.01fF
C10212 divbuf_0/a_29790_n1540# divbuf_0/a_30270_n1540# 0.11fF
C10213 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9600_n1600# 0.26fF
C10214 divbuf_2/a_30712_170# divbuf_2/a_30712_n240# 0.01fF
C10215 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10216 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_59550_n840# 0.04fF
C10217 pll_full_0/divbuf_1/a_1470_n1540# pll_full_0/divbuf_1/a_1950_n1540# 0.11fF
C10218 pll_full_0/divbuf_1/a_32190_n840# pll_full_0/divbuf_1/a_32190_n1540# 0.01fF
C10219 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/OUT5 0.26fF
C10220 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/a_14702_n240# 0.01fF
C10221 divbuf_2/a_22560_n1600# divbuf_2/a_22590_n1540# 0.19fF
C10222 divbuf_2/a_22952_n240# divbuf_2/OUT4 0.04fF
C10223 divbuf_2/a_22590_n840# divbuf_2/a_23070_n840# 0.07fF
C10224 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z4 0.15fF
C10225 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z2 0.30fF
C10226 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C10227 divbuf_3/a_12282_170# divbuf_3/a_12772_170# 0.07fF
C10228 divbuf_1/a_17612_n240# divbuf_1/a_17310_n840# 0.00fF
C10229 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10230 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36510_n840# 0.04fF
C10231 ro_div_0/ro_complete_0/cbank_1/switch_4/vin ro_div_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C10232 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/a_6822_170# 0.07fF
C10233 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/a_37992_n240# 0.04fF
C10234 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n840# 0.04fF
C10235 divbuf_3/a_36532_n240# divbuf_3/a_36510_n840# 0.05fF
C10236 divbuf_3/a_45600_n1600# divbuf_3/a_46080_n1600# 0.26fF
C10237 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/a_32190_n840# 0.06fF
C10238 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41760_n1600# 0.26fF
C10239 divbuf_3/a_37950_n1540# divbuf_3/a_38430_n1540# 0.11fF
C10240 pd_div_0/divbuf_0/a_18750_n840# pd_div_0/divbuf_0/a_18750_n1540# 0.01fF
C10241 pd_div_0/divbuf_0/a_48990_n840# pd_div_0/divbuf_0/a_49470_n840# 0.07fF
C10242 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C10243 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_48990_n1540# 0.19fF
C10244 ro_div_0/divbuf_0/a_33630_n1540# ro_div_0/divbuf_0/a_34110_n1540# 0.11fF
C10245 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_14702_n240# 0.05fF
C10246 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/a_34112_n240# 0.01fF
C10247 divbuf_2/a_21120_n1600# divbuf_2/OUT4 0.00fF
C10248 divbuf_1/a_12772_170# divbuf_1/a_13252_170# 0.07fF
C10249 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z4 0.12fF
C10250 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z2 1.07fF
C10251 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z3 0.38fF
C10252 divbuf_0/a_24892_170# divbuf_0/a_24892_n240# 0.01fF
C10253 divbuf_0/a_4392_n240# divbuf_0/a_4882_n240# 0.04fF
C10254 divbuf_1/a_37502_n240# divbuf_1/a_37470_n840# 0.05fF
C10255 divbuf_1/a_46560_n1600# divbuf_1/a_47040_n1600# 0.26fF
C10256 pll_full_0/divbuf_0/a_25950_n840# pll_full_0/divbuf_0/a_26430_n840# 0.07fF
C10257 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10258 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_25950_n1540# 0.19fF
C10259 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10260 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n1540# 0.19fF
C10261 divbuf_0/a_16830_n840# divbuf_0/a_17310_n840# 0.07fF
C10262 divbuf_0/a_11312_n240# divbuf_0/OUT4 0.07fF
C10263 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/a_16152_170# 0.07fF
C10264 divbuf_3/a_26832_170# divbuf_3/OUT4 0.19fF
C10265 divbuf_3/a_35520_n1600# divbuf_3/a_35550_n840# 0.04fF
C10266 divbuf_1/a_38910_n1540# divbuf_1/a_39390_n1540# 0.11fF
C10267 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/tspc_r_0/z5 0.20fF
C10268 ro_div_0/divbuf_0/a_1842_170# ro_div_0/divbuf_0/OUT2 0.19fF
C10269 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10270 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31230_n840# 0.04fF
C10271 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/a_39870_n840# 0.04fF
C10272 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_49440_n1600# 0.26fF
C10273 divbuf_2/a_9120_n1600# divbuf_2/a_9600_n1600# 0.26fF
C10274 pll_full_0/divbuf_1/a_41310_n1540# pll_full_0/divbuf_1/a_41790_n1540# 0.11fF
C10275 divbuf_2/a_1470_n1540# divbuf_2/a_1950_n1540# 0.11fF
C10276 divbuf_2/a_32190_n840# divbuf_2/a_32190_n1540# 0.01fF
C10277 divbuf_2/a_60480_n1600# divbuf_2/OUT5 0.26fF
C10278 divbuf_3/a_13252_n240# divbuf_3/a_13742_n240# 0.04fF
C10279 divbuf_3/a_33142_170# divbuf_3/a_33142_n240# 0.01fF
C10280 divbuf_1/a_25382_170# divbuf_1/OUT4 0.19fF
C10281 divbuf_1/a_36480_n1600# divbuf_1/a_36510_n840# 0.04fF
C10282 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/a_28772_n240# 0.01fF
C10283 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/a_8762_n240# 0.04fF
C10284 divbuf_0/a_10080_n1600# divbuf_0/OUT3 0.00fF
C10285 divbuf_3/a_24990_n840# divbuf_3/a_25470_n840# 0.07fF
C10286 divbuf_3/a_27802_n240# divbuf_3/OUT4 0.04fF
C10287 divbuf_3/a_24960_n1600# divbuf_3/a_24990_n1540# 0.19fF
C10288 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_36000_n1600# 0.26fF
C10289 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/a_26430_n840# 0.04fF
C10290 ro_div_0/divbuf_0/a_20670_n840# ro_div_0/divbuf_0/a_21150_n840# 0.07fF
C10291 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10292 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_20670_n1540# 0.19fF
C10293 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_38910_n840# 0.04fF
C10294 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10295 pd_div_0/divbuf_0/a_27870_n1540# pd_div_0/divbuf_0/a_28350_n1540# 0.11fF
C10296 pd_div_0/divbuf_0/a_58590_n840# pd_div_0/divbuf_0/a_58590_n1540# 0.01fF
C10297 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12960_n1600# 0.26fF
C10298 divbuf_1/a_14222_n240# divbuf_1/a_14702_n240# 0.05fF
C10299 divbuf_1/a_34112_170# divbuf_1/a_34112_n240# 0.01fF
C10300 divbuf_0/a_3360_n1600# divbuf_0/a_3840_n1600# 0.26fF
C10301 divbuf_1/a_25950_n840# divbuf_1/a_26430_n840# 0.07fF
C10302 divbuf_1/a_29742_n240# divbuf_1/OUT4 0.04fF
C10303 divbuf_1/a_25920_n1600# divbuf_1/a_25950_n1540# 0.19fF
C10304 pll_full_0/divbuf_0/a_4830_n1540# pll_full_0/divbuf_0/a_5310_n1540# 0.11fF
C10305 pll_full_0/divbuf_0/a_35550_n840# pll_full_0/divbuf_0/a_35550_n1540# 0.01fF
C10306 divbuf_0/a_56670_n840# divbuf_0/a_57150_n840# 0.07fF
C10307 divbuf_0/a_26430_n840# divbuf_0/a_26430_n1540# 0.01fF
C10308 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n1540# 0.19fF
C10309 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_17122_n240# 0.05fF
C10310 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/a_36532_n240# 0.01fF
C10311 divbuf_2/a_15672_170# divbuf_2/a_16152_170# 0.07fF
C10312 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25470_n840# 0.04fF
C10313 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/a_16152_n240# 0.01fF
C10314 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/a_36052_170# 0.07fF
C10315 pll_full_0/divbuf_1/a_28350_n840# pll_full_0/divbuf_1/a_28830_n840# 0.07fF
C10316 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10317 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28350_n1540# 0.19fF
C10318 divbuf_2/a_39932_n240# divbuf_2/a_39870_n840# 0.04fF
C10319 divbuf_2/a_48960_n1600# divbuf_2/a_49440_n1600# 0.26fF
C10320 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C10321 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C10322 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/nor_0/B 0.22fF
C10323 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C10324 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2430_n840# 0.04fF
C10325 divbuf_2/a_41310_n1540# divbuf_2/a_41790_n1540# 0.11fF
C10326 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C10327 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C10328 divbuf_0/a_14222_n240# divbuf_0/a_13950_n840# 0.01fF
C10329 divbuf_3/a_11520_n1600# divbuf_3/a_12000_n1600# 0.26fF
C10330 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7680_n1600# 0.26fF
C10331 divbuf_3/a_3870_n1540# divbuf_3/a_4350_n1540# 0.11fF
C10332 divbuf_3/a_34590_n840# divbuf_3/a_34590_n1540# 0.01fF
C10333 pd_div_0/divbuf_0/a_14910_n840# pd_div_0/divbuf_0/a_15390_n840# 0.07fF
C10334 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_14910_n1540# 0.19fF
C10335 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/a_60510_n1540# 0.19fF
C10336 ro_div_0/divbuf_0/a_60510_n840# ro_div_0/divbuf_0/a_60990_n840# 0.07fF
C10337 ro_div_0/divbuf_0/a_30270_n840# ro_div_0/divbuf_0/a_30270_n1540# 0.01fF
C10338 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C10339 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/a_5852_n240# 0.01fF
C10340 divbuf_2/a_38880_n1600# divbuf_2/a_38910_n840# 0.04fF
C10341 divbuf_2/a_33622_170# divbuf_2/OUT4 0.19fF
C10342 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52800_n1600# 0.26fF
C10343 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10344 divbuf_1/a_12480_n1600# divbuf_1/a_12960_n1600# 0.26fF
C10345 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C10346 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C10347 divbuf_1/a_4830_n1540# divbuf_1/a_5310_n1540# 0.11fF
C10348 divbuf_1/a_35550_n840# divbuf_1/a_35550_n1540# 0.01fF
C10349 divbuf_0/a_43200_n1600# divbuf_0/a_43680_n1600# 0.26fF
C10350 divbuf_0/a_34112_n240# divbuf_0/a_34110_n840# 0.06fF
C10351 pll_full_0/divbuf_0/a_44670_n1540# pll_full_0/divbuf_0/a_45150_n1540# 0.11fF
C10352 divbuf_3/a_1440_n1600# divbuf_3/a_1470_n840# 0.04fF
C10353 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_17790_n840# 0.00fF
C10354 divbuf_0/a_35550_n1540# divbuf_0/a_36030_n1540# 0.11fF
C10355 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_15360_n1600# 0.26fF
C10356 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/a_5310_n840# 0.04fF
C10357 divbuf_2/a_16642_n240# divbuf_2/a_17122_n240# 0.05fF
C10358 divbuf_2/a_36532_170# divbuf_2/a_36532_n240# 0.01fF
C10359 pll_full_0/divbuf_1/a_7230_n1540# pll_full_0/divbuf_1/a_7710_n1540# 0.11fF
C10360 pll_full_0/divbuf_1/a_37950_n840# pll_full_0/divbuf_1/a_37950_n1540# 0.01fF
C10361 divbuf_2/a_28350_n840# divbuf_2/a_28830_n840# 0.07fF
C10362 divbuf_2/a_34592_n240# divbuf_2/OUT4 0.04fF
C10363 divbuf_2/a_28320_n1600# divbuf_2/a_28350_n1540# 0.19fF
C10364 divbuf_3/a_18092_170# divbuf_3/a_18582_170# 0.07fF
C10365 divbuf_1/a_2400_n1600# divbuf_1/a_2430_n840# 0.04fF
C10366 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42270_n840# 0.04fF
C10367 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10368 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10369 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/a_15672_170# 0.07fF
C10370 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1920_n1600# 0.26fF
C10371 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n840# 0.04fF
C10372 divbuf_0/a_21982_170# divbuf_0/OUT4 0.19fF
C10373 divbuf_3/a_51360_n1600# divbuf_3/a_51840_n1600# 0.26fF
C10374 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47520_n1600# 0.26fF
C10375 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/a_37950_n840# 0.04fF
C10376 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/OUT3 0.19fF
C10377 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_4830_n840# 0.04fF
C10378 divbuf_3/a_43710_n1540# divbuf_3/a_44190_n1540# 0.11fF
C10379 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_54750_n1540# 0.19fF
C10380 pd_div_0/divbuf_0/a_24510_n840# pd_div_0/divbuf_0/a_24510_n1540# 0.01fF
C10381 pd_div_0/divbuf_0/a_54750_n840# pd_div_0/divbuf_0/a_55230_n840# 0.07fF
C10382 ro_div_0/divbuf_0/a_39390_n1540# ro_div_0/divbuf_0/a_39870_n1540# 0.11fF
C10383 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/a_20532_n240# 0.04fF
C10384 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/a_39932_n240# 0.01fF
C10385 divbuf_2/a_32640_n1600# divbuf_2/OUT4 0.00fF
C10386 divbuf_1/a_3422_170# divbuf_1/a_3422_n240# 0.01fF
C10387 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/a_22472_n240# 0.01fF
C10388 divbuf_0/a_30712_170# divbuf_0/a_30712_n240# 0.01fF
C10389 divbuf_1/a_52320_n1600# divbuf_1/a_52800_n1600# 0.26fF
C10390 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10391 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_31710_n1540# 0.19fF
C10392 pll_full_0/divbuf_0/a_1470_n840# pll_full_0/divbuf_0/a_1470_n1540# 0.01fF
C10393 pll_full_0/divbuf_0/a_31710_n840# pll_full_0/divbuf_0/a_32190_n840# 0.07fF
C10394 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C10395 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/a_15182_n240# 0.01fF
C10396 divbuf_0/a_22590_n840# divbuf_0/a_23070_n840# 0.07fF
C10397 divbuf_0/a_22952_n240# divbuf_0/OUT4 0.04fF
C10398 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n1540# 0.19fF
C10399 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/a_21982_170# 0.07fF
C10400 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C10401 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C10402 divbuf_3/a_41280_n1600# divbuf_3/a_41310_n840# 0.04fF
C10403 divbuf_3/a_38472_170# divbuf_3/OUT4 0.19fF
C10404 divbuf_1/a_44670_n1540# divbuf_1/a_45150_n1540# 0.11fF
C10405 pd_div_0/pd_0/tspc_r_0/z5 pd_div_0/pd_0/tspc_r_1/z5 0.02fF
C10406 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z2 0.25fF
C10407 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_36990_n840# 0.04fF
C10408 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10409 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/OUT3 0.19fF
C10410 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_55200_n1600# 0.26fF
C10411 divbuf_2/a_14880_n1600# divbuf_2/a_15360_n1600# 0.26fF
C10412 divbuf_2/a_5362_n240# divbuf_2/a_5310_n840# 0.04fF
C10413 pll_full_0/divbuf_1/a_47070_n1540# pll_full_0/divbuf_1/a_47550_n1540# 0.11fF
C10414 divbuf_2/a_7230_n1540# divbuf_2/a_7710_n1540# 0.11fF
C10415 divbuf_2/a_37950_n840# divbuf_2/a_37950_n1540# 0.01fF
C10416 divbuf_3/a_19072_n240# divbuf_3/a_19562_n240# 0.04fF
C10417 divbuf_3/a_38962_170# divbuf_3/a_38962_n240# 0.01fF
C10418 divbuf_1/a_42240_n1600# divbuf_1/a_42270_n840# 0.04fF
C10419 divbuf_1/a_40412_170# divbuf_1/OUT4 0.19fF
C10420 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/a_34592_n240# 0.01fF
C10421 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_15182_n240# 0.05fF
C10422 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41760_n1600# 0.26fF
C10423 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/a_32190_n840# 0.06fF
C10424 divbuf_0/a_21120_n1600# divbuf_0/OUT4 0.00fF
C10425 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_480_n1600# 0.00fF
C10426 divbuf_3/a_30750_n840# divbuf_3/a_31230_n840# 0.07fF
C10427 divbuf_3/a_39442_n240# divbuf_3/OUT4 0.04fF
C10428 divbuf_3/a_510_n840# divbuf_3/a_510_n1540# 0.01fF
C10429 divbuf_3/a_30720_n1600# divbuf_3/a_30750_n1540# 0.19fF
C10430 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26430_n1540# 0.19fF
C10431 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10432 ro_div_0/divbuf_0/a_26430_n840# ro_div_0/divbuf_0/a_26910_n840# 0.07fF
C10433 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C10434 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_44670_n840# 0.04fF
C10435 divbuf_2/a_4800_n1600# divbuf_2/a_4830_n840# 0.04fF
C10436 pd_div_0/divbuf_0/a_33630_n1540# pd_div_0/divbuf_0/a_34110_n1540# 0.11fF
C10437 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z1 0.03fF
C10438 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18720_n1600# 0.26fF
C10439 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/a_8670_n840# 0.03fF
C10440 divbuf_1/a_20042_n240# divbuf_1/a_20532_n240# 0.04fF
C10441 divbuf_1/a_39932_170# divbuf_1/a_39932_n240# 0.01fF
C10442 divbuf_0/a_9120_n1600# divbuf_0/a_9600_n1600# 0.26fF
C10443 divbuf_1/a_41382_n240# divbuf_1/OUT4 0.04fF
C10444 divbuf_1/a_31680_n1600# divbuf_1/a_31710_n1540# 0.19fF
C10445 divbuf_1/a_1470_n840# divbuf_1/a_1470_n1540# 0.01fF
C10446 divbuf_1/a_31710_n840# divbuf_1/a_32190_n840# 0.07fF
C10447 pll_full_0/divbuf_0/a_10590_n1540# pll_full_0/divbuf_0/a_11070_n1540# 0.11fF
C10448 pll_full_0/divbuf_0/a_41310_n840# pll_full_0/divbuf_0/a_41310_n1540# 0.01fF
C10449 divbuf_0/a_60480_n1600# divbuf_0/OUT5 0.26fF
C10450 divbuf_0/a_32190_n840# divbuf_0/a_32190_n1540# 0.01fF
C10451 divbuf_0/a_1470_n1540# divbuf_0/a_1950_n1540# 0.11fF
C10452 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/a_22952_n240# 0.05fF
C10453 divbuf_2/a_21502_170# divbuf_2/a_21982_170# 0.07fF
C10454 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31230_n840# 0.04fF
C10455 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34110_n1540# 0.19fF
C10456 pll_full_0/divbuf_1/a_3870_n840# pll_full_0/divbuf_1/a_3870_n1540# 0.01fF
C10457 pll_full_0/divbuf_1/a_34110_n840# pll_full_0/divbuf_1/a_34590_n840# 0.07fF
C10458 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C10459 divbuf_2/a_4882_170# divbuf_2/OUT3 0.19fF
C10460 divbuf_2/a_54720_n1600# divbuf_2/a_55200_n1600# 0.26fF
C10461 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/and_0/A 0.01fF
C10462 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/out1 0.31fF
C10463 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8190_n840# 0.04fF
C10464 divbuf_2/a_47070_n1540# divbuf_2/a_47550_n1540# 0.11fF
C10465 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C10466 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C10467 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_11550_n840# 0.02fF
C10468 divbuf_3/a_17280_n1600# divbuf_3/a_17760_n1600# 0.26fF
C10469 divbuf_3/a_7792_n240# divbuf_3/a_7710_n840# 0.03fF
C10470 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/a_3390_n840# 0.05fF
C10471 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_13440_n1600# 0.26fF
C10472 divbuf_3/a_9630_n1540# divbuf_3/a_10110_n1540# 0.11fF
C10473 divbuf_3/a_40350_n840# divbuf_3/a_40350_n1540# 0.01fF
C10474 divbuf_2/a_492_n240# divbuf_2/a_480_n1600# 0.00fF
C10475 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_20670_n1540# 0.19fF
C10476 pd_div_0/divbuf_0/a_20670_n840# pd_div_0/divbuf_0/a_21150_n840# 0.07fF
C10477 ro_div_0/divbuf_0/a_36030_n840# ro_div_0/divbuf_0/a_36030_n1540# 0.01fF
C10478 ro_div_0/divbuf_0/a_5310_n1540# ro_div_0/divbuf_0/a_5790_n1540# 0.11fF
C10479 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/a_25382_170# 0.07fF
C10480 divbuf_2/a_5852_n240# divbuf_2/OUT3 0.04fF
C10481 divbuf_2/a_44640_n1600# divbuf_2/a_44670_n840# 0.04fF
C10482 divbuf_1/a_7792_170# divbuf_1/a_7302_170# 0.07fF
C10483 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58560_n1600# 0.26fF
C10484 divbuf_1/a_18240_n1600# divbuf_1/a_18720_n1600# 0.26fF
C10485 divbuf_1/a_8762_n240# divbuf_1/a_8670_n840# 0.03fF
C10486 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C10487 ro_div_0/ro_complete_0/cbank_0/switch_2/vin ro_div_0/ro_complete_0/a3 0.09fF
C10488 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C10489 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/a1 0.14fF
C10490 divbuf_0/a_48960_n1600# divbuf_0/a_49440_n1600# 0.26fF
C10491 divbuf_0/a_39932_n240# divbuf_0/a_39870_n840# 0.04fF
C10492 divbuf_1/a_10590_n1540# divbuf_1/a_11070_n1540# 0.11fF
C10493 divbuf_1/a_41310_n840# divbuf_1/a_41310_n1540# 0.01fF
C10494 pll_full_0/divbuf_0/a_50430_n1540# pll_full_0/divbuf_0/a_50910_n1540# 0.11fF
C10495 divbuf_3/a_7200_n1600# divbuf_3/a_7230_n840# 0.04fF
C10496 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_2910_n840# 0.04fF
C10497 divbuf_0/a_41310_n1540# divbuf_0/a_41790_n1540# 0.11fF
C10498 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11550_n840# 0.02fF
C10499 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_21120_n1600# 0.26fF
C10500 divbuf_2/a_22472_n240# divbuf_2/a_22952_n240# 0.05fF
C10501 pll_full_0/divbuf_1/a_12990_n1540# pll_full_0/divbuf_1/a_13470_n1540# 0.11fF
C10502 pll_full_0/divbuf_1/a_43710_n840# pll_full_0/divbuf_1/a_43710_n1540# 0.01fF
C10503 divbuf_2/a_34080_n1600# divbuf_2/a_34110_n1540# 0.19fF
C10504 divbuf_2/a_3870_n840# divbuf_2/a_3870_n1540# 0.01fF
C10505 divbuf_2/a_34110_n840# divbuf_2/a_34590_n840# 0.07fF
C10506 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/nor_0/B 0.22fF
C10507 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C10508 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C10509 divbuf_0/a_15182_170# divbuf_0/a_15182_n240# 0.01fF
C10510 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10511 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48030_n840# 0.04fF
C10512 divbuf_3/a_23922_170# divbuf_3/a_24412_170# 0.07fF
C10513 divbuf_3/a_3912_170# divbuf_3/a_3912_n240# 0.01fF
C10514 divbuf_1/a_8160_n1600# divbuf_1/a_8190_n840# 0.04fF
C10515 divbuf_1/a_1352_170# divbuf_1/OUT2 0.23fF
C10516 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10517 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_3912_n240# 0.01fF
C10518 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7680_n1600# 0.26fF
C10519 divbuf_0/a_33622_170# divbuf_0/OUT4 0.19fF
C10520 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n840# 0.04fF
C10521 divbuf_3/a_9732_170# divbuf_3/OUT3 0.19fF
C10522 divbuf_3/a_57120_n1600# divbuf_3/a_57600_n1600# 0.26fF
C10523 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10524 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_53280_n1600# 0.26fF
C10525 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_10590_n840# 0.04fF
C10526 divbuf_3/a_49470_n1540# divbuf_3/a_49950_n1540# 0.11fF
C10527 pd_div_0/divbuf_0/a_30270_n840# pd_div_0/divbuf_0/a_30270_n1540# 0.01fF
C10528 pd_div_0/divbuf_0/a_60510_n840# pd_div_0/divbuf_0/a_60990_n840# 0.07fF
C10529 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/a_60510_n1540# 0.19fF
C10530 ro_div_0/divbuf_0/a_45150_n1540# ro_div_0/divbuf_0/a_45630_n1540# 0.11fF
C10531 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/a_26352_n240# 0.04fF
C10532 divbuf_1/a_31202_170# divbuf_1/a_31202_n240# 0.01fF
C10533 divbuf_1/a_21502_170# divbuf_1/a_21982_170# 0.07fF
C10534 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/a_28292_n240# 0.01fF
C10535 divbuf_0/a_36532_170# divbuf_0/a_36532_n240# 0.01fF
C10536 divbuf_0/a_16642_n240# divbuf_0/a_17122_n240# 0.05fF
C10537 divbuf_1/a_58080_n1600# divbuf_1/a_58560_n1600# 0.26fF
C10538 pll_full_0/divbuf_0/a_7230_n840# pll_full_0/divbuf_0/a_7230_n1540# 0.01fF
C10539 pll_full_0/divbuf_0/a_37470_n840# pll_full_0/divbuf_0/a_37950_n840# 0.07fF
C10540 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C10541 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37470_n1540# 0.19fF
C10542 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10543 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n1540# 0.19fF
C10544 divbuf_0/a_34592_n240# divbuf_0/OUT4 0.04fF
C10545 divbuf_0/a_28350_n840# divbuf_0/a_28830_n840# 0.07fF
C10546 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/a_7302_n240# 0.01fF
C10547 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/a_27802_170# 0.07fF
C10548 divbuf_3/a_10212_n240# divbuf_3/OUT4 0.04fF
C10549 divbuf_3/a_47040_n1600# divbuf_3/a_47070_n840# 0.04fF
C10550 divbuf_1/a_50430_n1540# divbuf_1/a_50910_n1540# 0.11fF
C10551 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/a_14702_170# 0.07fF
C10552 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/divider_0/clk 1.30fF
C10553 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10554 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/OUT2 0.04fF
C10555 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_42750_n840# 0.04fF
C10556 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10557 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C10558 divbuf_2/a_11312_n240# divbuf_2/a_11550_n840# 0.02fF
C10559 divbuf_2/a_20640_n1600# divbuf_2/a_21120_n1600# 0.26fF
C10560 pll_full_0/divbuf_1/a_52830_n1540# pll_full_0/divbuf_1/a_53310_n1540# 0.11fF
C10561 divbuf_2/a_12990_n1540# divbuf_2/a_13470_n1540# 0.11fF
C10562 divbuf_2/a_43710_n840# divbuf_2/a_43710_n1540# 0.01fF
C10563 divbuf_1/a_23922_170# divbuf_1/a_23922_n240# 0.01fF
C10564 divbuf_3/a_24892_n240# divbuf_3/a_25382_n240# 0.04fF
C10565 divbuf_1/a_12772_n240# divbuf_1/OUT4 0.04fF
C10566 divbuf_1/a_48000_n1600# divbuf_1/a_48030_n840# 0.04fF
C10567 divbuf_1/a_492_n240# divbuf_1/a_480_n1600# 0.00fF
C10568 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/a_40412_n240# 0.01fF
C10569 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/a_21012_n240# 0.05fF
C10570 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/a_37950_n840# 0.04fF
C10571 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47520_n1600# 0.26fF
C10572 divbuf_0/a_32640_n1600# divbuf_0/OUT4 0.00fF
C10573 divbuf_3/a_6270_n840# divbuf_3/a_6270_n1540# 0.01fF
C10574 divbuf_3/a_36510_n840# divbuf_3/a_36990_n840# 0.07fF
C10575 divbuf_3/a_9600_n1600# divbuf_3/OUT3 0.00fF
C10576 divbuf_3/a_36480_n1600# divbuf_3/a_36510_n1540# 0.19fF
C10577 ro_div_0/divbuf_0/a_32190_n840# ro_div_0/divbuf_0/a_32670_n840# 0.07fF
C10578 ro_div_0/divbuf_0/a_1950_n840# ro_div_0/divbuf_0/a_1950_n1540# 0.01fF
C10579 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32190_n1540# 0.19fF
C10580 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/OUT2 0.01fF
C10581 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50430_n840# 0.04fF
C10582 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10583 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/a_10212_170# 0.07fF
C10584 divbuf_2/a_10560_n1600# divbuf_2/a_10590_n840# 0.04fF
C10585 pd_div_0/divbuf_0/a_39390_n1540# pd_div_0/divbuf_0/a_39870_n1540# 0.11fF
C10586 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C10587 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z4 0.21fF
C10588 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/tspc_1/Z3 0.16fF
C10589 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/nor_1/A 0.01fF
C10590 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C10591 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24480_n1600# 0.26fF
C10592 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_14910_n840# 0.02fF
C10593 divbuf_1/a_25862_n240# divbuf_1/a_26352_n240# 0.04fF
C10594 ashish_0/von ashish_0/Gnd 0.33fF
C10595 divbuf_0/a_5362_n240# divbuf_0/a_5310_n840# 0.04fF
C10596 divbuf_0/a_14880_n1600# divbuf_0/a_15360_n1600# 0.26fF
C10597 divbuf_1/a_7230_n840# divbuf_1/a_7230_n1540# 0.01fF
C10598 divbuf_1/a_37470_n840# divbuf_1/a_37950_n840# 0.07fF
C10599 divbuf_1/a_11040_n1600# divbuf_1/OUT4 0.00fF
C10600 divbuf_1/a_37440_n1600# divbuf_1/a_37470_n1540# 0.19fF
C10601 pll_full_0/divbuf_0/a_16350_n1540# pll_full_0/divbuf_0/a_16830_n1540# 0.11fF
C10602 pll_full_0/divbuf_0/a_47070_n840# pll_full_0/divbuf_0/a_47070_n1540# 0.01fF
C10603 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_36990_n840# 0.04fF
C10604 divbuf_0/a_37950_n840# divbuf_0/a_37950_n1540# 0.01fF
C10605 divbuf_0/a_7230_n1540# divbuf_0/a_7710_n1540# 0.11fF
C10606 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/a_28772_n240# 0.05fF
C10607 divbuf_2/a_7302_170# divbuf_2/a_7302_n240# 0.01fF
C10608 divbuf_2/a_27322_170# divbuf_2/a_27802_170# 0.07fF
C10609 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/a_7792_n240# 0.04fF
C10610 pll_full_0/divbuf_1/a_9630_n840# pll_full_0/divbuf_1/a_9630_n1540# 0.01fF
C10611 pll_full_0/divbuf_1/a_39870_n840# pll_full_0/divbuf_1/a_40350_n840# 0.07fF
C10612 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_39870_n1540# 0.19fF
C10613 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C10614 divbuf_2/a_16642_170# divbuf_2/OUT4 0.19fF
C10615 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/and_0/B 0.29fF
C10616 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C10617 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_13950_n840# 0.04fF
C10618 divbuf_2/a_52830_n1540# divbuf_2/a_53310_n1540# 0.11fF
C10619 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_17310_n840# 0.00fF
C10620 divbuf_0/a_17612_170# divbuf_0/OUT4 0.19fF
C10621 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n840# 0.04fF
C10622 divbuf_3/a_13742_n240# divbuf_3/a_13950_n840# 0.02fF
C10623 divbuf_3/a_23040_n1600# divbuf_3/a_23520_n1600# 0.26fF
C10624 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/a_9150_n840# 0.03fF
C10625 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_19200_n1600# 0.26fF
C10626 divbuf_3/a_15390_n1540# divbuf_3/a_15870_n1540# 0.11fF
C10627 divbuf_3/a_46110_n840# divbuf_3/a_46110_n1540# 0.01fF
C10628 pd_div_0/divbuf_0/a_26430_n840# pd_div_0/divbuf_0/a_26910_n840# 0.07fF
C10629 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10630 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26430_n1540# 0.19fF
C10631 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/a_41790_n1540# 0.01fF
C10632 ro_div_0/divbuf_0/a_11070_n1540# ro_div_0/divbuf_0/a_11550_n1540# 0.11fF
C10633 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/a_31202_170# 0.07fF
C10634 divbuf_2/a_50400_n1600# divbuf_2/a_50430_n840# 0.04fF
C10635 divbuf_2/a_17612_n240# divbuf_2/OUT4 0.04fF
C10636 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z1 0.03fF
C10637 divbuf_0/a_21502_170# divbuf_0/a_21982_170# 0.07fF
C10638 pll_full_0/divbuf_0/a_3390_n840# pll_full_0/divbuf_0/a_3870_n840# 0.07fF
C10639 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10640 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3390_n1540# 0.19fF
C10641 divbuf_1/a_24000_n1600# divbuf_1/a_24480_n1600# 0.26fF
C10642 divbuf_1/a_14702_n240# divbuf_1/a_14910_n840# 0.02fF
C10643 ro_div_0/ro_complete_0/cbank_0/switch_5/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C10644 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_12282_170# 0.07fF
C10645 divbuf_0/a_54720_n1600# divbuf_0/a_55200_n1600# 0.26fF
C10646 divbuf_1/a_16350_n1540# divbuf_1/a_16830_n1540# 0.11fF
C10647 divbuf_1/a_47070_n840# divbuf_1/a_47070_n1540# 0.01fF
C10648 pll_full_0/divbuf_0/a_56190_n1540# pll_full_0/divbuf_0/a_56670_n1540# 0.11fF
C10649 divbuf_3/a_12960_n1600# divbuf_3/a_12990_n840# 0.04fF
C10650 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_8670_n840# 0.04fF
C10651 divbuf_0/a_47070_n1540# divbuf_0/a_47550_n1540# 0.11fF
C10652 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26880_n1600# 0.26fF
C10653 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_17310_n840# 0.02fF
C10654 divbuf_2/a_28292_n240# divbuf_2/a_28772_n240# 0.05fF
C10655 pll_full_0/divbuf_1/a_18750_n1540# pll_full_0/divbuf_1/a_19230_n1540# 0.11fF
C10656 pll_full_0/divbuf_1/a_49470_n840# pll_full_0/divbuf_1/a_49470_n1540# 0.01fF
C10657 divbuf_2/a_9630_n840# divbuf_2/a_9630_n1540# 0.01fF
C10658 divbuf_2/a_39870_n840# divbuf_2/a_40350_n840# 0.07fF
C10659 divbuf_2/a_39840_n1600# divbuf_2/a_39870_n1540# 0.19fF
C10660 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/out1 0.31fF
C10661 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/and_0/A 0.01fF
C10662 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_53790_n840# 0.04fF
C10663 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10664 divbuf_3/a_9732_170# divbuf_3/a_9732_n240# 0.01fF
C10665 divbuf_3/a_29742_170# divbuf_3/a_30232_170# 0.07fF
C10666 divbuf_1/a_8272_170# divbuf_1/OUT3 0.19fF
C10667 divbuf_1/a_13920_n1600# divbuf_1/a_13950_n840# 0.04fF
C10668 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10669 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/a_25862_170# 0.07fF
C10670 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n840# 0.04fF
C10671 divbuf_0/a_5852_n240# divbuf_0/OUT3 0.04fF
C10672 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_13440_n1600# 0.26fF
C10673 divbuf_3/a_2430_n840# divbuf_3/a_2910_n840# 0.07fF
C10674 divbuf_3/a_21502_170# divbuf_3/OUT4 0.19fF
C10675 divbuf_3/a_2400_n1600# divbuf_3/a_2430_n1540# 0.19fF
C10676 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/a_1842_170# 0.07fF
C10677 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Qbar1 0.12fF
C10678 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_59040_n1600# 0.26fF
C10679 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16350_n840# 0.04fF
C10680 divbuf_3/a_55230_n1540# divbuf_3/a_55710_n1540# 0.11fF
C10681 pd_div_0/divbuf_0/a_5310_n1540# pd_div_0/divbuf_0/a_5790_n1540# 0.11fF
C10682 pd_div_0/divbuf_0/a_36030_n840# pd_div_0/divbuf_0/a_36030_n1540# 0.01fF
C10683 ro_div_0/divbuf_0/a_50910_n1540# ro_div_0/divbuf_0/a_51390_n1540# 0.11fF
C10684 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/a_32172_n240# 0.04fF
C10685 divbuf_1/a_27322_170# divbuf_1/a_27802_170# 0.07fF
C10686 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/a_34112_n240# 0.01fF
C10687 divbuf_0/a_22472_n240# divbuf_0/a_22952_n240# 0.05fF
C10688 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C10689 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43230_n1540# 0.19fF
C10690 pll_full_0/divbuf_0/a_12990_n840# pll_full_0/divbuf_0/a_12990_n1540# 0.01fF
C10691 pll_full_0/divbuf_0/a_43230_n840# pll_full_0/divbuf_0/a_43710_n840# 0.07fF
C10692 divbuf_1/a_3390_n840# divbuf_1/a_3870_n840# 0.07fF
C10693 divbuf_1/a_20042_170# divbuf_1/OUT4 0.19fF
C10694 divbuf_1/a_3360_n1600# divbuf_1/a_3390_n1540# 0.19fF
C10695 divbuf_1/a_56190_n1540# divbuf_1/a_56670_n1540# 0.11fF
C10696 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_2910_n840# 0.04fF
C10697 divbuf_0/a_34110_n840# divbuf_0/a_34590_n840# 0.07fF
C10698 divbuf_0/a_3870_n840# divbuf_0/a_3870_n1540# 0.01fF
C10699 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n1540# 0.19fF
C10700 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/a_13742_n240# 0.01fF
C10701 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/a_33622_170# 0.07fF
C10702 divbuf_3/a_52800_n1600# divbuf_3/a_52830_n840# 0.04fF
C10703 divbuf_3/a_22472_n240# divbuf_3/OUT4 0.04fF
C10704 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/a_10212_170# 0.07fF
C10705 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48510_n840# 0.04fF
C10706 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10707 pll_full_0/divbuf_1/a_5790_n840# pll_full_0/divbuf_1/a_6270_n840# 0.07fF
C10708 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10709 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_5790_n1540# 0.19fF
C10710 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C10711 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C10712 divbuf_2/a_26400_n1600# divbuf_2/a_26880_n1600# 0.26fF
C10713 divbuf_2/a_17122_n240# divbuf_2/a_17310_n840# 0.02fF
C10714 pll_full_0/divbuf_1/a_58590_n1540# pll_full_0/divbuf_1/a_59070_n1540# 0.11fF
C10715 divbuf_2/a_18750_n1540# divbuf_2/a_19230_n1540# 0.11fF
C10716 divbuf_2/a_49470_n840# divbuf_2/a_49470_n1540# 0.01fF
C10717 divbuf_1/a_29742_170# divbuf_1/a_29742_n240# 0.01fF
C10718 divbuf_3/a_30712_n240# divbuf_3/a_31202_n240# 0.04fF
C10719 divbuf_1/a_53760_n1600# divbuf_1/a_53790_n840# 0.04fF
C10720 divbuf_1/a_24412_n240# divbuf_1/OUT4 0.04fF
C10721 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/a_26832_n240# 0.05fF
C10722 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_53280_n1600# 0.26fF
C10723 divbuf_3/a_12030_n840# divbuf_3/a_12030_n1540# 0.01fF
C10724 divbuf_3/a_42270_n840# divbuf_3/a_42750_n840# 0.07fF
C10725 divbuf_3/a_20640_n1600# divbuf_3/OUT4 0.00fF
C10726 divbuf_3/a_42240_n1600# divbuf_3/a_42270_n1540# 0.19fF
C10727 pd_div_0/divbuf_0/a_12282_170# pd_div_0/divbuf_0/a_12282_n240# 0.01fF
C10728 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_37950_n1540# 0.19fF
C10729 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C10730 ro_div_0/divbuf_0/a_37950_n840# ro_div_0/divbuf_0/a_38430_n840# 0.07fF
C10731 ro_div_0/divbuf_0/a_7710_n840# ro_div_0/divbuf_0/a_7710_n1540# 0.01fF
C10732 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10733 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56190_n840# 0.04fF
C10734 divbuf_2/a_16320_n1600# divbuf_2/a_16350_n840# 0.04fF
C10735 pd_div_0/divbuf_0/a_45150_n1540# pd_div_0/divbuf_0/a_45630_n1540# 0.11fF
C10736 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C10737 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_30240_n1600# 0.26fF
C10738 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/a_20670_n840# 0.03fF
C10739 divbuf_1/a_31682_n240# divbuf_1/a_32172_n240# 0.04fF
C10740 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C10741 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C10742 divbuf_0/a_20640_n1600# divbuf_0/a_21120_n1600# 0.26fF
C10743 divbuf_0/a_11312_n240# divbuf_0/a_11550_n840# 0.02fF
C10744 divbuf_1/a_22560_n1600# divbuf_1/OUT4 0.01fF
C10745 divbuf_1/a_43200_n1600# divbuf_1/a_43230_n1540# 0.19fF
C10746 divbuf_1/a_12990_n840# divbuf_1/a_12990_n1540# 0.01fF
C10747 divbuf_1/a_43230_n840# divbuf_1/a_43710_n840# 0.07fF
C10748 pll_full_0/divbuf_0/a_22110_n1540# pll_full_0/divbuf_0/a_22590_n1540# 0.11fF
C10749 pll_full_0/divbuf_0/a_52830_n840# pll_full_0/divbuf_0/a_52830_n1540# 0.01fF
C10750 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_42750_n840# 0.04fF
C10751 divbuf_0/a_43710_n840# divbuf_0/a_43710_n1540# 0.01fF
C10752 divbuf_0/a_12990_n1540# divbuf_0/a_13470_n1540# 0.11fF
C10753 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/a_34592_n240# 0.05fF
C10754 divbuf_3/a_990_n840# divbuf_3/OUT2 0.02fF
C10755 divbuf_2/a_13742_170# divbuf_2/a_13742_n240# 0.01fF
C10756 divbuf_2/a_33142_170# divbuf_2/a_33622_170# 0.07fF
C10757 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_14222_n240# 0.05fF
C10758 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_45630_n1540# 0.19fF
C10759 pll_full_0/divbuf_1/a_15390_n840# pll_full_0/divbuf_1/a_15390_n1540# 0.01fF
C10760 pll_full_0/divbuf_1/a_45630_n840# pll_full_0/divbuf_1/a_46110_n840# 0.07fF
C10761 divbuf_2/a_5790_n840# divbuf_2/a_6270_n840# 0.07fF
C10762 divbuf_2/a_28292_170# divbuf_2/OUT4 0.19fF
C10763 divbuf_2/a_5760_n1600# divbuf_2/a_5790_n1540# 0.19fF
C10764 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z2 0.23fF
C10765 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C10766 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_19710_n840# 0.04fF
C10767 divbuf_2/a_58590_n1540# divbuf_2/a_59070_n1540# 0.11fF
C10768 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n840# 0.04fF
C10769 divbuf_3/a_28800_n1600# divbuf_3/a_29280_n1600# 0.26fF
C10770 divbuf_3/a_19562_n240# divbuf_3/a_19710_n840# 0.03fF
C10771 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/OUT2 0.01fF
C10772 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32190_n1540# 0.19fF
C10773 pd_div_0/divbuf_0/a_1950_n840# pd_div_0/divbuf_0/a_1950_n1540# 0.01fF
C10774 pd_div_0/divbuf_0/a_32190_n840# pd_div_0/divbuf_0/a_32670_n840# 0.07fF
C10775 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_15390_n840# 0.02fF
C10776 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24960_n1600# 0.26fF
C10777 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/a_2430_n840# 0.03fF
C10778 divbuf_3/a_21150_n1540# divbuf_3/a_21630_n1540# 0.11fF
C10779 divbuf_3/a_51870_n840# divbuf_3/a_51870_n1540# 0.01fF
C10780 ro_div_0/divbuf_0/a_47550_n840# ro_div_0/divbuf_0/a_47550_n1540# 0.01fF
C10781 ro_div_0/divbuf_0/a_16830_n1540# ro_div_0/divbuf_0/a_17310_n1540# 0.11fF
C10782 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/a_37022_170# 0.07fF
C10783 divbuf_2/a_29262_n240# divbuf_2/OUT4 0.04fF
C10784 divbuf_2/a_56160_n1600# divbuf_2/a_56190_n840# 0.04fF
C10785 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/nor_1/A 0.01fF
C10786 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/tspc_1/Z3 0.16fF
C10787 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z4 0.21fF
C10788 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C10789 divbuf_0/a_27322_170# divbuf_0/a_27802_170# 0.07fF
C10790 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9150_n1540# 0.19fF
C10791 pll_full_0/divbuf_0/a_9150_n840# pll_full_0/divbuf_0/a_9630_n840# 0.07fF
C10792 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10793 divbuf_1/a_29760_n1600# divbuf_1/a_30240_n1600# 0.26fF
C10794 divbuf_1/a_20532_n240# divbuf_1/a_20670_n840# 0.03fF
C10795 divbuf_0/a_14222_170# divbuf_0/OUT4 0.19fF
C10796 divbuf_1/a_22110_n1540# divbuf_1/a_22590_n1540# 0.11fF
C10797 divbuf_1/a_52830_n840# divbuf_1/a_52830_n1540# 0.01fF
C10798 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C10799 divbuf_3/a_18720_n1600# divbuf_3/a_18750_n840# 0.04fF
C10800 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14430_n840# 0.04fF
C10801 divbuf_0/a_52830_n1540# divbuf_0/a_53310_n1540# 0.11fF
C10802 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/a_23070_n840# 0.03fF
C10803 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32640_n1600# 0.26fF
C10804 divbuf_2/a_34112_n240# divbuf_2/a_34592_n240# 0.05fF
C10805 pll_full_0/divbuf_1/a_24510_n1540# pll_full_0/divbuf_1/a_24990_n1540# 0.11fF
C10806 pll_full_0/divbuf_1/a_55230_n840# pll_full_0/divbuf_1/a_55230_n1540# 0.01fF
C10807 divbuf_2/a_45600_n1600# divbuf_2/a_45630_n1540# 0.19fF
C10808 divbuf_2/a_15390_n840# divbuf_2/a_15390_n1540# 0.01fF
C10809 divbuf_2/a_45630_n840# divbuf_2/a_46110_n840# 0.07fF
C10810 divbuf_1/a_17122_170# divbuf_1/a_17122_n240# 0.01fF
C10811 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/and_0/B 0.29fF
C10812 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_960_n1600# 0.00fF
C10813 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10814 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_59550_n840# 0.04fF
C10815 divbuf_3/a_16152_170# divbuf_3/a_16152_n240# 0.01fF
C10816 divbuf_3/a_35562_170# divbuf_3/a_36052_170# 0.07fF
C10817 divbuf_1/a_19680_n1600# divbuf_1/a_19710_n840# 0.04fF
C10818 divbuf_1/a_3422_170# divbuf_1/OUT3 0.23fF
C10819 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10820 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/a_31682_170# 0.07fF
C10821 divbuf_0/a_17612_n240# divbuf_0/OUT4 0.04fF
C10822 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n840# 0.04fF
C10823 io_clamp_high[0] io_analog[4] 0.53fF
C10824 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_19200_n1600# 0.26fF
C10825 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.32fF
C10826 divbuf_3/a_8190_n840# divbuf_3/a_8670_n840# 0.07fF
C10827 divbuf_3/a_33142_170# divbuf_3/OUT4 0.19fF
C10828 divbuf_3/a_8160_n1600# divbuf_3/a_8190_n1540# 0.19fF
C10829 pd_div_0/pd_0/R pd_div_0/pd_0/UP 0.45fF
C10830 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_3870_n1540# 0.19fF
C10831 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10832 ro_div_0/divbuf_0/a_3870_n840# ro_div_0/divbuf_0/a_4350_n840# 0.07fF
C10833 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22110_n840# 0.04fF
C10834 divbuf_2/a_2322_n240# divbuf_2/a_2430_n840# 0.03fF
C10835 pd_div_0/divbuf_0/a_11070_n1540# pd_div_0/divbuf_0/a_11550_n1540# 0.11fF
C10836 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/a_41790_n1540# 0.01fF
C10837 ro_div_0/divbuf_0/a_56670_n1540# ro_div_0/divbuf_0/a_57150_n1540# 0.11fF
C10838 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/a_37992_n240# 0.04fF
C10839 divbuf_1/a_36532_170# divbuf_1/a_37022_170# 0.07fF
C10840 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/a_39932_n240# 0.01fF
C10841 divbuf_0/a_28292_n240# divbuf_0/a_28772_n240# 0.05fF
C10842 divbuf_0/a_492_n240# divbuf_0/a_510_n840# 0.00fF
C10843 pll_full_0/divbuf_0/a_18750_n840# pll_full_0/divbuf_0/a_18750_n1540# 0.01fF
C10844 pll_full_0/divbuf_0/a_48990_n840# pll_full_0/divbuf_0/a_49470_n840# 0.07fF
C10845 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C10846 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_48990_n1540# 0.19fF
C10847 divbuf_1/a_9120_n1600# divbuf_1/a_9150_n1540# 0.19fF
C10848 divbuf_1/a_9150_n840# divbuf_1/a_9630_n840# 0.07fF
C10849 divbuf_1/a_35082_170# divbuf_1/OUT4 0.19fF
C10850 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n1540# 0.19fF
C10851 divbuf_0/a_39870_n840# divbuf_0/a_40350_n840# 0.07fF
C10852 divbuf_0/a_9630_n840# divbuf_0/a_9630_n1540# 0.01fF
C10853 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_8670_n840# 0.04fF
C10854 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/a_19562_n240# 0.01fF
C10855 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/a_39442_170# 0.07fF
C10856 divbuf_3/a_34112_n240# divbuf_3/OUT4 0.04fF
C10857 divbuf_3/a_58560_n1600# divbuf_3/a_58590_n840# 0.04fF
C10858 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/a_19072_170# 0.07fF
C10859 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54270_n840# 0.04fF
C10860 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10861 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_11550_n1540# 0.19fF
C10862 pll_full_0/divbuf_1/a_11550_n840# pll_full_0/divbuf_1/a_12030_n840# 0.07fF
C10863 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10864 divbuf_2/a_22952_n240# divbuf_2/a_23070_n840# 0.03fF
C10865 divbuf_2/a_32160_n1600# divbuf_2/a_32640_n1600# 0.26fF
C10866 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C10867 divbuf_0/a_8762_170# divbuf_0/a_9242_170# 0.07fF
C10868 divbuf_2/a_24510_n1540# divbuf_2/a_24990_n1540# 0.11fF
C10869 divbuf_2/a_55230_n840# divbuf_2/a_55230_n1540# 0.01fF
C10870 divbuf_3/a_36532_n240# divbuf_3/a_37022_n240# 0.04fF
C10871 divbuf_1/a_36052_n240# divbuf_1/OUT4 0.04fF
C10872 divbuf_1/a_59520_n1600# divbuf_1/a_59550_n840# 0.04fF
C10873 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/a_32652_n240# 0.05fF
C10874 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_59040_n1600# 0.26fF
C10875 divbuf_3/a_17790_n840# divbuf_3/a_17790_n1540# 0.01fF
C10876 divbuf_3/a_48030_n840# divbuf_3/a_48510_n840# 0.07fF
C10877 divbuf_3/a_32160_n1600# divbuf_3/OUT4 0.00fF
C10878 divbuf_3/a_48000_n1600# divbuf_3/a_48030_n1540# 0.19fF
C10879 ro_div_0/divbuf_0/a_43710_n840# ro_div_0/divbuf_0/a_44190_n840# 0.07fF
C10880 ro_div_0/divbuf_0/a_13470_n840# ro_div_0/divbuf_0/a_13470_n1540# 0.01fF
C10881 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_43710_n1540# 0.19fF
C10882 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C10883 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10884 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C10885 divbuf_2/a_22080_n1600# divbuf_2/a_22110_n840# 0.04fF
C10886 pd_div_0/divbuf_0/a_50910_n1540# pd_div_0/divbuf_0/a_51390_n1540# 0.11fF
C10887 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/Out 0.04fF
C10888 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C10889 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_36000_n1600# 0.26fF
C10890 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/a_26430_n840# 0.04fF
C10891 divbuf_1/a_37502_n240# divbuf_1/a_37992_n240# 0.04fF
C10892 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/a_8670_n840# 0.03fF
C10893 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C10894 divbuf_0/a_17122_n240# divbuf_0/a_17310_n840# 0.02fF
C10895 divbuf_0/a_26400_n1600# divbuf_0/a_26880_n1600# 0.26fF
C10896 divbuf_1/a_18750_n840# divbuf_1/a_18750_n1540# 0.01fF
C10897 divbuf_1/a_48990_n840# divbuf_1/a_49470_n840# 0.07fF
C10898 divbuf_1/a_34080_n1600# divbuf_1/OUT4 0.01fF
C10899 divbuf_1/a_48960_n1600# divbuf_1/a_48990_n1540# 0.19fF
C10900 pll_full_0/divbuf_0/a_27870_n1540# pll_full_0/divbuf_0/a_28350_n1540# 0.11fF
C10901 pll_full_0/divbuf_0/a_58590_n840# pll_full_0/divbuf_0/a_58590_n1540# 0.01fF
C10902 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48510_n840# 0.04fF
C10903 divbuf_0/a_49470_n840# divbuf_0/a_49470_n1540# 0.01fF
C10904 divbuf_0/a_18750_n1540# divbuf_0/a_19230_n1540# 0.11fF
C10905 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/a_40412_n240# 0.05fF
C10906 divbuf_2/a_19562_170# divbuf_2/a_19562_n240# 0.01fF
C10907 divbuf_2/a_38962_170# divbuf_2/a_39442_170# 0.07fF
C10908 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/a_20042_n240# 0.05fF
C10909 pll_full_0/divbuf_1/a_21150_n840# pll_full_0/divbuf_1/a_21150_n1540# 0.01fF
C10910 pll_full_0/divbuf_1/a_51390_n840# pll_full_0/divbuf_1/a_51870_n840# 0.07fF
C10911 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51390_n1540# 0.19fF
C10912 divbuf_2/a_11520_n1600# divbuf_2/a_11550_n1540# 0.19fF
C10913 divbuf_2/a_11550_n840# divbuf_2/a_12030_n840# 0.07fF
C10914 divbuf_2/a_39932_170# divbuf_2/OUT4 0.19fF
C10915 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25470_n840# 0.04fF
C10916 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n840# 0.04fF
C10917 divbuf_0/a_10212_170# divbuf_0/OUT3 0.19fF
C10918 divbuf_3/a_25382_n240# divbuf_3/a_25470_n840# 0.03fF
C10919 divbuf_3/a_34560_n1600# divbuf_3/a_35040_n1600# 0.26fF
C10920 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/a_26832_n240# 0.05fF
C10921 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/a_21150_n840# 0.03fF
C10922 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30720_n1600# 0.26fF
C10923 pd_div_0/divbuf_0/a_7710_n840# pd_div_0/divbuf_0/a_7710_n1540# 0.01fF
C10924 pd_div_0/divbuf_0/a_37950_n840# pd_div_0/divbuf_0/a_38430_n840# 0.07fF
C10925 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C10926 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_37950_n1540# 0.19fF
C10927 divbuf_3/a_26910_n1540# divbuf_3/a_27390_n1540# 0.11fF
C10928 divbuf_3/a_57630_n840# divbuf_3/a_57630_n1540# 0.01fF
C10929 ro_div_0/divbuf_0/a_53310_n840# ro_div_0/divbuf_0/a_53310_n1540# 0.01fF
C10930 ro_div_0/divbuf_0/a_22590_n1540# ro_div_0/divbuf_0/a_23070_n1540# 0.11fF
C10931 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/a_2322_n240# 0.05fF
C10932 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_960_n1600# 0.00fF
C10933 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/a_22952_n240# 0.01fF
C10934 divbuf_2/a_40902_n240# divbuf_2/OUT4 0.04fF
C10935 divbuf_2/a_480_n1600# divbuf_2/IN 0.00fF
C10936 divbuf_1/a_8272_170# divbuf_1/a_8762_170# 0.07fF
C10937 divbuf_0/a_33142_170# divbuf_0/a_33622_170# 0.07fF
C10938 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C10939 pll_full_0/divbuf_0/a_14910_n840# pll_full_0/divbuf_0/a_15390_n840# 0.07fF
C10940 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_14910_n1540# 0.19fF
C10941 divbuf_1/a_35520_n1600# divbuf_1/a_36000_n1600# 0.26fF
C10942 divbuf_1/a_26352_n240# divbuf_1/a_26430_n840# 0.04fF
C10943 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/OUT3 0.19fF
C10944 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n1540# 0.19fF
C10945 divbuf_0/a_28292_170# divbuf_0/OUT4 0.19fF
C10946 divbuf_0/a_5790_n840# divbuf_0/a_6270_n840# 0.07fF
C10947 divbuf_3/a_4392_170# divbuf_3/OUT3 0.19fF
C10948 divbuf_3/a_24480_n1600# divbuf_3/a_24510_n840# 0.04fF
C10949 divbuf_1/a_27870_n1540# divbuf_1/a_28350_n1540# 0.11fF
C10950 divbuf_1/a_58590_n840# divbuf_1/a_58590_n1540# 0.01fF
C10951 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/a_4392_170# 0.07fF
C10952 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20190_n840# 0.04fF
C10953 divbuf_0/a_58590_n1540# divbuf_0/a_59070_n1540# 0.11fF
C10954 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/a_28830_n840# 0.04fF
C10955 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_38400_n1600# 0.26fF
C10956 divbuf_2/a_39932_n240# divbuf_2/a_40412_n240# 0.05fF
C10957 pll_full_0/divbuf_1/a_30270_n1540# pll_full_0/divbuf_1/a_30750_n1540# 0.11fF
C10958 pll_full_0/divbuf_1/a_60990_n840# pll_full_0/divbuf_1/a_60990_n1540# 0.01fF
C10959 divbuf_2/a_21150_n840# divbuf_2/a_21150_n1540# 0.01fF
C10960 divbuf_2/a_51390_n840# divbuf_2/a_51870_n840# 0.07fF
C10961 divbuf_2/a_51360_n1600# divbuf_2/a_51390_n1540# 0.19fF
C10962 divbuf_3/a_21982_170# divbuf_3/a_21982_n240# 0.01fF
C10963 divbuf_1/a_25440_n1600# divbuf_1/a_25470_n840# 0.04fF
C10964 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10965 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/a_37502_170# 0.07fF
C10966 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n840# 0.04fF
C10967 divbuf_0/a_29262_n240# divbuf_0/OUT4 0.04fF
C10968 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24960_n1600# 0.26fF
C10969 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C10970 divbuf_3/a_5362_n240# divbuf_3/OUT3 0.04fF
C10971 divbuf_3/a_13950_n840# divbuf_3/a_14430_n840# 0.07fF
C10972 divbuf_3/a_13920_n1600# divbuf_3/a_13950_n1540# 0.19fF
C10973 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/a_6822_170# 0.07fF
C10974 pd_div_0/pd_0/UP pd_div_0/pd_0/and_pd_0/Out1 0.33fF
C10975 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10976 ro_div_0/divbuf_0/a_9630_n840# ro_div_0/divbuf_0/a_10110_n840# 0.07fF
C10977 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_9630_n1540# 0.19fF
C10978 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_27870_n840# 0.04fF
C10979 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/OUT4 0.23fF
C10980 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C10981 pd_div_0/divbuf_0/a_16830_n1540# pd_div_0/divbuf_0/a_17310_n1540# 0.11fF
C10982 pd_div_0/divbuf_0/a_47550_n840# pd_div_0/divbuf_0/a_47550_n1540# 0.01fF
C10983 ro_div_0/divbuf_0/a_60990_n1540# ro_div_0/divbuf_0/OUT5 0.19fF
C10984 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1920_n1600# 0.26fF
C10985 divbuf_1/a_1842_n240# divbuf_1/a_2322_n240# 0.05fF
C10986 divbuf_0/a_34112_n240# divbuf_0/a_34592_n240# 0.05fF
C10987 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_54750_n1540# 0.19fF
C10988 pll_full_0/divbuf_0/a_24510_n840# pll_full_0/divbuf_0/a_24510_n1540# 0.01fF
C10989 pll_full_0/divbuf_0/a_54750_n840# pll_full_0/divbuf_0/a_55230_n840# 0.07fF
C10990 divbuf_1/a_7302_n240# divbuf_1/OUT3 0.04fF
C10991 divbuf_1/a_14910_n840# divbuf_1/a_15390_n840# 0.07fF
C10992 divbuf_1/a_14880_n1600# divbuf_1/a_14910_n1540# 0.19fF
C10993 divbuf_0/a_45630_n840# divbuf_0/a_46110_n840# 0.07fF
C10994 divbuf_0/a_15390_n840# divbuf_0/a_15390_n1540# 0.01fF
C10995 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n1540# 0.19fF
C10996 divbuf_2/a_3912_170# divbuf_2/a_4392_170# 0.07fF
C10997 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14430_n840# 0.04fF
C10998 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/a_5362_n240# 0.05fF
C10999 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/a_25382_n240# 0.01fF
C11000 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/a_24892_170# 0.07fF
C11001 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60030_n840# 0.04fF
C11002 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11003 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11004 pll_full_0/divbuf_1/a_17310_n840# pll_full_0/divbuf_1/a_17790_n840# 0.07fF
C11005 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17310_n1540# 0.19fF
C11006 divbuf_2/a_28772_n240# divbuf_2/a_28830_n840# 0.04fF
C11007 divbuf_2/a_37920_n1600# divbuf_2/a_38400_n1600# 0.26fF
C11008 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Q 0.51fF
C11009 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z3 0.06fF
C11010 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12030_n840# 0.02fF
C11011 divbuf_2/a_30270_n1540# divbuf_2/a_30750_n1540# 0.11fF
C11012 divbuf_2/a_60990_n840# divbuf_2/a_60990_n1540# 0.01fF
C11013 divbuf_0/a_2322_n240# divbuf_0/a_2430_n840# 0.03fF
C11014 divbuf_3/a_480_n1600# divbuf_3/a_960_n1600# 0.26fF
C11015 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/a_38472_n240# 0.05fF
C11016 pd_div_0/divbuf_0/a_3870_n840# pd_div_0/divbuf_0/a_4350_n840# 0.07fF
C11017 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_3870_n1540# 0.19fF
C11018 divbuf_3/a_53760_n1600# divbuf_3/a_53790_n1540# 0.19fF
C11019 divbuf_3/a_23550_n840# divbuf_3/a_23550_n1540# 0.01fF
C11020 divbuf_3/a_53790_n840# divbuf_3/a_54270_n840# 0.07fF
C11021 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49470_n1540# 0.19fF
C11022 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C11023 ro_div_0/divbuf_0/a_49470_n840# ro_div_0/divbuf_0/a_49950_n840# 0.07fF
C11024 ro_div_0/divbuf_0/a_19230_n840# ro_div_0/divbuf_0/a_19230_n1540# 0.01fF
C11025 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C11026 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/a_6822_170# 0.07fF
C11027 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C11028 divbuf_2/a_27840_n1600# divbuf_2/a_27870_n840# 0.04fF
C11029 divbuf_2/a_11312_170# divbuf_2/OUT4 0.23fF
C11030 pd_div_0/divbuf_0/a_56670_n1540# pd_div_0/divbuf_0/a_57150_n1540# 0.11fF
C11031 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z4 0.22fF
C11032 ro_div_0/divider_0/tspc_2/Z2 ro_div_0/divider_0/tspc_2/Z3 0.16fF
C11033 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C11034 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C11035 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_0/B 0.47fF
C11036 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C11037 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/Z3 0.05fF
C11038 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C11039 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C11040 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41760_n1600# 0.26fF
C11041 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/a_32190_n840# 0.06fF
C11042 divbuf_1/a_1440_n1600# divbuf_1/a_1920_n1600# 0.26fF
C11043 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_14910_n840# 0.02fF
C11044 divbuf_0/a_32160_n1600# divbuf_0/a_32640_n1600# 0.26fF
C11045 divbuf_0/a_22952_n240# divbuf_0/a_23070_n840# 0.03fF
C11046 pll_full_0/divbuf_0/a_33630_n1540# pll_full_0/divbuf_0/a_34110_n1540# 0.11fF
C11047 divbuf_3/a_11312_n240# divbuf_3/a_11070_n840# 0.02fF
C11048 divbuf_1/a_54720_n1600# divbuf_1/a_54750_n1540# 0.19fF
C11049 divbuf_1/a_24510_n840# divbuf_1/a_24510_n1540# 0.01fF
C11050 divbuf_1/a_54750_n840# divbuf_1/a_55230_n840# 0.07fF
C11051 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11052 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54270_n840# 0.04fF
C11053 divbuf_0/a_55230_n840# divbuf_0/a_55230_n1540# 0.01fF
C11054 divbuf_0/a_24510_n1540# divbuf_0/a_24990_n1540# 0.11fF
C11055 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_4320_n1600# 0.26fF
C11056 divbuf_2/a_4882_n240# divbuf_2/a_5362_n240# 0.05fF
C11057 divbuf_2/a_25382_170# divbuf_2/a_25382_n240# 0.01fF
C11058 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57150_n1540# 0.19fF
C11059 pll_full_0/divbuf_1/a_26910_n840# pll_full_0/divbuf_1/a_26910_n1540# 0.01fF
C11060 pll_full_0/divbuf_1/a_57150_n840# pll_full_0/divbuf_1/a_57630_n840# 0.07fF
C11061 divbuf_2/a_12282_n240# divbuf_2/OUT4 0.04fF
C11062 divbuf_2/a_17310_n840# divbuf_2/a_17790_n840# 0.07fF
C11063 divbuf_2/a_17280_n1600# divbuf_2/a_17310_n1540# 0.19fF
C11064 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C11065 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31230_n840# 0.04fF
C11066 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11067 pll_full_0/divbuf_0/a_1842_170# pll_full_0/divbuf_0/OUT2 0.19fF
C11068 divbuf_3/a_6332_170# divbuf_3/a_6822_170# 0.07fF
C11069 divbuf_1/a_12282_n240# divbuf_1/a_12030_n840# 0.02fF
C11070 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C11071 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C11072 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n840# 0.04fF
C11073 divbuf_3/a_40320_n1600# divbuf_3/a_40800_n1600# 0.26fF
C11074 divbuf_3/a_31202_n240# divbuf_3/a_31230_n840# 0.05fF
C11075 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/a_32652_n240# 0.05fF
C11076 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36480_n1600# 0.26fF
C11077 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/a_26910_n840# 0.04fF
C11078 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C11079 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_43710_n1540# 0.19fF
C11080 pd_div_0/divbuf_0/a_13470_n840# pd_div_0/divbuf_0/a_13470_n1540# 0.01fF
C11081 pd_div_0/divbuf_0/a_43710_n840# pd_div_0/divbuf_0/a_44190_n840# 0.07fF
C11082 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_14430_n840# 0.01fF
C11083 divbuf_3/a_32670_n1540# divbuf_3/a_33150_n1540# 0.11fF
C11084 ro_div_0/divbuf_0/a_59070_n840# ro_div_0/divbuf_0/a_59070_n1540# 0.01fF
C11085 ro_div_0/divbuf_0/a_28350_n1540# ro_div_0/divbuf_0/a_28830_n1540# 0.11fF
C11086 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/a_8762_n240# 0.04fF
C11087 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/a_28772_n240# 0.01fF
C11088 divbuf_2/a_11040_n1600# divbuf_2/OUT3 0.00fF
C11089 divbuf_1/a_33622_170# divbuf_1/a_34112_170# 0.07fF
C11090 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/Out 0.04fF
C11091 divbuf_0/a_38962_170# divbuf_0/a_39442_170# 0.07fF
C11092 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_20670_n1540# 0.19fF
C11093 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11094 pll_full_0/divbuf_0/a_20670_n840# pll_full_0/divbuf_0/a_21150_n840# 0.07fF
C11095 divbuf_1/a_41280_n1600# divbuf_1/a_41760_n1600# 0.26fF
C11096 divbuf_1/a_18092_170# divbuf_1/OUT4 0.19fF
C11097 divbuf_1/a_32172_n240# divbuf_1/a_32190_n840# 0.06fF
C11098 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11099 divbuf_0/a_39932_170# divbuf_0/OUT4 0.19fF
C11100 divbuf_0/a_11550_n840# divbuf_0/a_12030_n840# 0.07fF
C11101 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n1540# 0.19fF
C11102 divbuf_3/a_30240_n1600# divbuf_3/a_30270_n840# 0.04fF
C11103 divbuf_3/a_16152_170# divbuf_3/OUT4 0.19fF
C11104 divbuf_1/a_33630_n1540# divbuf_1/a_34110_n1540# 0.11fF
C11105 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/a_10212_170# 0.07fF
C11106 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_25950_n840# 0.04fF
C11107 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/OUT3 0.19fF
C11108 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/a_34590_n840# 0.06fF
C11109 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_44160_n1600# 0.26fF
C11110 divbuf_2/a_3840_n1600# divbuf_2/a_4320_n1600# 0.26fF
C11111 pll_full_0/divbuf_1/a_36030_n1540# pll_full_0/divbuf_1/a_36510_n1540# 0.11fF
C11112 divbuf_2/a_57120_n1600# divbuf_2/a_57150_n1540# 0.19fF
C11113 divbuf_2/a_26910_n840# divbuf_2/a_26910_n1540# 0.01fF
C11114 divbuf_2/a_57150_n840# divbuf_2/a_57630_n840# 0.07fF
C11115 divbuf_3/a_7302_n240# divbuf_3/a_7792_n240# 0.04fF
C11116 divbuf_3/a_27802_170# divbuf_3/a_27802_n240# 0.01fF
C11117 divbuf_1/a_31200_n1600# divbuf_1/a_31230_n840# 0.04fF
C11118 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/a_23442_n240# 0.01fF
C11119 divbuf_0/a_480_n1600# divbuf_0/IN 0.00fF
C11120 divbuf_0/a_40902_n240# divbuf_0/OUT4 0.04fF
C11121 divbuf_3/a_19680_n1600# divbuf_3/a_19710_n1540# 0.19fF
C11122 divbuf_3/a_17122_n240# divbuf_3/OUT4 0.04fF
C11123 divbuf_3/a_19710_n840# divbuf_3/a_20190_n840# 0.07fF
C11124 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30720_n1600# 0.26fF
C11125 ro_div_0/ro_complete_0/cbank_1/switch_4/vin ro_div_0/divider_0/clk 1.30fF
C11126 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15390_n1540# 0.19fF
C11127 ro_div_0/divbuf_0/a_15390_n840# ro_div_0/divbuf_0/a_15870_n840# 0.07fF
C11128 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C11129 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11130 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_33630_n840# 0.04fF
C11131 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C11132 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C11133 divbuf_2/a_14702_n240# divbuf_2/a_14430_n840# 0.01fF
C11134 pd_div_0/divbuf_0/a_22590_n1540# pd_div_0/divbuf_0/a_23070_n1540# 0.11fF
C11135 pd_div_0/divbuf_0/a_53310_n840# pd_div_0/divbuf_0/a_53310_n1540# 0.01fF
C11136 ro_complete_0/a5 ro_complete_0/cbank_0/switch_0/vin 0.09fF
C11137 divbuf_0/a_17122_170# divbuf_0/a_17612_170# 0.07fF
C11138 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7680_n1600# 0.26fF
C11139 divbuf_1/a_8272_n240# divbuf_1/a_8762_n240# 0.04fF
C11140 divbuf_0/a_39932_n240# divbuf_0/a_40412_n240# 0.05fF
C11141 pll_full_0/divbuf_0/a_30270_n840# pll_full_0/divbuf_0/a_30270_n1540# 0.01fF
C11142 pll_full_0/divbuf_0/a_60510_n840# pll_full_0/divbuf_0/a_60990_n840# 0.07fF
C11143 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/a_60510_n1540# 0.19fF
C11144 divbuf_1/a_20640_n1600# divbuf_1/a_20670_n1540# 0.19fF
C11145 divbuf_1/a_19072_n240# divbuf_1/OUT4 0.04fF
C11146 divbuf_1/a_20670_n840# divbuf_1/a_21150_n840# 0.07fF
C11147 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n1540# 0.19fF
C11148 divbuf_0/a_51390_n840# divbuf_0/a_51870_n840# 0.07fF
C11149 divbuf_0/a_21150_n840# divbuf_0/a_21150_n1540# 0.01fF
C11150 divbuf_2/a_9732_170# divbuf_2/a_10212_170# 0.07fF
C11151 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20190_n840# 0.04fF
C11152 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/a_31202_n240# 0.01fF
C11153 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11802_n240# 0.04fF
C11154 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/a_30712_170# 0.07fF
C11155 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23070_n1540# 0.19fF
C11156 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11157 pll_full_0/divbuf_1/a_23070_n840# pll_full_0/divbuf_1/a_23550_n840# 0.07fF
C11158 divbuf_2/a_34592_n240# divbuf_2/a_34590_n840# 0.06fF
C11159 divbuf_2/a_43680_n1600# divbuf_2/a_44160_n1600# 0.26fF
C11160 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/and_0/B 0.78fF
C11161 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C11162 ro_div_0/divider_0/tspc_1/Z3 ro_div_0/divider_0/tspc_1/Z4 0.65fF
C11163 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/a3 0.09fF
C11164 ro_complete_0/a1 ro_complete_0/cbank_0/switch_3/vin 0.14fF
C11165 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/B 0.22fF
C11166 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C11167 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C11168 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_17790_n840# 0.00fF
C11169 divbuf_2/a_36030_n1540# divbuf_2/a_36510_n1540# 0.11fF
C11170 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C11171 divbuf_3/a_6240_n1600# divbuf_3/a_6720_n1600# 0.26fF
C11172 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_2400_n1600# 0.26fF
C11173 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_9630_n1540# 0.19fF
C11174 pd_div_0/divbuf_0/a_9630_n840# pd_div_0/divbuf_0/a_10110_n840# 0.07fF
C11175 divbuf_3/a_29310_n840# divbuf_3/a_29310_n1540# 0.01fF
C11176 divbuf_3/a_59550_n840# divbuf_3/a_60030_n840# 0.07fF
C11177 divbuf_3/a_59520_n1600# divbuf_3/a_59550_n1540# 0.19fF
C11178 ro_div_0/divbuf_0/a_55230_n840# ro_div_0/divbuf_0/a_55710_n840# 0.07fF
C11179 ro_div_0/divbuf_0/a_24990_n840# ro_div_0/divbuf_0/a_24990_n1540# 0.01fF
C11180 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55230_n1540# 0.19fF
C11181 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C11182 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/a_15672_170# 0.07fF
C11183 divbuf_2/a_22952_170# divbuf_2/OUT4 0.19fF
C11184 divbuf_2/a_33600_n1600# divbuf_2/a_33630_n840# 0.04fF
C11185 pd_div_0/divbuf_0/a_60990_n1540# pd_div_0/divbuf_0/OUT5 0.19fF
C11186 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C11187 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/OUT3 0.19fF
C11188 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/a_37950_n840# 0.04fF
C11189 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47520_n1600# 0.26fF
C11190 divbuf_1/a_7200_n1600# divbuf_1/a_7680_n1600# 0.26fF
C11191 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/a_20670_n840# 0.03fF
C11192 divbuf_0/a_37920_n1600# divbuf_0/a_38400_n1600# 0.26fF
C11193 divbuf_0/a_28772_n240# divbuf_0/a_28830_n840# 0.04fF
C11194 pll_full_0/divbuf_0/a_39390_n1540# pll_full_0/divbuf_0/a_39870_n1540# 0.11fF
C11195 divbuf_3/a_17122_n240# divbuf_3/a_16830_n840# 0.00fF
C11196 divbuf_1/a_30270_n840# divbuf_1/a_30270_n1540# 0.01fF
C11197 divbuf_1/a_60510_n840# divbuf_1/a_60990_n840# 0.07fF
C11198 divbuf_1/a_60480_n1600# divbuf_1/a_60510_n1540# 0.19fF
C11199 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_12510_n840# 0.01fF
C11200 divbuf_2/a_31202_170# divbuf_2/a_31202_n240# 0.01fF
C11201 divbuf_2/a_11312_n240# divbuf_2/a_11802_n240# 0.04fF
C11202 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11203 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60030_n840# 0.04fF
C11204 divbuf_0/a_60990_n840# divbuf_0/a_60990_n1540# 0.01fF
C11205 divbuf_0/a_30270_n1540# divbuf_0/a_30750_n1540# 0.11fF
C11206 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_10080_n1600# 0.26fF
C11207 pll_full_0/divbuf_1/a_1950_n1540# pll_full_0/divbuf_1/a_2430_n1540# 0.11fF
C11208 pll_full_0/divbuf_1/a_32670_n840# pll_full_0/divbuf_1/a_32670_n1540# 0.01fF
C11209 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/OUT 0.07fF
C11210 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/a_15182_n240# 0.01fF
C11211 divbuf_2/a_23040_n1600# divbuf_2/a_23070_n1540# 0.19fF
C11212 divbuf_2/a_23922_n240# divbuf_2/OUT4 0.04fF
C11213 divbuf_2/a_23070_n840# divbuf_2/a_23550_n840# 0.07fF
C11214 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z3 0.06fF
C11215 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Q 0.51fF
C11216 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11217 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_36990_n840# 0.04fF
C11218 divbuf_3/a_12772_170# divbuf_3/a_13252_170# 0.07fF
C11219 divbuf_1/a_18092_n240# divbuf_1/a_17790_n840# 0.00fF
C11220 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C11221 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/a_7302_170# 0.07fF
C11222 divbuf_0/a_11312_170# divbuf_0/OUT4 0.23fF
C11223 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n840# 0.04fF
C11224 divbuf_3/a_37022_n240# divbuf_3/a_36990_n840# 0.05fF
C11225 divbuf_3/a_46080_n1600# divbuf_3/a_46560_n1600# 0.26fF
C11226 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/a_38472_n240# 0.05fF
C11227 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/a_32670_n840# 0.06fF
C11228 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_42240_n1600# 0.26fF
C11229 pd_div_0/divbuf_0/a_19230_n840# pd_div_0/divbuf_0/a_19230_n1540# 0.01fF
C11230 pd_div_0/divbuf_0/a_49470_n840# pd_div_0/divbuf_0/a_49950_n840# 0.07fF
C11231 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C11232 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49470_n1540# 0.19fF
C11233 divbuf_3/a_38430_n1540# divbuf_3/a_38910_n1540# 0.11fF
C11234 ro_div_0/divbuf_0/a_34110_n1540# ro_div_0/divbuf_0/a_34590_n1540# 0.11fF
C11235 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_15182_n240# 0.05fF
C11236 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/a_34592_n240# 0.01fF
C11237 divbuf_2/a_22080_n1600# divbuf_2/OUT4 0.01fF
C11238 pd_div_0/divider_0/tspc_2/Z2 pd_div_0/divider_0/tspc_2/Z3 0.16fF
C11239 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z4 0.22fF
C11240 pd_div_0/div pd_div_0/divbuf_0/a_0_n1600# 0.26fF
C11241 divbuf_0/a_25382_170# divbuf_0/a_25382_n240# 0.01fF
C11242 divbuf_0/a_4882_n240# divbuf_0/a_5362_n240# 0.05fF
C11243 pll_full_0/divbuf_0/a_26430_n840# pll_full_0/divbuf_0/a_26910_n840# 0.07fF
C11244 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11245 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26430_n1540# 0.19fF
C11246 divbuf_1/a_6332_170# divbuf_1/OUT3 0.19fF
C11247 divbuf_1/a_37992_n240# divbuf_1/a_37950_n840# 0.04fF
C11248 divbuf_1/a_47040_n1600# divbuf_1/a_47520_n1600# 0.26fF
C11249 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11250 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n1540# 0.19fF
C11251 divbuf_0/a_17310_n840# divbuf_0/a_17790_n840# 0.07fF
C11252 divbuf_0/a_12282_n240# divbuf_0/OUT4 0.04fF
C11253 divbuf_3/a_27802_170# divbuf_3/OUT4 0.19fF
C11254 divbuf_3/a_36000_n1600# divbuf_3/a_36030_n840# 0.04fF
C11255 divbuf_1/a_39390_n1540# divbuf_1/a_39870_n1540# 0.11fF
C11256 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/a_16642_170# 0.07fF
C11257 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_31710_n840# 0.04fF
C11258 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/a_40350_n840# 0.04fF
C11259 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49920_n1600# 0.26fF
C11260 divbuf_2/a_9600_n1600# divbuf_2/a_10080_n1600# 0.26fF
C11261 pll_full_0/divbuf_1/a_41790_n1540# pll_full_0/divbuf_1/a_42270_n1540# 0.11fF
C11262 divbuf_2/a_1950_n1540# divbuf_2/a_2430_n1540# 0.11fF
C11263 divbuf_2/a_32670_n840# divbuf_2/a_32670_n1540# 0.01fF
C11264 divbuf_2/a_510_n840# divbuf_2/OUT 0.07fF
C11265 divbuf_1/a_13252_170# divbuf_1/a_13252_n240# 0.01fF
C11266 divbuf_3/a_13742_n240# divbuf_3/a_14222_n240# 0.05fF
C11267 divbuf_3/a_33622_170# divbuf_3/a_33622_n240# 0.01fF
C11268 divbuf_1/a_26352_170# divbuf_1/OUT4 0.19fF
C11269 divbuf_1/a_36960_n1600# divbuf_1/a_36990_n840# 0.04fF
C11270 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/a_9242_n240# 0.05fF
C11271 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/a_29262_n240# 0.01fF
C11272 divbuf_0/a_11040_n1600# divbuf_0/OUT3 0.00fF
C11273 divbuf_3/a_25470_n840# divbuf_3/a_25950_n840# 0.07fF
C11274 divbuf_3/a_28772_n240# divbuf_3/OUT4 0.04fF
C11275 divbuf_3/a_25440_n1600# divbuf_3/a_25470_n1540# 0.19fF
C11276 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/a_26910_n840# 0.04fF
C11277 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36480_n1600# 0.26fF
C11278 ro_div_0/divbuf_0/a_21150_n840# ro_div_0/divbuf_0/a_21630_n840# 0.07fF
C11279 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11280 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21150_n1540# 0.19fF
C11281 pd_div_0/divbuf_0/a_28350_n1540# pd_div_0/divbuf_0/a_28830_n1540# 0.11fF
C11282 pd_div_0/divbuf_0/a_59070_n840# pd_div_0/divbuf_0/a_59070_n1540# 0.01fF
C11283 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39390_n840# 0.04fF
C11284 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11285 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a2 0.09fF
C11286 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_13440_n1600# 0.26fF
C11287 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/a_3390_n840# 0.05fF
C11288 divbuf_1/a_14702_n240# divbuf_1/a_15182_n240# 0.05fF
C11289 divbuf_1/a_34592_170# divbuf_1/a_34592_n240# 0.01fF
C11290 divbuf_0/a_3840_n1600# divbuf_0/a_4320_n1600# 0.26fF
C11291 pll_full_0/divbuf_0/a_5310_n1540# pll_full_0/divbuf_0/a_5790_n1540# 0.11fF
C11292 pll_full_0/divbuf_0/a_36030_n840# pll_full_0/divbuf_0/a_36030_n1540# 0.01fF
C11293 divbuf_1/a_26430_n840# divbuf_1/a_26910_n840# 0.07fF
C11294 divbuf_1/a_30712_n240# divbuf_1/OUT4 0.04fF
C11295 divbuf_1/a_26400_n1600# divbuf_1/a_26430_n1540# 0.19fF
C11296 divbuf_0/a_57150_n840# divbuf_0/a_57630_n840# 0.07fF
C11297 divbuf_0/a_26910_n840# divbuf_0/a_26910_n1540# 0.01fF
C11298 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n1540# 0.19fF
C11299 divbuf_2/a_16152_170# divbuf_2/a_16642_170# 0.07fF
C11300 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_25950_n840# 0.04fF
C11301 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_17612_n240# 0.04fF
C11302 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/a_37022_n240# 0.01fF
C11303 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/a_16642_n240# 0.01fF
C11304 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/a_36532_170# 0.07fF
C11305 pll_full_0/divbuf_1/a_28830_n840# pll_full_0/divbuf_1/a_29310_n840# 0.07fF
C11306 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11307 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_28830_n1540# 0.19fF
C11308 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C11309 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C11310 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C11311 divbuf_2/a_40412_n240# divbuf_2/a_40350_n840# 0.04fF
C11312 divbuf_2/a_49440_n1600# divbuf_2/a_49920_n1600# 0.26fF
C11313 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C11314 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z2 0.14fF
C11315 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/and_0/B 0.31fF
C11316 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C11317 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/A 0.21fF
C11318 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C11319 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_2910_n840# 0.04fF
C11320 divbuf_2/a_41790_n1540# divbuf_2/a_42270_n1540# 0.11fF
C11321 divbuf_0/a_14702_n240# divbuf_0/a_14430_n840# 0.01fF
C11322 divbuf_3/a_12000_n1600# divbuf_3/a_12480_n1600# 0.26fF
C11323 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_8160_n1600# 0.26fF
C11324 pd_div_0/divbuf_0/a_15390_n840# pd_div_0/divbuf_0/a_15870_n840# 0.07fF
C11325 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15390_n1540# 0.19fF
C11326 divbuf_3/a_4350_n1540# divbuf_3/a_4830_n1540# 0.11fF
C11327 divbuf_3/a_35070_n840# divbuf_3/a_35070_n1540# 0.01fF
C11328 ro_div_0/divbuf_0/a_30750_n840# ro_div_0/divbuf_0/a_30750_n1540# 0.01fF
C11329 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C11330 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/a_3912_n240# 0.01fF
C11331 divbuf_2/a_39360_n1600# divbuf_2/a_39390_n840# 0.04fF
C11332 divbuf_2/a_34592_170# divbuf_2/OUT4 0.19fF
C11333 divbuf_1/a_30712_170# divbuf_1/a_31202_170# 0.07fF
C11334 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C11335 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C11336 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z2 0.40fF
C11337 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/clk 0.05fF
C11338 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_53280_n1600# 0.26fF
C11339 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11340 divbuf_1/a_12960_n1600# divbuf_1/a_13440_n1600# 0.26fF
C11341 divbuf_1/a_3422_n240# divbuf_1/a_3390_n840# 0.05fF
C11342 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_4392_170# 0.07fF
C11343 divbuf_0/a_43680_n1600# divbuf_0/a_44160_n1600# 0.26fF
C11344 divbuf_0/a_34592_n240# divbuf_0/a_34590_n840# 0.06fF
C11345 pll_full_0/divbuf_0/a_45150_n1540# pll_full_0/divbuf_0/a_45630_n1540# 0.11fF
C11346 divbuf_3/a_1920_n1600# divbuf_3/a_1950_n840# 0.04fF
C11347 divbuf_1/a_5310_n1540# divbuf_1/a_5790_n1540# 0.11fF
C11348 divbuf_1/a_36030_n840# divbuf_1/a_36030_n1540# 0.01fF
C11349 divbuf_0/a_36030_n1540# divbuf_0/a_36510_n1540# 0.11fF
C11350 divbuf_2/a_17122_n240# divbuf_2/a_17612_n240# 0.04fF
C11351 divbuf_2/a_37022_170# divbuf_2/a_37022_n240# 0.01fF
C11352 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15840_n1600# 0.26fF
C11353 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/a_5790_n840# 0.04fF
C11354 pll_full_0/divbuf_1/a_7710_n1540# pll_full_0/divbuf_1/a_8190_n1540# 0.11fF
C11355 pll_full_0/divbuf_1/a_38430_n840# pll_full_0/divbuf_1/a_38430_n1540# 0.01fF
C11356 divbuf_2/a_28830_n840# divbuf_2/a_29310_n840# 0.07fF
C11357 divbuf_2/a_35562_n240# divbuf_2/OUT4 0.04fF
C11358 divbuf_2/a_28800_n1600# divbuf_2/a_28830_n1540# 0.19fF
C11359 pd_div_0/divider_0/tspc_1/Z3 pd_div_0/divider_0/tspc_1/Z4 0.65fF
C11360 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C11361 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/and_0/B 0.78fF
C11362 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_42750_n840# 0.04fF
C11363 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/OUT2 0.04fF
C11364 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11365 divbuf_3/a_18582_170# divbuf_3/a_19072_170# 0.07fF
C11366 divbuf_1/a_2880_n1600# divbuf_1/a_2910_n840# 0.04fF
C11367 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11368 ro_div_0/ro_complete_0/cbank_2/switch_2/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C11369 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/a_16152_170# 0.07fF
C11370 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_7792_n240# 0.01fF
C11371 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n840# 0.04fF
C11372 divbuf_0/a_22952_170# divbuf_0/OUT4 0.19fF
C11373 divbuf_3/a_51840_n1600# divbuf_3/a_52320_n1600# 0.26fF
C11374 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_2400_n1600# 0.26fF
C11375 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_48000_n1600# 0.26fF
C11376 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/a_38430_n840# 0.04fF
C11377 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/OUT3 0.19fF
C11378 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55230_n1540# 0.19fF
C11379 pd_div_0/divbuf_0/a_24990_n840# pd_div_0/divbuf_0/a_24990_n1540# 0.01fF
C11380 pd_div_0/divbuf_0/a_55230_n840# pd_div_0/divbuf_0/a_55710_n840# 0.07fF
C11381 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5310_n840# 0.04fF
C11382 divbuf_3/a_44190_n1540# divbuf_3/a_44670_n1540# 0.11fF
C11383 ro_div_0/divbuf_0/a_39870_n1540# ro_div_0/divbuf_0/a_40350_n1540# 0.11fF
C11384 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/a_21012_n240# 0.05fF
C11385 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/a_40412_n240# 0.01fF
C11386 divbuf_2/a_33600_n1600# divbuf_2/OUT4 0.01fF
C11387 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/a_22952_n240# 0.01fF
C11388 divbuf_0/a_11312_n240# divbuf_0/a_11802_n240# 0.04fF
C11389 divbuf_0/a_31202_170# divbuf_0/a_31202_n240# 0.01fF
C11390 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/OUT2 0.01fF
C11391 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32190_n1540# 0.19fF
C11392 pll_full_0/divbuf_0/a_1950_n840# pll_full_0/divbuf_0/a_1950_n1540# 0.01fF
C11393 pll_full_0/divbuf_0/a_32190_n840# pll_full_0/divbuf_0/a_32670_n840# 0.07fF
C11394 divbuf_1/a_52800_n1600# divbuf_1/a_53280_n1600# 0.26fF
C11395 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C11396 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/a_15672_n240# 0.01fF
C11397 divbuf_0/a_23070_n840# divbuf_0/a_23550_n840# 0.07fF
C11398 divbuf_0/a_23922_n240# divbuf_0/OUT4 0.04fF
C11399 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n1540# 0.19fF
C11400 divbuf_3/a_41760_n1600# divbuf_3/a_41790_n840# 0.04fF
C11401 divbuf_3/a_39442_170# divbuf_3/OUT4 0.19fF
C11402 divbuf_1/a_45150_n1540# divbuf_1/a_45630_n1540# 0.11fF
C11403 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/a_22472_170# 0.07fF
C11404 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/a_1352_n240# 0.01fF
C11405 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37470_n840# 0.04fF
C11406 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11407 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/tspc_r_1/Qbar 0.01fF
C11408 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/OUT3 0.19fF
C11409 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55680_n1600# 0.26fF
C11410 divbuf_2/a_15360_n1600# divbuf_2/a_15840_n1600# 0.26fF
C11411 divbuf_2/a_5852_n240# divbuf_2/a_5790_n840# 0.04fF
C11412 pll_full_0/divbuf_1/a_47550_n1540# pll_full_0/divbuf_1/a_48030_n1540# 0.11fF
C11413 divbuf_2/a_7710_n1540# divbuf_2/a_8190_n1540# 0.11fF
C11414 divbuf_2/a_38430_n840# divbuf_2/a_38430_n1540# 0.01fF
C11415 divbuf_3/a_19562_n240# divbuf_3/a_20042_n240# 0.05fF
C11416 divbuf_3/a_39442_170# divbuf_3/a_39442_n240# 0.01fF
C11417 divbuf_1/a_42720_n1600# divbuf_1/a_42750_n840# 0.04fF
C11418 divbuf_1/a_1842_n240# divbuf_1/OUT2 0.04fF
C11419 divbuf_1/a_41382_170# divbuf_1/OUT4 0.19fF
C11420 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/a_35082_n240# 0.01fF
C11421 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_15672_n240# 0.04fF
C11422 divbuf_0/a_22080_n1600# divbuf_0/OUT4 0.01fF
C11423 divbuf_3/a_40412_n240# divbuf_3/OUT4 0.04fF
C11424 divbuf_3/a_31200_n1600# divbuf_3/a_31230_n1540# 0.19fF
C11425 divbuf_3/a_990_n840# divbuf_3/a_990_n1540# 0.01fF
C11426 divbuf_3/a_31230_n840# divbuf_3/a_31710_n840# 0.07fF
C11427 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_42240_n1600# 0.26fF
C11428 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/a_32670_n840# 0.06fF
C11429 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_26910_n1540# 0.19fF
C11430 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11431 ro_div_0/divbuf_0/a_26910_n840# ro_div_0/divbuf_0/a_27390_n840# 0.07fF
C11432 pd_div_0/divbuf_0/a_34110_n1540# pd_div_0/divbuf_0/a_34590_n1540# 0.11fF
C11433 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C11434 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45150_n840# 0.04fF
C11435 divbuf_2/a_5280_n1600# divbuf_2/a_5310_n840# 0.04fF
C11436 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_0/a_630_n680# 0.04fF
C11437 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_19200_n1600# 0.26fF
C11438 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/a_9150_n840# 0.03fF
C11439 divbuf_1/a_20532_n240# divbuf_1/a_21012_n240# 0.05fF
C11440 divbuf_1/a_40412_170# divbuf_1/a_40412_n240# 0.01fF
C11441 divbuf_0/a_9600_n1600# divbuf_0/a_10080_n1600# 0.26fF
C11442 pll_full_0/divbuf_0/a_11070_n1540# pll_full_0/divbuf_0/a_11550_n1540# 0.11fF
C11443 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/a_41790_n1540# 0.01fF
C11444 divbuf_1/a_1440_n1600# divbuf_1/OUT2 0.01fF
C11445 divbuf_1/a_32160_n1600# divbuf_1/a_32190_n1540# 0.19fF
C11446 divbuf_1/a_1950_n840# divbuf_1/a_1950_n1540# 0.01fF
C11447 divbuf_1/a_32190_n840# divbuf_1/a_32670_n840# 0.07fF
C11448 divbuf_0/a_510_n840# divbuf_0/OUT 0.07fF
C11449 divbuf_0/a_32670_n840# divbuf_0/a_32670_n1540# 0.01fF
C11450 divbuf_0/a_1950_n1540# divbuf_0/a_2430_n1540# 0.11fF
C11451 divbuf_2/a_21982_170# divbuf_2/a_22472_170# 0.07fF
C11452 divbuf_2/a_1352_170# divbuf_2/a_1352_n240# 0.01fF
C11453 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_31710_n840# 0.04fF
C11454 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/a_23442_n240# 0.04fF
C11455 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/a_1842_n240# 0.04fF
C11456 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_34590_n1540# 0.19fF
C11457 pll_full_0/divbuf_1/a_4350_n840# pll_full_0/divbuf_1/a_4350_n1540# 0.01fF
C11458 pll_full_0/divbuf_1/a_34590_n840# pll_full_0/divbuf_1/a_35070_n840# 0.07fF
C11459 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_12282_170# 0.07fF
C11460 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C11461 divbuf_2/a_5852_170# divbuf_2/OUT3 0.19fF
C11462 divbuf_2/a_55200_n1600# divbuf_2/a_55680_n1600# 0.26fF
C11463 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/clk 0.04fF
C11464 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C11465 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_1/A 0.15fF
C11466 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C11467 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_8670_n840# 0.04fF
C11468 divbuf_2/a_47550_n1540# divbuf_2/a_48030_n1540# 0.11fF
C11469 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12030_n840# 0.02fF
C11470 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C11471 divbuf_3/a_17760_n1600# divbuf_3/a_18240_n1600# 0.26fF
C11472 divbuf_3/a_8272_n240# divbuf_3/a_8190_n840# 0.03fF
C11473 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/a_3870_n840# 0.04fF
C11474 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13920_n1600# 0.26fF
C11475 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21150_n1540# 0.19fF
C11476 pd_div_0/divbuf_0/a_21150_n840# pd_div_0/divbuf_0/a_21630_n840# 0.07fF
C11477 divbuf_3/a_10110_n1540# divbuf_3/a_10590_n1540# 0.11fF
C11478 divbuf_3/a_40830_n840# divbuf_3/a_40830_n1540# 0.01fF
C11479 ro_div_0/divbuf_0/a_36510_n840# ro_div_0/divbuf_0/a_36510_n1540# 0.01fF
C11480 ro_div_0/divbuf_0/a_5790_n1540# ro_div_0/divbuf_0/a_6270_n1540# 0.11fF
C11481 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/a_25862_170# 0.07fF
C11482 divbuf_2/a_6822_n240# divbuf_2/OUT3 0.04fF
C11483 divbuf_2/a_45120_n1600# divbuf_2/a_45150_n840# 0.04fF
C11484 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_59040_n1600# 0.26fF
C11485 divbuf_1/a_18720_n1600# divbuf_1/a_19200_n1600# 0.26fF
C11486 divbuf_1/a_9242_n240# divbuf_1/a_9150_n840# 0.03fF
C11487 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/a1 0.14fF
C11488 divbuf_0/a_49440_n1600# divbuf_0/a_49920_n1600# 0.26fF
C11489 divbuf_0/a_40412_n240# divbuf_0/a_40350_n840# 0.04fF
C11490 pll_full_0/divbuf_0/a_50910_n1540# pll_full_0/divbuf_0/a_51390_n1540# 0.11fF
C11491 divbuf_3/a_7680_n1600# divbuf_3/a_7710_n840# 0.04fF
C11492 divbuf_1/a_11070_n1540# divbuf_1/a_11550_n1540# 0.11fF
C11493 divbuf_1/a_41790_n840# divbuf_1/a_41790_n1540# 0.01fF
C11494 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3390_n840# 0.04fF
C11495 divbuf_0/a_41790_n1540# divbuf_0/a_42270_n1540# 0.11fF
C11496 divbuf_2/a_22952_n240# divbuf_2/a_23442_n240# 0.04fF
C11497 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_12030_n840# 0.02fF
C11498 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21600_n1600# 0.26fF
C11499 pll_full_0/divbuf_1/a_13470_n1540# pll_full_0/divbuf_1/a_13950_n1540# 0.11fF
C11500 pll_full_0/divbuf_1/a_44190_n840# pll_full_0/divbuf_1/a_44190_n1540# 0.01fF
C11501 divbuf_2/a_34560_n1600# divbuf_2/a_34590_n1540# 0.19fF
C11502 divbuf_2/a_4350_n840# divbuf_2/a_4350_n1540# 0.01fF
C11503 divbuf_2/a_34590_n840# divbuf_2/a_35070_n840# 0.07fF
C11504 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/and_0/B 0.31fF
C11505 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z2 0.14fF
C11506 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C11507 divbuf_0/a_15672_170# divbuf_0/a_15672_n240# 0.01fF
C11508 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11509 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48510_n840# 0.04fF
C11510 divbuf_3/a_4392_170# divbuf_3/a_4392_n240# 0.01fF
C11511 divbuf_3/a_24412_170# divbuf_3/a_24892_170# 0.07fF
C11512 divbuf_1/a_8640_n1600# divbuf_1/a_8670_n840# 0.04fF
C11513 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11514 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/a_20532_170# 0.07fF
C11515 divbuf_0/a_34592_170# divbuf_0/OUT4 0.19fF
C11516 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n840# 0.04fF
C11517 divbuf_3/a_57600_n1600# divbuf_3/a_58080_n1600# 0.26fF
C11518 divbuf_3/a_10212_170# divbuf_3/OUT4 0.07fF
C11519 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_8160_n1600# 0.26fF
C11520 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53760_n1600# 0.26fF
C11521 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/OUT2 0.42fF
C11522 pd_div_0/divbuf_0/a_30750_n840# pd_div_0/divbuf_0/a_30750_n1540# 0.01fF
C11523 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11070_n840# 0.04fF
C11524 divbuf_3/a_49950_n1540# divbuf_3/a_50430_n1540# 0.11fF
C11525 ro_div_0/divbuf_0/a_45630_n1540# ro_div_0/divbuf_0/a_46110_n1540# 0.11fF
C11526 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/a_26832_n240# 0.05fF
C11527 divbuf_1/a_31682_170# divbuf_1/a_31682_n240# 0.01fF
C11528 divbuf_1/a_21982_170# divbuf_1/a_22472_170# 0.07fF
C11529 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/a_28772_n240# 0.01fF
C11530 divbuf_0/a_37022_170# divbuf_0/a_37022_n240# 0.01fF
C11531 divbuf_0/a_17122_n240# divbuf_0/a_17612_n240# 0.04fF
C11532 pll_full_0/divbuf_0/a_7710_n840# pll_full_0/divbuf_0/a_7710_n1540# 0.01fF
C11533 pll_full_0/divbuf_0/a_37950_n840# pll_full_0/divbuf_0/a_38430_n840# 0.07fF
C11534 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C11535 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_37950_n1540# 0.19fF
C11536 divbuf_1/a_58560_n1600# divbuf_1/a_59040_n1600# 0.26fF
C11537 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11538 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n1540# 0.19fF
C11539 divbuf_0/a_35562_n240# divbuf_0/OUT4 0.04fF
C11540 divbuf_0/a_28830_n840# divbuf_0/a_29310_n840# 0.07fF
C11541 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/a_7792_n240# 0.01fF
C11542 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/a_28292_170# 0.07fF
C11543 divbuf_3/a_11802_n240# divbuf_3/OUT4 0.04fF
C11544 divbuf_3/a_47520_n1600# divbuf_3/a_47550_n840# 0.04fF
C11545 divbuf_1/a_50910_n1540# divbuf_1/a_51390_n1540# 0.11fF
C11546 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43230_n840# 0.04fF
C11547 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C11548 divbuf_2/a_11802_n240# divbuf_2/a_12030_n840# 0.02fF
C11549 divbuf_2/a_21120_n1600# divbuf_2/a_21600_n1600# 0.26fF
C11550 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/a_990_n840# 0.07fF
C11551 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_510_n1540# 0.19fF
C11552 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11553 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C11554 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C11555 pll_full_0/divbuf_1/a_53310_n1540# pll_full_0/divbuf_1/a_53790_n1540# 0.11fF
C11556 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_510_n1540# 0.11fF
C11557 divbuf_2/a_13470_n1540# divbuf_2/a_13950_n1540# 0.11fF
C11558 divbuf_2/a_44190_n840# divbuf_2/a_44190_n1540# 0.01fF
C11559 divbuf_1/a_24412_170# divbuf_1/a_24412_n240# 0.01fF
C11560 divbuf_3/a_25382_n240# divbuf_3/a_25862_n240# 0.05fF
C11561 divbuf_1/a_13742_n240# divbuf_1/OUT4 0.04fF
C11562 divbuf_1/a_48480_n1600# divbuf_1/a_48510_n840# 0.04fF
C11563 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/a_21502_n240# 0.04fF
C11564 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/a_40902_n240# 0.01fF
C11565 divbuf_0/a_33600_n1600# divbuf_0/OUT4 0.01fF
C11566 divbuf_3/a_6750_n840# divbuf_3/a_6750_n1540# 0.01fF
C11567 divbuf_3/a_36990_n840# divbuf_3/a_37470_n840# 0.07fF
C11568 divbuf_3/a_10560_n1600# divbuf_3/OUT3 0.01fF
C11569 divbuf_3/a_36960_n1600# divbuf_3/a_36990_n1540# 0.19fF
C11570 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/a_38430_n840# 0.04fF
C11571 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_48000_n1600# 0.26fF
C11572 ro_div_0/divbuf_0/a_32670_n840# ro_div_0/divbuf_0/a_33150_n840# 0.07fF
C11573 ro_div_0/divbuf_0/a_2430_n840# ro_div_0/divbuf_0/a_2430_n1540# 0.01fF
C11574 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_32670_n1540# 0.19fF
C11575 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C11576 pd_div_0/divbuf_0/a_39870_n1540# pd_div_0/divbuf_0/a_40350_n1540# 0.11fF
C11577 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_50910_n840# 0.04fF
C11578 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11579 divbuf_2/a_11040_n1600# divbuf_2/a_11070_n840# 0.04fF
C11580 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C11581 ro_div_0/divider_0/tspc_1/Z3 ro_div_0/divider_0/tspc_1/Q 0.05fF
C11582 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_1/B 0.18fF
C11583 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24960_n1600# 0.26fF
C11584 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_15390_n840# 0.02fF
C11585 divbuf_1/a_26352_n240# divbuf_1/a_26832_n240# 0.05fF
C11586 divbuf_0/a_5852_n240# divbuf_0/a_5790_n840# 0.04fF
C11587 divbuf_0/a_15360_n1600# divbuf_0/a_15840_n1600# 0.26fF
C11588 pll_full_0/divbuf_0/a_16830_n1540# pll_full_0/divbuf_0/a_17310_n1540# 0.11fF
C11589 pll_full_0/divbuf_0/a_47550_n840# pll_full_0/divbuf_0/a_47550_n1540# 0.01fF
C11590 divbuf_1/a_7710_n840# divbuf_1/a_7710_n1540# 0.01fF
C11591 divbuf_1/a_37950_n840# divbuf_1/a_38430_n840# 0.07fF
C11592 divbuf_1/a_12000_n1600# divbuf_1/OUT4 0.00fF
C11593 divbuf_1/a_37920_n1600# divbuf_1/a_37950_n1540# 0.19fF
C11594 divbuf_0/a_38430_n840# divbuf_0/a_38430_n1540# 0.01fF
C11595 divbuf_0/a_7710_n1540# divbuf_0/a_8190_n1540# 0.11fF
C11596 divbuf_2/a_7792_170# divbuf_2/a_7792_n240# 0.01fF
C11597 divbuf_2/a_27802_170# divbuf_2/a_28292_170# 0.07fF
C11598 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37470_n840# 0.04fF
C11599 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/a_29262_n240# 0.04fF
C11600 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/a_8272_n240# 0.05fF
C11601 pll_full_0/divbuf_1/a_10110_n840# pll_full_0/divbuf_1/a_10110_n1540# 0.01fF
C11602 pll_full_0/divbuf_1/a_40350_n840# pll_full_0/divbuf_1/a_40830_n840# 0.07fF
C11603 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40350_n1540# 0.19fF
C11604 divbuf_2/a_510_n840# divbuf_2/a_990_n840# 0.07fF
C11605 divbuf_2/a_480_n1600# divbuf_2/a_510_n1540# 0.19fF
C11606 divbuf_2/a_17612_170# divbuf_2/OUT4 0.19fF
Xashish_0 ashish_0/von ashish_0/vop ashish_0/Gnd ashish
Xpd_0 VDD gnd pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xcp_0 vdd vdd gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 gnd filter_0/v filter
Xro_div_0/ro_complete_0 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/a1 ro_div_0/ro_complete_0/a5
+ ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/a2 ro_complete
Xro_div_0/divbuf_0 VDD ro_div_0/divbuf_0/IN ro_div_0/divbuf_0/OUT ro_div_0/divbuf_0/OUT2
+ ro_div_0/divbuf_0/OUT3 ro_div_0/divbuf_0/OUT4 ro_div_0/divbuf_0/OUT5 gnd divbuf
Xro_div_0/divider_0 gnd vdd ro_div_0/divbuf_0/IN ro_div_0/divider_0/clk gnd divider
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xdivbuf_0 VDD divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ gnd divbuf
Xpd_div_0 pd_div_0/div pd_div_0/bufin pd_div
Xdivbuf_1 VDD divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4 divbuf_1/OUT5
+ gnd divbuf
Xdivbuf_2 VDD divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4 divbuf_2/OUT5
+ gnd divbuf
Xdivbuf_3 VDD divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4 divbuf_3/OUT5
+ gnd divbuf
Xpll_full_0 vdd pll_full
C11607 io_analog[4] vdd 25.05fF
C11608 io_analog[5] vdd 25.05fF
C11609 io_analog[6] vdd 25.05fF
C11610 io_in_3v3[0] vdd 0.61fF
C11611 io_oeb[26] vdd 0.61fF
C11612 io_in[0] vdd 0.61fF
C11613 io_out[26] vdd 0.61fF
C11614 io_out[0] vdd 0.61fF
C11615 io_oeb[0] vdd 0.61fF
C11616 io_in_3v3[1] vdd 0.61fF
C11617 io_in[1] vdd 0.61fF
C11618 io_out[1] vdd 0.61fF
C11619 io_oeb[1] vdd 0.61fF
C11620 io_in_3v3[2] vdd 0.61fF
C11621 io_in[2] vdd 0.61fF
C11622 io_out[2] vdd 0.61fF
C11623 io_oeb[2] vdd 0.61fF
C11624 io_in_3v3[3] vdd 0.61fF
C11625 io_in[3] vdd 0.61fF
C11626 io_out[3] vdd 0.61fF
C11627 io_oeb[3] vdd 0.61fF
C11628 io_in_3v3[4] vdd 0.61fF
C11629 io_in[4] vdd 0.61fF
C11630 io_out[4] vdd 0.61fF
C11631 io_oeb[4] vdd 0.61fF
C11632 io_in_3v3[5] vdd 0.61fF
C11633 io_in[5] vdd 0.61fF
C11634 io_out[5] vdd 0.61fF
C11635 io_oeb[5] vdd 0.61fF
C11636 io_in_3v3[6] vdd 0.61fF
C11637 io_in[6] vdd 0.61fF
C11638 io_out[6] vdd 0.61fF
C11639 io_oeb[6] vdd 0.61fF
C11640 vssa1 vdd 2139.00fF
C11641 io_in[26] vdd 0.61fF
C11642 io_in_3v3[26] vdd 0.61fF
C11643 io_oeb[25] vdd 0.61fF
C11644 io_out[25] vdd 0.61fF
C11645 io_in[25] vdd 0.61fF
C11646 io_in_3v3[25] vdd 0.61fF
C11647 io_oeb[24] vdd 0.61fF
C11648 io_out[24] vdd 0.61fF
C11649 io_in[24] vdd 0.61fF
C11650 io_in_3v3[24] vdd 0.61fF
C11651 gpio_noesd[17] vdd 0.61fF
C11652 gpio_analog[17] vdd 0.61fF
C11653 io_oeb[23] vdd 0.61fF
C11654 io_out[23] vdd 0.61fF
C11655 io_in[23] vdd 0.61fF
C11656 io_in_3v3[23] vdd 0.61fF
C11657 gpio_noesd[16] vdd 0.61fF
C11658 gpio_analog[16] vdd 0.61fF
C11659 io_oeb[22] vdd 0.61fF
C11660 io_out[22] vdd 0.61fF
C11661 io_in[22] vdd 0.61fF
C11662 io_in_3v3[22] vdd 0.61fF
C11663 gpio_noesd[15] vdd 0.61fF
C11664 gpio_analog[15] vdd 0.61fF
C11665 io_oeb[21] vdd 0.61fF
C11666 io_out[21] vdd 0.61fF
C11667 io_in[21] vdd 0.61fF
C11668 io_in_3v3[21] vdd 0.61fF
C11669 gpio_noesd[14] vdd 0.61fF
C11670 gpio_analog[14] vdd 0.61fF
C11671 vssd1 vdd 13.04fF
C11672 vdda1 vdd 3262.24fF
C11673 gpio_analog[0] vdd 0.61fF
C11674 gpio_noesd[0] vdd 0.61fF
C11675 io_in_3v3[7] vdd 0.61fF
C11676 io_in[7] vdd 0.61fF
C11677 io_out[7] vdd 0.61fF
C11678 io_oeb[7] vdd 0.61fF
C11679 gpio_analog[1] vdd 0.61fF
C11680 gpio_noesd[1] vdd 0.61fF
C11681 io_in_3v3[8] vdd 0.61fF
C11682 io_in[8] vdd 0.61fF
C11683 io_out[8] vdd 0.61fF
C11684 io_oeb[8] vdd 0.61fF
C11685 gpio_analog[2] vdd 0.61fF
C11686 gpio_noesd[2] vdd 0.61fF
C11687 io_in_3v3[9] vdd 0.61fF
C11688 io_in[9] vdd 0.61fF
C11689 io_out[9] vdd 0.61fF
C11690 io_oeb[9] vdd 0.61fF
C11691 gpio_analog[3] vdd 0.61fF
C11692 gpio_noesd[3] vdd 0.61fF
C11693 io_in_3v3[10] vdd 0.61fF
C11694 io_in[10] vdd 0.61fF
C11695 io_out[10] vdd 0.61fF
C11696 io_oeb[10] vdd 0.61fF
C11697 gpio_analog[4] vdd 0.61fF
C11698 gpio_noesd[4] vdd 0.61fF
C11699 io_in_3v3[11] vdd 0.61fF
C11700 io_in[11] vdd 0.61fF
C11701 io_out[11] vdd 0.61fF
C11702 io_oeb[11] vdd 0.61fF
C11703 gpio_analog[5] vdd 0.61fF
C11704 gpio_noesd[5] vdd 0.61fF
C11705 io_in_3v3[12] vdd 0.61fF
C11706 io_in[12] vdd 0.61fF
C11707 io_out[12] vdd 0.61fF
C11708 io_oeb[12] vdd 0.61fF
C11709 vssd2 vdd 13.04fF
C11710 vdda2 vdd 13.04fF
C11711 io_oeb[20] vdd 0.61fF
C11712 io_out[20] vdd 0.61fF
C11713 io_in[20] vdd 0.61fF
C11714 io_in_3v3[20] vdd 0.61fF
C11715 gpio_noesd[13] vdd 0.61fF
C11716 gpio_analog[13] vdd 0.61fF
C11717 io_oeb[19] vdd 0.61fF
C11718 io_out[19] vdd 0.61fF
C11719 io_in[19] vdd 0.61fF
C11720 io_in_3v3[19] vdd 0.61fF
C11721 gpio_noesd[12] vdd 0.61fF
C11722 gpio_analog[12] vdd 0.61fF
C11723 io_oeb[18] vdd 0.61fF
C11724 io_out[18] vdd 0.61fF
C11725 io_in[18] vdd 0.61fF
C11726 io_in_3v3[18] vdd 0.61fF
C11727 gpio_noesd[11] vdd 0.61fF
C11728 gpio_analog[11] vdd 0.61fF
C11729 io_oeb[17] vdd 0.61fF
C11730 io_out[17] vdd 0.61fF
C11731 io_in[17] vdd 0.61fF
C11732 io_in_3v3[17] vdd 0.61fF
C11733 gpio_noesd[10] vdd 0.61fF
C11734 gpio_analog[10] vdd 0.61fF
C11735 io_oeb[16] vdd 0.61fF
C11736 io_out[16] vdd 0.61fF
C11737 io_in[16] vdd 0.61fF
C11738 io_in_3v3[16] vdd 0.61fF
C11739 gpio_noesd[9] vdd 0.61fF
C11740 gpio_analog[9] vdd 0.61fF
C11741 io_oeb[15] vdd 0.61fF
C11742 io_out[15] vdd 0.61fF
C11743 io_in[15] vdd 0.61fF
C11744 io_in_3v3[15] vdd 0.61fF
C11745 gpio_noesd[8] vdd 0.61fF
C11746 gpio_analog[8] vdd 0.61fF
C11747 io_oeb[14] vdd 0.61fF
C11748 io_out[14] vdd 0.61fF
C11749 io_in[14] vdd 0.61fF
C11750 io_in_3v3[14] vdd 0.61fF
C11751 gpio_noesd[7] vdd 0.61fF
C11752 gpio_analog[7] vdd 0.61fF
C11753 vssa2 vdd 13.04fF
C11754 gpio_analog[6] vdd 0.61fF
C11755 gpio_noesd[6] vdd 0.61fF
C11756 io_in_3v3[13] vdd 0.61fF
C11757 io_in[13] vdd 0.61fF
C11758 io_out[13] vdd 0.61fF
C11759 io_oeb[13] vdd 0.61fF
C11760 vccd1 vdd 13.04fF
C11761 vccd2 vdd 13.04fF
C11762 io_analog[0] vdd 7.42fF
C11763 io_analog[10] vdd 6.83fF
C11764 io_analog[1] vdd 10.18fF
C11765 io_analog[2] vdd 7.88fF
C11766 io_analog[3] vdd 6.86fF
C11767 io_clamp_high[0] vdd 3.58fF
C11768 io_clamp_low[0] vdd 3.58fF
C11769 io_clamp_high[1] vdd 3.58fF
C11770 io_clamp_low[1] vdd 3.58fF
C11771 io_clamp_high[2] vdd 3.58fF
C11772 io_clamp_low[2] vdd 3.58fF
C11773 io_analog[7] vdd 6.83fF
C11774 io_analog[8] vdd 6.83fF
C11775 io_analog[9] vdd 6.83fF
C11776 user_irq[2] vdd 0.63fF
C11777 user_irq[1] vdd 0.63fF
C11778 user_irq[0] vdd 0.63fF
C11779 user_clock2 vdd 0.63fF
C11780 la_oenb[127] vdd 0.63fF
C11781 la_data_out[127] vdd 0.63fF
C11782 la_data_in[127] vdd 0.63fF
C11783 la_oenb[126] vdd 0.63fF
C11784 la_data_out[126] vdd 0.63fF
C11785 la_data_in[126] vdd 0.63fF
C11786 la_oenb[125] vdd 0.63fF
C11787 la_data_out[125] vdd 0.63fF
C11788 la_data_in[125] vdd 0.63fF
C11789 la_oenb[124] vdd 0.63fF
C11790 la_data_out[124] vdd 0.63fF
C11791 la_data_in[124] vdd 0.63fF
C11792 la_oenb[123] vdd 0.63fF
C11793 la_data_out[123] vdd 0.63fF
C11794 la_data_in[123] vdd 0.63fF
C11795 la_oenb[122] vdd 0.63fF
C11796 la_data_out[122] vdd 0.63fF
C11797 la_data_in[122] vdd 0.63fF
C11798 la_oenb[121] vdd 0.63fF
C11799 la_data_out[121] vdd 0.63fF
C11800 la_data_in[121] vdd 0.63fF
C11801 la_oenb[120] vdd 0.63fF
C11802 la_data_out[120] vdd 0.63fF
C11803 la_data_in[120] vdd 0.63fF
C11804 la_oenb[119] vdd 0.63fF
C11805 la_data_out[119] vdd 0.63fF
C11806 la_data_in[119] vdd 0.63fF
C11807 la_oenb[118] vdd 0.63fF
C11808 la_data_out[118] vdd 0.63fF
C11809 la_data_in[118] vdd 0.63fF
C11810 la_oenb[117] vdd 0.63fF
C11811 la_data_out[117] vdd 0.63fF
C11812 la_data_in[117] vdd 0.63fF
C11813 la_oenb[116] vdd 0.63fF
C11814 la_data_out[116] vdd 0.63fF
C11815 la_data_in[116] vdd 0.63fF
C11816 la_oenb[115] vdd 0.63fF
C11817 la_data_out[115] vdd 0.63fF
C11818 la_data_in[115] vdd 0.63fF
C11819 la_oenb[114] vdd 0.63fF
C11820 la_data_out[114] vdd 0.63fF
C11821 la_data_in[114] vdd 0.63fF
C11822 la_oenb[113] vdd 0.63fF
C11823 la_data_out[113] vdd 0.63fF
C11824 la_data_in[113] vdd 0.63fF
C11825 la_oenb[112] vdd 0.63fF
C11826 la_data_out[112] vdd 0.63fF
C11827 la_data_in[112] vdd 0.63fF
C11828 la_oenb[111] vdd 0.63fF
C11829 la_data_out[111] vdd 0.63fF
C11830 la_data_in[111] vdd 0.63fF
C11831 la_oenb[110] vdd 0.63fF
C11832 la_data_out[110] vdd 0.63fF
C11833 la_data_in[110] vdd 0.63fF
C11834 la_oenb[109] vdd 0.63fF
C11835 la_data_out[109] vdd 0.63fF
C11836 la_data_in[109] vdd 0.63fF
C11837 la_oenb[108] vdd 0.63fF
C11838 la_data_out[108] vdd 0.63fF
C11839 la_data_in[108] vdd 0.63fF
C11840 la_oenb[107] vdd 0.63fF
C11841 la_data_out[107] vdd 0.63fF
C11842 la_data_in[107] vdd 0.63fF
C11843 la_oenb[106] vdd 0.63fF
C11844 la_data_out[106] vdd 0.63fF
C11845 la_data_in[106] vdd 0.63fF
C11846 la_oenb[105] vdd 0.63fF
C11847 la_data_out[105] vdd 0.63fF
C11848 la_data_in[105] vdd 0.63fF
C11849 la_oenb[104] vdd 0.63fF
C11850 la_data_out[104] vdd 0.63fF
C11851 la_data_in[104] vdd 0.63fF
C11852 la_oenb[103] vdd 0.63fF
C11853 la_data_out[103] vdd 0.63fF
C11854 la_data_in[103] vdd 0.63fF
C11855 la_oenb[102] vdd 0.63fF
C11856 la_data_out[102] vdd 0.63fF
C11857 la_data_in[102] vdd 0.63fF
C11858 la_oenb[101] vdd 0.63fF
C11859 la_data_out[101] vdd 0.63fF
C11860 la_data_in[101] vdd 0.63fF
C11861 la_oenb[100] vdd 0.63fF
C11862 la_data_out[100] vdd 0.63fF
C11863 la_data_in[100] vdd 0.63fF
C11864 la_oenb[99] vdd 0.63fF
C11865 la_data_out[99] vdd 0.63fF
C11866 la_data_in[99] vdd 0.63fF
C11867 la_oenb[98] vdd 0.63fF
C11868 la_data_out[98] vdd 0.63fF
C11869 la_data_in[98] vdd 0.63fF
C11870 la_oenb[97] vdd 0.63fF
C11871 la_data_out[97] vdd 0.63fF
C11872 la_data_in[97] vdd 0.63fF
C11873 la_oenb[96] vdd 0.63fF
C11874 la_data_out[96] vdd 0.63fF
C11875 la_data_in[96] vdd 0.63fF
C11876 la_oenb[95] vdd 0.63fF
C11877 la_data_out[95] vdd 0.63fF
C11878 la_data_in[95] vdd 0.63fF
C11879 la_oenb[94] vdd 0.63fF
C11880 la_data_out[94] vdd 0.63fF
C11881 la_data_in[94] vdd 0.63fF
C11882 la_oenb[93] vdd 0.63fF
C11883 la_data_out[93] vdd 0.63fF
C11884 la_data_in[93] vdd 0.63fF
C11885 la_oenb[92] vdd 0.63fF
C11886 la_data_out[92] vdd 0.63fF
C11887 la_data_in[92] vdd 0.63fF
C11888 la_oenb[91] vdd 0.63fF
C11889 la_data_out[91] vdd 0.63fF
C11890 la_data_in[91] vdd 0.63fF
C11891 la_oenb[90] vdd 0.63fF
C11892 la_data_out[90] vdd 0.63fF
C11893 la_data_in[90] vdd 0.63fF
C11894 la_oenb[89] vdd 0.63fF
C11895 la_data_out[89] vdd 0.63fF
C11896 la_data_in[89] vdd 0.63fF
C11897 la_oenb[88] vdd 0.63fF
C11898 la_data_out[88] vdd 0.63fF
C11899 la_data_in[88] vdd 0.63fF
C11900 la_oenb[87] vdd 0.63fF
C11901 la_data_out[87] vdd 0.63fF
C11902 la_data_in[87] vdd 0.63fF
C11903 la_oenb[86] vdd 0.63fF
C11904 la_data_out[86] vdd 0.63fF
C11905 la_data_in[86] vdd 0.63fF
C11906 la_oenb[85] vdd 0.63fF
C11907 la_data_out[85] vdd 0.63fF
C11908 la_data_in[85] vdd 0.63fF
C11909 la_oenb[84] vdd 0.63fF
C11910 la_data_out[84] vdd 0.63fF
C11911 la_data_in[84] vdd 0.63fF
C11912 la_oenb[83] vdd 0.63fF
C11913 la_data_out[83] vdd 0.63fF
C11914 la_data_in[83] vdd 0.63fF
C11915 la_oenb[82] vdd 0.63fF
C11916 la_data_out[82] vdd 0.63fF
C11917 la_data_in[82] vdd 0.63fF
C11918 la_oenb[81] vdd 0.63fF
C11919 la_data_out[81] vdd 0.63fF
C11920 la_data_in[81] vdd 0.63fF
C11921 la_oenb[80] vdd 0.63fF
C11922 la_data_out[80] vdd 0.63fF
C11923 la_data_in[80] vdd 0.63fF
C11924 la_oenb[79] vdd 0.63fF
C11925 la_data_out[79] vdd 0.63fF
C11926 la_data_in[79] vdd 0.63fF
C11927 la_oenb[78] vdd 0.63fF
C11928 la_data_out[78] vdd 0.63fF
C11929 la_data_in[78] vdd 0.63fF
C11930 la_oenb[77] vdd 0.63fF
C11931 la_data_out[77] vdd 0.63fF
C11932 la_data_in[77] vdd 0.63fF
C11933 la_oenb[76] vdd 0.63fF
C11934 la_data_out[76] vdd 0.63fF
C11935 la_data_in[76] vdd 0.63fF
C11936 la_oenb[75] vdd 0.63fF
C11937 la_data_out[75] vdd 0.63fF
C11938 la_data_in[75] vdd 0.63fF
C11939 la_oenb[74] vdd 0.63fF
C11940 la_data_out[74] vdd 0.63fF
C11941 la_data_in[74] vdd 0.63fF
C11942 la_oenb[73] vdd 0.63fF
C11943 la_data_out[73] vdd 0.63fF
C11944 la_data_in[73] vdd 0.63fF
C11945 la_oenb[72] vdd 0.63fF
C11946 la_data_out[72] vdd 0.63fF
C11947 la_data_in[72] vdd 0.63fF
C11948 la_oenb[71] vdd 0.63fF
C11949 la_data_out[71] vdd 0.63fF
C11950 la_data_in[71] vdd 0.63fF
C11951 la_oenb[70] vdd 0.63fF
C11952 la_data_out[70] vdd 0.63fF
C11953 la_data_in[70] vdd 0.63fF
C11954 la_oenb[69] vdd 0.63fF
C11955 la_data_out[69] vdd 0.63fF
C11956 la_data_in[69] vdd 0.63fF
C11957 la_oenb[68] vdd 0.63fF
C11958 la_data_out[68] vdd 0.63fF
C11959 la_data_in[68] vdd 0.63fF
C11960 la_oenb[67] vdd 0.63fF
C11961 la_data_out[67] vdd 0.63fF
C11962 la_data_in[67] vdd 0.63fF
C11963 la_oenb[66] vdd 0.63fF
C11964 la_data_out[66] vdd 0.63fF
C11965 la_data_in[66] vdd 0.63fF
C11966 la_oenb[65] vdd 0.63fF
C11967 la_data_out[65] vdd 0.63fF
C11968 la_data_in[65] vdd 0.63fF
C11969 la_oenb[64] vdd 0.63fF
C11970 la_data_out[64] vdd 0.63fF
C11971 la_data_in[64] vdd 0.63fF
C11972 la_oenb[63] vdd 0.63fF
C11973 la_data_out[63] vdd 0.63fF
C11974 la_data_in[63] vdd 0.63fF
C11975 la_oenb[62] vdd 0.63fF
C11976 la_data_out[62] vdd 0.63fF
C11977 la_data_in[62] vdd 0.63fF
C11978 la_oenb[61] vdd 0.63fF
C11979 la_data_out[61] vdd 0.63fF
C11980 la_data_in[61] vdd 0.63fF
C11981 la_oenb[60] vdd 0.63fF
C11982 la_data_out[60] vdd 0.63fF
C11983 la_data_in[60] vdd 0.63fF
C11984 la_oenb[59] vdd 0.63fF
C11985 la_data_out[59] vdd 0.63fF
C11986 la_data_in[59] vdd 0.63fF
C11987 la_oenb[58] vdd 0.63fF
C11988 la_data_out[58] vdd 0.63fF
C11989 la_data_in[58] vdd 0.63fF
C11990 la_oenb[57] vdd 0.63fF
C11991 la_data_out[57] vdd 0.63fF
C11992 la_data_in[57] vdd 0.63fF
C11993 la_oenb[56] vdd 0.63fF
C11994 la_data_out[56] vdd 0.63fF
C11995 la_data_in[56] vdd 0.63fF
C11996 la_oenb[55] vdd 0.63fF
C11997 la_data_out[55] vdd 0.63fF
C11998 la_data_in[55] vdd 0.63fF
C11999 la_oenb[54] vdd 0.63fF
C12000 la_data_out[54] vdd 0.63fF
C12001 la_data_in[54] vdd 0.63fF
C12002 la_oenb[53] vdd 0.63fF
C12003 la_data_out[53] vdd 0.63fF
C12004 la_data_in[53] vdd 0.63fF
C12005 la_oenb[52] vdd 0.63fF
C12006 la_data_out[52] vdd 0.63fF
C12007 la_data_in[52] vdd 0.63fF
C12008 la_oenb[51] vdd 0.63fF
C12009 la_data_out[51] vdd 0.63fF
C12010 la_data_in[51] vdd 0.63fF
C12011 la_oenb[50] vdd 0.63fF
C12012 la_data_out[50] vdd 0.63fF
C12013 la_data_in[50] vdd 0.63fF
C12014 la_oenb[49] vdd 0.63fF
C12015 la_data_out[49] vdd 0.63fF
C12016 la_data_in[49] vdd 0.63fF
C12017 la_oenb[48] vdd 0.63fF
C12018 la_data_out[48] vdd 0.63fF
C12019 la_data_in[48] vdd 0.63fF
C12020 la_oenb[47] vdd 0.63fF
C12021 la_data_out[47] vdd 0.63fF
C12022 la_data_in[47] vdd 0.63fF
C12023 la_oenb[46] vdd 0.63fF
C12024 la_data_out[46] vdd 0.63fF
C12025 la_data_in[46] vdd 0.63fF
C12026 la_oenb[45] vdd 0.63fF
C12027 la_data_out[45] vdd 0.63fF
C12028 la_data_in[45] vdd 0.63fF
C12029 la_oenb[44] vdd 0.63fF
C12030 la_data_out[44] vdd 0.63fF
C12031 la_data_in[44] vdd 0.63fF
C12032 la_oenb[43] vdd 0.63fF
C12033 la_data_out[43] vdd 0.63fF
C12034 la_data_in[43] vdd 0.63fF
C12035 la_oenb[42] vdd 0.63fF
C12036 la_data_out[42] vdd 0.63fF
C12037 la_data_in[42] vdd 0.63fF
C12038 la_oenb[41] vdd 0.63fF
C12039 la_data_out[41] vdd 0.63fF
C12040 la_data_in[41] vdd 0.63fF
C12041 la_oenb[40] vdd 0.63fF
C12042 la_data_out[40] vdd 0.63fF
C12043 la_data_in[40] vdd 0.63fF
C12044 la_oenb[39] vdd 0.63fF
C12045 la_data_out[39] vdd 0.63fF
C12046 la_data_in[39] vdd 0.63fF
C12047 la_oenb[38] vdd 0.63fF
C12048 la_data_out[38] vdd 0.63fF
C12049 la_data_in[38] vdd 0.63fF
C12050 la_oenb[37] vdd 0.63fF
C12051 la_data_out[37] vdd 0.63fF
C12052 la_data_in[37] vdd 0.63fF
C12053 la_oenb[36] vdd 0.63fF
C12054 la_data_out[36] vdd 0.63fF
C12055 la_data_in[36] vdd 0.63fF
C12056 la_oenb[35] vdd 0.63fF
C12057 la_data_out[35] vdd 0.63fF
C12058 la_data_in[35] vdd 0.63fF
C12059 la_oenb[34] vdd 0.63fF
C12060 la_data_out[34] vdd 0.63fF
C12061 la_data_in[34] vdd 0.63fF
C12062 la_oenb[33] vdd 0.63fF
C12063 la_data_out[33] vdd 0.63fF
C12064 la_data_in[33] vdd 0.63fF
C12065 la_oenb[32] vdd 0.63fF
C12066 la_data_out[32] vdd 0.63fF
C12067 la_data_in[32] vdd 0.63fF
C12068 la_oenb[31] vdd 0.63fF
C12069 la_data_out[31] vdd 0.63fF
C12070 la_data_in[31] vdd 0.63fF
C12071 la_oenb[30] vdd 0.63fF
C12072 la_data_out[30] vdd 0.63fF
C12073 la_data_in[30] vdd 0.63fF
C12074 la_oenb[29] vdd 0.63fF
C12075 la_data_out[29] vdd 0.63fF
C12076 la_data_in[29] vdd 0.63fF
C12077 la_oenb[28] vdd 0.63fF
C12078 la_data_out[28] vdd 0.63fF
C12079 la_data_in[28] vdd 0.63fF
C12080 la_oenb[27] vdd 0.63fF
C12081 la_data_out[27] vdd 0.63fF
C12082 la_data_in[27] vdd 0.63fF
C12083 la_oenb[26] vdd 0.63fF
C12084 la_data_out[26] vdd 0.63fF
C12085 la_data_in[26] vdd 0.63fF
C12086 la_oenb[25] vdd 0.63fF
C12087 la_data_out[25] vdd 0.63fF
C12088 la_data_in[25] vdd 0.63fF
C12089 la_oenb[24] vdd 0.63fF
C12090 la_data_out[24] vdd 0.63fF
C12091 la_data_in[24] vdd 0.63fF
C12092 la_oenb[23] vdd 0.63fF
C12093 la_data_out[23] vdd 0.63fF
C12094 la_data_in[23] vdd 0.63fF
C12095 la_oenb[22] vdd 0.63fF
C12096 la_data_out[22] vdd 0.63fF
C12097 la_data_in[22] vdd 0.63fF
C12098 la_oenb[21] vdd 0.63fF
C12099 la_data_out[21] vdd 0.63fF
C12100 la_data_in[21] vdd 0.63fF
C12101 la_oenb[20] vdd 0.63fF
C12102 la_data_out[20] vdd 0.63fF
C12103 la_data_in[20] vdd 0.63fF
C12104 la_oenb[19] vdd 0.63fF
C12105 la_data_out[19] vdd 0.63fF
C12106 la_data_in[19] vdd 0.63fF
C12107 la_oenb[18] vdd 0.63fF
C12108 la_data_out[18] vdd 0.63fF
C12109 la_data_in[18] vdd 0.63fF
C12110 la_oenb[17] vdd 0.63fF
C12111 la_data_out[17] vdd 0.63fF
C12112 la_data_in[17] vdd 0.63fF
C12113 la_oenb[16] vdd 0.63fF
C12114 la_data_out[16] vdd 0.63fF
C12115 la_data_in[16] vdd 0.63fF
C12116 la_oenb[15] vdd 0.63fF
C12117 la_data_out[15] vdd 0.63fF
C12118 la_data_in[15] vdd 0.63fF
C12119 la_oenb[14] vdd 0.63fF
C12120 la_data_out[14] vdd 0.63fF
C12121 la_data_in[14] vdd 0.63fF
C12122 la_oenb[13] vdd 0.63fF
C12123 la_data_out[13] vdd 0.63fF
C12124 la_data_in[13] vdd 0.63fF
C12125 la_oenb[12] vdd 0.63fF
C12126 la_data_out[12] vdd 0.63fF
C12127 la_data_in[12] vdd 0.63fF
C12128 la_oenb[11] vdd 0.63fF
C12129 la_data_out[11] vdd 0.63fF
C12130 la_data_in[11] vdd 0.63fF
C12131 la_oenb[10] vdd 0.63fF
C12132 la_data_out[10] vdd 0.63fF
C12133 la_data_in[10] vdd 0.63fF
C12134 la_oenb[9] vdd 0.63fF
C12135 la_data_out[9] vdd 0.63fF
C12136 la_data_in[9] vdd 0.63fF
C12137 la_oenb[8] vdd 0.63fF
C12138 la_data_out[8] vdd 0.63fF
C12139 la_data_in[8] vdd 0.63fF
C12140 la_oenb[7] vdd 0.63fF
C12141 la_data_out[7] vdd 0.63fF
C12142 la_data_in[7] vdd 0.63fF
C12143 la_oenb[6] vdd 0.63fF
C12144 la_data_out[6] vdd 0.63fF
C12145 la_data_in[6] vdd 0.63fF
C12146 la_oenb[5] vdd 0.63fF
C12147 la_data_out[5] vdd 0.63fF
C12148 la_data_in[5] vdd 0.63fF
C12149 la_oenb[4] vdd 0.63fF
C12150 la_data_out[4] vdd 0.63fF
C12151 la_data_in[4] vdd 0.63fF
C12152 la_oenb[3] vdd 0.63fF
C12153 la_data_out[3] vdd 0.63fF
C12154 la_data_in[3] vdd 0.63fF
C12155 la_oenb[2] vdd 0.63fF
C12156 la_data_out[2] vdd 0.63fF
C12157 la_data_in[2] vdd 0.63fF
C12158 la_oenb[1] vdd 0.63fF
C12159 la_data_out[1] vdd 0.63fF
C12160 la_data_in[1] vdd 0.63fF
C12161 la_oenb[0] vdd 0.63fF
C12162 la_data_out[0] vdd 0.63fF
C12163 la_data_in[0] vdd 0.63fF
C12164 wbs_dat_o[31] vdd 0.63fF
C12165 wbs_dat_i[31] vdd 0.63fF
C12166 wbs_adr_i[31] vdd 0.63fF
C12167 wbs_dat_o[30] vdd 0.63fF
C12168 wbs_dat_i[30] vdd 0.63fF
C12169 wbs_adr_i[30] vdd 0.63fF
C12170 wbs_dat_o[29] vdd 0.63fF
C12171 wbs_dat_i[29] vdd 0.63fF
C12172 wbs_adr_i[29] vdd 0.63fF
C12173 wbs_dat_o[28] vdd 0.63fF
C12174 wbs_dat_i[28] vdd 0.63fF
C12175 wbs_adr_i[28] vdd 0.63fF
C12176 wbs_dat_o[27] vdd 0.63fF
C12177 wbs_dat_i[27] vdd 0.63fF
C12178 wbs_adr_i[27] vdd 0.63fF
C12179 wbs_dat_o[26] vdd 0.63fF
C12180 wbs_dat_i[26] vdd 0.63fF
C12181 wbs_adr_i[26] vdd 0.63fF
C12182 wbs_dat_o[25] vdd 0.63fF
C12183 wbs_dat_i[25] vdd 0.63fF
C12184 wbs_adr_i[25] vdd 0.63fF
C12185 wbs_dat_o[24] vdd 0.63fF
C12186 wbs_dat_i[24] vdd 0.63fF
C12187 wbs_adr_i[24] vdd 0.63fF
C12188 wbs_dat_o[23] vdd 0.63fF
C12189 wbs_dat_i[23] vdd 0.63fF
C12190 wbs_adr_i[23] vdd 0.63fF
C12191 wbs_dat_o[22] vdd 0.63fF
C12192 wbs_dat_i[22] vdd 0.63fF
C12193 wbs_adr_i[22] vdd 0.63fF
C12194 wbs_dat_o[21] vdd 0.63fF
C12195 wbs_dat_i[21] vdd 0.63fF
C12196 wbs_adr_i[21] vdd 0.63fF
C12197 wbs_dat_o[20] vdd 0.63fF
C12198 wbs_dat_i[20] vdd 0.63fF
C12199 wbs_adr_i[20] vdd 0.63fF
C12200 wbs_dat_o[19] vdd 0.63fF
C12201 wbs_dat_i[19] vdd 0.63fF
C12202 wbs_adr_i[19] vdd 0.63fF
C12203 wbs_dat_o[18] vdd 0.63fF
C12204 wbs_dat_i[18] vdd 0.63fF
C12205 wbs_adr_i[18] vdd 0.63fF
C12206 wbs_dat_o[17] vdd 0.63fF
C12207 wbs_dat_i[17] vdd 0.63fF
C12208 wbs_adr_i[17] vdd 0.63fF
C12209 wbs_dat_o[16] vdd 0.63fF
C12210 wbs_dat_i[16] vdd 0.63fF
C12211 wbs_adr_i[16] vdd 0.63fF
C12212 wbs_dat_o[15] vdd 0.63fF
C12213 wbs_dat_i[15] vdd 0.63fF
C12214 wbs_adr_i[15] vdd 0.63fF
C12215 wbs_dat_o[14] vdd 0.63fF
C12216 wbs_dat_i[14] vdd 0.63fF
C12217 wbs_adr_i[14] vdd 0.63fF
C12218 wbs_dat_o[13] vdd 0.63fF
C12219 wbs_dat_i[13] vdd 0.63fF
C12220 wbs_adr_i[13] vdd 0.63fF
C12221 wbs_dat_o[12] vdd 0.63fF
C12222 wbs_dat_i[12] vdd 0.63fF
C12223 wbs_adr_i[12] vdd 0.63fF
C12224 wbs_dat_o[11] vdd 0.63fF
C12225 wbs_dat_i[11] vdd 0.63fF
C12226 wbs_adr_i[11] vdd 0.63fF
C12227 wbs_dat_o[10] vdd 0.63fF
C12228 wbs_dat_i[10] vdd 0.63fF
C12229 wbs_adr_i[10] vdd 0.63fF
C12230 wbs_dat_o[9] vdd 0.63fF
C12231 wbs_dat_i[9] vdd 0.63fF
C12232 wbs_adr_i[9] vdd 0.63fF
C12233 wbs_dat_o[8] vdd 0.63fF
C12234 wbs_dat_i[8] vdd 0.63fF
C12235 wbs_adr_i[8] vdd 0.63fF
C12236 wbs_dat_o[7] vdd 0.63fF
C12237 wbs_dat_i[7] vdd 0.63fF
C12238 wbs_adr_i[7] vdd 0.63fF
C12239 wbs_dat_o[6] vdd 0.63fF
C12240 wbs_dat_i[6] vdd 0.63fF
C12241 wbs_adr_i[6] vdd 0.63fF
C12242 wbs_dat_o[5] vdd 0.63fF
C12243 wbs_dat_i[5] vdd 0.63fF
C12244 wbs_adr_i[5] vdd 0.63fF
C12245 wbs_dat_o[4] vdd 0.63fF
C12246 wbs_dat_i[4] vdd 0.63fF
C12247 wbs_adr_i[4] vdd 0.63fF
C12248 wbs_sel_i[3] vdd 0.63fF
C12249 wbs_dat_o[3] vdd 0.63fF
C12250 wbs_dat_i[3] vdd 0.63fF
C12251 wbs_adr_i[3] vdd 0.63fF
C12252 wbs_sel_i[2] vdd 0.63fF
C12253 wbs_dat_o[2] vdd 0.63fF
C12254 wbs_dat_i[2] vdd 0.63fF
C12255 wbs_adr_i[2] vdd 0.63fF
C12256 wbs_sel_i[1] vdd 0.63fF
C12257 wbs_dat_o[1] vdd 0.63fF
C12258 wbs_dat_i[1] vdd 0.63fF
C12259 wbs_adr_i[1] vdd 0.63fF
C12260 wbs_sel_i[0] vdd 0.63fF
C12261 wbs_dat_o[0] vdd 0.63fF
C12262 wbs_dat_i[0] vdd 0.63fF
C12263 wbs_adr_i[0] vdd 0.63fF
C12264 wbs_we_i vdd 0.63fF
C12265 wbs_stb_i vdd 0.63fF
C12266 wbs_cyc_i vdd 0.63fF
C12267 wbs_ack_o vdd 0.63fF
C12268 wb_rst_i vdd 0.63fF
C12269 wb_clk_i vdd 0.63fF
C12270 pll_full_0/divider_0/and_0/Z1 vdd 0.65fF
C12271 pll_full_0/divider_0/and_0/B vdd 2.45fF
C12272 pll_full_0/divider_0/and_0/A vdd 2.35fF
C12273 pll_full_0/divider_0/and_0/out1 vdd 2.99fF
C12274 pll_full_0/divider_0/tspc_2/Z4 vdd 0.86fF
C12275 pll_full_0/divbuf_0/IN vdd 9.95fF
C12276 pll_full_0/divider_0/tspc_2/Z3 vdd 2.26fF
C12277 pll_full_0/divider_0/tspc_2/Z2 vdd 1.46fF
C12278 pll_full_0/divider_0/tspc_2/Z1 vdd 0.99fF
C12279 pll_full_0/divider_0/nor_0/B vdd 6.48fF
C12280 pll_full_0/divider_0/tspc_2/a_630_n680# vdd 1.14fF **FLOATING
C12281 pll_full_0/divider_0/tspc_1/Z4 vdd 0.86fF
C12282 pll_full_0/divider_0/tspc_1/Q vdd 3.12fF
C12283 pll_full_0/divider_0/tspc_1/Z3 vdd 2.26fF
C12284 pll_full_0/divider_0/tspc_1/Z2 vdd 1.46fF
C12285 pll_full_0/divider_0/tspc_1/Z1 vdd 0.99fF
C12286 pll_full_0/divider_0/nor_1/B vdd 7.12fF
C12287 pll_full_0/divider_0/tspc_1/a_630_n680# vdd 1.15fF **FLOATING
C12288 pll_full_0/divider_0/tspc_0/Z4 vdd 0.86fF
C12289 pll_full_0/divider_0/tspc_0/Q vdd 3.14fF
C12290 pll_full_0/divider_0/tspc_0/Z3 vdd 2.26fF
C12291 pll_full_0/divider_0/tspc_0/Z2 vdd 1.46fF
C12292 pll_full_0/divider_0/tspc_0/Z1 vdd 0.99fF
C12293 pll_full_0/divider_0/nor_1/A vdd 7.08fF
C12294 pll_full_0/divider_0/tspc_0/a_630_n680# vdd 1.15fF **FLOATING
C12295 pll_full_0/divider_0/clk vdd 31.85fF
C12296 pll_full_0/divider_0/prescaler_0/Out vdd 4.59fF
C12297 pll_full_0/divider_0/prescaler_0/nand_1/z1 vdd 0.36fF
C12298 pll_full_0/divider_0/prescaler_0/tspc_2/D vdd 2.64fF
C12299 pll_full_0/divider_0/prescaler_0/tspc_0/Q vdd 3.64fF
C12300 pll_full_0/divider_0/prescaler_0/tspc_1/Q vdd 3.61fF
C12301 pll_full_0/divider_0/prescaler_0/nand_0/z1 vdd 0.36fF
C12302 pll_full_0/divider_0/prescaler_0/tspc_0/D vdd 3.12fF
C12303 pll_full_0/divider_0/and_0/OUT vdd 5.67fF
C12304 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.86fF
C12305 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.26fF
C12306 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.46fF
C12307 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C12308 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 1.16fF **FLOATING
C12309 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 2.11fF **FLOATING
C12310 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.86fF
C12311 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.26fF
C12312 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.48fF
C12313 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C12314 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 1.14fF **FLOATING
C12315 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vdd 4.22fF **FLOATING
C12316 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.86fF
C12317 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.26fF
C12318 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.19fF
C12319 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C12320 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 1.47fF **FLOATING
C12321 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 2.11fF **FLOATING
C12322 pll_full_0/divider_0/nor_1/Z1 vdd 1.34fF
C12323 pll_full_0/divider_0/nor_0/Z1 vdd 1.34fF
C12324 pll_full_0/divbuf_1/OUT vdd 3.28fF
C12325 pll_full_0/divbuf_1/OUT5 vdd 16.40fF
C12326 pll_full_0/divbuf_1/OUT4 vdd 100.06fF
C12327 pll_full_0/divbuf_1/OUT3 vdd 27.01fF
C12328 pll_full_0/divbuf_1/OUT2 vdd 8.71fF
C12329 pll_full_0/divbuf_1/a_60990_n1540# vdd 1.57fF **FLOATING
C12330 pll_full_0/divbuf_1/a_60510_n1540# vdd 1.62fF **FLOATING
C12331 pll_full_0/divbuf_1/a_60030_n1540# vdd 1.62fF **FLOATING
C12332 pll_full_0/divbuf_1/a_59550_n1540# vdd 1.62fF **FLOATING
C12333 pll_full_0/divbuf_1/a_59070_n1540# vdd 1.62fF **FLOATING
C12334 pll_full_0/divbuf_1/a_58590_n1540# vdd 1.62fF **FLOATING
C12335 pll_full_0/divbuf_1/a_58110_n1540# vdd 1.62fF **FLOATING
C12336 pll_full_0/divbuf_1/a_57630_n1540# vdd 1.62fF **FLOATING
C12337 pll_full_0/divbuf_1/a_57150_n1540# vdd 1.62fF **FLOATING
C12338 pll_full_0/divbuf_1/a_56670_n1540# vdd 1.62fF **FLOATING
C12339 pll_full_0/divbuf_1/a_56190_n1540# vdd 1.62fF **FLOATING
C12340 pll_full_0/divbuf_1/a_55710_n1540# vdd 1.62fF **FLOATING
C12341 pll_full_0/divbuf_1/a_55230_n1540# vdd 1.62fF **FLOATING
C12342 pll_full_0/divbuf_1/a_54750_n1540# vdd 1.62fF **FLOATING
C12343 pll_full_0/divbuf_1/a_54270_n1540# vdd 1.62fF **FLOATING
C12344 pll_full_0/divbuf_1/a_53790_n1540# vdd 1.62fF **FLOATING
C12345 pll_full_0/divbuf_1/a_53310_n1540# vdd 1.62fF **FLOATING
C12346 pll_full_0/divbuf_1/a_52830_n1540# vdd 1.62fF **FLOATING
C12347 pll_full_0/divbuf_1/a_52350_n1540# vdd 1.62fF **FLOATING
C12348 pll_full_0/divbuf_1/a_51870_n1540# vdd 1.62fF **FLOATING
C12349 pll_full_0/divbuf_1/a_51390_n1540# vdd 1.62fF **FLOATING
C12350 pll_full_0/divbuf_1/a_50910_n1540# vdd 1.62fF **FLOATING
C12351 pll_full_0/divbuf_1/a_50430_n1540# vdd 1.62fF **FLOATING
C12352 pll_full_0/divbuf_1/a_49950_n1540# vdd 1.62fF **FLOATING
C12353 pll_full_0/divbuf_1/a_49470_n1540# vdd 1.62fF **FLOATING
C12354 pll_full_0/divbuf_1/a_48990_n1540# vdd 1.62fF **FLOATING
C12355 pll_full_0/divbuf_1/a_48510_n1540# vdd 1.62fF **FLOATING
C12356 pll_full_0/divbuf_1/a_48030_n1540# vdd 1.62fF **FLOATING
C12357 pll_full_0/divbuf_1/a_47550_n1540# vdd 1.62fF **FLOATING
C12358 pll_full_0/divbuf_1/a_47070_n1540# vdd 1.62fF **FLOATING
C12359 pll_full_0/divbuf_1/a_46590_n1540# vdd 1.62fF **FLOATING
C12360 pll_full_0/divbuf_1/a_46110_n1540# vdd 1.62fF **FLOATING
C12361 pll_full_0/divbuf_1/a_45630_n1540# vdd 1.62fF **FLOATING
C12362 pll_full_0/divbuf_1/a_45150_n1540# vdd 1.62fF **FLOATING
C12363 pll_full_0/divbuf_1/a_44670_n1540# vdd 1.62fF **FLOATING
C12364 pll_full_0/divbuf_1/a_44190_n1540# vdd 1.62fF **FLOATING
C12365 pll_full_0/divbuf_1/a_43710_n1540# vdd 1.62fF **FLOATING
C12366 pll_full_0/divbuf_1/a_43230_n1540# vdd 1.62fF **FLOATING
C12367 pll_full_0/divbuf_1/a_42750_n1540# vdd 1.62fF **FLOATING
C12368 pll_full_0/divbuf_1/a_42270_n1540# vdd 1.62fF **FLOATING
C12369 pll_full_0/divbuf_1/a_41790_n1540# vdd 1.62fF **FLOATING
C12370 pll_full_0/divbuf_1/a_41310_n1540# vdd 1.62fF **FLOATING
C12371 pll_full_0/divbuf_1/a_40830_n1540# vdd 1.62fF **FLOATING
C12372 pll_full_0/divbuf_1/a_40350_n1540# vdd 1.62fF **FLOATING
C12373 pll_full_0/divbuf_1/a_39870_n1540# vdd 1.62fF **FLOATING
C12374 pll_full_0/divbuf_1/a_39390_n1540# vdd 1.62fF **FLOATING
C12375 pll_full_0/divbuf_1/a_38910_n1540# vdd 1.62fF **FLOATING
C12376 pll_full_0/divbuf_1/a_38430_n1540# vdd 1.62fF **FLOATING
C12377 pll_full_0/divbuf_1/a_37950_n1540# vdd 1.62fF **FLOATING
C12378 pll_full_0/divbuf_1/a_37470_n1540# vdd 1.62fF **FLOATING
C12379 pll_full_0/divbuf_1/a_36990_n1540# vdd 1.62fF **FLOATING
C12380 pll_full_0/divbuf_1/a_36510_n1540# vdd 1.62fF **FLOATING
C12381 pll_full_0/divbuf_1/a_36030_n1540# vdd 1.62fF **FLOATING
C12382 pll_full_0/divbuf_1/a_35550_n1540# vdd 1.62fF **FLOATING
C12383 pll_full_0/divbuf_1/a_35070_n1540# vdd 1.62fF **FLOATING
C12384 pll_full_0/divbuf_1/a_34590_n1540# vdd 1.62fF **FLOATING
C12385 pll_full_0/divbuf_1/a_34110_n1540# vdd 1.62fF **FLOATING
C12386 pll_full_0/divbuf_1/a_33630_n1540# vdd 1.62fF **FLOATING
C12387 pll_full_0/divbuf_1/a_33150_n1540# vdd 1.62fF **FLOATING
C12388 pll_full_0/divbuf_1/a_32670_n1540# vdd 1.62fF **FLOATING
C12389 pll_full_0/divbuf_1/a_32190_n1540# vdd 1.62fF **FLOATING
C12390 pll_full_0/divbuf_1/a_31710_n1540# vdd 1.62fF **FLOATING
C12391 pll_full_0/divbuf_1/a_31230_n1540# vdd 1.62fF **FLOATING
C12392 pll_full_0/divbuf_1/a_30750_n1540# vdd 1.62fF **FLOATING
C12393 pll_full_0/divbuf_1/a_30270_n1540# vdd 1.62fF **FLOATING
C12394 pll_full_0/divbuf_1/a_29790_n1540# vdd 1.62fF **FLOATING
C12395 pll_full_0/divbuf_1/a_29310_n1540# vdd 1.62fF **FLOATING
C12396 pll_full_0/divbuf_1/a_28830_n1540# vdd 1.62fF **FLOATING
C12397 pll_full_0/divbuf_1/a_28350_n1540# vdd 1.62fF **FLOATING
C12398 pll_full_0/divbuf_1/a_27870_n1540# vdd 1.62fF **FLOATING
C12399 pll_full_0/divbuf_1/a_27390_n1540# vdd 1.62fF **FLOATING
C12400 pll_full_0/divbuf_1/a_26910_n1540# vdd 1.62fF **FLOATING
C12401 pll_full_0/divbuf_1/a_26430_n1540# vdd 1.62fF **FLOATING
C12402 pll_full_0/divbuf_1/a_25950_n1540# vdd 1.62fF **FLOATING
C12403 pll_full_0/divbuf_1/a_25470_n1540# vdd 1.62fF **FLOATING
C12404 pll_full_0/divbuf_1/a_24990_n1540# vdd 1.62fF **FLOATING
C12405 pll_full_0/divbuf_1/a_24510_n1540# vdd 1.62fF **FLOATING
C12406 pll_full_0/divbuf_1/a_24030_n1540# vdd 1.62fF **FLOATING
C12407 pll_full_0/divbuf_1/a_23550_n1540# vdd 1.62fF **FLOATING
C12408 pll_full_0/divbuf_1/a_23070_n1540# vdd 1.62fF **FLOATING
C12409 pll_full_0/divbuf_1/a_22590_n1540# vdd 1.62fF **FLOATING
C12410 pll_full_0/divbuf_1/a_22110_n1540# vdd 1.62fF **FLOATING
C12411 pll_full_0/divbuf_1/a_21630_n1540# vdd 1.62fF **FLOATING
C12412 pll_full_0/divbuf_1/a_21150_n1540# vdd 1.62fF **FLOATING
C12413 pll_full_0/divbuf_1/a_20670_n1540# vdd 1.62fF **FLOATING
C12414 pll_full_0/divbuf_1/a_20190_n1540# vdd 1.62fF **FLOATING
C12415 pll_full_0/divbuf_1/a_19710_n1540# vdd 1.62fF **FLOATING
C12416 pll_full_0/divbuf_1/a_19230_n1540# vdd 1.62fF **FLOATING
C12417 pll_full_0/divbuf_1/a_18750_n1540# vdd 1.62fF **FLOATING
C12418 pll_full_0/divbuf_1/a_18270_n1540# vdd 1.62fF **FLOATING
C12419 pll_full_0/divbuf_1/a_17790_n1540# vdd 1.62fF **FLOATING
C12420 pll_full_0/divbuf_1/a_17310_n1540# vdd 1.62fF **FLOATING
C12421 pll_full_0/divbuf_1/a_16830_n1540# vdd 1.62fF **FLOATING
C12422 pll_full_0/divbuf_1/a_16350_n1540# vdd 1.62fF **FLOATING
C12423 pll_full_0/divbuf_1/a_15870_n1540# vdd 1.62fF **FLOATING
C12424 pll_full_0/divbuf_1/a_15390_n1540# vdd 1.62fF **FLOATING
C12425 pll_full_0/divbuf_1/a_14910_n1540# vdd 1.62fF **FLOATING
C12426 pll_full_0/divbuf_1/a_14430_n1540# vdd 1.62fF **FLOATING
C12427 pll_full_0/divbuf_1/a_13950_n1540# vdd 1.62fF **FLOATING
C12428 pll_full_0/divbuf_1/a_13470_n1540# vdd 1.62fF **FLOATING
C12429 pll_full_0/divbuf_1/a_12990_n1540# vdd 1.62fF **FLOATING
C12430 pll_full_0/divbuf_1/a_12510_n1540# vdd 1.62fF **FLOATING
C12431 pll_full_0/divbuf_1/a_12030_n1540# vdd 1.62fF **FLOATING
C12432 pll_full_0/divbuf_1/a_11550_n1540# vdd 1.62fF **FLOATING
C12433 pll_full_0/divbuf_1/a_11070_n1540# vdd 1.62fF **FLOATING
C12434 pll_full_0/divbuf_1/a_10590_n1540# vdd 1.62fF **FLOATING
C12435 pll_full_0/divbuf_1/a_10110_n1540# vdd 1.62fF **FLOATING
C12436 pll_full_0/divbuf_1/a_9630_n1540# vdd 1.62fF **FLOATING
C12437 pll_full_0/divbuf_1/a_9150_n1540# vdd 1.62fF **FLOATING
C12438 pll_full_0/divbuf_1/a_8670_n1540# vdd 1.62fF **FLOATING
C12439 pll_full_0/divbuf_1/a_8190_n1540# vdd 1.62fF **FLOATING
C12440 pll_full_0/divbuf_1/a_7710_n1540# vdd 1.62fF **FLOATING
C12441 pll_full_0/divbuf_1/a_7230_n1540# vdd 1.62fF **FLOATING
C12442 pll_full_0/divbuf_1/a_6750_n1540# vdd 1.62fF **FLOATING
C12443 pll_full_0/divbuf_1/a_6270_n1540# vdd 1.62fF **FLOATING
C12444 pll_full_0/divbuf_1/a_5790_n1540# vdd 1.62fF **FLOATING
C12445 pll_full_0/divbuf_1/a_5310_n1540# vdd 1.62fF **FLOATING
C12446 pll_full_0/divbuf_1/a_4830_n1540# vdd 1.62fF **FLOATING
C12447 pll_full_0/divbuf_1/a_4350_n1540# vdd 1.62fF **FLOATING
C12448 pll_full_0/divbuf_1/a_3870_n1540# vdd 1.62fF **FLOATING
C12449 pll_full_0/divbuf_1/a_3390_n1540# vdd 1.62fF **FLOATING
C12450 pll_full_0/divbuf_1/a_2910_n1540# vdd 1.62fF **FLOATING
C12451 pll_full_0/divbuf_1/a_2430_n1540# vdd 1.62fF **FLOATING
C12452 pll_full_0/divbuf_1/a_1950_n1540# vdd 1.62fF **FLOATING
C12453 pll_full_0/divbuf_1/a_1470_n1540# vdd 1.62fF **FLOATING
C12454 pll_full_0/divbuf_1/a_990_n1540# vdd 1.62fF **FLOATING
C12455 pll_full_0/divbuf_1/a_510_n1540# vdd 1.62fF **FLOATING
C12456 pll_full_0/divbuf_1/a_60990_n840# vdd 1.06fF **FLOATING
C12457 pll_full_0/divbuf_1/a_60510_n840# vdd 1.09fF **FLOATING
C12458 pll_full_0/divbuf_1/a_60030_n840# vdd 1.09fF **FLOATING
C12459 pll_full_0/divbuf_1/a_59550_n840# vdd 1.09fF **FLOATING
C12460 pll_full_0/divbuf_1/a_59070_n840# vdd 1.09fF **FLOATING
C12461 pll_full_0/divbuf_1/a_58590_n840# vdd 1.09fF **FLOATING
C12462 pll_full_0/divbuf_1/a_58110_n840# vdd 1.09fF **FLOATING
C12463 pll_full_0/divbuf_1/a_57630_n840# vdd 1.09fF **FLOATING
C12464 pll_full_0/divbuf_1/a_57150_n840# vdd 1.09fF **FLOATING
C12465 pll_full_0/divbuf_1/a_56670_n840# vdd 1.09fF **FLOATING
C12466 pll_full_0/divbuf_1/a_56190_n840# vdd 1.09fF **FLOATING
C12467 pll_full_0/divbuf_1/a_55710_n840# vdd 1.09fF **FLOATING
C12468 pll_full_0/divbuf_1/a_55230_n840# vdd 1.09fF **FLOATING
C12469 pll_full_0/divbuf_1/a_54750_n840# vdd 1.09fF **FLOATING
C12470 pll_full_0/divbuf_1/a_54270_n840# vdd 1.09fF **FLOATING
C12471 pll_full_0/divbuf_1/a_53790_n840# vdd 1.09fF **FLOATING
C12472 pll_full_0/divbuf_1/a_53310_n840# vdd 1.09fF **FLOATING
C12473 pll_full_0/divbuf_1/a_52830_n840# vdd 1.09fF **FLOATING
C12474 pll_full_0/divbuf_1/a_52350_n840# vdd 1.09fF **FLOATING
C12475 pll_full_0/divbuf_1/a_51870_n840# vdd 1.09fF **FLOATING
C12476 pll_full_0/divbuf_1/a_51390_n840# vdd 1.09fF **FLOATING
C12477 pll_full_0/divbuf_1/a_50910_n840# vdd 1.09fF **FLOATING
C12478 pll_full_0/divbuf_1/a_50430_n840# vdd 1.09fF **FLOATING
C12479 pll_full_0/divbuf_1/a_49950_n840# vdd 1.09fF **FLOATING
C12480 pll_full_0/divbuf_1/a_49470_n840# vdd 1.09fF **FLOATING
C12481 pll_full_0/divbuf_1/a_48990_n840# vdd 1.09fF **FLOATING
C12482 pll_full_0/divbuf_1/a_48510_n840# vdd 1.09fF **FLOATING
C12483 pll_full_0/divbuf_1/a_48030_n840# vdd 1.09fF **FLOATING
C12484 pll_full_0/divbuf_1/a_47550_n840# vdd 1.09fF **FLOATING
C12485 pll_full_0/divbuf_1/a_47070_n840# vdd 1.09fF **FLOATING
C12486 pll_full_0/divbuf_1/a_46590_n840# vdd 1.09fF **FLOATING
C12487 pll_full_0/divbuf_1/a_46110_n840# vdd 1.09fF **FLOATING
C12488 pll_full_0/divbuf_1/a_45630_n840# vdd 1.09fF **FLOATING
C12489 pll_full_0/divbuf_1/a_45150_n840# vdd 1.09fF **FLOATING
C12490 pll_full_0/divbuf_1/a_44670_n840# vdd 1.09fF **FLOATING
C12491 pll_full_0/divbuf_1/a_44190_n840# vdd 1.09fF **FLOATING
C12492 pll_full_0/divbuf_1/a_43710_n840# vdd 1.09fF **FLOATING
C12493 pll_full_0/divbuf_1/a_43230_n840# vdd 1.09fF **FLOATING
C12494 pll_full_0/divbuf_1/a_42750_n840# vdd 1.08fF **FLOATING
C12495 pll_full_0/divbuf_1/a_42270_n840# vdd 1.08fF **FLOATING
C12496 pll_full_0/divbuf_1/a_41790_n840# vdd 1.10fF **FLOATING
C12497 pll_full_0/divbuf_1/a_41310_n840# vdd 1.09fF **FLOATING
C12498 pll_full_0/divbuf_1/a_40830_n840# vdd 1.09fF **FLOATING
C12499 pll_full_0/divbuf_1/a_40350_n840# vdd 1.09fF **FLOATING
C12500 pll_full_0/divbuf_1/a_39870_n840# vdd 1.09fF **FLOATING
C12501 pll_full_0/divbuf_1/a_39390_n840# vdd 1.09fF **FLOATING
C12502 pll_full_0/divbuf_1/a_38910_n840# vdd 1.09fF **FLOATING
C12503 pll_full_0/divbuf_1/a_38430_n840# vdd 1.09fF **FLOATING
C12504 pll_full_0/divbuf_1/a_37950_n840# vdd 1.09fF **FLOATING
C12505 pll_full_0/divbuf_1/a_37470_n840# vdd 1.09fF **FLOATING
C12506 pll_full_0/divbuf_1/a_36990_n840# vdd 1.09fF **FLOATING
C12507 pll_full_0/divbuf_1/a_36510_n840# vdd 1.09fF **FLOATING
C12508 pll_full_0/divbuf_1/a_36030_n840# vdd 1.09fF **FLOATING
C12509 pll_full_0/divbuf_1/a_35550_n840# vdd 1.09fF **FLOATING
C12510 pll_full_0/divbuf_1/a_35070_n840# vdd 1.09fF **FLOATING
C12511 pll_full_0/divbuf_1/a_34590_n840# vdd 1.09fF **FLOATING
C12512 pll_full_0/divbuf_1/a_34110_n840# vdd 1.09fF **FLOATING
C12513 pll_full_0/divbuf_1/a_33630_n840# vdd 1.09fF **FLOATING
C12514 pll_full_0/divbuf_1/a_33150_n840# vdd 1.09fF **FLOATING
C12515 pll_full_0/divbuf_1/a_32670_n840# vdd 1.09fF **FLOATING
C12516 pll_full_0/divbuf_1/a_32190_n840# vdd 1.09fF **FLOATING
C12517 pll_full_0/divbuf_1/a_31710_n840# vdd 1.11fF **FLOATING
C12518 pll_full_0/divbuf_1/a_31230_n840# vdd 1.13fF **FLOATING
C12519 pll_full_0/divbuf_1/a_30750_n840# vdd 1.09fF **FLOATING
C12520 pll_full_0/divbuf_1/a_30270_n840# vdd 1.09fF **FLOATING
C12521 pll_full_0/divbuf_1/a_29790_n840# vdd 1.09fF **FLOATING
C12522 pll_full_0/divbuf_1/a_29310_n840# vdd 1.09fF **FLOATING
C12523 pll_full_0/divbuf_1/a_28830_n840# vdd 1.09fF **FLOATING
C12524 pll_full_0/divbuf_1/a_28350_n840# vdd 1.09fF **FLOATING
C12525 pll_full_0/divbuf_1/a_27870_n840# vdd 1.08fF **FLOATING
C12526 pll_full_0/divbuf_1/a_27390_n840# vdd 1.11fF **FLOATING
C12527 pll_full_0/divbuf_1/a_26910_n840# vdd 1.10fF **FLOATING
C12528 pll_full_0/divbuf_1/a_26430_n840# vdd 1.10fF **FLOATING
C12529 pll_full_0/divbuf_1/a_25950_n840# vdd 1.10fF **FLOATING
C12530 pll_full_0/divbuf_1/a_25470_n840# vdd 1.10fF **FLOATING
C12531 pll_full_0/divbuf_1/a_24990_n840# vdd 1.10fF **FLOATING
C12532 pll_full_0/divbuf_1/a_24510_n840# vdd 1.10fF **FLOATING
C12533 pll_full_0/divbuf_1/a_24030_n840# vdd 1.09fF **FLOATING
C12534 pll_full_0/divbuf_1/a_23550_n840# vdd 1.11fF **FLOATING
C12535 pll_full_0/divbuf_1/a_23070_n840# vdd 1.10fF **FLOATING
C12536 pll_full_0/divbuf_1/a_22590_n840# vdd 1.10fF **FLOATING
C12537 pll_full_0/divbuf_1/a_22110_n840# vdd 1.10fF **FLOATING
C12538 pll_full_0/divbuf_1/a_21630_n840# vdd 1.10fF **FLOATING
C12539 pll_full_0/divbuf_1/a_21150_n840# vdd 1.10fF **FLOATING
C12540 pll_full_0/divbuf_1/a_20670_n840# vdd 1.10fF **FLOATING
C12541 pll_full_0/divbuf_1/a_20190_n840# vdd 1.09fF **FLOATING
C12542 pll_full_0/divbuf_1/a_19710_n840# vdd 1.09fF **FLOATING
C12543 pll_full_0/divbuf_1/a_19230_n840# vdd 1.09fF **FLOATING
C12544 pll_full_0/divbuf_1/a_18750_n840# vdd 1.09fF **FLOATING
C12545 pll_full_0/divbuf_1/a_18270_n840# vdd 1.08fF **FLOATING
C12546 pll_full_0/divbuf_1/a_17790_n840# vdd 1.08fF **FLOATING
C12547 pll_full_0/divbuf_1/a_17310_n840# vdd 1.07fF **FLOATING
C12548 pll_full_0/divbuf_1/a_16830_n840# vdd 1.07fF **FLOATING
C12549 pll_full_0/divbuf_1/a_16350_n840# vdd 1.07fF **FLOATING
C12550 pll_full_0/divbuf_1/a_15870_n840# vdd 1.07fF **FLOATING
C12551 pll_full_0/divbuf_1/a_15390_n840# vdd 1.08fF **FLOATING
C12552 pll_full_0/divbuf_1/a_14910_n840# vdd 1.07fF **FLOATING
C12553 pll_full_0/divbuf_1/a_14430_n840# vdd 1.07fF **FLOATING
C12554 pll_full_0/divbuf_1/a_13950_n840# vdd 1.07fF **FLOATING
C12555 pll_full_0/divbuf_1/a_13470_n840# vdd 1.07fF **FLOATING
C12556 pll_full_0/divbuf_1/a_12990_n840# vdd 1.10fF **FLOATING
C12557 pll_full_0/divbuf_1/a_12510_n840# vdd 1.08fF **FLOATING
C12558 pll_full_0/divbuf_1/a_12030_n840# vdd 1.07fF **FLOATING
C12559 pll_full_0/divbuf_1/a_11550_n840# vdd 1.07fF **FLOATING
C12560 pll_full_0/divbuf_1/a_11070_n840# vdd 1.08fF **FLOATING
C12561 pll_full_0/divbuf_1/a_10590_n840# vdd 1.10fF **FLOATING
C12562 pll_full_0/divbuf_1/a_10110_n840# vdd 1.10fF **FLOATING
C12563 pll_full_0/divbuf_1/a_9630_n840# vdd 1.10fF **FLOATING
C12564 pll_full_0/divbuf_1/a_9150_n840# vdd 1.10fF **FLOATING
C12565 pll_full_0/divbuf_1/a_8670_n840# vdd 1.10fF **FLOATING
C12566 pll_full_0/divbuf_1/a_8190_n840# vdd 1.12fF **FLOATING
C12567 pll_full_0/divbuf_1/a_7710_n840# vdd 1.10fF **FLOATING
C12568 pll_full_0/divbuf_1/a_7230_n840# vdd 1.09fF **FLOATING
C12569 pll_full_0/divbuf_1/a_6750_n840# vdd 1.09fF **FLOATING
C12570 pll_full_0/divbuf_1/a_6270_n840# vdd 1.09fF **FLOATING
C12571 pll_full_0/divbuf_1/a_5790_n840# vdd 1.09fF **FLOATING
C12572 pll_full_0/divbuf_1/a_5310_n840# vdd 1.09fF **FLOATING
C12573 pll_full_0/divbuf_1/a_4830_n840# vdd 1.09fF **FLOATING
C12574 pll_full_0/divbuf_1/a_4350_n840# vdd 1.09fF **FLOATING
C12575 pll_full_0/divbuf_1/a_3870_n840# vdd 1.09fF **FLOATING
C12576 pll_full_0/divbuf_1/a_3390_n840# vdd 1.09fF **FLOATING
C12577 pll_full_0/divbuf_1/a_2910_n840# vdd 1.10fF **FLOATING
C12578 pll_full_0/divbuf_1/a_2430_n840# vdd 1.10fF **FLOATING
C12579 pll_full_0/divbuf_1/a_1950_n840# vdd 1.10fF **FLOATING
C12580 pll_full_0/divbuf_1/a_1470_n840# vdd 1.10fF **FLOATING
C12581 pll_full_0/divbuf_1/a_990_n840# vdd 1.08fF **FLOATING
C12582 pll_full_0/divbuf_1/a_510_n840# vdd 1.07fF **FLOATING
C12583 pll_full_0/divbuf_1/a_60480_n1600# vdd 1.48fF **FLOATING
C12584 pll_full_0/divbuf_1/a_60000_n1600# vdd 1.48fF **FLOATING
C12585 pll_full_0/divbuf_1/a_59520_n1600# vdd 1.48fF **FLOATING
C12586 pll_full_0/divbuf_1/a_59040_n1600# vdd 1.48fF **FLOATING
C12587 pll_full_0/divbuf_1/a_58560_n1600# vdd 1.48fF **FLOATING
C12588 pll_full_0/divbuf_1/a_58080_n1600# vdd 1.48fF **FLOATING
C12589 pll_full_0/divbuf_1/a_57600_n1600# vdd 1.48fF **FLOATING
C12590 pll_full_0/divbuf_1/a_57120_n1600# vdd 1.48fF **FLOATING
C12591 pll_full_0/divbuf_1/a_56640_n1600# vdd 1.48fF **FLOATING
C12592 pll_full_0/divbuf_1/a_56160_n1600# vdd 1.48fF **FLOATING
C12593 pll_full_0/divbuf_1/a_55680_n1600# vdd 1.48fF **FLOATING
C12594 pll_full_0/divbuf_1/a_55200_n1600# vdd 1.48fF **FLOATING
C12595 pll_full_0/divbuf_1/a_54720_n1600# vdd 1.48fF **FLOATING
C12596 pll_full_0/divbuf_1/a_54240_n1600# vdd 1.48fF **FLOATING
C12597 pll_full_0/divbuf_1/a_53760_n1600# vdd 1.48fF **FLOATING
C12598 pll_full_0/divbuf_1/a_53280_n1600# vdd 1.48fF **FLOATING
C12599 pll_full_0/divbuf_1/a_52800_n1600# vdd 1.48fF **FLOATING
C12600 pll_full_0/divbuf_1/a_52320_n1600# vdd 1.48fF **FLOATING
C12601 pll_full_0/divbuf_1/a_51840_n1600# vdd 1.48fF **FLOATING
C12602 pll_full_0/divbuf_1/a_51360_n1600# vdd 1.48fF **FLOATING
C12603 pll_full_0/divbuf_1/a_50880_n1600# vdd 1.48fF **FLOATING
C12604 pll_full_0/divbuf_1/a_50400_n1600# vdd 1.48fF **FLOATING
C12605 pll_full_0/divbuf_1/a_49920_n1600# vdd 1.48fF **FLOATING
C12606 pll_full_0/divbuf_1/a_49440_n1600# vdd 1.48fF **FLOATING
C12607 pll_full_0/divbuf_1/a_48960_n1600# vdd 1.48fF **FLOATING
C12608 pll_full_0/divbuf_1/a_48480_n1600# vdd 1.48fF **FLOATING
C12609 pll_full_0/divbuf_1/a_48000_n1600# vdd 1.48fF **FLOATING
C12610 pll_full_0/divbuf_1/a_47520_n1600# vdd 1.48fF **FLOATING
C12611 pll_full_0/divbuf_1/a_47040_n1600# vdd 1.48fF **FLOATING
C12612 pll_full_0/divbuf_1/a_46560_n1600# vdd 1.48fF **FLOATING
C12613 pll_full_0/divbuf_1/a_46080_n1600# vdd 1.48fF **FLOATING
C12614 pll_full_0/divbuf_1/a_45600_n1600# vdd 1.48fF **FLOATING
C12615 pll_full_0/divbuf_1/a_45120_n1600# vdd 1.48fF **FLOATING
C12616 pll_full_0/divbuf_1/a_44640_n1600# vdd 1.48fF **FLOATING
C12617 pll_full_0/divbuf_1/a_44160_n1600# vdd 1.48fF **FLOATING
C12618 pll_full_0/divbuf_1/a_43680_n1600# vdd 1.48fF **FLOATING
C12619 pll_full_0/divbuf_1/a_43200_n1600# vdd 1.48fF **FLOATING
C12620 pll_full_0/divbuf_1/a_42720_n1600# vdd 1.48fF **FLOATING
C12621 pll_full_0/divbuf_1/a_42240_n1600# vdd 1.48fF **FLOATING
C12622 pll_full_0/divbuf_1/a_41760_n1600# vdd 1.48fF **FLOATING
C12623 pll_full_0/divbuf_1/a_41280_n1600# vdd 1.48fF **FLOATING
C12624 pll_full_0/divbuf_1/a_40800_n1600# vdd 1.48fF **FLOATING
C12625 pll_full_0/divbuf_1/a_40320_n1600# vdd 1.48fF **FLOATING
C12626 pll_full_0/divbuf_1/a_39840_n1600# vdd 1.48fF **FLOATING
C12627 pll_full_0/divbuf_1/a_39360_n1600# vdd 1.48fF **FLOATING
C12628 pll_full_0/divbuf_1/a_38880_n1600# vdd 1.48fF **FLOATING
C12629 pll_full_0/divbuf_1/a_38400_n1600# vdd 1.48fF **FLOATING
C12630 pll_full_0/divbuf_1/a_37920_n1600# vdd 1.48fF **FLOATING
C12631 pll_full_0/divbuf_1/a_37440_n1600# vdd 1.48fF **FLOATING
C12632 pll_full_0/divbuf_1/a_36960_n1600# vdd 1.48fF **FLOATING
C12633 pll_full_0/divbuf_1/a_36480_n1600# vdd 1.48fF **FLOATING
C12634 pll_full_0/divbuf_1/a_36000_n1600# vdd 1.48fF **FLOATING
C12635 pll_full_0/divbuf_1/a_35520_n1600# vdd 1.48fF **FLOATING
C12636 pll_full_0/divbuf_1/a_35040_n1600# vdd 1.48fF **FLOATING
C12637 pll_full_0/divbuf_1/a_34560_n1600# vdd 1.48fF **FLOATING
C12638 pll_full_0/divbuf_1/a_34080_n1600# vdd 1.48fF **FLOATING
C12639 pll_full_0/divbuf_1/a_33600_n1600# vdd 1.48fF **FLOATING
C12640 pll_full_0/divbuf_1/a_33120_n1600# vdd 1.48fF **FLOATING
C12641 pll_full_0/divbuf_1/a_32640_n1600# vdd 1.48fF **FLOATING
C12642 pll_full_0/divbuf_1/a_32160_n1600# vdd 1.48fF **FLOATING
C12643 pll_full_0/divbuf_1/a_31680_n1600# vdd 1.48fF **FLOATING
C12644 pll_full_0/divbuf_1/a_31200_n1600# vdd 1.48fF **FLOATING
C12645 pll_full_0/divbuf_1/a_30720_n1600# vdd 1.48fF **FLOATING
C12646 pll_full_0/divbuf_1/a_30240_n1600# vdd 1.48fF **FLOATING
C12647 pll_full_0/divbuf_1/a_29760_n1600# vdd 1.48fF **FLOATING
C12648 pll_full_0/divbuf_1/a_29280_n1600# vdd 1.48fF **FLOATING
C12649 pll_full_0/divbuf_1/a_28800_n1600# vdd 1.48fF **FLOATING
C12650 pll_full_0/divbuf_1/a_28320_n1600# vdd 1.48fF **FLOATING
C12651 pll_full_0/divbuf_1/a_27840_n1600# vdd 1.48fF **FLOATING
C12652 pll_full_0/divbuf_1/a_27360_n1600# vdd 1.48fF **FLOATING
C12653 pll_full_0/divbuf_1/a_26880_n1600# vdd 1.48fF **FLOATING
C12654 pll_full_0/divbuf_1/a_26400_n1600# vdd 1.48fF **FLOATING
C12655 pll_full_0/divbuf_1/a_25920_n1600# vdd 1.48fF **FLOATING
C12656 pll_full_0/divbuf_1/a_25440_n1600# vdd 1.48fF **FLOATING
C12657 pll_full_0/divbuf_1/a_24960_n1600# vdd 1.48fF **FLOATING
C12658 pll_full_0/divbuf_1/a_24480_n1600# vdd 1.48fF **FLOATING
C12659 pll_full_0/divbuf_1/a_24000_n1600# vdd 1.48fF **FLOATING
C12660 pll_full_0/divbuf_1/a_23520_n1600# vdd 1.48fF **FLOATING
C12661 pll_full_0/divbuf_1/a_23040_n1600# vdd 1.48fF **FLOATING
C12662 pll_full_0/divbuf_1/a_22560_n1600# vdd 1.48fF **FLOATING
C12663 pll_full_0/divbuf_1/a_22080_n1600# vdd 1.48fF **FLOATING
C12664 pll_full_0/divbuf_1/a_21600_n1600# vdd 1.48fF **FLOATING
C12665 pll_full_0/divbuf_1/a_21120_n1600# vdd 1.48fF **FLOATING
C12666 pll_full_0/divbuf_1/a_20640_n1600# vdd 1.48fF **FLOATING
C12667 pll_full_0/divbuf_1/a_20160_n1600# vdd 1.48fF **FLOATING
C12668 pll_full_0/divbuf_1/a_19680_n1600# vdd 1.48fF **FLOATING
C12669 pll_full_0/divbuf_1/a_19200_n1600# vdd 1.48fF **FLOATING
C12670 pll_full_0/divbuf_1/a_18720_n1600# vdd 1.48fF **FLOATING
C12671 pll_full_0/divbuf_1/a_18240_n1600# vdd 1.48fF **FLOATING
C12672 pll_full_0/divbuf_1/a_17760_n1600# vdd 1.48fF **FLOATING
C12673 pll_full_0/divbuf_1/a_17280_n1600# vdd 1.48fF **FLOATING
C12674 pll_full_0/divbuf_1/a_16800_n1600# vdd 1.48fF **FLOATING
C12675 pll_full_0/divbuf_1/a_16320_n1600# vdd 1.48fF **FLOATING
C12676 pll_full_0/divbuf_1/a_15840_n1600# vdd 1.48fF **FLOATING
C12677 pll_full_0/divbuf_1/a_15360_n1600# vdd 1.48fF **FLOATING
C12678 pll_full_0/divbuf_1/a_14880_n1600# vdd 1.48fF **FLOATING
C12679 pll_full_0/divbuf_1/a_14400_n1600# vdd 1.48fF **FLOATING
C12680 pll_full_0/divbuf_1/a_13920_n1600# vdd 1.48fF **FLOATING
C12681 pll_full_0/divbuf_1/a_13440_n1600# vdd 1.48fF **FLOATING
C12682 pll_full_0/divbuf_1/a_12960_n1600# vdd 1.48fF **FLOATING
C12683 pll_full_0/divbuf_1/a_12480_n1600# vdd 1.48fF **FLOATING
C12684 pll_full_0/divbuf_1/a_12000_n1600# vdd 1.48fF **FLOATING
C12685 pll_full_0/divbuf_1/a_11520_n1600# vdd 1.48fF **FLOATING
C12686 pll_full_0/divbuf_1/a_11040_n1600# vdd 1.48fF **FLOATING
C12687 pll_full_0/divbuf_1/a_10560_n1600# vdd 1.48fF **FLOATING
C12688 pll_full_0/divbuf_1/a_10080_n1600# vdd 1.48fF **FLOATING
C12689 pll_full_0/divbuf_1/a_9600_n1600# vdd 1.48fF **FLOATING
C12690 pll_full_0/divbuf_1/a_9120_n1600# vdd 1.48fF **FLOATING
C12691 pll_full_0/divbuf_1/a_8640_n1600# vdd 1.48fF **FLOATING
C12692 pll_full_0/divbuf_1/a_8160_n1600# vdd 1.48fF **FLOATING
C12693 pll_full_0/divbuf_1/a_7680_n1600# vdd 1.48fF **FLOATING
C12694 pll_full_0/divbuf_1/a_7200_n1600# vdd 1.48fF **FLOATING
C12695 pll_full_0/divbuf_1/a_6720_n1600# vdd 1.48fF **FLOATING
C12696 pll_full_0/divbuf_1/a_6240_n1600# vdd 1.48fF **FLOATING
C12697 pll_full_0/divbuf_1/a_5760_n1600# vdd 1.48fF **FLOATING
C12698 pll_full_0/divbuf_1/a_5280_n1600# vdd 1.48fF **FLOATING
C12699 pll_full_0/divbuf_1/a_4800_n1600# vdd 1.48fF **FLOATING
C12700 pll_full_0/divbuf_1/a_4320_n1600# vdd 1.48fF **FLOATING
C12701 pll_full_0/divbuf_1/a_3840_n1600# vdd 1.48fF **FLOATING
C12702 pll_full_0/divbuf_1/a_3360_n1600# vdd 1.48fF **FLOATING
C12703 pll_full_0/divbuf_1/a_2880_n1600# vdd 1.48fF **FLOATING
C12704 pll_full_0/divbuf_1/a_2400_n1600# vdd 1.48fF **FLOATING
C12705 pll_full_0/divbuf_1/a_1920_n1600# vdd 1.48fF **FLOATING
C12706 pll_full_0/divbuf_1/a_1440_n1600# vdd 1.48fF **FLOATING
C12707 pll_full_0/divbuf_1/a_960_n1600# vdd 1.48fF **FLOATING
C12708 pll_full_0/divbuf_1/a_480_n1600# vdd 1.48fF **FLOATING
C12709 pll_full_0/divbuf_1/a_0_n1600# vdd 1.48fF **FLOATING
C12710 pll_full_0/divbuf_1/a_41382_n240# vdd 0.90fF **FLOATING
C12711 pll_full_0/divbuf_1/a_40902_n240# vdd 0.90fF **FLOATING
C12712 pll_full_0/divbuf_1/a_40412_n240# vdd 0.90fF **FLOATING
C12713 pll_full_0/divbuf_1/a_39932_n240# vdd 0.90fF **FLOATING
C12714 pll_full_0/divbuf_1/a_39442_n240# vdd 0.90fF **FLOATING
C12715 pll_full_0/divbuf_1/a_38962_n240# vdd 0.91fF **FLOATING
C12716 pll_full_0/divbuf_1/a_38472_n240# vdd 0.90fF **FLOATING
C12717 pll_full_0/divbuf_1/a_37992_n240# vdd 0.90fF **FLOATING
C12718 pll_full_0/divbuf_1/a_37502_n240# vdd 0.90fF **FLOATING
C12719 pll_full_0/divbuf_1/a_37022_n240# vdd 0.90fF **FLOATING
C12720 pll_full_0/divbuf_1/a_36532_n240# vdd 0.90fF **FLOATING
C12721 pll_full_0/divbuf_1/a_36052_n240# vdd 0.90fF **FLOATING
C12722 pll_full_0/divbuf_1/a_35562_n240# vdd 0.90fF **FLOATING
C12723 pll_full_0/divbuf_1/a_35082_n240# vdd 0.91fF **FLOATING
C12724 pll_full_0/divbuf_1/a_34592_n240# vdd 0.90fF **FLOATING
C12725 pll_full_0/divbuf_1/a_34112_n240# vdd 0.90fF **FLOATING
C12726 pll_full_0/divbuf_1/a_33622_n240# vdd 0.90fF **FLOATING
C12727 pll_full_0/divbuf_1/a_33142_n240# vdd 0.90fF **FLOATING
C12728 pll_full_0/divbuf_1/a_32652_n240# vdd 0.90fF **FLOATING
C12729 pll_full_0/divbuf_1/a_32172_n240# vdd 0.90fF **FLOATING
C12730 pll_full_0/divbuf_1/a_31682_n240# vdd 0.89fF **FLOATING
C12731 pll_full_0/divbuf_1/a_31202_n240# vdd 0.92fF **FLOATING
C12732 pll_full_0/divbuf_1/a_30712_n240# vdd 0.90fF **FLOATING
C12733 pll_full_0/divbuf_1/a_30232_n240# vdd 0.90fF **FLOATING
C12734 pll_full_0/divbuf_1/a_29742_n240# vdd 0.90fF **FLOATING
C12735 pll_full_0/divbuf_1/a_29262_n240# vdd 0.90fF **FLOATING
C12736 pll_full_0/divbuf_1/a_28772_n240# vdd 0.90fF **FLOATING
C12737 pll_full_0/divbuf_1/a_28292_n240# vdd 0.90fF **FLOATING
C12738 pll_full_0/divbuf_1/a_27802_n240# vdd 0.89fF **FLOATING
C12739 pll_full_0/divbuf_1/a_27322_n240# vdd 0.95fF **FLOATING
C12740 pll_full_0/divbuf_1/a_26832_n240# vdd 0.91fF **FLOATING
C12741 pll_full_0/divbuf_1/a_26352_n240# vdd 0.91fF **FLOATING
C12742 pll_full_0/divbuf_1/a_25862_n240# vdd 0.91fF **FLOATING
C12743 pll_full_0/divbuf_1/a_25382_n240# vdd 0.91fF **FLOATING
C12744 pll_full_0/divbuf_1/a_24892_n240# vdd 0.91fF **FLOATING
C12745 pll_full_0/divbuf_1/a_24412_n240# vdd 0.91fF **FLOATING
C12746 pll_full_0/divbuf_1/a_23922_n240# vdd 0.92fF **FLOATING
C12747 pll_full_0/divbuf_1/a_23442_n240# vdd 0.94fF **FLOATING
C12748 pll_full_0/divbuf_1/a_22952_n240# vdd 0.91fF **FLOATING
C12749 pll_full_0/divbuf_1/a_22472_n240# vdd 0.91fF **FLOATING
C12750 pll_full_0/divbuf_1/a_21982_n240# vdd 0.91fF **FLOATING
C12751 pll_full_0/divbuf_1/a_21502_n240# vdd 0.91fF **FLOATING
C12752 pll_full_0/divbuf_1/a_21012_n240# vdd 0.91fF **FLOATING
C12753 pll_full_0/divbuf_1/a_20532_n240# vdd 0.91fF **FLOATING
C12754 pll_full_0/divbuf_1/a_20042_n240# vdd 0.90fF **FLOATING
C12755 pll_full_0/divbuf_1/a_19562_n240# vdd 0.90fF **FLOATING
C12756 pll_full_0/divbuf_1/a_19072_n240# vdd 0.90fF **FLOATING
C12757 pll_full_0/divbuf_1/a_18582_n240# vdd 0.89fF **FLOATING
C12758 pll_full_0/divbuf_1/a_18092_n240# vdd 0.89fF **FLOATING
C12759 pll_full_0/divbuf_1/a_17612_n240# vdd 0.89fF **FLOATING
C12760 pll_full_0/divbuf_1/a_17122_n240# vdd 0.88fF **FLOATING
C12761 pll_full_0/divbuf_1/a_16642_n240# vdd 0.88fF **FLOATING
C12762 pll_full_0/divbuf_1/a_16152_n240# vdd 0.88fF **FLOATING
C12763 pll_full_0/divbuf_1/a_15672_n240# vdd 0.90fF **FLOATING
C12764 pll_full_0/divbuf_1/a_15182_n240# vdd 0.88fF **FLOATING
C12765 pll_full_0/divbuf_1/a_14702_n240# vdd 0.88fF **FLOATING
C12766 pll_full_0/divbuf_1/a_14222_n240# vdd 0.88fF **FLOATING
C12767 pll_full_0/divbuf_1/a_13742_n240# vdd 0.88fF **FLOATING
C12768 pll_full_0/divbuf_1/a_13252_n240# vdd 0.88fF **FLOATING
C12769 pll_full_0/divbuf_1/a_12772_n240# vdd 0.88fF **FLOATING
C12770 pll_full_0/divbuf_1/a_12282_n240# vdd 0.88fF **FLOATING
C12771 pll_full_0/divbuf_1/a_11802_n240# vdd 0.88fF **FLOATING
C12772 pll_full_0/divbuf_1/a_11312_n240# vdd 0.89fF **FLOATING
C12773 pll_full_0/divbuf_1/a_10212_n240# vdd 0.91fF **FLOATING
C12774 pll_full_0/divbuf_1/a_9732_n240# vdd 0.91fF **FLOATING
C12775 pll_full_0/divbuf_1/a_9242_n240# vdd 0.91fF **FLOATING
C12776 pll_full_0/divbuf_1/a_8762_n240# vdd 0.91fF **FLOATING
C12777 pll_full_0/divbuf_1/a_8272_n240# vdd 0.91fF **FLOATING
C12778 pll_full_0/divbuf_1/a_7792_n240# vdd 0.92fF **FLOATING
C12779 pll_full_0/divbuf_1/a_7302_n240# vdd 0.90fF **FLOATING
C12780 pll_full_0/divbuf_1/a_6822_n240# vdd 0.90fF **FLOATING
C12781 pll_full_0/divbuf_1/a_6332_n240# vdd 0.90fF **FLOATING
C12782 pll_full_0/divbuf_1/a_5852_n240# vdd 0.90fF **FLOATING
C12783 pll_full_0/divbuf_1/a_5362_n240# vdd 0.90fF **FLOATING
C12784 pll_full_0/divbuf_1/a_4882_n240# vdd 0.90fF **FLOATING
C12785 pll_full_0/divbuf_1/a_4392_n240# vdd 0.90fF **FLOATING
C12786 pll_full_0/divbuf_1/a_3912_n240# vdd 0.90fF **FLOATING
C12787 pll_full_0/divbuf_1/a_3422_n240# vdd 0.90fF **FLOATING
C12788 pll_full_0/divbuf_1/a_2322_n240# vdd 0.91fF **FLOATING
C12789 pll_full_0/divbuf_1/a_1842_n240# vdd 0.91fF **FLOATING
C12790 pll_full_0/divbuf_1/a_1352_n240# vdd 0.91fF **FLOATING
C12791 pll_full_0/divbuf_1/a_41382_170# vdd 1.07fF **FLOATING
C12792 pll_full_0/divbuf_1/a_40902_170# vdd 1.09fF **FLOATING
C12793 pll_full_0/divbuf_1/a_40412_170# vdd 1.09fF **FLOATING
C12794 pll_full_0/divbuf_1/a_39932_170# vdd 1.09fF **FLOATING
C12795 pll_full_0/divbuf_1/a_39442_170# vdd 1.09fF **FLOATING
C12796 pll_full_0/divbuf_1/a_38962_170# vdd 1.07fF **FLOATING
C12797 pll_full_0/divbuf_1/a_38472_170# vdd 1.09fF **FLOATING
C12798 pll_full_0/divbuf_1/a_37992_170# vdd 1.09fF **FLOATING
C12799 pll_full_0/divbuf_1/a_37502_170# vdd 1.09fF **FLOATING
C12800 pll_full_0/divbuf_1/a_37022_170# vdd 1.09fF **FLOATING
C12801 pll_full_0/divbuf_1/a_36532_170# vdd 1.09fF **FLOATING
C12802 pll_full_0/divbuf_1/a_36052_170# vdd 1.09fF **FLOATING
C12803 pll_full_0/divbuf_1/a_35562_170# vdd 1.09fF **FLOATING
C12804 pll_full_0/divbuf_1/a_35082_170# vdd 1.09fF **FLOATING
C12805 pll_full_0/divbuf_1/a_34592_170# vdd 1.07fF **FLOATING
C12806 pll_full_0/divbuf_1/a_34112_170# vdd 1.09fF **FLOATING
C12807 pll_full_0/divbuf_1/a_33622_170# vdd 1.09fF **FLOATING
C12808 pll_full_0/divbuf_1/a_33142_170# vdd 1.09fF **FLOATING
C12809 pll_full_0/divbuf_1/a_32652_170# vdd 1.09fF **FLOATING
C12810 pll_full_0/divbuf_1/a_32172_170# vdd 1.09fF **FLOATING
C12811 pll_full_0/divbuf_1/a_31682_170# vdd 1.09fF **FLOATING
C12812 pll_full_0/divbuf_1/a_31202_170# vdd 1.09fF **FLOATING
C12813 pll_full_0/divbuf_1/a_30712_170# vdd 1.09fF **FLOATING
C12814 pll_full_0/divbuf_1/a_30232_170# vdd 1.07fF **FLOATING
C12815 pll_full_0/divbuf_1/a_29742_170# vdd 1.09fF **FLOATING
C12816 pll_full_0/divbuf_1/a_29262_170# vdd 1.09fF **FLOATING
C12817 pll_full_0/divbuf_1/a_28772_170# vdd 1.09fF **FLOATING
C12818 pll_full_0/divbuf_1/a_28292_170# vdd 1.09fF **FLOATING
C12819 pll_full_0/divbuf_1/a_27802_170# vdd 1.09fF **FLOATING
C12820 pll_full_0/divbuf_1/a_27322_170# vdd 1.09fF **FLOATING
C12821 pll_full_0/divbuf_1/a_26832_170# vdd 1.09fF **FLOATING
C12822 pll_full_0/divbuf_1/a_26352_170# vdd 1.09fF **FLOATING
C12823 pll_full_0/divbuf_1/a_25862_170# vdd 1.07fF **FLOATING
C12824 pll_full_0/divbuf_1/a_25382_170# vdd 1.09fF **FLOATING
C12825 pll_full_0/divbuf_1/a_24892_170# vdd 1.09fF **FLOATING
C12826 pll_full_0/divbuf_1/a_24412_170# vdd 1.09fF **FLOATING
C12827 pll_full_0/divbuf_1/a_23922_170# vdd 1.09fF **FLOATING
C12828 pll_full_0/divbuf_1/a_23442_170# vdd 1.09fF **FLOATING
C12829 pll_full_0/divbuf_1/a_22952_170# vdd 1.09fF **FLOATING
C12830 pll_full_0/divbuf_1/a_22472_170# vdd 1.07fF **FLOATING
C12831 pll_full_0/divbuf_1/a_21982_170# vdd 1.09fF **FLOATING
C12832 pll_full_0/divbuf_1/a_21502_170# vdd 1.09fF **FLOATING
C12833 pll_full_0/divbuf_1/a_21012_170# vdd 1.09fF **FLOATING
C12834 pll_full_0/divbuf_1/a_20532_170# vdd 1.09fF **FLOATING
C12835 pll_full_0/divbuf_1/a_20042_170# vdd 1.09fF **FLOATING
C12836 pll_full_0/divbuf_1/a_19562_170# vdd 1.09fF **FLOATING
C12837 pll_full_0/divbuf_1/a_19072_170# vdd 1.09fF **FLOATING
C12838 pll_full_0/divbuf_1/a_18582_170# vdd 1.07fF **FLOATING
C12839 pll_full_0/divbuf_1/a_18092_170# vdd 1.09fF **FLOATING
C12840 pll_full_0/divbuf_1/a_17612_170# vdd 1.09fF **FLOATING
C12841 pll_full_0/divbuf_1/a_17122_170# vdd 1.09fF **FLOATING
C12842 pll_full_0/divbuf_1/a_16642_170# vdd 1.09fF **FLOATING
C12843 pll_full_0/divbuf_1/a_16152_170# vdd 1.09fF **FLOATING
C12844 pll_full_0/divbuf_1/a_15672_170# vdd 1.09fF **FLOATING
C12845 pll_full_0/divbuf_1/a_15182_170# vdd 1.09fF **FLOATING
C12846 pll_full_0/divbuf_1/a_14702_170# vdd 1.10fF **FLOATING
C12847 pll_full_0/divbuf_1/a_14222_170# vdd 1.10fF **FLOATING
C12848 pll_full_0/divbuf_1/a_13742_170# vdd 1.09fF **FLOATING
C12849 pll_full_0/divbuf_1/a_13252_170# vdd 1.09fF **FLOATING
C12850 pll_full_0/divbuf_1/a_12772_170# vdd 1.07fF **FLOATING
C12851 pll_full_0/divbuf_1/a_12282_170# vdd 1.09fF **FLOATING
C12852 pll_full_0/divbuf_1/a_11802_170# vdd 1.09fF **FLOATING
C12853 pll_full_0/divbuf_1/a_11312_170# vdd 1.10fF **FLOATING
C12854 pll_full_0/divbuf_1/a_10212_170# vdd 1.09fF **FLOATING
C12855 pll_full_0/divbuf_1/a_9732_170# vdd 1.09fF **FLOATING
C12856 pll_full_0/divbuf_1/a_9242_170# vdd 1.09fF **FLOATING
C12857 pll_full_0/divbuf_1/a_8762_170# vdd 1.09fF **FLOATING
C12858 pll_full_0/divbuf_1/a_8272_170# vdd 1.07fF **FLOATING
C12859 pll_full_0/divbuf_1/a_7792_170# vdd 1.09fF **FLOATING
C12860 pll_full_0/divbuf_1/a_7302_170# vdd 1.09fF **FLOATING
C12861 pll_full_0/divbuf_1/a_6822_170# vdd 1.09fF **FLOATING
C12862 pll_full_0/divbuf_1/a_6332_170# vdd 1.09fF **FLOATING
C12863 pll_full_0/divbuf_1/a_5852_170# vdd 1.09fF **FLOATING
C12864 pll_full_0/divbuf_1/a_5362_170# vdd 1.09fF **FLOATING
C12865 pll_full_0/divbuf_1/a_4882_170# vdd 1.09fF **FLOATING
C12866 pll_full_0/divbuf_1/a_4392_170# vdd 1.07fF **FLOATING
C12867 pll_full_0/divbuf_1/a_3912_170# vdd 1.09fF **FLOATING
C12868 pll_full_0/divbuf_1/a_3422_170# vdd 1.10fF **FLOATING
C12869 pll_full_0/divbuf_1/a_2322_170# vdd 1.09fF **FLOATING
C12870 pll_full_0/divbuf_1/a_1842_170# vdd 1.09fF **FLOATING
C12871 pll_full_0/divbuf_1/a_1352_170# vdd 1.10fF **FLOATING
C12872 pll_full_0/divbuf_1/a_492_n240# vdd 2.46fF **FLOATING
C12873 pll_full_0/divbuf_0/OUT5 vdd 16.40fF
C12874 pll_full_0/divbuf_0/OUT4 vdd 100.06fF
C12875 pll_full_0/divbuf_0/OUT3 vdd 27.01fF
C12876 pll_full_0/divbuf_0/OUT2 vdd 8.71fF
C12877 pll_full_0/divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C12878 pll_full_0/divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C12879 pll_full_0/divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C12880 pll_full_0/divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C12881 pll_full_0/divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C12882 pll_full_0/divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C12883 pll_full_0/divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C12884 pll_full_0/divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C12885 pll_full_0/divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C12886 pll_full_0/divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C12887 pll_full_0/divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C12888 pll_full_0/divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C12889 pll_full_0/divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C12890 pll_full_0/divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C12891 pll_full_0/divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C12892 pll_full_0/divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C12893 pll_full_0/divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C12894 pll_full_0/divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C12895 pll_full_0/divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C12896 pll_full_0/divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C12897 pll_full_0/divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C12898 pll_full_0/divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C12899 pll_full_0/divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C12900 pll_full_0/divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C12901 pll_full_0/divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C12902 pll_full_0/divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C12903 pll_full_0/divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C12904 pll_full_0/divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C12905 pll_full_0/divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C12906 pll_full_0/divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C12907 pll_full_0/divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C12908 pll_full_0/divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C12909 pll_full_0/divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C12910 pll_full_0/divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C12911 pll_full_0/divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C12912 pll_full_0/divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C12913 pll_full_0/divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C12914 pll_full_0/divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C12915 pll_full_0/divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C12916 pll_full_0/divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C12917 pll_full_0/divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C12918 pll_full_0/divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C12919 pll_full_0/divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C12920 pll_full_0/divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C12921 pll_full_0/divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C12922 pll_full_0/divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C12923 pll_full_0/divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C12924 pll_full_0/divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C12925 pll_full_0/divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C12926 pll_full_0/divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C12927 pll_full_0/divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C12928 pll_full_0/divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C12929 pll_full_0/divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C12930 pll_full_0/divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C12931 pll_full_0/divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C12932 pll_full_0/divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C12933 pll_full_0/divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C12934 pll_full_0/divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C12935 pll_full_0/divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C12936 pll_full_0/divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C12937 pll_full_0/divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C12938 pll_full_0/divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C12939 pll_full_0/divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C12940 pll_full_0/divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C12941 pll_full_0/divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C12942 pll_full_0/divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C12943 pll_full_0/divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C12944 pll_full_0/divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C12945 pll_full_0/divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C12946 pll_full_0/divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C12947 pll_full_0/divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C12948 pll_full_0/divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C12949 pll_full_0/divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C12950 pll_full_0/divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C12951 pll_full_0/divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C12952 pll_full_0/divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C12953 pll_full_0/divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C12954 pll_full_0/divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C12955 pll_full_0/divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C12956 pll_full_0/divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C12957 pll_full_0/divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C12958 pll_full_0/divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C12959 pll_full_0/divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C12960 pll_full_0/divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C12961 pll_full_0/divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C12962 pll_full_0/divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C12963 pll_full_0/divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C12964 pll_full_0/divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C12965 pll_full_0/divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C12966 pll_full_0/divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C12967 pll_full_0/divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C12968 pll_full_0/divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C12969 pll_full_0/divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C12970 pll_full_0/divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C12971 pll_full_0/divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C12972 pll_full_0/divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C12973 pll_full_0/divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C12974 pll_full_0/divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C12975 pll_full_0/divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C12976 pll_full_0/divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C12977 pll_full_0/divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C12978 pll_full_0/divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C12979 pll_full_0/divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C12980 pll_full_0/divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C12981 pll_full_0/divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C12982 pll_full_0/divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C12983 pll_full_0/divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C12984 pll_full_0/divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C12985 pll_full_0/divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C12986 pll_full_0/divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C12987 pll_full_0/divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C12988 pll_full_0/divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C12989 pll_full_0/divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C12990 pll_full_0/divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C12991 pll_full_0/divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C12992 pll_full_0/divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C12993 pll_full_0/divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C12994 pll_full_0/divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C12995 pll_full_0/divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C12996 pll_full_0/divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C12997 pll_full_0/divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C12998 pll_full_0/divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C12999 pll_full_0/divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C13000 pll_full_0/divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C13001 pll_full_0/divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C13002 pll_full_0/divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C13003 pll_full_0/divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C13004 pll_full_0/divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C13005 pll_full_0/divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C13006 pll_full_0/divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C13007 pll_full_0/divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C13008 pll_full_0/divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C13009 pll_full_0/divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C13010 pll_full_0/divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C13011 pll_full_0/divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C13012 pll_full_0/divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C13013 pll_full_0/divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C13014 pll_full_0/divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C13015 pll_full_0/divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C13016 pll_full_0/divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C13017 pll_full_0/divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C13018 pll_full_0/divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C13019 pll_full_0/divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C13020 pll_full_0/divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C13021 pll_full_0/divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C13022 pll_full_0/divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C13023 pll_full_0/divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C13024 pll_full_0/divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C13025 pll_full_0/divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C13026 pll_full_0/divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C13027 pll_full_0/divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C13028 pll_full_0/divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C13029 pll_full_0/divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C13030 pll_full_0/divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C13031 pll_full_0/divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C13032 pll_full_0/divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C13033 pll_full_0/divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C13034 pll_full_0/divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C13035 pll_full_0/divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C13036 pll_full_0/divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C13037 pll_full_0/divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C13038 pll_full_0/divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C13039 pll_full_0/divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C13040 pll_full_0/divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C13041 pll_full_0/divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C13042 pll_full_0/divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C13043 pll_full_0/divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C13044 pll_full_0/divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C13045 pll_full_0/divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C13046 pll_full_0/divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C13047 pll_full_0/divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C13048 pll_full_0/divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C13049 pll_full_0/divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C13050 pll_full_0/divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C13051 pll_full_0/divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C13052 pll_full_0/divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C13053 pll_full_0/divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C13054 pll_full_0/divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C13055 pll_full_0/divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C13056 pll_full_0/divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C13057 pll_full_0/divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C13058 pll_full_0/divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C13059 pll_full_0/divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C13060 pll_full_0/divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C13061 pll_full_0/divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C13062 pll_full_0/divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C13063 pll_full_0/divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C13064 pll_full_0/divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C13065 pll_full_0/divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C13066 pll_full_0/divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C13067 pll_full_0/divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C13068 pll_full_0/divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C13069 pll_full_0/divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C13070 pll_full_0/divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C13071 pll_full_0/divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C13072 pll_full_0/divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C13073 pll_full_0/divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C13074 pll_full_0/divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C13075 pll_full_0/divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C13076 pll_full_0/divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C13077 pll_full_0/divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C13078 pll_full_0/divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C13079 pll_full_0/divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C13080 pll_full_0/divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C13081 pll_full_0/divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C13082 pll_full_0/divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C13083 pll_full_0/divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C13084 pll_full_0/divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C13085 pll_full_0/divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C13086 pll_full_0/divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C13087 pll_full_0/divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C13088 pll_full_0/divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C13089 pll_full_0/divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C13090 pll_full_0/divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C13091 pll_full_0/divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C13092 pll_full_0/divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C13093 pll_full_0/divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C13094 pll_full_0/divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C13095 pll_full_0/divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C13096 pll_full_0/divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C13097 pll_full_0/divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C13098 pll_full_0/divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C13099 pll_full_0/divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C13100 pll_full_0/divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C13101 pll_full_0/divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C13102 pll_full_0/divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C13103 pll_full_0/divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C13104 pll_full_0/divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C13105 pll_full_0/divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C13106 pll_full_0/divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C13107 pll_full_0/divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C13108 pll_full_0/divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C13109 pll_full_0/divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C13110 pll_full_0/divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C13111 pll_full_0/divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C13112 pll_full_0/divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C13113 pll_full_0/divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C13114 pll_full_0/divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C13115 pll_full_0/divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C13116 pll_full_0/divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C13117 pll_full_0/divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C13118 pll_full_0/divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C13119 pll_full_0/divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C13120 pll_full_0/divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C13121 pll_full_0/divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C13122 pll_full_0/divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C13123 pll_full_0/divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C13124 pll_full_0/divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C13125 pll_full_0/divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C13126 pll_full_0/divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C13127 pll_full_0/divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C13128 pll_full_0/divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C13129 pll_full_0/divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C13130 pll_full_0/divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C13131 pll_full_0/divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C13132 pll_full_0/divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C13133 pll_full_0/divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C13134 pll_full_0/divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C13135 pll_full_0/divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C13136 pll_full_0/divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C13137 pll_full_0/divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C13138 pll_full_0/divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C13139 pll_full_0/divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C13140 pll_full_0/divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C13141 pll_full_0/divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C13142 pll_full_0/divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C13143 pll_full_0/divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C13144 pll_full_0/divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C13145 pll_full_0/divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C13146 pll_full_0/divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C13147 pll_full_0/divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C13148 pll_full_0/divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C13149 pll_full_0/divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C13150 pll_full_0/divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C13151 pll_full_0/divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C13152 pll_full_0/divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C13153 pll_full_0/divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C13154 pll_full_0/divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C13155 pll_full_0/divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C13156 pll_full_0/divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C13157 pll_full_0/divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C13158 pll_full_0/divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C13159 pll_full_0/divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C13160 pll_full_0/divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C13161 pll_full_0/divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C13162 pll_full_0/divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C13163 pll_full_0/divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C13164 pll_full_0/divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C13165 pll_full_0/divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C13166 pll_full_0/divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C13167 pll_full_0/divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C13168 pll_full_0/divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C13169 pll_full_0/divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C13170 pll_full_0/divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C13171 pll_full_0/divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C13172 pll_full_0/divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C13173 pll_full_0/divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C13174 pll_full_0/divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C13175 pll_full_0/divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C13176 pll_full_0/divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C13177 pll_full_0/divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C13178 pll_full_0/divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C13179 pll_full_0/divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C13180 pll_full_0/divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C13181 pll_full_0/divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C13182 pll_full_0/divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C13183 pll_full_0/divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C13184 pll_full_0/divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C13185 pll_full_0/divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C13186 pll_full_0/divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C13187 pll_full_0/divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C13188 pll_full_0/divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C13189 pll_full_0/divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C13190 pll_full_0/divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C13191 pll_full_0/divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C13192 pll_full_0/divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C13193 pll_full_0/divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C13194 pll_full_0/divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C13195 pll_full_0/divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C13196 pll_full_0/divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C13197 pll_full_0/divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C13198 pll_full_0/divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C13199 pll_full_0/divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C13200 pll_full_0/divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C13201 pll_full_0/divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C13202 pll_full_0/divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C13203 pll_full_0/divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C13204 pll_full_0/divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C13205 pll_full_0/divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C13206 pll_full_0/divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C13207 pll_full_0/divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C13208 pll_full_0/divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C13209 pll_full_0/divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C13210 pll_full_0/divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C13211 pll_full_0/divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C13212 pll_full_0/divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C13213 pll_full_0/divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C13214 pll_full_0/divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C13215 pll_full_0/divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C13216 pll_full_0/divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C13217 pll_full_0/divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C13218 pll_full_0/divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C13219 pll_full_0/divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C13220 pll_full_0/divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C13221 pll_full_0/divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C13222 pll_full_0/divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C13223 pll_full_0/divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C13224 pll_full_0/divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C13225 pll_full_0/divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C13226 pll_full_0/divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C13227 pll_full_0/divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C13228 pll_full_0/divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C13229 pll_full_0/divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C13230 pll_full_0/divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C13231 pll_full_0/divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C13232 pll_full_0/divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C13233 pll_full_0/divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C13234 pll_full_0/divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C13235 pll_full_0/divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C13236 pll_full_0/divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C13237 pll_full_0/divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C13238 pll_full_0/divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C13239 pll_full_0/divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C13240 pll_full_0/divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C13241 pll_full_0/divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C13242 pll_full_0/divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C13243 pll_full_0/divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C13244 pll_full_0/divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C13245 pll_full_0/divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C13246 pll_full_0/divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C13247 pll_full_0/divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C13248 pll_full_0/divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C13249 pll_full_0/divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C13250 pll_full_0/divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C13251 pll_full_0/divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C13252 pll_full_0/divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C13253 pll_full_0/divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C13254 pll_full_0/divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C13255 pll_full_0/divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C13256 pll_full_0/divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C13257 pll_full_0/divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C13258 pll_full_0/divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C13259 pll_full_0/divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C13260 pll_full_0/divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C13261 pll_full_0/divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C13262 pll_full_0/divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C13263 pll_full_0/divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C13264 pll_full_0/divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C13265 pll_full_0/divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C13266 pll_full_0/divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C13267 pll_full_0/divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C13268 pll_full_0/divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C13269 pll_full_0/divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C13270 pll_full_0/divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C13271 pll_full_0/divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C13272 pll_full_0/divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C13273 pll_full_0/divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C13274 pll_full_0/divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C13275 pll_full_0/divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C13276 pll_full_0/divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C13277 pll_full_0/divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C13278 pll_full_0/divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C13279 pll_full_0/divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C13280 pll_full_0/divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C13281 pll_full_0/divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C13282 pll_full_0/divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C13283 pll_full_0/divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C13284 pll_full_0/divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C13285 pll_full_0/divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C13286 pll_full_0/divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C13287 pll_full_0/divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C13288 pll_full_0/divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C13289 pll_full_0/divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C13290 pll_full_0/divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C13291 pll_full_0/divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C13292 pll_full_0/divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C13293 pll_full_0/divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C13294 pll_full_0/divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C13295 pll_full_0/divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C13296 pll_full_0/divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C13297 pll_full_0/divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C13298 pll_full_0/divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C13299 pll_full_0/divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C13300 pll_full_0/divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C13301 pll_full_0/divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C13302 pll_full_0/divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C13303 pll_full_0/divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C13304 pll_full_0/divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C13305 pll_full_0/divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C13306 pll_full_0/divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C13307 pll_full_0/divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C13308 pll_full_0/divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C13309 pll_full_0/divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C13310 pll_full_0/divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C13311 pll_full_0/divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C13312 pll_full_0/divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C13313 pll_full_0/divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C13314 pll_full_0/divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C13315 pll_full_0/divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C13316 pll_full_0/divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C13317 pll_full_0/divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C13318 pll_full_0/divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C13319 pll_full_0/divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C13320 pll_full_0/divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C13321 pll_full_0/divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C13322 pll_full_0/divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C13323 pll_full_0/divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C13324 pll_full_0/divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C13325 pll_full_0/divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C13326 pll_full_0/divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C13327 pll_full_0/divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C13328 pll_full_0/divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C13329 pll_full_0/divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C13330 pll_full_0/divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C13331 pll_full_0/divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C13332 pll_full_0/divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C13333 pll_full_0/divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C13334 pll_full_0/divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C13335 pll_full_0/divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C13336 pll_full_0/divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C13337 pll_full_0/divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C13338 pll_full_0/divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C13339 pll_full_0/divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C13340 pll_full_0/divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C13341 pll_full_0/divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C13342 pll_full_0/divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C13343 pll_full_0/divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C13344 pll_full_0/divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C13345 pll_full_0/divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C13346 pll_full_0/divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C13347 pll_full_0/divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C13348 pll_full_0/divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C13349 pll_full_0/divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C13350 pll_full_0/divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C13351 pll_full_0/divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C13352 pll_full_0/divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C13353 pll_full_0/divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C13354 pll_full_0/divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C13355 pll_full_0/divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C13356 pll_full_0/divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C13357 pll_full_0/divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C13358 pll_full_0/divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C13359 pll_full_0/divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C13360 pll_full_0/divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C13361 pll_full_0/divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C13362 pll_full_0/divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C13363 pll_full_0/divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C13364 pll_full_0/divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C13365 pll_full_0/divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C13366 pll_full_0/divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C13367 pll_full_0/divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C13368 pll_full_0/divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C13369 pll_full_0/divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C13370 pll_full_0/divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C13371 pll_full_0/divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C13372 pll_full_0/divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C13373 pll_full_0/divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C13374 pll_full_0/divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C13375 pll_full_0/divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C13376 pll_full_0/divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C13377 pll_full_0/divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C13378 pll_full_0/divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C13379 pll_full_0/divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C13380 pll_full_0/divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C13381 pll_full_0/divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C13382 pll_full_0/divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C13383 pll_full_0/divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C13384 pll_full_0/divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C13385 pll_full_0/divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C13386 pll_full_0/divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C13387 pll_full_0/divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C13388 pll_full_0/divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C13389 pll_full_0/divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C13390 pll_full_0/divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C13391 pll_full_0/divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C13392 pll_full_0/divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C13393 pll_full_0/divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C13394 pll_full_0/divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C13395 pll_full_0/divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C13396 pll_full_0/divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C13397 pll_full_0/divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C13398 pll_full_0/divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C13399 pll_full_0/divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C13400 pll_full_0/divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C13401 pll_full_0/divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C13402 pll_full_0/divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C13403 pll_full_0/divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C13404 pll_full_0/divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C13405 pll_full_0/divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C13406 pll_full_0/divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C13407 pll_full_0/divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C13408 pll_full_0/divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C13409 pll_full_0/divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C13410 pll_full_0/divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C13411 pll_full_0/divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C13412 pll_full_0/divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C13413 pll_full_0/divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C13414 pll_full_0/divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C13415 pll_full_0/divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C13416 pll_full_0/divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C13417 pll_full_0/divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C13418 pll_full_0/divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C13419 pll_full_0/divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C13420 pll_full_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C13421 pll_full_0/ro_complete_0/cbank_2/v vdd 17.88fF
C13422 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C13423 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C13424 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C13425 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C13426 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C13427 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C13428 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C13429 pll_full_0/ro_complete_0/a0 vdd 7.88fF
C13430 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C13431 pll_full_0/ro_complete_0/a1 vdd 5.39fF
C13432 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C13433 pll_full_0/ro_complete_0/a3 vdd 6.85fF
C13434 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C13435 pll_full_0/ro_complete_0/a2 vdd 5.48fF
C13436 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C13437 pll_full_0/ro_complete_0/a4 vdd 5.36fF
C13438 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C13439 pll_full_0/ro_complete_0/a5 vdd 5.19fF
C13440 pll_full_0/ro_complete_0/cbank_0/v vdd 15.02fF
C13441 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C13442 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C13443 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C13444 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C13445 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C13446 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C13447 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C13448 pll_full_0/filter_0/a_4216_n5230# vdd 419.25fF **FLOATING
C13449 pll_full_0/filter_0/a_4216_n2998# vdd 1.39fF **FLOATING
C13450 pll_full_0/cp_0/down vdd 1.54fF
C13451 pll_full_0/cp_0/upbar vdd 1.79fF
C13452 pll_full_0/cp_0/a_7110_n2840# vdd 0.17fF **FLOATING
C13453 pll_full_0/cp_0/a_3060_n2840# vdd 1.71fF **FLOATING
C13454 pll_full_0/cp_0/a_7110_0# vdd 0.17fF **FLOATING
C13455 pll_full_0/cp_0/a_6370_0# vdd 0.40fF **FLOATING
C13456 pll_full_0/cp_0/a_3060_0# vdd 2.49fF **FLOATING
C13457 pll_full_0/cp_0/a_1710_0# vdd 7.47fF **FLOATING
C13458 pll_full_0/pd_0/and_pd_0/Z1 vdd 0.39fF
C13459 pll_full_0/pd_0/and_pd_0/Out1 vdd 2.22fF
C13460 pll_full_0/pd_0/tspc_r_1/z5 vdd 1.10fF
C13461 pll_full_0/pd_0/tspc_r_1/Z4 vdd 1.07fF
C13462 pll_full_0/pd_0/tspc_r_1/Qbar vdd 0.88fF
C13463 pll_full_0/pd_0/tspc_r_1/Z2 vdd 1.22fF
C13464 pll_full_0/pd_0/tspc_r_1/Z1 vdd 0.67fF
C13465 pll_full_0/pd_0/UP vdd 6.61fF
C13466 pll_full_0/pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C13467 pll_full_0/pd_0/tspc_r_1/Z3 vdd 2.12fF
C13468 pll_full_0/pd_0/REF vdd 6.44fF
C13469 pll_full_0/pd_0/tspc_r_0/z5 vdd 1.10fF
C13470 pll_full_0/pd_0/tspc_r_0/Z4 vdd 1.07fF
C13471 pll_full_0/pd_0/R vdd 3.05fF
C13472 pll_full_0/pd_0/tspc_r_0/Qbar vdd 0.79fF
C13473 pll_full_0/pd_0/tspc_r_0/Z2 vdd 1.22fF
C13474 pll_full_0/pd_0/tspc_r_0/Z1 vdd 0.67fF
C13475 pll_full_0/pd_0/DOWN vdd 7.24fF
C13476 pll_full_0/pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C13477 pll_full_0/pd_0/tspc_r_0/Z3 vdd 2.12fF
C13478 pll_full_0/pd_0/DIV vdd 11.33fF
C13479 divbuf_3/OUT vdd 3.28fF
C13480 divbuf_3/OUT5 vdd 16.40fF
C13481 divbuf_3/OUT4 vdd 100.06fF
C13482 divbuf_3/OUT3 vdd 27.01fF
C13483 divbuf_3/OUT2 vdd 8.71fF
C13484 divbuf_3/IN vdd 0.89fF
C13485 divbuf_3/a_60990_n1540# vdd 1.57fF **FLOATING
C13486 divbuf_3/a_60510_n1540# vdd 1.62fF **FLOATING
C13487 divbuf_3/a_60030_n1540# vdd 1.62fF **FLOATING
C13488 divbuf_3/a_59550_n1540# vdd 1.62fF **FLOATING
C13489 divbuf_3/a_59070_n1540# vdd 1.62fF **FLOATING
C13490 divbuf_3/a_58590_n1540# vdd 1.62fF **FLOATING
C13491 divbuf_3/a_58110_n1540# vdd 1.62fF **FLOATING
C13492 divbuf_3/a_57630_n1540# vdd 1.62fF **FLOATING
C13493 divbuf_3/a_57150_n1540# vdd 1.62fF **FLOATING
C13494 divbuf_3/a_56670_n1540# vdd 1.62fF **FLOATING
C13495 divbuf_3/a_56190_n1540# vdd 1.62fF **FLOATING
C13496 divbuf_3/a_55710_n1540# vdd 1.62fF **FLOATING
C13497 divbuf_3/a_55230_n1540# vdd 1.62fF **FLOATING
C13498 divbuf_3/a_54750_n1540# vdd 1.62fF **FLOATING
C13499 divbuf_3/a_54270_n1540# vdd 1.62fF **FLOATING
C13500 divbuf_3/a_53790_n1540# vdd 1.62fF **FLOATING
C13501 divbuf_3/a_53310_n1540# vdd 1.62fF **FLOATING
C13502 divbuf_3/a_52830_n1540# vdd 1.62fF **FLOATING
C13503 divbuf_3/a_52350_n1540# vdd 1.62fF **FLOATING
C13504 divbuf_3/a_51870_n1540# vdd 1.62fF **FLOATING
C13505 divbuf_3/a_51390_n1540# vdd 1.62fF **FLOATING
C13506 divbuf_3/a_50910_n1540# vdd 1.62fF **FLOATING
C13507 divbuf_3/a_50430_n1540# vdd 1.62fF **FLOATING
C13508 divbuf_3/a_49950_n1540# vdd 1.62fF **FLOATING
C13509 divbuf_3/a_49470_n1540# vdd 1.62fF **FLOATING
C13510 divbuf_3/a_48990_n1540# vdd 1.62fF **FLOATING
C13511 divbuf_3/a_48510_n1540# vdd 1.62fF **FLOATING
C13512 divbuf_3/a_48030_n1540# vdd 1.62fF **FLOATING
C13513 divbuf_3/a_47550_n1540# vdd 1.62fF **FLOATING
C13514 divbuf_3/a_47070_n1540# vdd 1.62fF **FLOATING
C13515 divbuf_3/a_46590_n1540# vdd 1.62fF **FLOATING
C13516 divbuf_3/a_46110_n1540# vdd 1.62fF **FLOATING
C13517 divbuf_3/a_45630_n1540# vdd 1.62fF **FLOATING
C13518 divbuf_3/a_45150_n1540# vdd 1.62fF **FLOATING
C13519 divbuf_3/a_44670_n1540# vdd 1.62fF **FLOATING
C13520 divbuf_3/a_44190_n1540# vdd 1.62fF **FLOATING
C13521 divbuf_3/a_43710_n1540# vdd 1.62fF **FLOATING
C13522 divbuf_3/a_43230_n1540# vdd 1.62fF **FLOATING
C13523 divbuf_3/a_42750_n1540# vdd 1.62fF **FLOATING
C13524 divbuf_3/a_42270_n1540# vdd 1.62fF **FLOATING
C13525 divbuf_3/a_41790_n1540# vdd 1.62fF **FLOATING
C13526 divbuf_3/a_41310_n1540# vdd 1.62fF **FLOATING
C13527 divbuf_3/a_40830_n1540# vdd 1.62fF **FLOATING
C13528 divbuf_3/a_40350_n1540# vdd 1.62fF **FLOATING
C13529 divbuf_3/a_39870_n1540# vdd 1.62fF **FLOATING
C13530 divbuf_3/a_39390_n1540# vdd 1.62fF **FLOATING
C13531 divbuf_3/a_38910_n1540# vdd 1.62fF **FLOATING
C13532 divbuf_3/a_38430_n1540# vdd 1.62fF **FLOATING
C13533 divbuf_3/a_37950_n1540# vdd 1.62fF **FLOATING
C13534 divbuf_3/a_37470_n1540# vdd 1.62fF **FLOATING
C13535 divbuf_3/a_36990_n1540# vdd 1.62fF **FLOATING
C13536 divbuf_3/a_36510_n1540# vdd 1.62fF **FLOATING
C13537 divbuf_3/a_36030_n1540# vdd 1.62fF **FLOATING
C13538 divbuf_3/a_35550_n1540# vdd 1.62fF **FLOATING
C13539 divbuf_3/a_35070_n1540# vdd 1.62fF **FLOATING
C13540 divbuf_3/a_34590_n1540# vdd 1.62fF **FLOATING
C13541 divbuf_3/a_34110_n1540# vdd 1.62fF **FLOATING
C13542 divbuf_3/a_33630_n1540# vdd 1.62fF **FLOATING
C13543 divbuf_3/a_33150_n1540# vdd 1.62fF **FLOATING
C13544 divbuf_3/a_32670_n1540# vdd 1.62fF **FLOATING
C13545 divbuf_3/a_32190_n1540# vdd 1.62fF **FLOATING
C13546 divbuf_3/a_31710_n1540# vdd 1.62fF **FLOATING
C13547 divbuf_3/a_31230_n1540# vdd 1.62fF **FLOATING
C13548 divbuf_3/a_30750_n1540# vdd 1.62fF **FLOATING
C13549 divbuf_3/a_30270_n1540# vdd 1.62fF **FLOATING
C13550 divbuf_3/a_29790_n1540# vdd 1.62fF **FLOATING
C13551 divbuf_3/a_29310_n1540# vdd 1.62fF **FLOATING
C13552 divbuf_3/a_28830_n1540# vdd 1.62fF **FLOATING
C13553 divbuf_3/a_28350_n1540# vdd 1.62fF **FLOATING
C13554 divbuf_3/a_27870_n1540# vdd 1.62fF **FLOATING
C13555 divbuf_3/a_27390_n1540# vdd 1.62fF **FLOATING
C13556 divbuf_3/a_26910_n1540# vdd 1.62fF **FLOATING
C13557 divbuf_3/a_26430_n1540# vdd 1.62fF **FLOATING
C13558 divbuf_3/a_25950_n1540# vdd 1.62fF **FLOATING
C13559 divbuf_3/a_25470_n1540# vdd 1.62fF **FLOATING
C13560 divbuf_3/a_24990_n1540# vdd 1.62fF **FLOATING
C13561 divbuf_3/a_24510_n1540# vdd 1.62fF **FLOATING
C13562 divbuf_3/a_24030_n1540# vdd 1.62fF **FLOATING
C13563 divbuf_3/a_23550_n1540# vdd 1.62fF **FLOATING
C13564 divbuf_3/a_23070_n1540# vdd 1.62fF **FLOATING
C13565 divbuf_3/a_22590_n1540# vdd 1.62fF **FLOATING
C13566 divbuf_3/a_22110_n1540# vdd 1.62fF **FLOATING
C13567 divbuf_3/a_21630_n1540# vdd 1.62fF **FLOATING
C13568 divbuf_3/a_21150_n1540# vdd 1.62fF **FLOATING
C13569 divbuf_3/a_20670_n1540# vdd 1.62fF **FLOATING
C13570 divbuf_3/a_20190_n1540# vdd 1.62fF **FLOATING
C13571 divbuf_3/a_19710_n1540# vdd 1.62fF **FLOATING
C13572 divbuf_3/a_19230_n1540# vdd 1.62fF **FLOATING
C13573 divbuf_3/a_18750_n1540# vdd 1.62fF **FLOATING
C13574 divbuf_3/a_18270_n1540# vdd 1.62fF **FLOATING
C13575 divbuf_3/a_17790_n1540# vdd 1.62fF **FLOATING
C13576 divbuf_3/a_17310_n1540# vdd 1.62fF **FLOATING
C13577 divbuf_3/a_16830_n1540# vdd 1.62fF **FLOATING
C13578 divbuf_3/a_16350_n1540# vdd 1.62fF **FLOATING
C13579 divbuf_3/a_15870_n1540# vdd 1.62fF **FLOATING
C13580 divbuf_3/a_15390_n1540# vdd 1.62fF **FLOATING
C13581 divbuf_3/a_14910_n1540# vdd 1.62fF **FLOATING
C13582 divbuf_3/a_14430_n1540# vdd 1.62fF **FLOATING
C13583 divbuf_3/a_13950_n1540# vdd 1.62fF **FLOATING
C13584 divbuf_3/a_13470_n1540# vdd 1.62fF **FLOATING
C13585 divbuf_3/a_12990_n1540# vdd 1.62fF **FLOATING
C13586 divbuf_3/a_12510_n1540# vdd 1.62fF **FLOATING
C13587 divbuf_3/a_12030_n1540# vdd 1.62fF **FLOATING
C13588 divbuf_3/a_11550_n1540# vdd 1.62fF **FLOATING
C13589 divbuf_3/a_11070_n1540# vdd 1.62fF **FLOATING
C13590 divbuf_3/a_10590_n1540# vdd 1.62fF **FLOATING
C13591 divbuf_3/a_10110_n1540# vdd 1.62fF **FLOATING
C13592 divbuf_3/a_9630_n1540# vdd 1.62fF **FLOATING
C13593 divbuf_3/a_9150_n1540# vdd 1.62fF **FLOATING
C13594 divbuf_3/a_8670_n1540# vdd 1.62fF **FLOATING
C13595 divbuf_3/a_8190_n1540# vdd 1.62fF **FLOATING
C13596 divbuf_3/a_7710_n1540# vdd 1.62fF **FLOATING
C13597 divbuf_3/a_7230_n1540# vdd 1.62fF **FLOATING
C13598 divbuf_3/a_6750_n1540# vdd 1.62fF **FLOATING
C13599 divbuf_3/a_6270_n1540# vdd 1.62fF **FLOATING
C13600 divbuf_3/a_5790_n1540# vdd 1.62fF **FLOATING
C13601 divbuf_3/a_5310_n1540# vdd 1.62fF **FLOATING
C13602 divbuf_3/a_4830_n1540# vdd 1.62fF **FLOATING
C13603 divbuf_3/a_4350_n1540# vdd 1.62fF **FLOATING
C13604 divbuf_3/a_3870_n1540# vdd 1.62fF **FLOATING
C13605 divbuf_3/a_3390_n1540# vdd 1.62fF **FLOATING
C13606 divbuf_3/a_2910_n1540# vdd 1.62fF **FLOATING
C13607 divbuf_3/a_2430_n1540# vdd 1.62fF **FLOATING
C13608 divbuf_3/a_1950_n1540# vdd 1.62fF **FLOATING
C13609 divbuf_3/a_1470_n1540# vdd 1.62fF **FLOATING
C13610 divbuf_3/a_990_n1540# vdd 1.62fF **FLOATING
C13611 divbuf_3/a_510_n1540# vdd 1.62fF **FLOATING
C13612 divbuf_3/a_60990_n840# vdd 1.06fF **FLOATING
C13613 divbuf_3/a_60510_n840# vdd 1.09fF **FLOATING
C13614 divbuf_3/a_60030_n840# vdd 1.09fF **FLOATING
C13615 divbuf_3/a_59550_n840# vdd 1.09fF **FLOATING
C13616 divbuf_3/a_59070_n840# vdd 1.09fF **FLOATING
C13617 divbuf_3/a_58590_n840# vdd 1.09fF **FLOATING
C13618 divbuf_3/a_58110_n840# vdd 1.09fF **FLOATING
C13619 divbuf_3/a_57630_n840# vdd 1.09fF **FLOATING
C13620 divbuf_3/a_57150_n840# vdd 1.09fF **FLOATING
C13621 divbuf_3/a_56670_n840# vdd 1.09fF **FLOATING
C13622 divbuf_3/a_56190_n840# vdd 1.09fF **FLOATING
C13623 divbuf_3/a_55710_n840# vdd 1.09fF **FLOATING
C13624 divbuf_3/a_55230_n840# vdd 1.09fF **FLOATING
C13625 divbuf_3/a_54750_n840# vdd 1.09fF **FLOATING
C13626 divbuf_3/a_54270_n840# vdd 1.09fF **FLOATING
C13627 divbuf_3/a_53790_n840# vdd 1.09fF **FLOATING
C13628 divbuf_3/a_53310_n840# vdd 1.09fF **FLOATING
C13629 divbuf_3/a_52830_n840# vdd 1.09fF **FLOATING
C13630 divbuf_3/a_52350_n840# vdd 1.09fF **FLOATING
C13631 divbuf_3/a_51870_n840# vdd 1.09fF **FLOATING
C13632 divbuf_3/a_51390_n840# vdd 1.09fF **FLOATING
C13633 divbuf_3/a_50910_n840# vdd 1.09fF **FLOATING
C13634 divbuf_3/a_50430_n840# vdd 1.09fF **FLOATING
C13635 divbuf_3/a_49950_n840# vdd 1.09fF **FLOATING
C13636 divbuf_3/a_49470_n840# vdd 1.09fF **FLOATING
C13637 divbuf_3/a_48990_n840# vdd 1.09fF **FLOATING
C13638 divbuf_3/a_48510_n840# vdd 1.09fF **FLOATING
C13639 divbuf_3/a_48030_n840# vdd 1.09fF **FLOATING
C13640 divbuf_3/a_47550_n840# vdd 1.09fF **FLOATING
C13641 divbuf_3/a_47070_n840# vdd 1.09fF **FLOATING
C13642 divbuf_3/a_46590_n840# vdd 1.09fF **FLOATING
C13643 divbuf_3/a_46110_n840# vdd 1.09fF **FLOATING
C13644 divbuf_3/a_45630_n840# vdd 1.09fF **FLOATING
C13645 divbuf_3/a_45150_n840# vdd 1.09fF **FLOATING
C13646 divbuf_3/a_44670_n840# vdd 1.09fF **FLOATING
C13647 divbuf_3/a_44190_n840# vdd 1.09fF **FLOATING
C13648 divbuf_3/a_43710_n840# vdd 1.09fF **FLOATING
C13649 divbuf_3/a_43230_n840# vdd 1.09fF **FLOATING
C13650 divbuf_3/a_42750_n840# vdd 1.08fF **FLOATING
C13651 divbuf_3/a_42270_n840# vdd 1.08fF **FLOATING
C13652 divbuf_3/a_41790_n840# vdd 1.10fF **FLOATING
C13653 divbuf_3/a_41310_n840# vdd 1.09fF **FLOATING
C13654 divbuf_3/a_40830_n840# vdd 1.09fF **FLOATING
C13655 divbuf_3/a_40350_n840# vdd 1.09fF **FLOATING
C13656 divbuf_3/a_39870_n840# vdd 1.09fF **FLOATING
C13657 divbuf_3/a_39390_n840# vdd 1.09fF **FLOATING
C13658 divbuf_3/a_38910_n840# vdd 1.09fF **FLOATING
C13659 divbuf_3/a_38430_n840# vdd 1.09fF **FLOATING
C13660 divbuf_3/a_37950_n840# vdd 1.09fF **FLOATING
C13661 divbuf_3/a_37470_n840# vdd 1.09fF **FLOATING
C13662 divbuf_3/a_36990_n840# vdd 1.09fF **FLOATING
C13663 divbuf_3/a_36510_n840# vdd 1.09fF **FLOATING
C13664 divbuf_3/a_36030_n840# vdd 1.09fF **FLOATING
C13665 divbuf_3/a_35550_n840# vdd 1.09fF **FLOATING
C13666 divbuf_3/a_35070_n840# vdd 1.09fF **FLOATING
C13667 divbuf_3/a_34590_n840# vdd 1.09fF **FLOATING
C13668 divbuf_3/a_34110_n840# vdd 1.09fF **FLOATING
C13669 divbuf_3/a_33630_n840# vdd 1.09fF **FLOATING
C13670 divbuf_3/a_33150_n840# vdd 1.09fF **FLOATING
C13671 divbuf_3/a_32670_n840# vdd 1.09fF **FLOATING
C13672 divbuf_3/a_32190_n840# vdd 1.09fF **FLOATING
C13673 divbuf_3/a_31710_n840# vdd 1.11fF **FLOATING
C13674 divbuf_3/a_31230_n840# vdd 1.13fF **FLOATING
C13675 divbuf_3/a_30750_n840# vdd 1.09fF **FLOATING
C13676 divbuf_3/a_30270_n840# vdd 1.09fF **FLOATING
C13677 divbuf_3/a_29790_n840# vdd 1.09fF **FLOATING
C13678 divbuf_3/a_29310_n840# vdd 1.09fF **FLOATING
C13679 divbuf_3/a_28830_n840# vdd 1.09fF **FLOATING
C13680 divbuf_3/a_28350_n840# vdd 1.09fF **FLOATING
C13681 divbuf_3/a_27870_n840# vdd 1.08fF **FLOATING
C13682 divbuf_3/a_27390_n840# vdd 1.11fF **FLOATING
C13683 divbuf_3/a_26910_n840# vdd 1.10fF **FLOATING
C13684 divbuf_3/a_26430_n840# vdd 1.10fF **FLOATING
C13685 divbuf_3/a_25950_n840# vdd 1.10fF **FLOATING
C13686 divbuf_3/a_25470_n840# vdd 1.10fF **FLOATING
C13687 divbuf_3/a_24990_n840# vdd 1.10fF **FLOATING
C13688 divbuf_3/a_24510_n840# vdd 1.10fF **FLOATING
C13689 divbuf_3/a_24030_n840# vdd 1.09fF **FLOATING
C13690 divbuf_3/a_23550_n840# vdd 1.11fF **FLOATING
C13691 divbuf_3/a_23070_n840# vdd 1.10fF **FLOATING
C13692 divbuf_3/a_22590_n840# vdd 1.10fF **FLOATING
C13693 divbuf_3/a_22110_n840# vdd 1.10fF **FLOATING
C13694 divbuf_3/a_21630_n840# vdd 1.10fF **FLOATING
C13695 divbuf_3/a_21150_n840# vdd 1.10fF **FLOATING
C13696 divbuf_3/a_20670_n840# vdd 1.10fF **FLOATING
C13697 divbuf_3/a_20190_n840# vdd 1.09fF **FLOATING
C13698 divbuf_3/a_19710_n840# vdd 1.09fF **FLOATING
C13699 divbuf_3/a_19230_n840# vdd 1.09fF **FLOATING
C13700 divbuf_3/a_18750_n840# vdd 1.09fF **FLOATING
C13701 divbuf_3/a_18270_n840# vdd 1.08fF **FLOATING
C13702 divbuf_3/a_17790_n840# vdd 1.08fF **FLOATING
C13703 divbuf_3/a_17310_n840# vdd 1.07fF **FLOATING
C13704 divbuf_3/a_16830_n840# vdd 1.07fF **FLOATING
C13705 divbuf_3/a_16350_n840# vdd 1.07fF **FLOATING
C13706 divbuf_3/a_15870_n840# vdd 1.07fF **FLOATING
C13707 divbuf_3/a_15390_n840# vdd 1.08fF **FLOATING
C13708 divbuf_3/a_14910_n840# vdd 1.07fF **FLOATING
C13709 divbuf_3/a_14430_n840# vdd 1.07fF **FLOATING
C13710 divbuf_3/a_13950_n840# vdd 1.07fF **FLOATING
C13711 divbuf_3/a_13470_n840# vdd 1.07fF **FLOATING
C13712 divbuf_3/a_12990_n840# vdd 1.10fF **FLOATING
C13713 divbuf_3/a_12510_n840# vdd 1.08fF **FLOATING
C13714 divbuf_3/a_12030_n840# vdd 1.07fF **FLOATING
C13715 divbuf_3/a_11550_n840# vdd 1.07fF **FLOATING
C13716 divbuf_3/a_11070_n840# vdd 1.08fF **FLOATING
C13717 divbuf_3/a_10590_n840# vdd 1.10fF **FLOATING
C13718 divbuf_3/a_10110_n840# vdd 1.10fF **FLOATING
C13719 divbuf_3/a_9630_n840# vdd 1.10fF **FLOATING
C13720 divbuf_3/a_9150_n840# vdd 1.10fF **FLOATING
C13721 divbuf_3/a_8670_n840# vdd 1.10fF **FLOATING
C13722 divbuf_3/a_8190_n840# vdd 1.12fF **FLOATING
C13723 divbuf_3/a_7710_n840# vdd 1.10fF **FLOATING
C13724 divbuf_3/a_7230_n840# vdd 1.09fF **FLOATING
C13725 divbuf_3/a_6750_n840# vdd 1.09fF **FLOATING
C13726 divbuf_3/a_6270_n840# vdd 1.09fF **FLOATING
C13727 divbuf_3/a_5790_n840# vdd 1.09fF **FLOATING
C13728 divbuf_3/a_5310_n840# vdd 1.09fF **FLOATING
C13729 divbuf_3/a_4830_n840# vdd 1.09fF **FLOATING
C13730 divbuf_3/a_4350_n840# vdd 1.09fF **FLOATING
C13731 divbuf_3/a_3870_n840# vdd 1.09fF **FLOATING
C13732 divbuf_3/a_3390_n840# vdd 1.09fF **FLOATING
C13733 divbuf_3/a_2910_n840# vdd 1.10fF **FLOATING
C13734 divbuf_3/a_2430_n840# vdd 1.10fF **FLOATING
C13735 divbuf_3/a_1950_n840# vdd 1.10fF **FLOATING
C13736 divbuf_3/a_1470_n840# vdd 1.10fF **FLOATING
C13737 divbuf_3/a_990_n840# vdd 1.08fF **FLOATING
C13738 divbuf_3/a_510_n840# vdd 1.07fF **FLOATING
C13739 divbuf_3/a_60480_n1600# vdd 1.48fF **FLOATING
C13740 divbuf_3/a_60000_n1600# vdd 1.48fF **FLOATING
C13741 divbuf_3/a_59520_n1600# vdd 1.48fF **FLOATING
C13742 divbuf_3/a_59040_n1600# vdd 1.48fF **FLOATING
C13743 divbuf_3/a_58560_n1600# vdd 1.48fF **FLOATING
C13744 divbuf_3/a_58080_n1600# vdd 1.48fF **FLOATING
C13745 divbuf_3/a_57600_n1600# vdd 1.48fF **FLOATING
C13746 divbuf_3/a_57120_n1600# vdd 1.48fF **FLOATING
C13747 divbuf_3/a_56640_n1600# vdd 1.48fF **FLOATING
C13748 divbuf_3/a_56160_n1600# vdd 1.48fF **FLOATING
C13749 divbuf_3/a_55680_n1600# vdd 1.48fF **FLOATING
C13750 divbuf_3/a_55200_n1600# vdd 1.48fF **FLOATING
C13751 divbuf_3/a_54720_n1600# vdd 1.48fF **FLOATING
C13752 divbuf_3/a_54240_n1600# vdd 1.48fF **FLOATING
C13753 divbuf_3/a_53760_n1600# vdd 1.48fF **FLOATING
C13754 divbuf_3/a_53280_n1600# vdd 1.48fF **FLOATING
C13755 divbuf_3/a_52800_n1600# vdd 1.48fF **FLOATING
C13756 divbuf_3/a_52320_n1600# vdd 1.48fF **FLOATING
C13757 divbuf_3/a_51840_n1600# vdd 1.48fF **FLOATING
C13758 divbuf_3/a_51360_n1600# vdd 1.48fF **FLOATING
C13759 divbuf_3/a_50880_n1600# vdd 1.48fF **FLOATING
C13760 divbuf_3/a_50400_n1600# vdd 1.48fF **FLOATING
C13761 divbuf_3/a_49920_n1600# vdd 1.48fF **FLOATING
C13762 divbuf_3/a_49440_n1600# vdd 1.48fF **FLOATING
C13763 divbuf_3/a_48960_n1600# vdd 1.48fF **FLOATING
C13764 divbuf_3/a_48480_n1600# vdd 1.48fF **FLOATING
C13765 divbuf_3/a_48000_n1600# vdd 1.48fF **FLOATING
C13766 divbuf_3/a_47520_n1600# vdd 1.48fF **FLOATING
C13767 divbuf_3/a_47040_n1600# vdd 1.48fF **FLOATING
C13768 divbuf_3/a_46560_n1600# vdd 1.48fF **FLOATING
C13769 divbuf_3/a_46080_n1600# vdd 1.48fF **FLOATING
C13770 divbuf_3/a_45600_n1600# vdd 1.48fF **FLOATING
C13771 divbuf_3/a_45120_n1600# vdd 1.48fF **FLOATING
C13772 divbuf_3/a_44640_n1600# vdd 1.48fF **FLOATING
C13773 divbuf_3/a_44160_n1600# vdd 1.48fF **FLOATING
C13774 divbuf_3/a_43680_n1600# vdd 1.48fF **FLOATING
C13775 divbuf_3/a_43200_n1600# vdd 1.48fF **FLOATING
C13776 divbuf_3/a_42720_n1600# vdd 1.48fF **FLOATING
C13777 divbuf_3/a_42240_n1600# vdd 1.48fF **FLOATING
C13778 divbuf_3/a_41760_n1600# vdd 1.48fF **FLOATING
C13779 divbuf_3/a_41280_n1600# vdd 1.48fF **FLOATING
C13780 divbuf_3/a_40800_n1600# vdd 1.48fF **FLOATING
C13781 divbuf_3/a_40320_n1600# vdd 1.48fF **FLOATING
C13782 divbuf_3/a_39840_n1600# vdd 1.48fF **FLOATING
C13783 divbuf_3/a_39360_n1600# vdd 1.48fF **FLOATING
C13784 divbuf_3/a_38880_n1600# vdd 1.48fF **FLOATING
C13785 divbuf_3/a_38400_n1600# vdd 1.48fF **FLOATING
C13786 divbuf_3/a_37920_n1600# vdd 1.48fF **FLOATING
C13787 divbuf_3/a_37440_n1600# vdd 1.48fF **FLOATING
C13788 divbuf_3/a_36960_n1600# vdd 1.48fF **FLOATING
C13789 divbuf_3/a_36480_n1600# vdd 1.48fF **FLOATING
C13790 divbuf_3/a_36000_n1600# vdd 1.48fF **FLOATING
C13791 divbuf_3/a_35520_n1600# vdd 1.48fF **FLOATING
C13792 divbuf_3/a_35040_n1600# vdd 1.48fF **FLOATING
C13793 divbuf_3/a_34560_n1600# vdd 1.48fF **FLOATING
C13794 divbuf_3/a_34080_n1600# vdd 1.48fF **FLOATING
C13795 divbuf_3/a_33600_n1600# vdd 1.48fF **FLOATING
C13796 divbuf_3/a_33120_n1600# vdd 1.48fF **FLOATING
C13797 divbuf_3/a_32640_n1600# vdd 1.48fF **FLOATING
C13798 divbuf_3/a_32160_n1600# vdd 1.48fF **FLOATING
C13799 divbuf_3/a_31680_n1600# vdd 1.48fF **FLOATING
C13800 divbuf_3/a_31200_n1600# vdd 1.48fF **FLOATING
C13801 divbuf_3/a_30720_n1600# vdd 1.48fF **FLOATING
C13802 divbuf_3/a_30240_n1600# vdd 1.48fF **FLOATING
C13803 divbuf_3/a_29760_n1600# vdd 1.48fF **FLOATING
C13804 divbuf_3/a_29280_n1600# vdd 1.48fF **FLOATING
C13805 divbuf_3/a_28800_n1600# vdd 1.48fF **FLOATING
C13806 divbuf_3/a_28320_n1600# vdd 1.48fF **FLOATING
C13807 divbuf_3/a_27840_n1600# vdd 1.48fF **FLOATING
C13808 divbuf_3/a_27360_n1600# vdd 1.48fF **FLOATING
C13809 divbuf_3/a_26880_n1600# vdd 1.48fF **FLOATING
C13810 divbuf_3/a_26400_n1600# vdd 1.48fF **FLOATING
C13811 divbuf_3/a_25920_n1600# vdd 1.48fF **FLOATING
C13812 divbuf_3/a_25440_n1600# vdd 1.48fF **FLOATING
C13813 divbuf_3/a_24960_n1600# vdd 1.48fF **FLOATING
C13814 divbuf_3/a_24480_n1600# vdd 1.48fF **FLOATING
C13815 divbuf_3/a_24000_n1600# vdd 1.48fF **FLOATING
C13816 divbuf_3/a_23520_n1600# vdd 1.48fF **FLOATING
C13817 divbuf_3/a_23040_n1600# vdd 1.48fF **FLOATING
C13818 divbuf_3/a_22560_n1600# vdd 1.48fF **FLOATING
C13819 divbuf_3/a_22080_n1600# vdd 1.48fF **FLOATING
C13820 divbuf_3/a_21600_n1600# vdd 1.48fF **FLOATING
C13821 divbuf_3/a_21120_n1600# vdd 1.48fF **FLOATING
C13822 divbuf_3/a_20640_n1600# vdd 1.48fF **FLOATING
C13823 divbuf_3/a_20160_n1600# vdd 1.48fF **FLOATING
C13824 divbuf_3/a_19680_n1600# vdd 1.48fF **FLOATING
C13825 divbuf_3/a_19200_n1600# vdd 1.48fF **FLOATING
C13826 divbuf_3/a_18720_n1600# vdd 1.48fF **FLOATING
C13827 divbuf_3/a_18240_n1600# vdd 1.48fF **FLOATING
C13828 divbuf_3/a_17760_n1600# vdd 1.48fF **FLOATING
C13829 divbuf_3/a_17280_n1600# vdd 1.48fF **FLOATING
C13830 divbuf_3/a_16800_n1600# vdd 1.48fF **FLOATING
C13831 divbuf_3/a_16320_n1600# vdd 1.48fF **FLOATING
C13832 divbuf_3/a_15840_n1600# vdd 1.48fF **FLOATING
C13833 divbuf_3/a_15360_n1600# vdd 1.48fF **FLOATING
C13834 divbuf_3/a_14880_n1600# vdd 1.48fF **FLOATING
C13835 divbuf_3/a_14400_n1600# vdd 1.48fF **FLOATING
C13836 divbuf_3/a_13920_n1600# vdd 1.48fF **FLOATING
C13837 divbuf_3/a_13440_n1600# vdd 1.48fF **FLOATING
C13838 divbuf_3/a_12960_n1600# vdd 1.48fF **FLOATING
C13839 divbuf_3/a_12480_n1600# vdd 1.48fF **FLOATING
C13840 divbuf_3/a_12000_n1600# vdd 1.48fF **FLOATING
C13841 divbuf_3/a_11520_n1600# vdd 1.48fF **FLOATING
C13842 divbuf_3/a_11040_n1600# vdd 1.48fF **FLOATING
C13843 divbuf_3/a_10560_n1600# vdd 1.48fF **FLOATING
C13844 divbuf_3/a_10080_n1600# vdd 1.48fF **FLOATING
C13845 divbuf_3/a_9600_n1600# vdd 1.48fF **FLOATING
C13846 divbuf_3/a_9120_n1600# vdd 1.48fF **FLOATING
C13847 divbuf_3/a_8640_n1600# vdd 1.48fF **FLOATING
C13848 divbuf_3/a_8160_n1600# vdd 1.48fF **FLOATING
C13849 divbuf_3/a_7680_n1600# vdd 1.48fF **FLOATING
C13850 divbuf_3/a_7200_n1600# vdd 1.48fF **FLOATING
C13851 divbuf_3/a_6720_n1600# vdd 1.48fF **FLOATING
C13852 divbuf_3/a_6240_n1600# vdd 1.48fF **FLOATING
C13853 divbuf_3/a_5760_n1600# vdd 1.48fF **FLOATING
C13854 divbuf_3/a_5280_n1600# vdd 1.48fF **FLOATING
C13855 divbuf_3/a_4800_n1600# vdd 1.48fF **FLOATING
C13856 divbuf_3/a_4320_n1600# vdd 1.48fF **FLOATING
C13857 divbuf_3/a_3840_n1600# vdd 1.48fF **FLOATING
C13858 divbuf_3/a_3360_n1600# vdd 1.48fF **FLOATING
C13859 divbuf_3/a_2880_n1600# vdd 1.48fF **FLOATING
C13860 divbuf_3/a_2400_n1600# vdd 1.48fF **FLOATING
C13861 divbuf_3/a_1920_n1600# vdd 1.48fF **FLOATING
C13862 divbuf_3/a_1440_n1600# vdd 1.48fF **FLOATING
C13863 divbuf_3/a_960_n1600# vdd 1.48fF **FLOATING
C13864 divbuf_3/a_480_n1600# vdd 1.48fF **FLOATING
C13865 divbuf_3/a_0_n1600# vdd 1.48fF **FLOATING
C13866 divbuf_3/a_41382_n240# vdd 0.90fF **FLOATING
C13867 divbuf_3/a_40902_n240# vdd 0.90fF **FLOATING
C13868 divbuf_3/a_40412_n240# vdd 0.90fF **FLOATING
C13869 divbuf_3/a_39932_n240# vdd 0.90fF **FLOATING
C13870 divbuf_3/a_39442_n240# vdd 0.90fF **FLOATING
C13871 divbuf_3/a_38962_n240# vdd 0.91fF **FLOATING
C13872 divbuf_3/a_38472_n240# vdd 0.90fF **FLOATING
C13873 divbuf_3/a_37992_n240# vdd 0.90fF **FLOATING
C13874 divbuf_3/a_37502_n240# vdd 0.90fF **FLOATING
C13875 divbuf_3/a_37022_n240# vdd 0.90fF **FLOATING
C13876 divbuf_3/a_36532_n240# vdd 0.90fF **FLOATING
C13877 divbuf_3/a_36052_n240# vdd 0.90fF **FLOATING
C13878 divbuf_3/a_35562_n240# vdd 0.90fF **FLOATING
C13879 divbuf_3/a_35082_n240# vdd 0.91fF **FLOATING
C13880 divbuf_3/a_34592_n240# vdd 0.90fF **FLOATING
C13881 divbuf_3/a_34112_n240# vdd 0.90fF **FLOATING
C13882 divbuf_3/a_33622_n240# vdd 0.90fF **FLOATING
C13883 divbuf_3/a_33142_n240# vdd 0.90fF **FLOATING
C13884 divbuf_3/a_32652_n240# vdd 0.90fF **FLOATING
C13885 divbuf_3/a_32172_n240# vdd 0.90fF **FLOATING
C13886 divbuf_3/a_31682_n240# vdd 0.89fF **FLOATING
C13887 divbuf_3/a_31202_n240# vdd 0.92fF **FLOATING
C13888 divbuf_3/a_30712_n240# vdd 0.90fF **FLOATING
C13889 divbuf_3/a_30232_n240# vdd 0.90fF **FLOATING
C13890 divbuf_3/a_29742_n240# vdd 0.90fF **FLOATING
C13891 divbuf_3/a_29262_n240# vdd 0.90fF **FLOATING
C13892 divbuf_3/a_28772_n240# vdd 0.90fF **FLOATING
C13893 divbuf_3/a_28292_n240# vdd 0.90fF **FLOATING
C13894 divbuf_3/a_27802_n240# vdd 0.89fF **FLOATING
C13895 divbuf_3/a_27322_n240# vdd 0.95fF **FLOATING
C13896 divbuf_3/a_26832_n240# vdd 0.91fF **FLOATING
C13897 divbuf_3/a_26352_n240# vdd 0.91fF **FLOATING
C13898 divbuf_3/a_25862_n240# vdd 0.91fF **FLOATING
C13899 divbuf_3/a_25382_n240# vdd 0.91fF **FLOATING
C13900 divbuf_3/a_24892_n240# vdd 0.91fF **FLOATING
C13901 divbuf_3/a_24412_n240# vdd 0.91fF **FLOATING
C13902 divbuf_3/a_23922_n240# vdd 0.92fF **FLOATING
C13903 divbuf_3/a_23442_n240# vdd 0.94fF **FLOATING
C13904 divbuf_3/a_22952_n240# vdd 0.91fF **FLOATING
C13905 divbuf_3/a_22472_n240# vdd 0.91fF **FLOATING
C13906 divbuf_3/a_21982_n240# vdd 0.91fF **FLOATING
C13907 divbuf_3/a_21502_n240# vdd 0.91fF **FLOATING
C13908 divbuf_3/a_21012_n240# vdd 0.91fF **FLOATING
C13909 divbuf_3/a_20532_n240# vdd 0.91fF **FLOATING
C13910 divbuf_3/a_20042_n240# vdd 0.90fF **FLOATING
C13911 divbuf_3/a_19562_n240# vdd 0.90fF **FLOATING
C13912 divbuf_3/a_19072_n240# vdd 0.90fF **FLOATING
C13913 divbuf_3/a_18582_n240# vdd 0.89fF **FLOATING
C13914 divbuf_3/a_18092_n240# vdd 0.89fF **FLOATING
C13915 divbuf_3/a_17612_n240# vdd 0.89fF **FLOATING
C13916 divbuf_3/a_17122_n240# vdd 0.88fF **FLOATING
C13917 divbuf_3/a_16642_n240# vdd 0.88fF **FLOATING
C13918 divbuf_3/a_16152_n240# vdd 0.88fF **FLOATING
C13919 divbuf_3/a_15672_n240# vdd 0.90fF **FLOATING
C13920 divbuf_3/a_15182_n240# vdd 0.88fF **FLOATING
C13921 divbuf_3/a_14702_n240# vdd 0.88fF **FLOATING
C13922 divbuf_3/a_14222_n240# vdd 0.88fF **FLOATING
C13923 divbuf_3/a_13742_n240# vdd 0.88fF **FLOATING
C13924 divbuf_3/a_13252_n240# vdd 0.88fF **FLOATING
C13925 divbuf_3/a_12772_n240# vdd 0.88fF **FLOATING
C13926 divbuf_3/a_12282_n240# vdd 0.88fF **FLOATING
C13927 divbuf_3/a_11802_n240# vdd 0.88fF **FLOATING
C13928 divbuf_3/a_11312_n240# vdd 0.89fF **FLOATING
C13929 divbuf_3/a_10212_n240# vdd 0.91fF **FLOATING
C13930 divbuf_3/a_9732_n240# vdd 0.91fF **FLOATING
C13931 divbuf_3/a_9242_n240# vdd 0.91fF **FLOATING
C13932 divbuf_3/a_8762_n240# vdd 0.91fF **FLOATING
C13933 divbuf_3/a_8272_n240# vdd 0.91fF **FLOATING
C13934 divbuf_3/a_7792_n240# vdd 0.92fF **FLOATING
C13935 divbuf_3/a_7302_n240# vdd 0.90fF **FLOATING
C13936 divbuf_3/a_6822_n240# vdd 0.90fF **FLOATING
C13937 divbuf_3/a_6332_n240# vdd 0.90fF **FLOATING
C13938 divbuf_3/a_5852_n240# vdd 0.90fF **FLOATING
C13939 divbuf_3/a_5362_n240# vdd 0.90fF **FLOATING
C13940 divbuf_3/a_4882_n240# vdd 0.90fF **FLOATING
C13941 divbuf_3/a_4392_n240# vdd 0.90fF **FLOATING
C13942 divbuf_3/a_3912_n240# vdd 0.90fF **FLOATING
C13943 divbuf_3/a_3422_n240# vdd 0.90fF **FLOATING
C13944 divbuf_3/a_2322_n240# vdd 0.91fF **FLOATING
C13945 divbuf_3/a_1842_n240# vdd 0.91fF **FLOATING
C13946 divbuf_3/a_1352_n240# vdd 0.91fF **FLOATING
C13947 divbuf_3/a_41382_170# vdd 1.07fF **FLOATING
C13948 divbuf_3/a_40902_170# vdd 1.09fF **FLOATING
C13949 divbuf_3/a_40412_170# vdd 1.09fF **FLOATING
C13950 divbuf_3/a_39932_170# vdd 1.09fF **FLOATING
C13951 divbuf_3/a_39442_170# vdd 1.09fF **FLOATING
C13952 divbuf_3/a_38962_170# vdd 1.07fF **FLOATING
C13953 divbuf_3/a_38472_170# vdd 1.09fF **FLOATING
C13954 divbuf_3/a_37992_170# vdd 1.09fF **FLOATING
C13955 divbuf_3/a_37502_170# vdd 1.09fF **FLOATING
C13956 divbuf_3/a_37022_170# vdd 1.09fF **FLOATING
C13957 divbuf_3/a_36532_170# vdd 1.09fF **FLOATING
C13958 divbuf_3/a_36052_170# vdd 1.09fF **FLOATING
C13959 divbuf_3/a_35562_170# vdd 1.09fF **FLOATING
C13960 divbuf_3/a_35082_170# vdd 1.09fF **FLOATING
C13961 divbuf_3/a_34592_170# vdd 1.07fF **FLOATING
C13962 divbuf_3/a_34112_170# vdd 1.09fF **FLOATING
C13963 divbuf_3/a_33622_170# vdd 1.09fF **FLOATING
C13964 divbuf_3/a_33142_170# vdd 1.09fF **FLOATING
C13965 divbuf_3/a_32652_170# vdd 1.09fF **FLOATING
C13966 divbuf_3/a_32172_170# vdd 1.09fF **FLOATING
C13967 divbuf_3/a_31682_170# vdd 1.09fF **FLOATING
C13968 divbuf_3/a_31202_170# vdd 1.09fF **FLOATING
C13969 divbuf_3/a_30712_170# vdd 1.09fF **FLOATING
C13970 divbuf_3/a_30232_170# vdd 1.07fF **FLOATING
C13971 divbuf_3/a_29742_170# vdd 1.09fF **FLOATING
C13972 divbuf_3/a_29262_170# vdd 1.09fF **FLOATING
C13973 divbuf_3/a_28772_170# vdd 1.09fF **FLOATING
C13974 divbuf_3/a_28292_170# vdd 1.09fF **FLOATING
C13975 divbuf_3/a_27802_170# vdd 1.09fF **FLOATING
C13976 divbuf_3/a_27322_170# vdd 1.09fF **FLOATING
C13977 divbuf_3/a_26832_170# vdd 1.09fF **FLOATING
C13978 divbuf_3/a_26352_170# vdd 1.09fF **FLOATING
C13979 divbuf_3/a_25862_170# vdd 1.07fF **FLOATING
C13980 divbuf_3/a_25382_170# vdd 1.09fF **FLOATING
C13981 divbuf_3/a_24892_170# vdd 1.09fF **FLOATING
C13982 divbuf_3/a_24412_170# vdd 1.09fF **FLOATING
C13983 divbuf_3/a_23922_170# vdd 1.09fF **FLOATING
C13984 divbuf_3/a_23442_170# vdd 1.09fF **FLOATING
C13985 divbuf_3/a_22952_170# vdd 1.09fF **FLOATING
C13986 divbuf_3/a_22472_170# vdd 1.07fF **FLOATING
C13987 divbuf_3/a_21982_170# vdd 1.09fF **FLOATING
C13988 divbuf_3/a_21502_170# vdd 1.09fF **FLOATING
C13989 divbuf_3/a_21012_170# vdd 1.09fF **FLOATING
C13990 divbuf_3/a_20532_170# vdd 1.09fF **FLOATING
C13991 divbuf_3/a_20042_170# vdd 1.09fF **FLOATING
C13992 divbuf_3/a_19562_170# vdd 1.09fF **FLOATING
C13993 divbuf_3/a_19072_170# vdd 1.09fF **FLOATING
C13994 divbuf_3/a_18582_170# vdd 1.07fF **FLOATING
C13995 divbuf_3/a_18092_170# vdd 1.09fF **FLOATING
C13996 divbuf_3/a_17612_170# vdd 1.09fF **FLOATING
C13997 divbuf_3/a_17122_170# vdd 1.09fF **FLOATING
C13998 divbuf_3/a_16642_170# vdd 1.09fF **FLOATING
C13999 divbuf_3/a_16152_170# vdd 1.09fF **FLOATING
C14000 divbuf_3/a_15672_170# vdd 1.09fF **FLOATING
C14001 divbuf_3/a_15182_170# vdd 1.09fF **FLOATING
C14002 divbuf_3/a_14702_170# vdd 1.10fF **FLOATING
C14003 divbuf_3/a_14222_170# vdd 1.10fF **FLOATING
C14004 divbuf_3/a_13742_170# vdd 1.09fF **FLOATING
C14005 divbuf_3/a_13252_170# vdd 1.09fF **FLOATING
C14006 divbuf_3/a_12772_170# vdd 1.07fF **FLOATING
C14007 divbuf_3/a_12282_170# vdd 1.09fF **FLOATING
C14008 divbuf_3/a_11802_170# vdd 1.09fF **FLOATING
C14009 divbuf_3/a_11312_170# vdd 1.10fF **FLOATING
C14010 divbuf_3/a_10212_170# vdd 1.09fF **FLOATING
C14011 divbuf_3/a_9732_170# vdd 1.09fF **FLOATING
C14012 divbuf_3/a_9242_170# vdd 1.09fF **FLOATING
C14013 divbuf_3/a_8762_170# vdd 1.09fF **FLOATING
C14014 divbuf_3/a_8272_170# vdd 1.07fF **FLOATING
C14015 divbuf_3/a_7792_170# vdd 1.09fF **FLOATING
C14016 divbuf_3/a_7302_170# vdd 1.09fF **FLOATING
C14017 divbuf_3/a_6822_170# vdd 1.09fF **FLOATING
C14018 divbuf_3/a_6332_170# vdd 1.09fF **FLOATING
C14019 divbuf_3/a_5852_170# vdd 1.09fF **FLOATING
C14020 divbuf_3/a_5362_170# vdd 1.09fF **FLOATING
C14021 divbuf_3/a_4882_170# vdd 1.09fF **FLOATING
C14022 divbuf_3/a_4392_170# vdd 1.07fF **FLOATING
C14023 divbuf_3/a_3912_170# vdd 1.09fF **FLOATING
C14024 divbuf_3/a_3422_170# vdd 1.10fF **FLOATING
C14025 divbuf_3/a_2322_170# vdd 1.09fF **FLOATING
C14026 divbuf_3/a_1842_170# vdd 1.09fF **FLOATING
C14027 divbuf_3/a_1352_170# vdd 1.10fF **FLOATING
C14028 divbuf_3/a_492_n240# vdd 2.46fF **FLOATING
C14029 divbuf_2/OUT vdd 3.28fF
C14030 divbuf_2/OUT5 vdd 16.40fF
C14031 divbuf_2/OUT4 vdd 100.06fF
C14032 divbuf_2/OUT3 vdd 27.01fF
C14033 divbuf_2/OUT2 vdd 8.71fF
C14034 divbuf_2/IN vdd 0.89fF
C14035 divbuf_2/a_60990_n1540# vdd 1.57fF **FLOATING
C14036 divbuf_2/a_60510_n1540# vdd 1.62fF **FLOATING
C14037 divbuf_2/a_60030_n1540# vdd 1.62fF **FLOATING
C14038 divbuf_2/a_59550_n1540# vdd 1.62fF **FLOATING
C14039 divbuf_2/a_59070_n1540# vdd 1.62fF **FLOATING
C14040 divbuf_2/a_58590_n1540# vdd 1.62fF **FLOATING
C14041 divbuf_2/a_58110_n1540# vdd 1.62fF **FLOATING
C14042 divbuf_2/a_57630_n1540# vdd 1.62fF **FLOATING
C14043 divbuf_2/a_57150_n1540# vdd 1.62fF **FLOATING
C14044 divbuf_2/a_56670_n1540# vdd 1.62fF **FLOATING
C14045 divbuf_2/a_56190_n1540# vdd 1.62fF **FLOATING
C14046 divbuf_2/a_55710_n1540# vdd 1.62fF **FLOATING
C14047 divbuf_2/a_55230_n1540# vdd 1.62fF **FLOATING
C14048 divbuf_2/a_54750_n1540# vdd 1.62fF **FLOATING
C14049 divbuf_2/a_54270_n1540# vdd 1.62fF **FLOATING
C14050 divbuf_2/a_53790_n1540# vdd 1.62fF **FLOATING
C14051 divbuf_2/a_53310_n1540# vdd 1.62fF **FLOATING
C14052 divbuf_2/a_52830_n1540# vdd 1.62fF **FLOATING
C14053 divbuf_2/a_52350_n1540# vdd 1.62fF **FLOATING
C14054 divbuf_2/a_51870_n1540# vdd 1.62fF **FLOATING
C14055 divbuf_2/a_51390_n1540# vdd 1.62fF **FLOATING
C14056 divbuf_2/a_50910_n1540# vdd 1.62fF **FLOATING
C14057 divbuf_2/a_50430_n1540# vdd 1.62fF **FLOATING
C14058 divbuf_2/a_49950_n1540# vdd 1.62fF **FLOATING
C14059 divbuf_2/a_49470_n1540# vdd 1.62fF **FLOATING
C14060 divbuf_2/a_48990_n1540# vdd 1.62fF **FLOATING
C14061 divbuf_2/a_48510_n1540# vdd 1.62fF **FLOATING
C14062 divbuf_2/a_48030_n1540# vdd 1.62fF **FLOATING
C14063 divbuf_2/a_47550_n1540# vdd 1.62fF **FLOATING
C14064 divbuf_2/a_47070_n1540# vdd 1.62fF **FLOATING
C14065 divbuf_2/a_46590_n1540# vdd 1.62fF **FLOATING
C14066 divbuf_2/a_46110_n1540# vdd 1.62fF **FLOATING
C14067 divbuf_2/a_45630_n1540# vdd 1.62fF **FLOATING
C14068 divbuf_2/a_45150_n1540# vdd 1.62fF **FLOATING
C14069 divbuf_2/a_44670_n1540# vdd 1.62fF **FLOATING
C14070 divbuf_2/a_44190_n1540# vdd 1.62fF **FLOATING
C14071 divbuf_2/a_43710_n1540# vdd 1.62fF **FLOATING
C14072 divbuf_2/a_43230_n1540# vdd 1.62fF **FLOATING
C14073 divbuf_2/a_42750_n1540# vdd 1.62fF **FLOATING
C14074 divbuf_2/a_42270_n1540# vdd 1.62fF **FLOATING
C14075 divbuf_2/a_41790_n1540# vdd 1.62fF **FLOATING
C14076 divbuf_2/a_41310_n1540# vdd 1.62fF **FLOATING
C14077 divbuf_2/a_40830_n1540# vdd 1.62fF **FLOATING
C14078 divbuf_2/a_40350_n1540# vdd 1.62fF **FLOATING
C14079 divbuf_2/a_39870_n1540# vdd 1.62fF **FLOATING
C14080 divbuf_2/a_39390_n1540# vdd 1.62fF **FLOATING
C14081 divbuf_2/a_38910_n1540# vdd 1.62fF **FLOATING
C14082 divbuf_2/a_38430_n1540# vdd 1.62fF **FLOATING
C14083 divbuf_2/a_37950_n1540# vdd 1.62fF **FLOATING
C14084 divbuf_2/a_37470_n1540# vdd 1.62fF **FLOATING
C14085 divbuf_2/a_36990_n1540# vdd 1.62fF **FLOATING
C14086 divbuf_2/a_36510_n1540# vdd 1.62fF **FLOATING
C14087 divbuf_2/a_36030_n1540# vdd 1.62fF **FLOATING
C14088 divbuf_2/a_35550_n1540# vdd 1.62fF **FLOATING
C14089 divbuf_2/a_35070_n1540# vdd 1.62fF **FLOATING
C14090 divbuf_2/a_34590_n1540# vdd 1.62fF **FLOATING
C14091 divbuf_2/a_34110_n1540# vdd 1.62fF **FLOATING
C14092 divbuf_2/a_33630_n1540# vdd 1.62fF **FLOATING
C14093 divbuf_2/a_33150_n1540# vdd 1.62fF **FLOATING
C14094 divbuf_2/a_32670_n1540# vdd 1.62fF **FLOATING
C14095 divbuf_2/a_32190_n1540# vdd 1.62fF **FLOATING
C14096 divbuf_2/a_31710_n1540# vdd 1.62fF **FLOATING
C14097 divbuf_2/a_31230_n1540# vdd 1.62fF **FLOATING
C14098 divbuf_2/a_30750_n1540# vdd 1.62fF **FLOATING
C14099 divbuf_2/a_30270_n1540# vdd 1.62fF **FLOATING
C14100 divbuf_2/a_29790_n1540# vdd 1.62fF **FLOATING
C14101 divbuf_2/a_29310_n1540# vdd 1.62fF **FLOATING
C14102 divbuf_2/a_28830_n1540# vdd 1.62fF **FLOATING
C14103 divbuf_2/a_28350_n1540# vdd 1.62fF **FLOATING
C14104 divbuf_2/a_27870_n1540# vdd 1.62fF **FLOATING
C14105 divbuf_2/a_27390_n1540# vdd 1.62fF **FLOATING
C14106 divbuf_2/a_26910_n1540# vdd 1.62fF **FLOATING
C14107 divbuf_2/a_26430_n1540# vdd 1.62fF **FLOATING
C14108 divbuf_2/a_25950_n1540# vdd 1.62fF **FLOATING
C14109 divbuf_2/a_25470_n1540# vdd 1.62fF **FLOATING
C14110 divbuf_2/a_24990_n1540# vdd 1.62fF **FLOATING
C14111 divbuf_2/a_24510_n1540# vdd 1.62fF **FLOATING
C14112 divbuf_2/a_24030_n1540# vdd 1.62fF **FLOATING
C14113 divbuf_2/a_23550_n1540# vdd 1.62fF **FLOATING
C14114 divbuf_2/a_23070_n1540# vdd 1.62fF **FLOATING
C14115 divbuf_2/a_22590_n1540# vdd 1.62fF **FLOATING
C14116 divbuf_2/a_22110_n1540# vdd 1.62fF **FLOATING
C14117 divbuf_2/a_21630_n1540# vdd 1.62fF **FLOATING
C14118 divbuf_2/a_21150_n1540# vdd 1.62fF **FLOATING
C14119 divbuf_2/a_20670_n1540# vdd 1.62fF **FLOATING
C14120 divbuf_2/a_20190_n1540# vdd 1.62fF **FLOATING
C14121 divbuf_2/a_19710_n1540# vdd 1.62fF **FLOATING
C14122 divbuf_2/a_19230_n1540# vdd 1.62fF **FLOATING
C14123 divbuf_2/a_18750_n1540# vdd 1.62fF **FLOATING
C14124 divbuf_2/a_18270_n1540# vdd 1.62fF **FLOATING
C14125 divbuf_2/a_17790_n1540# vdd 1.62fF **FLOATING
C14126 divbuf_2/a_17310_n1540# vdd 1.62fF **FLOATING
C14127 divbuf_2/a_16830_n1540# vdd 1.62fF **FLOATING
C14128 divbuf_2/a_16350_n1540# vdd 1.62fF **FLOATING
C14129 divbuf_2/a_15870_n1540# vdd 1.62fF **FLOATING
C14130 divbuf_2/a_15390_n1540# vdd 1.62fF **FLOATING
C14131 divbuf_2/a_14910_n1540# vdd 1.62fF **FLOATING
C14132 divbuf_2/a_14430_n1540# vdd 1.62fF **FLOATING
C14133 divbuf_2/a_13950_n1540# vdd 1.62fF **FLOATING
C14134 divbuf_2/a_13470_n1540# vdd 1.62fF **FLOATING
C14135 divbuf_2/a_12990_n1540# vdd 1.62fF **FLOATING
C14136 divbuf_2/a_12510_n1540# vdd 1.62fF **FLOATING
C14137 divbuf_2/a_12030_n1540# vdd 1.62fF **FLOATING
C14138 divbuf_2/a_11550_n1540# vdd 1.62fF **FLOATING
C14139 divbuf_2/a_11070_n1540# vdd 1.62fF **FLOATING
C14140 divbuf_2/a_10590_n1540# vdd 1.62fF **FLOATING
C14141 divbuf_2/a_10110_n1540# vdd 1.62fF **FLOATING
C14142 divbuf_2/a_9630_n1540# vdd 1.62fF **FLOATING
C14143 divbuf_2/a_9150_n1540# vdd 1.62fF **FLOATING
C14144 divbuf_2/a_8670_n1540# vdd 1.62fF **FLOATING
C14145 divbuf_2/a_8190_n1540# vdd 1.62fF **FLOATING
C14146 divbuf_2/a_7710_n1540# vdd 1.62fF **FLOATING
C14147 divbuf_2/a_7230_n1540# vdd 1.62fF **FLOATING
C14148 divbuf_2/a_6750_n1540# vdd 1.62fF **FLOATING
C14149 divbuf_2/a_6270_n1540# vdd 1.62fF **FLOATING
C14150 divbuf_2/a_5790_n1540# vdd 1.62fF **FLOATING
C14151 divbuf_2/a_5310_n1540# vdd 1.62fF **FLOATING
C14152 divbuf_2/a_4830_n1540# vdd 1.62fF **FLOATING
C14153 divbuf_2/a_4350_n1540# vdd 1.62fF **FLOATING
C14154 divbuf_2/a_3870_n1540# vdd 1.62fF **FLOATING
C14155 divbuf_2/a_3390_n1540# vdd 1.62fF **FLOATING
C14156 divbuf_2/a_2910_n1540# vdd 1.62fF **FLOATING
C14157 divbuf_2/a_2430_n1540# vdd 1.62fF **FLOATING
C14158 divbuf_2/a_1950_n1540# vdd 1.62fF **FLOATING
C14159 divbuf_2/a_1470_n1540# vdd 1.62fF **FLOATING
C14160 divbuf_2/a_990_n1540# vdd 1.62fF **FLOATING
C14161 divbuf_2/a_510_n1540# vdd 1.62fF **FLOATING
C14162 divbuf_2/a_60990_n840# vdd 1.06fF **FLOATING
C14163 divbuf_2/a_60510_n840# vdd 1.09fF **FLOATING
C14164 divbuf_2/a_60030_n840# vdd 1.09fF **FLOATING
C14165 divbuf_2/a_59550_n840# vdd 1.09fF **FLOATING
C14166 divbuf_2/a_59070_n840# vdd 1.09fF **FLOATING
C14167 divbuf_2/a_58590_n840# vdd 1.09fF **FLOATING
C14168 divbuf_2/a_58110_n840# vdd 1.09fF **FLOATING
C14169 divbuf_2/a_57630_n840# vdd 1.09fF **FLOATING
C14170 divbuf_2/a_57150_n840# vdd 1.09fF **FLOATING
C14171 divbuf_2/a_56670_n840# vdd 1.09fF **FLOATING
C14172 divbuf_2/a_56190_n840# vdd 1.09fF **FLOATING
C14173 divbuf_2/a_55710_n840# vdd 1.09fF **FLOATING
C14174 divbuf_2/a_55230_n840# vdd 1.09fF **FLOATING
C14175 divbuf_2/a_54750_n840# vdd 1.09fF **FLOATING
C14176 divbuf_2/a_54270_n840# vdd 1.09fF **FLOATING
C14177 divbuf_2/a_53790_n840# vdd 1.09fF **FLOATING
C14178 divbuf_2/a_53310_n840# vdd 1.09fF **FLOATING
C14179 divbuf_2/a_52830_n840# vdd 1.09fF **FLOATING
C14180 divbuf_2/a_52350_n840# vdd 1.09fF **FLOATING
C14181 divbuf_2/a_51870_n840# vdd 1.09fF **FLOATING
C14182 divbuf_2/a_51390_n840# vdd 1.09fF **FLOATING
C14183 divbuf_2/a_50910_n840# vdd 1.09fF **FLOATING
C14184 divbuf_2/a_50430_n840# vdd 1.09fF **FLOATING
C14185 divbuf_2/a_49950_n840# vdd 1.09fF **FLOATING
C14186 divbuf_2/a_49470_n840# vdd 1.09fF **FLOATING
C14187 divbuf_2/a_48990_n840# vdd 1.09fF **FLOATING
C14188 divbuf_2/a_48510_n840# vdd 1.09fF **FLOATING
C14189 divbuf_2/a_48030_n840# vdd 1.09fF **FLOATING
C14190 divbuf_2/a_47550_n840# vdd 1.09fF **FLOATING
C14191 divbuf_2/a_47070_n840# vdd 1.09fF **FLOATING
C14192 divbuf_2/a_46590_n840# vdd 1.09fF **FLOATING
C14193 divbuf_2/a_46110_n840# vdd 1.09fF **FLOATING
C14194 divbuf_2/a_45630_n840# vdd 1.09fF **FLOATING
C14195 divbuf_2/a_45150_n840# vdd 1.09fF **FLOATING
C14196 divbuf_2/a_44670_n840# vdd 1.09fF **FLOATING
C14197 divbuf_2/a_44190_n840# vdd 1.09fF **FLOATING
C14198 divbuf_2/a_43710_n840# vdd 1.09fF **FLOATING
C14199 divbuf_2/a_43230_n840# vdd 1.09fF **FLOATING
C14200 divbuf_2/a_42750_n840# vdd 1.08fF **FLOATING
C14201 divbuf_2/a_42270_n840# vdd 1.08fF **FLOATING
C14202 divbuf_2/a_41790_n840# vdd 1.10fF **FLOATING
C14203 divbuf_2/a_41310_n840# vdd 1.09fF **FLOATING
C14204 divbuf_2/a_40830_n840# vdd 1.09fF **FLOATING
C14205 divbuf_2/a_40350_n840# vdd 1.09fF **FLOATING
C14206 divbuf_2/a_39870_n840# vdd 1.09fF **FLOATING
C14207 divbuf_2/a_39390_n840# vdd 1.09fF **FLOATING
C14208 divbuf_2/a_38910_n840# vdd 1.09fF **FLOATING
C14209 divbuf_2/a_38430_n840# vdd 1.09fF **FLOATING
C14210 divbuf_2/a_37950_n840# vdd 1.09fF **FLOATING
C14211 divbuf_2/a_37470_n840# vdd 1.09fF **FLOATING
C14212 divbuf_2/a_36990_n840# vdd 1.09fF **FLOATING
C14213 divbuf_2/a_36510_n840# vdd 1.09fF **FLOATING
C14214 divbuf_2/a_36030_n840# vdd 1.09fF **FLOATING
C14215 divbuf_2/a_35550_n840# vdd 1.09fF **FLOATING
C14216 divbuf_2/a_35070_n840# vdd 1.09fF **FLOATING
C14217 divbuf_2/a_34590_n840# vdd 1.09fF **FLOATING
C14218 divbuf_2/a_34110_n840# vdd 1.09fF **FLOATING
C14219 divbuf_2/a_33630_n840# vdd 1.09fF **FLOATING
C14220 divbuf_2/a_33150_n840# vdd 1.09fF **FLOATING
C14221 divbuf_2/a_32670_n840# vdd 1.09fF **FLOATING
C14222 divbuf_2/a_32190_n840# vdd 1.09fF **FLOATING
C14223 divbuf_2/a_31710_n840# vdd 1.11fF **FLOATING
C14224 divbuf_2/a_31230_n840# vdd 1.13fF **FLOATING
C14225 divbuf_2/a_30750_n840# vdd 1.09fF **FLOATING
C14226 divbuf_2/a_30270_n840# vdd 1.09fF **FLOATING
C14227 divbuf_2/a_29790_n840# vdd 1.09fF **FLOATING
C14228 divbuf_2/a_29310_n840# vdd 1.09fF **FLOATING
C14229 divbuf_2/a_28830_n840# vdd 1.09fF **FLOATING
C14230 divbuf_2/a_28350_n840# vdd 1.09fF **FLOATING
C14231 divbuf_2/a_27870_n840# vdd 1.08fF **FLOATING
C14232 divbuf_2/a_27390_n840# vdd 1.11fF **FLOATING
C14233 divbuf_2/a_26910_n840# vdd 1.10fF **FLOATING
C14234 divbuf_2/a_26430_n840# vdd 1.10fF **FLOATING
C14235 divbuf_2/a_25950_n840# vdd 1.10fF **FLOATING
C14236 divbuf_2/a_25470_n840# vdd 1.10fF **FLOATING
C14237 divbuf_2/a_24990_n840# vdd 1.10fF **FLOATING
C14238 divbuf_2/a_24510_n840# vdd 1.10fF **FLOATING
C14239 divbuf_2/a_24030_n840# vdd 1.09fF **FLOATING
C14240 divbuf_2/a_23550_n840# vdd 1.11fF **FLOATING
C14241 divbuf_2/a_23070_n840# vdd 1.10fF **FLOATING
C14242 divbuf_2/a_22590_n840# vdd 1.10fF **FLOATING
C14243 divbuf_2/a_22110_n840# vdd 1.10fF **FLOATING
C14244 divbuf_2/a_21630_n840# vdd 1.10fF **FLOATING
C14245 divbuf_2/a_21150_n840# vdd 1.10fF **FLOATING
C14246 divbuf_2/a_20670_n840# vdd 1.10fF **FLOATING
C14247 divbuf_2/a_20190_n840# vdd 1.09fF **FLOATING
C14248 divbuf_2/a_19710_n840# vdd 1.09fF **FLOATING
C14249 divbuf_2/a_19230_n840# vdd 1.09fF **FLOATING
C14250 divbuf_2/a_18750_n840# vdd 1.09fF **FLOATING
C14251 divbuf_2/a_18270_n840# vdd 1.08fF **FLOATING
C14252 divbuf_2/a_17790_n840# vdd 1.08fF **FLOATING
C14253 divbuf_2/a_17310_n840# vdd 1.07fF **FLOATING
C14254 divbuf_2/a_16830_n840# vdd 1.07fF **FLOATING
C14255 divbuf_2/a_16350_n840# vdd 1.07fF **FLOATING
C14256 divbuf_2/a_15870_n840# vdd 1.07fF **FLOATING
C14257 divbuf_2/a_15390_n840# vdd 1.08fF **FLOATING
C14258 divbuf_2/a_14910_n840# vdd 1.07fF **FLOATING
C14259 divbuf_2/a_14430_n840# vdd 1.07fF **FLOATING
C14260 divbuf_2/a_13950_n840# vdd 1.07fF **FLOATING
C14261 divbuf_2/a_13470_n840# vdd 1.07fF **FLOATING
C14262 divbuf_2/a_12990_n840# vdd 1.10fF **FLOATING
C14263 divbuf_2/a_12510_n840# vdd 1.08fF **FLOATING
C14264 divbuf_2/a_12030_n840# vdd 1.07fF **FLOATING
C14265 divbuf_2/a_11550_n840# vdd 1.07fF **FLOATING
C14266 divbuf_2/a_11070_n840# vdd 1.08fF **FLOATING
C14267 divbuf_2/a_10590_n840# vdd 1.10fF **FLOATING
C14268 divbuf_2/a_10110_n840# vdd 1.10fF **FLOATING
C14269 divbuf_2/a_9630_n840# vdd 1.10fF **FLOATING
C14270 divbuf_2/a_9150_n840# vdd 1.10fF **FLOATING
C14271 divbuf_2/a_8670_n840# vdd 1.10fF **FLOATING
C14272 divbuf_2/a_8190_n840# vdd 1.12fF **FLOATING
C14273 divbuf_2/a_7710_n840# vdd 1.10fF **FLOATING
C14274 divbuf_2/a_7230_n840# vdd 1.09fF **FLOATING
C14275 divbuf_2/a_6750_n840# vdd 1.09fF **FLOATING
C14276 divbuf_2/a_6270_n840# vdd 1.09fF **FLOATING
C14277 divbuf_2/a_5790_n840# vdd 1.09fF **FLOATING
C14278 divbuf_2/a_5310_n840# vdd 1.09fF **FLOATING
C14279 divbuf_2/a_4830_n840# vdd 1.09fF **FLOATING
C14280 divbuf_2/a_4350_n840# vdd 1.09fF **FLOATING
C14281 divbuf_2/a_3870_n840# vdd 1.09fF **FLOATING
C14282 divbuf_2/a_3390_n840# vdd 1.09fF **FLOATING
C14283 divbuf_2/a_2910_n840# vdd 1.10fF **FLOATING
C14284 divbuf_2/a_2430_n840# vdd 1.10fF **FLOATING
C14285 divbuf_2/a_1950_n840# vdd 1.10fF **FLOATING
C14286 divbuf_2/a_1470_n840# vdd 1.10fF **FLOATING
C14287 divbuf_2/a_990_n840# vdd 1.08fF **FLOATING
C14288 divbuf_2/a_510_n840# vdd 1.07fF **FLOATING
C14289 divbuf_2/a_60480_n1600# vdd 1.48fF **FLOATING
C14290 divbuf_2/a_60000_n1600# vdd 1.48fF **FLOATING
C14291 divbuf_2/a_59520_n1600# vdd 1.48fF **FLOATING
C14292 divbuf_2/a_59040_n1600# vdd 1.48fF **FLOATING
C14293 divbuf_2/a_58560_n1600# vdd 1.48fF **FLOATING
C14294 divbuf_2/a_58080_n1600# vdd 1.48fF **FLOATING
C14295 divbuf_2/a_57600_n1600# vdd 1.48fF **FLOATING
C14296 divbuf_2/a_57120_n1600# vdd 1.48fF **FLOATING
C14297 divbuf_2/a_56640_n1600# vdd 1.48fF **FLOATING
C14298 divbuf_2/a_56160_n1600# vdd 1.48fF **FLOATING
C14299 divbuf_2/a_55680_n1600# vdd 1.48fF **FLOATING
C14300 divbuf_2/a_55200_n1600# vdd 1.48fF **FLOATING
C14301 divbuf_2/a_54720_n1600# vdd 1.48fF **FLOATING
C14302 divbuf_2/a_54240_n1600# vdd 1.48fF **FLOATING
C14303 divbuf_2/a_53760_n1600# vdd 1.48fF **FLOATING
C14304 divbuf_2/a_53280_n1600# vdd 1.48fF **FLOATING
C14305 divbuf_2/a_52800_n1600# vdd 1.48fF **FLOATING
C14306 divbuf_2/a_52320_n1600# vdd 1.48fF **FLOATING
C14307 divbuf_2/a_51840_n1600# vdd 1.48fF **FLOATING
C14308 divbuf_2/a_51360_n1600# vdd 1.48fF **FLOATING
C14309 divbuf_2/a_50880_n1600# vdd 1.48fF **FLOATING
C14310 divbuf_2/a_50400_n1600# vdd 1.48fF **FLOATING
C14311 divbuf_2/a_49920_n1600# vdd 1.48fF **FLOATING
C14312 divbuf_2/a_49440_n1600# vdd 1.48fF **FLOATING
C14313 divbuf_2/a_48960_n1600# vdd 1.48fF **FLOATING
C14314 divbuf_2/a_48480_n1600# vdd 1.48fF **FLOATING
C14315 divbuf_2/a_48000_n1600# vdd 1.48fF **FLOATING
C14316 divbuf_2/a_47520_n1600# vdd 1.48fF **FLOATING
C14317 divbuf_2/a_47040_n1600# vdd 1.48fF **FLOATING
C14318 divbuf_2/a_46560_n1600# vdd 1.48fF **FLOATING
C14319 divbuf_2/a_46080_n1600# vdd 1.48fF **FLOATING
C14320 divbuf_2/a_45600_n1600# vdd 1.48fF **FLOATING
C14321 divbuf_2/a_45120_n1600# vdd 1.48fF **FLOATING
C14322 divbuf_2/a_44640_n1600# vdd 1.48fF **FLOATING
C14323 divbuf_2/a_44160_n1600# vdd 1.48fF **FLOATING
C14324 divbuf_2/a_43680_n1600# vdd 1.48fF **FLOATING
C14325 divbuf_2/a_43200_n1600# vdd 1.48fF **FLOATING
C14326 divbuf_2/a_42720_n1600# vdd 1.48fF **FLOATING
C14327 divbuf_2/a_42240_n1600# vdd 1.48fF **FLOATING
C14328 divbuf_2/a_41760_n1600# vdd 1.48fF **FLOATING
C14329 divbuf_2/a_41280_n1600# vdd 1.48fF **FLOATING
C14330 divbuf_2/a_40800_n1600# vdd 1.48fF **FLOATING
C14331 divbuf_2/a_40320_n1600# vdd 1.48fF **FLOATING
C14332 divbuf_2/a_39840_n1600# vdd 1.48fF **FLOATING
C14333 divbuf_2/a_39360_n1600# vdd 1.48fF **FLOATING
C14334 divbuf_2/a_38880_n1600# vdd 1.48fF **FLOATING
C14335 divbuf_2/a_38400_n1600# vdd 1.48fF **FLOATING
C14336 divbuf_2/a_37920_n1600# vdd 1.48fF **FLOATING
C14337 divbuf_2/a_37440_n1600# vdd 1.48fF **FLOATING
C14338 divbuf_2/a_36960_n1600# vdd 1.48fF **FLOATING
C14339 divbuf_2/a_36480_n1600# vdd 1.48fF **FLOATING
C14340 divbuf_2/a_36000_n1600# vdd 1.48fF **FLOATING
C14341 divbuf_2/a_35520_n1600# vdd 1.48fF **FLOATING
C14342 divbuf_2/a_35040_n1600# vdd 1.48fF **FLOATING
C14343 divbuf_2/a_34560_n1600# vdd 1.48fF **FLOATING
C14344 divbuf_2/a_34080_n1600# vdd 1.48fF **FLOATING
C14345 divbuf_2/a_33600_n1600# vdd 1.48fF **FLOATING
C14346 divbuf_2/a_33120_n1600# vdd 1.48fF **FLOATING
C14347 divbuf_2/a_32640_n1600# vdd 1.48fF **FLOATING
C14348 divbuf_2/a_32160_n1600# vdd 1.48fF **FLOATING
C14349 divbuf_2/a_31680_n1600# vdd 1.48fF **FLOATING
C14350 divbuf_2/a_31200_n1600# vdd 1.48fF **FLOATING
C14351 divbuf_2/a_30720_n1600# vdd 1.48fF **FLOATING
C14352 divbuf_2/a_30240_n1600# vdd 1.48fF **FLOATING
C14353 divbuf_2/a_29760_n1600# vdd 1.48fF **FLOATING
C14354 divbuf_2/a_29280_n1600# vdd 1.48fF **FLOATING
C14355 divbuf_2/a_28800_n1600# vdd 1.48fF **FLOATING
C14356 divbuf_2/a_28320_n1600# vdd 1.48fF **FLOATING
C14357 divbuf_2/a_27840_n1600# vdd 1.48fF **FLOATING
C14358 divbuf_2/a_27360_n1600# vdd 1.48fF **FLOATING
C14359 divbuf_2/a_26880_n1600# vdd 1.48fF **FLOATING
C14360 divbuf_2/a_26400_n1600# vdd 1.48fF **FLOATING
C14361 divbuf_2/a_25920_n1600# vdd 1.48fF **FLOATING
C14362 divbuf_2/a_25440_n1600# vdd 1.48fF **FLOATING
C14363 divbuf_2/a_24960_n1600# vdd 1.48fF **FLOATING
C14364 divbuf_2/a_24480_n1600# vdd 1.48fF **FLOATING
C14365 divbuf_2/a_24000_n1600# vdd 1.48fF **FLOATING
C14366 divbuf_2/a_23520_n1600# vdd 1.48fF **FLOATING
C14367 divbuf_2/a_23040_n1600# vdd 1.48fF **FLOATING
C14368 divbuf_2/a_22560_n1600# vdd 1.48fF **FLOATING
C14369 divbuf_2/a_22080_n1600# vdd 1.48fF **FLOATING
C14370 divbuf_2/a_21600_n1600# vdd 1.48fF **FLOATING
C14371 divbuf_2/a_21120_n1600# vdd 1.48fF **FLOATING
C14372 divbuf_2/a_20640_n1600# vdd 1.48fF **FLOATING
C14373 divbuf_2/a_20160_n1600# vdd 1.48fF **FLOATING
C14374 divbuf_2/a_19680_n1600# vdd 1.48fF **FLOATING
C14375 divbuf_2/a_19200_n1600# vdd 1.48fF **FLOATING
C14376 divbuf_2/a_18720_n1600# vdd 1.48fF **FLOATING
C14377 divbuf_2/a_18240_n1600# vdd 1.48fF **FLOATING
C14378 divbuf_2/a_17760_n1600# vdd 1.48fF **FLOATING
C14379 divbuf_2/a_17280_n1600# vdd 1.48fF **FLOATING
C14380 divbuf_2/a_16800_n1600# vdd 1.48fF **FLOATING
C14381 divbuf_2/a_16320_n1600# vdd 1.48fF **FLOATING
C14382 divbuf_2/a_15840_n1600# vdd 1.48fF **FLOATING
C14383 divbuf_2/a_15360_n1600# vdd 1.48fF **FLOATING
C14384 divbuf_2/a_14880_n1600# vdd 1.48fF **FLOATING
C14385 divbuf_2/a_14400_n1600# vdd 1.48fF **FLOATING
C14386 divbuf_2/a_13920_n1600# vdd 1.48fF **FLOATING
C14387 divbuf_2/a_13440_n1600# vdd 1.48fF **FLOATING
C14388 divbuf_2/a_12960_n1600# vdd 1.48fF **FLOATING
C14389 divbuf_2/a_12480_n1600# vdd 1.48fF **FLOATING
C14390 divbuf_2/a_12000_n1600# vdd 1.48fF **FLOATING
C14391 divbuf_2/a_11520_n1600# vdd 1.48fF **FLOATING
C14392 divbuf_2/a_11040_n1600# vdd 1.48fF **FLOATING
C14393 divbuf_2/a_10560_n1600# vdd 1.48fF **FLOATING
C14394 divbuf_2/a_10080_n1600# vdd 1.48fF **FLOATING
C14395 divbuf_2/a_9600_n1600# vdd 1.48fF **FLOATING
C14396 divbuf_2/a_9120_n1600# vdd 1.48fF **FLOATING
C14397 divbuf_2/a_8640_n1600# vdd 1.48fF **FLOATING
C14398 divbuf_2/a_8160_n1600# vdd 1.48fF **FLOATING
C14399 divbuf_2/a_7680_n1600# vdd 1.48fF **FLOATING
C14400 divbuf_2/a_7200_n1600# vdd 1.48fF **FLOATING
C14401 divbuf_2/a_6720_n1600# vdd 1.48fF **FLOATING
C14402 divbuf_2/a_6240_n1600# vdd 1.48fF **FLOATING
C14403 divbuf_2/a_5760_n1600# vdd 1.48fF **FLOATING
C14404 divbuf_2/a_5280_n1600# vdd 1.48fF **FLOATING
C14405 divbuf_2/a_4800_n1600# vdd 1.48fF **FLOATING
C14406 divbuf_2/a_4320_n1600# vdd 1.48fF **FLOATING
C14407 divbuf_2/a_3840_n1600# vdd 1.48fF **FLOATING
C14408 divbuf_2/a_3360_n1600# vdd 1.48fF **FLOATING
C14409 divbuf_2/a_2880_n1600# vdd 1.48fF **FLOATING
C14410 divbuf_2/a_2400_n1600# vdd 1.48fF **FLOATING
C14411 divbuf_2/a_1920_n1600# vdd 1.48fF **FLOATING
C14412 divbuf_2/a_1440_n1600# vdd 1.48fF **FLOATING
C14413 divbuf_2/a_960_n1600# vdd 1.48fF **FLOATING
C14414 divbuf_2/a_480_n1600# vdd 1.48fF **FLOATING
C14415 divbuf_2/a_0_n1600# vdd 1.48fF **FLOATING
C14416 divbuf_2/a_41382_n240# vdd 0.90fF **FLOATING
C14417 divbuf_2/a_40902_n240# vdd 0.90fF **FLOATING
C14418 divbuf_2/a_40412_n240# vdd 0.90fF **FLOATING
C14419 divbuf_2/a_39932_n240# vdd 0.90fF **FLOATING
C14420 divbuf_2/a_39442_n240# vdd 0.90fF **FLOATING
C14421 divbuf_2/a_38962_n240# vdd 0.91fF **FLOATING
C14422 divbuf_2/a_38472_n240# vdd 0.90fF **FLOATING
C14423 divbuf_2/a_37992_n240# vdd 0.90fF **FLOATING
C14424 divbuf_2/a_37502_n240# vdd 0.90fF **FLOATING
C14425 divbuf_2/a_37022_n240# vdd 0.90fF **FLOATING
C14426 divbuf_2/a_36532_n240# vdd 0.90fF **FLOATING
C14427 divbuf_2/a_36052_n240# vdd 0.90fF **FLOATING
C14428 divbuf_2/a_35562_n240# vdd 0.90fF **FLOATING
C14429 divbuf_2/a_35082_n240# vdd 0.91fF **FLOATING
C14430 divbuf_2/a_34592_n240# vdd 0.90fF **FLOATING
C14431 divbuf_2/a_34112_n240# vdd 0.90fF **FLOATING
C14432 divbuf_2/a_33622_n240# vdd 0.90fF **FLOATING
C14433 divbuf_2/a_33142_n240# vdd 0.90fF **FLOATING
C14434 divbuf_2/a_32652_n240# vdd 0.90fF **FLOATING
C14435 divbuf_2/a_32172_n240# vdd 0.90fF **FLOATING
C14436 divbuf_2/a_31682_n240# vdd 0.89fF **FLOATING
C14437 divbuf_2/a_31202_n240# vdd 0.92fF **FLOATING
C14438 divbuf_2/a_30712_n240# vdd 0.90fF **FLOATING
C14439 divbuf_2/a_30232_n240# vdd 0.90fF **FLOATING
C14440 divbuf_2/a_29742_n240# vdd 0.90fF **FLOATING
C14441 divbuf_2/a_29262_n240# vdd 0.90fF **FLOATING
C14442 divbuf_2/a_28772_n240# vdd 0.90fF **FLOATING
C14443 divbuf_2/a_28292_n240# vdd 0.90fF **FLOATING
C14444 divbuf_2/a_27802_n240# vdd 0.89fF **FLOATING
C14445 divbuf_2/a_27322_n240# vdd 0.95fF **FLOATING
C14446 divbuf_2/a_26832_n240# vdd 0.91fF **FLOATING
C14447 divbuf_2/a_26352_n240# vdd 0.91fF **FLOATING
C14448 divbuf_2/a_25862_n240# vdd 0.91fF **FLOATING
C14449 divbuf_2/a_25382_n240# vdd 0.91fF **FLOATING
C14450 divbuf_2/a_24892_n240# vdd 0.91fF **FLOATING
C14451 divbuf_2/a_24412_n240# vdd 0.91fF **FLOATING
C14452 divbuf_2/a_23922_n240# vdd 0.92fF **FLOATING
C14453 divbuf_2/a_23442_n240# vdd 0.94fF **FLOATING
C14454 divbuf_2/a_22952_n240# vdd 0.91fF **FLOATING
C14455 divbuf_2/a_22472_n240# vdd 0.91fF **FLOATING
C14456 divbuf_2/a_21982_n240# vdd 0.91fF **FLOATING
C14457 divbuf_2/a_21502_n240# vdd 0.91fF **FLOATING
C14458 divbuf_2/a_21012_n240# vdd 0.91fF **FLOATING
C14459 divbuf_2/a_20532_n240# vdd 0.91fF **FLOATING
C14460 divbuf_2/a_20042_n240# vdd 0.90fF **FLOATING
C14461 divbuf_2/a_19562_n240# vdd 0.90fF **FLOATING
C14462 divbuf_2/a_19072_n240# vdd 0.90fF **FLOATING
C14463 divbuf_2/a_18582_n240# vdd 0.89fF **FLOATING
C14464 divbuf_2/a_18092_n240# vdd 0.89fF **FLOATING
C14465 divbuf_2/a_17612_n240# vdd 0.89fF **FLOATING
C14466 divbuf_2/a_17122_n240# vdd 0.88fF **FLOATING
C14467 divbuf_2/a_16642_n240# vdd 0.88fF **FLOATING
C14468 divbuf_2/a_16152_n240# vdd 0.88fF **FLOATING
C14469 divbuf_2/a_15672_n240# vdd 0.90fF **FLOATING
C14470 divbuf_2/a_15182_n240# vdd 0.88fF **FLOATING
C14471 divbuf_2/a_14702_n240# vdd 0.88fF **FLOATING
C14472 divbuf_2/a_14222_n240# vdd 0.88fF **FLOATING
C14473 divbuf_2/a_13742_n240# vdd 0.88fF **FLOATING
C14474 divbuf_2/a_13252_n240# vdd 0.88fF **FLOATING
C14475 divbuf_2/a_12772_n240# vdd 0.88fF **FLOATING
C14476 divbuf_2/a_12282_n240# vdd 0.88fF **FLOATING
C14477 divbuf_2/a_11802_n240# vdd 0.88fF **FLOATING
C14478 divbuf_2/a_11312_n240# vdd 0.89fF **FLOATING
C14479 divbuf_2/a_10212_n240# vdd 0.91fF **FLOATING
C14480 divbuf_2/a_9732_n240# vdd 0.91fF **FLOATING
C14481 divbuf_2/a_9242_n240# vdd 0.91fF **FLOATING
C14482 divbuf_2/a_8762_n240# vdd 0.91fF **FLOATING
C14483 divbuf_2/a_8272_n240# vdd 0.91fF **FLOATING
C14484 divbuf_2/a_7792_n240# vdd 0.92fF **FLOATING
C14485 divbuf_2/a_7302_n240# vdd 0.90fF **FLOATING
C14486 divbuf_2/a_6822_n240# vdd 0.90fF **FLOATING
C14487 divbuf_2/a_6332_n240# vdd 0.90fF **FLOATING
C14488 divbuf_2/a_5852_n240# vdd 0.90fF **FLOATING
C14489 divbuf_2/a_5362_n240# vdd 0.90fF **FLOATING
C14490 divbuf_2/a_4882_n240# vdd 0.90fF **FLOATING
C14491 divbuf_2/a_4392_n240# vdd 0.90fF **FLOATING
C14492 divbuf_2/a_3912_n240# vdd 0.90fF **FLOATING
C14493 divbuf_2/a_3422_n240# vdd 0.90fF **FLOATING
C14494 divbuf_2/a_2322_n240# vdd 0.91fF **FLOATING
C14495 divbuf_2/a_1842_n240# vdd 0.91fF **FLOATING
C14496 divbuf_2/a_1352_n240# vdd 0.91fF **FLOATING
C14497 divbuf_2/a_41382_170# vdd 1.07fF **FLOATING
C14498 divbuf_2/a_40902_170# vdd 1.09fF **FLOATING
C14499 divbuf_2/a_40412_170# vdd 1.09fF **FLOATING
C14500 divbuf_2/a_39932_170# vdd 1.09fF **FLOATING
C14501 divbuf_2/a_39442_170# vdd 1.09fF **FLOATING
C14502 divbuf_2/a_38962_170# vdd 1.07fF **FLOATING
C14503 divbuf_2/a_38472_170# vdd 1.09fF **FLOATING
C14504 divbuf_2/a_37992_170# vdd 1.09fF **FLOATING
C14505 divbuf_2/a_37502_170# vdd 1.09fF **FLOATING
C14506 divbuf_2/a_37022_170# vdd 1.09fF **FLOATING
C14507 divbuf_2/a_36532_170# vdd 1.09fF **FLOATING
C14508 divbuf_2/a_36052_170# vdd 1.09fF **FLOATING
C14509 divbuf_2/a_35562_170# vdd 1.09fF **FLOATING
C14510 divbuf_2/a_35082_170# vdd 1.09fF **FLOATING
C14511 divbuf_2/a_34592_170# vdd 1.07fF **FLOATING
C14512 divbuf_2/a_34112_170# vdd 1.09fF **FLOATING
C14513 divbuf_2/a_33622_170# vdd 1.09fF **FLOATING
C14514 divbuf_2/a_33142_170# vdd 1.09fF **FLOATING
C14515 divbuf_2/a_32652_170# vdd 1.09fF **FLOATING
C14516 divbuf_2/a_32172_170# vdd 1.09fF **FLOATING
C14517 divbuf_2/a_31682_170# vdd 1.09fF **FLOATING
C14518 divbuf_2/a_31202_170# vdd 1.09fF **FLOATING
C14519 divbuf_2/a_30712_170# vdd 1.09fF **FLOATING
C14520 divbuf_2/a_30232_170# vdd 1.07fF **FLOATING
C14521 divbuf_2/a_29742_170# vdd 1.09fF **FLOATING
C14522 divbuf_2/a_29262_170# vdd 1.09fF **FLOATING
C14523 divbuf_2/a_28772_170# vdd 1.09fF **FLOATING
C14524 divbuf_2/a_28292_170# vdd 1.09fF **FLOATING
C14525 divbuf_2/a_27802_170# vdd 1.09fF **FLOATING
C14526 divbuf_2/a_27322_170# vdd 1.09fF **FLOATING
C14527 divbuf_2/a_26832_170# vdd 1.09fF **FLOATING
C14528 divbuf_2/a_26352_170# vdd 1.09fF **FLOATING
C14529 divbuf_2/a_25862_170# vdd 1.07fF **FLOATING
C14530 divbuf_2/a_25382_170# vdd 1.09fF **FLOATING
C14531 divbuf_2/a_24892_170# vdd 1.09fF **FLOATING
C14532 divbuf_2/a_24412_170# vdd 1.09fF **FLOATING
C14533 divbuf_2/a_23922_170# vdd 1.09fF **FLOATING
C14534 divbuf_2/a_23442_170# vdd 1.09fF **FLOATING
C14535 divbuf_2/a_22952_170# vdd 1.09fF **FLOATING
C14536 divbuf_2/a_22472_170# vdd 1.07fF **FLOATING
C14537 divbuf_2/a_21982_170# vdd 1.09fF **FLOATING
C14538 divbuf_2/a_21502_170# vdd 1.09fF **FLOATING
C14539 divbuf_2/a_21012_170# vdd 1.09fF **FLOATING
C14540 divbuf_2/a_20532_170# vdd 1.09fF **FLOATING
C14541 divbuf_2/a_20042_170# vdd 1.09fF **FLOATING
C14542 divbuf_2/a_19562_170# vdd 1.09fF **FLOATING
C14543 divbuf_2/a_19072_170# vdd 1.09fF **FLOATING
C14544 divbuf_2/a_18582_170# vdd 1.07fF **FLOATING
C14545 divbuf_2/a_18092_170# vdd 1.09fF **FLOATING
C14546 divbuf_2/a_17612_170# vdd 1.09fF **FLOATING
C14547 divbuf_2/a_17122_170# vdd 1.09fF **FLOATING
C14548 divbuf_2/a_16642_170# vdd 1.09fF **FLOATING
C14549 divbuf_2/a_16152_170# vdd 1.09fF **FLOATING
C14550 divbuf_2/a_15672_170# vdd 1.09fF **FLOATING
C14551 divbuf_2/a_15182_170# vdd 1.09fF **FLOATING
C14552 divbuf_2/a_14702_170# vdd 1.10fF **FLOATING
C14553 divbuf_2/a_14222_170# vdd 1.10fF **FLOATING
C14554 divbuf_2/a_13742_170# vdd 1.09fF **FLOATING
C14555 divbuf_2/a_13252_170# vdd 1.09fF **FLOATING
C14556 divbuf_2/a_12772_170# vdd 1.07fF **FLOATING
C14557 divbuf_2/a_12282_170# vdd 1.09fF **FLOATING
C14558 divbuf_2/a_11802_170# vdd 1.09fF **FLOATING
C14559 divbuf_2/a_11312_170# vdd 1.10fF **FLOATING
C14560 divbuf_2/a_10212_170# vdd 1.09fF **FLOATING
C14561 divbuf_2/a_9732_170# vdd 1.09fF **FLOATING
C14562 divbuf_2/a_9242_170# vdd 1.09fF **FLOATING
C14563 divbuf_2/a_8762_170# vdd 1.09fF **FLOATING
C14564 divbuf_2/a_8272_170# vdd 1.07fF **FLOATING
C14565 divbuf_2/a_7792_170# vdd 1.09fF **FLOATING
C14566 divbuf_2/a_7302_170# vdd 1.09fF **FLOATING
C14567 divbuf_2/a_6822_170# vdd 1.09fF **FLOATING
C14568 divbuf_2/a_6332_170# vdd 1.09fF **FLOATING
C14569 divbuf_2/a_5852_170# vdd 1.09fF **FLOATING
C14570 divbuf_2/a_5362_170# vdd 1.09fF **FLOATING
C14571 divbuf_2/a_4882_170# vdd 1.09fF **FLOATING
C14572 divbuf_2/a_4392_170# vdd 1.07fF **FLOATING
C14573 divbuf_2/a_3912_170# vdd 1.09fF **FLOATING
C14574 divbuf_2/a_3422_170# vdd 1.10fF **FLOATING
C14575 divbuf_2/a_2322_170# vdd 1.09fF **FLOATING
C14576 divbuf_2/a_1842_170# vdd 1.09fF **FLOATING
C14577 divbuf_2/a_1352_170# vdd 1.10fF **FLOATING
C14578 divbuf_2/a_492_n240# vdd 2.46fF **FLOATING
C14579 divbuf_1/OUT vdd 3.28fF
C14580 divbuf_1/OUT5 vdd 16.40fF
C14581 divbuf_1/OUT4 vdd 100.06fF
C14582 divbuf_1/OUT3 vdd 27.01fF
C14583 divbuf_1/OUT2 vdd 8.71fF
C14584 divbuf_1/IN vdd 0.89fF
C14585 divbuf_1/a_60990_n1540# vdd 1.57fF **FLOATING
C14586 divbuf_1/a_60510_n1540# vdd 1.62fF **FLOATING
C14587 divbuf_1/a_60030_n1540# vdd 1.62fF **FLOATING
C14588 divbuf_1/a_59550_n1540# vdd 1.62fF **FLOATING
C14589 divbuf_1/a_59070_n1540# vdd 1.62fF **FLOATING
C14590 divbuf_1/a_58590_n1540# vdd 1.62fF **FLOATING
C14591 divbuf_1/a_58110_n1540# vdd 1.62fF **FLOATING
C14592 divbuf_1/a_57630_n1540# vdd 1.62fF **FLOATING
C14593 divbuf_1/a_57150_n1540# vdd 1.62fF **FLOATING
C14594 divbuf_1/a_56670_n1540# vdd 1.62fF **FLOATING
C14595 divbuf_1/a_56190_n1540# vdd 1.62fF **FLOATING
C14596 divbuf_1/a_55710_n1540# vdd 1.62fF **FLOATING
C14597 divbuf_1/a_55230_n1540# vdd 1.62fF **FLOATING
C14598 divbuf_1/a_54750_n1540# vdd 1.62fF **FLOATING
C14599 divbuf_1/a_54270_n1540# vdd 1.62fF **FLOATING
C14600 divbuf_1/a_53790_n1540# vdd 1.62fF **FLOATING
C14601 divbuf_1/a_53310_n1540# vdd 1.62fF **FLOATING
C14602 divbuf_1/a_52830_n1540# vdd 1.62fF **FLOATING
C14603 divbuf_1/a_52350_n1540# vdd 1.62fF **FLOATING
C14604 divbuf_1/a_51870_n1540# vdd 1.62fF **FLOATING
C14605 divbuf_1/a_51390_n1540# vdd 1.62fF **FLOATING
C14606 divbuf_1/a_50910_n1540# vdd 1.62fF **FLOATING
C14607 divbuf_1/a_50430_n1540# vdd 1.62fF **FLOATING
C14608 divbuf_1/a_49950_n1540# vdd 1.62fF **FLOATING
C14609 divbuf_1/a_49470_n1540# vdd 1.62fF **FLOATING
C14610 divbuf_1/a_48990_n1540# vdd 1.62fF **FLOATING
C14611 divbuf_1/a_48510_n1540# vdd 1.62fF **FLOATING
C14612 divbuf_1/a_48030_n1540# vdd 1.62fF **FLOATING
C14613 divbuf_1/a_47550_n1540# vdd 1.62fF **FLOATING
C14614 divbuf_1/a_47070_n1540# vdd 1.62fF **FLOATING
C14615 divbuf_1/a_46590_n1540# vdd 1.62fF **FLOATING
C14616 divbuf_1/a_46110_n1540# vdd 1.62fF **FLOATING
C14617 divbuf_1/a_45630_n1540# vdd 1.62fF **FLOATING
C14618 divbuf_1/a_45150_n1540# vdd 1.62fF **FLOATING
C14619 divbuf_1/a_44670_n1540# vdd 1.62fF **FLOATING
C14620 divbuf_1/a_44190_n1540# vdd 1.62fF **FLOATING
C14621 divbuf_1/a_43710_n1540# vdd 1.62fF **FLOATING
C14622 divbuf_1/a_43230_n1540# vdd 1.62fF **FLOATING
C14623 divbuf_1/a_42750_n1540# vdd 1.62fF **FLOATING
C14624 divbuf_1/a_42270_n1540# vdd 1.62fF **FLOATING
C14625 divbuf_1/a_41790_n1540# vdd 1.62fF **FLOATING
C14626 divbuf_1/a_41310_n1540# vdd 1.62fF **FLOATING
C14627 divbuf_1/a_40830_n1540# vdd 1.62fF **FLOATING
C14628 divbuf_1/a_40350_n1540# vdd 1.62fF **FLOATING
C14629 divbuf_1/a_39870_n1540# vdd 1.62fF **FLOATING
C14630 divbuf_1/a_39390_n1540# vdd 1.62fF **FLOATING
C14631 divbuf_1/a_38910_n1540# vdd 1.62fF **FLOATING
C14632 divbuf_1/a_38430_n1540# vdd 1.62fF **FLOATING
C14633 divbuf_1/a_37950_n1540# vdd 1.62fF **FLOATING
C14634 divbuf_1/a_37470_n1540# vdd 1.62fF **FLOATING
C14635 divbuf_1/a_36990_n1540# vdd 1.62fF **FLOATING
C14636 divbuf_1/a_36510_n1540# vdd 1.62fF **FLOATING
C14637 divbuf_1/a_36030_n1540# vdd 1.62fF **FLOATING
C14638 divbuf_1/a_35550_n1540# vdd 1.62fF **FLOATING
C14639 divbuf_1/a_35070_n1540# vdd 1.62fF **FLOATING
C14640 divbuf_1/a_34590_n1540# vdd 1.62fF **FLOATING
C14641 divbuf_1/a_34110_n1540# vdd 1.62fF **FLOATING
C14642 divbuf_1/a_33630_n1540# vdd 1.62fF **FLOATING
C14643 divbuf_1/a_33150_n1540# vdd 1.62fF **FLOATING
C14644 divbuf_1/a_32670_n1540# vdd 1.62fF **FLOATING
C14645 divbuf_1/a_32190_n1540# vdd 1.62fF **FLOATING
C14646 divbuf_1/a_31710_n1540# vdd 1.62fF **FLOATING
C14647 divbuf_1/a_31230_n1540# vdd 1.62fF **FLOATING
C14648 divbuf_1/a_30750_n1540# vdd 1.62fF **FLOATING
C14649 divbuf_1/a_30270_n1540# vdd 1.62fF **FLOATING
C14650 divbuf_1/a_29790_n1540# vdd 1.62fF **FLOATING
C14651 divbuf_1/a_29310_n1540# vdd 1.62fF **FLOATING
C14652 divbuf_1/a_28830_n1540# vdd 1.62fF **FLOATING
C14653 divbuf_1/a_28350_n1540# vdd 1.62fF **FLOATING
C14654 divbuf_1/a_27870_n1540# vdd 1.62fF **FLOATING
C14655 divbuf_1/a_27390_n1540# vdd 1.62fF **FLOATING
C14656 divbuf_1/a_26910_n1540# vdd 1.62fF **FLOATING
C14657 divbuf_1/a_26430_n1540# vdd 1.62fF **FLOATING
C14658 divbuf_1/a_25950_n1540# vdd 1.62fF **FLOATING
C14659 divbuf_1/a_25470_n1540# vdd 1.62fF **FLOATING
C14660 divbuf_1/a_24990_n1540# vdd 1.62fF **FLOATING
C14661 divbuf_1/a_24510_n1540# vdd 1.62fF **FLOATING
C14662 divbuf_1/a_24030_n1540# vdd 1.62fF **FLOATING
C14663 divbuf_1/a_23550_n1540# vdd 1.62fF **FLOATING
C14664 divbuf_1/a_23070_n1540# vdd 1.62fF **FLOATING
C14665 divbuf_1/a_22590_n1540# vdd 1.62fF **FLOATING
C14666 divbuf_1/a_22110_n1540# vdd 1.62fF **FLOATING
C14667 divbuf_1/a_21630_n1540# vdd 1.62fF **FLOATING
C14668 divbuf_1/a_21150_n1540# vdd 1.62fF **FLOATING
C14669 divbuf_1/a_20670_n1540# vdd 1.62fF **FLOATING
C14670 divbuf_1/a_20190_n1540# vdd 1.62fF **FLOATING
C14671 divbuf_1/a_19710_n1540# vdd 1.62fF **FLOATING
C14672 divbuf_1/a_19230_n1540# vdd 1.62fF **FLOATING
C14673 divbuf_1/a_18750_n1540# vdd 1.62fF **FLOATING
C14674 divbuf_1/a_18270_n1540# vdd 1.62fF **FLOATING
C14675 divbuf_1/a_17790_n1540# vdd 1.62fF **FLOATING
C14676 divbuf_1/a_17310_n1540# vdd 1.62fF **FLOATING
C14677 divbuf_1/a_16830_n1540# vdd 1.62fF **FLOATING
C14678 divbuf_1/a_16350_n1540# vdd 1.62fF **FLOATING
C14679 divbuf_1/a_15870_n1540# vdd 1.62fF **FLOATING
C14680 divbuf_1/a_15390_n1540# vdd 1.62fF **FLOATING
C14681 divbuf_1/a_14910_n1540# vdd 1.62fF **FLOATING
C14682 divbuf_1/a_14430_n1540# vdd 1.62fF **FLOATING
C14683 divbuf_1/a_13950_n1540# vdd 1.62fF **FLOATING
C14684 divbuf_1/a_13470_n1540# vdd 1.62fF **FLOATING
C14685 divbuf_1/a_12990_n1540# vdd 1.62fF **FLOATING
C14686 divbuf_1/a_12510_n1540# vdd 1.62fF **FLOATING
C14687 divbuf_1/a_12030_n1540# vdd 1.62fF **FLOATING
C14688 divbuf_1/a_11550_n1540# vdd 1.62fF **FLOATING
C14689 divbuf_1/a_11070_n1540# vdd 1.62fF **FLOATING
C14690 divbuf_1/a_10590_n1540# vdd 1.62fF **FLOATING
C14691 divbuf_1/a_10110_n1540# vdd 1.62fF **FLOATING
C14692 divbuf_1/a_9630_n1540# vdd 1.62fF **FLOATING
C14693 divbuf_1/a_9150_n1540# vdd 1.62fF **FLOATING
C14694 divbuf_1/a_8670_n1540# vdd 1.62fF **FLOATING
C14695 divbuf_1/a_8190_n1540# vdd 1.62fF **FLOATING
C14696 divbuf_1/a_7710_n1540# vdd 1.62fF **FLOATING
C14697 divbuf_1/a_7230_n1540# vdd 1.62fF **FLOATING
C14698 divbuf_1/a_6750_n1540# vdd 1.62fF **FLOATING
C14699 divbuf_1/a_6270_n1540# vdd 1.62fF **FLOATING
C14700 divbuf_1/a_5790_n1540# vdd 1.62fF **FLOATING
C14701 divbuf_1/a_5310_n1540# vdd 1.62fF **FLOATING
C14702 divbuf_1/a_4830_n1540# vdd 1.62fF **FLOATING
C14703 divbuf_1/a_4350_n1540# vdd 1.62fF **FLOATING
C14704 divbuf_1/a_3870_n1540# vdd 1.62fF **FLOATING
C14705 divbuf_1/a_3390_n1540# vdd 1.62fF **FLOATING
C14706 divbuf_1/a_2910_n1540# vdd 1.62fF **FLOATING
C14707 divbuf_1/a_2430_n1540# vdd 1.62fF **FLOATING
C14708 divbuf_1/a_1950_n1540# vdd 1.62fF **FLOATING
C14709 divbuf_1/a_1470_n1540# vdd 1.62fF **FLOATING
C14710 divbuf_1/a_990_n1540# vdd 1.62fF **FLOATING
C14711 divbuf_1/a_510_n1540# vdd 1.62fF **FLOATING
C14712 divbuf_1/a_60990_n840# vdd 1.06fF **FLOATING
C14713 divbuf_1/a_60510_n840# vdd 1.09fF **FLOATING
C14714 divbuf_1/a_60030_n840# vdd 1.09fF **FLOATING
C14715 divbuf_1/a_59550_n840# vdd 1.09fF **FLOATING
C14716 divbuf_1/a_59070_n840# vdd 1.09fF **FLOATING
C14717 divbuf_1/a_58590_n840# vdd 1.09fF **FLOATING
C14718 divbuf_1/a_58110_n840# vdd 1.09fF **FLOATING
C14719 divbuf_1/a_57630_n840# vdd 1.09fF **FLOATING
C14720 divbuf_1/a_57150_n840# vdd 1.09fF **FLOATING
C14721 divbuf_1/a_56670_n840# vdd 1.09fF **FLOATING
C14722 divbuf_1/a_56190_n840# vdd 1.09fF **FLOATING
C14723 divbuf_1/a_55710_n840# vdd 1.09fF **FLOATING
C14724 divbuf_1/a_55230_n840# vdd 1.09fF **FLOATING
C14725 divbuf_1/a_54750_n840# vdd 1.09fF **FLOATING
C14726 divbuf_1/a_54270_n840# vdd 1.09fF **FLOATING
C14727 divbuf_1/a_53790_n840# vdd 1.09fF **FLOATING
C14728 divbuf_1/a_53310_n840# vdd 1.09fF **FLOATING
C14729 divbuf_1/a_52830_n840# vdd 1.09fF **FLOATING
C14730 divbuf_1/a_52350_n840# vdd 1.09fF **FLOATING
C14731 divbuf_1/a_51870_n840# vdd 1.09fF **FLOATING
C14732 divbuf_1/a_51390_n840# vdd 1.09fF **FLOATING
C14733 divbuf_1/a_50910_n840# vdd 1.09fF **FLOATING
C14734 divbuf_1/a_50430_n840# vdd 1.09fF **FLOATING
C14735 divbuf_1/a_49950_n840# vdd 1.09fF **FLOATING
C14736 divbuf_1/a_49470_n840# vdd 1.09fF **FLOATING
C14737 divbuf_1/a_48990_n840# vdd 1.09fF **FLOATING
C14738 divbuf_1/a_48510_n840# vdd 1.09fF **FLOATING
C14739 divbuf_1/a_48030_n840# vdd 1.09fF **FLOATING
C14740 divbuf_1/a_47550_n840# vdd 1.09fF **FLOATING
C14741 divbuf_1/a_47070_n840# vdd 1.09fF **FLOATING
C14742 divbuf_1/a_46590_n840# vdd 1.09fF **FLOATING
C14743 divbuf_1/a_46110_n840# vdd 1.09fF **FLOATING
C14744 divbuf_1/a_45630_n840# vdd 1.09fF **FLOATING
C14745 divbuf_1/a_45150_n840# vdd 1.09fF **FLOATING
C14746 divbuf_1/a_44670_n840# vdd 1.09fF **FLOATING
C14747 divbuf_1/a_44190_n840# vdd 1.09fF **FLOATING
C14748 divbuf_1/a_43710_n840# vdd 1.09fF **FLOATING
C14749 divbuf_1/a_43230_n840# vdd 1.09fF **FLOATING
C14750 divbuf_1/a_42750_n840# vdd 1.08fF **FLOATING
C14751 divbuf_1/a_42270_n840# vdd 1.08fF **FLOATING
C14752 divbuf_1/a_41790_n840# vdd 1.10fF **FLOATING
C14753 divbuf_1/a_41310_n840# vdd 1.09fF **FLOATING
C14754 divbuf_1/a_40830_n840# vdd 1.09fF **FLOATING
C14755 divbuf_1/a_40350_n840# vdd 1.09fF **FLOATING
C14756 divbuf_1/a_39870_n840# vdd 1.09fF **FLOATING
C14757 divbuf_1/a_39390_n840# vdd 1.09fF **FLOATING
C14758 divbuf_1/a_38910_n840# vdd 1.09fF **FLOATING
C14759 divbuf_1/a_38430_n840# vdd 1.09fF **FLOATING
C14760 divbuf_1/a_37950_n840# vdd 1.09fF **FLOATING
C14761 divbuf_1/a_37470_n840# vdd 1.09fF **FLOATING
C14762 divbuf_1/a_36990_n840# vdd 1.09fF **FLOATING
C14763 divbuf_1/a_36510_n840# vdd 1.09fF **FLOATING
C14764 divbuf_1/a_36030_n840# vdd 1.09fF **FLOATING
C14765 divbuf_1/a_35550_n840# vdd 1.09fF **FLOATING
C14766 divbuf_1/a_35070_n840# vdd 1.09fF **FLOATING
C14767 divbuf_1/a_34590_n840# vdd 1.09fF **FLOATING
C14768 divbuf_1/a_34110_n840# vdd 1.09fF **FLOATING
C14769 divbuf_1/a_33630_n840# vdd 1.09fF **FLOATING
C14770 divbuf_1/a_33150_n840# vdd 1.09fF **FLOATING
C14771 divbuf_1/a_32670_n840# vdd 1.09fF **FLOATING
C14772 divbuf_1/a_32190_n840# vdd 1.09fF **FLOATING
C14773 divbuf_1/a_31710_n840# vdd 1.11fF **FLOATING
C14774 divbuf_1/a_31230_n840# vdd 1.13fF **FLOATING
C14775 divbuf_1/a_30750_n840# vdd 1.09fF **FLOATING
C14776 divbuf_1/a_30270_n840# vdd 1.09fF **FLOATING
C14777 divbuf_1/a_29790_n840# vdd 1.09fF **FLOATING
C14778 divbuf_1/a_29310_n840# vdd 1.09fF **FLOATING
C14779 divbuf_1/a_28830_n840# vdd 1.09fF **FLOATING
C14780 divbuf_1/a_28350_n840# vdd 1.09fF **FLOATING
C14781 divbuf_1/a_27870_n840# vdd 1.08fF **FLOATING
C14782 divbuf_1/a_27390_n840# vdd 1.11fF **FLOATING
C14783 divbuf_1/a_26910_n840# vdd 1.10fF **FLOATING
C14784 divbuf_1/a_26430_n840# vdd 1.10fF **FLOATING
C14785 divbuf_1/a_25950_n840# vdd 1.10fF **FLOATING
C14786 divbuf_1/a_25470_n840# vdd 1.10fF **FLOATING
C14787 divbuf_1/a_24990_n840# vdd 1.10fF **FLOATING
C14788 divbuf_1/a_24510_n840# vdd 1.10fF **FLOATING
C14789 divbuf_1/a_24030_n840# vdd 1.09fF **FLOATING
C14790 divbuf_1/a_23550_n840# vdd 1.11fF **FLOATING
C14791 divbuf_1/a_23070_n840# vdd 1.10fF **FLOATING
C14792 divbuf_1/a_22590_n840# vdd 1.10fF **FLOATING
C14793 divbuf_1/a_22110_n840# vdd 1.10fF **FLOATING
C14794 divbuf_1/a_21630_n840# vdd 1.10fF **FLOATING
C14795 divbuf_1/a_21150_n840# vdd 1.10fF **FLOATING
C14796 divbuf_1/a_20670_n840# vdd 1.10fF **FLOATING
C14797 divbuf_1/a_20190_n840# vdd 1.09fF **FLOATING
C14798 divbuf_1/a_19710_n840# vdd 1.09fF **FLOATING
C14799 divbuf_1/a_19230_n840# vdd 1.09fF **FLOATING
C14800 divbuf_1/a_18750_n840# vdd 1.09fF **FLOATING
C14801 divbuf_1/a_18270_n840# vdd 1.08fF **FLOATING
C14802 divbuf_1/a_17790_n840# vdd 1.08fF **FLOATING
C14803 divbuf_1/a_17310_n840# vdd 1.07fF **FLOATING
C14804 divbuf_1/a_16830_n840# vdd 1.07fF **FLOATING
C14805 divbuf_1/a_16350_n840# vdd 1.07fF **FLOATING
C14806 divbuf_1/a_15870_n840# vdd 1.07fF **FLOATING
C14807 divbuf_1/a_15390_n840# vdd 1.08fF **FLOATING
C14808 divbuf_1/a_14910_n840# vdd 1.07fF **FLOATING
C14809 divbuf_1/a_14430_n840# vdd 1.07fF **FLOATING
C14810 divbuf_1/a_13950_n840# vdd 1.07fF **FLOATING
C14811 divbuf_1/a_13470_n840# vdd 1.07fF **FLOATING
C14812 divbuf_1/a_12990_n840# vdd 1.10fF **FLOATING
C14813 divbuf_1/a_12510_n840# vdd 1.08fF **FLOATING
C14814 divbuf_1/a_12030_n840# vdd 1.07fF **FLOATING
C14815 divbuf_1/a_11550_n840# vdd 1.07fF **FLOATING
C14816 divbuf_1/a_11070_n840# vdd 1.08fF **FLOATING
C14817 divbuf_1/a_10590_n840# vdd 1.10fF **FLOATING
C14818 divbuf_1/a_10110_n840# vdd 1.10fF **FLOATING
C14819 divbuf_1/a_9630_n840# vdd 1.10fF **FLOATING
C14820 divbuf_1/a_9150_n840# vdd 1.10fF **FLOATING
C14821 divbuf_1/a_8670_n840# vdd 1.10fF **FLOATING
C14822 divbuf_1/a_8190_n840# vdd 1.12fF **FLOATING
C14823 divbuf_1/a_7710_n840# vdd 1.10fF **FLOATING
C14824 divbuf_1/a_7230_n840# vdd 1.09fF **FLOATING
C14825 divbuf_1/a_6750_n840# vdd 1.09fF **FLOATING
C14826 divbuf_1/a_6270_n840# vdd 1.09fF **FLOATING
C14827 divbuf_1/a_5790_n840# vdd 1.09fF **FLOATING
C14828 divbuf_1/a_5310_n840# vdd 1.09fF **FLOATING
C14829 divbuf_1/a_4830_n840# vdd 1.09fF **FLOATING
C14830 divbuf_1/a_4350_n840# vdd 1.09fF **FLOATING
C14831 divbuf_1/a_3870_n840# vdd 1.09fF **FLOATING
C14832 divbuf_1/a_3390_n840# vdd 1.09fF **FLOATING
C14833 divbuf_1/a_2910_n840# vdd 1.10fF **FLOATING
C14834 divbuf_1/a_2430_n840# vdd 1.10fF **FLOATING
C14835 divbuf_1/a_1950_n840# vdd 1.10fF **FLOATING
C14836 divbuf_1/a_1470_n840# vdd 1.10fF **FLOATING
C14837 divbuf_1/a_990_n840# vdd 1.08fF **FLOATING
C14838 divbuf_1/a_510_n840# vdd 1.07fF **FLOATING
C14839 divbuf_1/a_60480_n1600# vdd 1.48fF **FLOATING
C14840 divbuf_1/a_60000_n1600# vdd 1.48fF **FLOATING
C14841 divbuf_1/a_59520_n1600# vdd 1.48fF **FLOATING
C14842 divbuf_1/a_59040_n1600# vdd 1.48fF **FLOATING
C14843 divbuf_1/a_58560_n1600# vdd 1.48fF **FLOATING
C14844 divbuf_1/a_58080_n1600# vdd 1.48fF **FLOATING
C14845 divbuf_1/a_57600_n1600# vdd 1.48fF **FLOATING
C14846 divbuf_1/a_57120_n1600# vdd 1.48fF **FLOATING
C14847 divbuf_1/a_56640_n1600# vdd 1.48fF **FLOATING
C14848 divbuf_1/a_56160_n1600# vdd 1.48fF **FLOATING
C14849 divbuf_1/a_55680_n1600# vdd 1.48fF **FLOATING
C14850 divbuf_1/a_55200_n1600# vdd 1.48fF **FLOATING
C14851 divbuf_1/a_54720_n1600# vdd 1.48fF **FLOATING
C14852 divbuf_1/a_54240_n1600# vdd 1.48fF **FLOATING
C14853 divbuf_1/a_53760_n1600# vdd 1.48fF **FLOATING
C14854 divbuf_1/a_53280_n1600# vdd 1.48fF **FLOATING
C14855 divbuf_1/a_52800_n1600# vdd 1.48fF **FLOATING
C14856 divbuf_1/a_52320_n1600# vdd 1.48fF **FLOATING
C14857 divbuf_1/a_51840_n1600# vdd 1.48fF **FLOATING
C14858 divbuf_1/a_51360_n1600# vdd 1.48fF **FLOATING
C14859 divbuf_1/a_50880_n1600# vdd 1.48fF **FLOATING
C14860 divbuf_1/a_50400_n1600# vdd 1.48fF **FLOATING
C14861 divbuf_1/a_49920_n1600# vdd 1.48fF **FLOATING
C14862 divbuf_1/a_49440_n1600# vdd 1.48fF **FLOATING
C14863 divbuf_1/a_48960_n1600# vdd 1.48fF **FLOATING
C14864 divbuf_1/a_48480_n1600# vdd 1.48fF **FLOATING
C14865 divbuf_1/a_48000_n1600# vdd 1.48fF **FLOATING
C14866 divbuf_1/a_47520_n1600# vdd 1.48fF **FLOATING
C14867 divbuf_1/a_47040_n1600# vdd 1.48fF **FLOATING
C14868 divbuf_1/a_46560_n1600# vdd 1.48fF **FLOATING
C14869 divbuf_1/a_46080_n1600# vdd 1.48fF **FLOATING
C14870 divbuf_1/a_45600_n1600# vdd 1.48fF **FLOATING
C14871 divbuf_1/a_45120_n1600# vdd 1.48fF **FLOATING
C14872 divbuf_1/a_44640_n1600# vdd 1.48fF **FLOATING
C14873 divbuf_1/a_44160_n1600# vdd 1.48fF **FLOATING
C14874 divbuf_1/a_43680_n1600# vdd 1.48fF **FLOATING
C14875 divbuf_1/a_43200_n1600# vdd 1.48fF **FLOATING
C14876 divbuf_1/a_42720_n1600# vdd 1.48fF **FLOATING
C14877 divbuf_1/a_42240_n1600# vdd 1.48fF **FLOATING
C14878 divbuf_1/a_41760_n1600# vdd 1.48fF **FLOATING
C14879 divbuf_1/a_41280_n1600# vdd 1.48fF **FLOATING
C14880 divbuf_1/a_40800_n1600# vdd 1.48fF **FLOATING
C14881 divbuf_1/a_40320_n1600# vdd 1.48fF **FLOATING
C14882 divbuf_1/a_39840_n1600# vdd 1.48fF **FLOATING
C14883 divbuf_1/a_39360_n1600# vdd 1.48fF **FLOATING
C14884 divbuf_1/a_38880_n1600# vdd 1.48fF **FLOATING
C14885 divbuf_1/a_38400_n1600# vdd 1.48fF **FLOATING
C14886 divbuf_1/a_37920_n1600# vdd 1.48fF **FLOATING
C14887 divbuf_1/a_37440_n1600# vdd 1.48fF **FLOATING
C14888 divbuf_1/a_36960_n1600# vdd 1.48fF **FLOATING
C14889 divbuf_1/a_36480_n1600# vdd 1.48fF **FLOATING
C14890 divbuf_1/a_36000_n1600# vdd 1.48fF **FLOATING
C14891 divbuf_1/a_35520_n1600# vdd 1.48fF **FLOATING
C14892 divbuf_1/a_35040_n1600# vdd 1.48fF **FLOATING
C14893 divbuf_1/a_34560_n1600# vdd 1.48fF **FLOATING
C14894 divbuf_1/a_34080_n1600# vdd 1.48fF **FLOATING
C14895 divbuf_1/a_33600_n1600# vdd 1.48fF **FLOATING
C14896 divbuf_1/a_33120_n1600# vdd 1.48fF **FLOATING
C14897 divbuf_1/a_32640_n1600# vdd 1.48fF **FLOATING
C14898 divbuf_1/a_32160_n1600# vdd 1.48fF **FLOATING
C14899 divbuf_1/a_31680_n1600# vdd 1.48fF **FLOATING
C14900 divbuf_1/a_31200_n1600# vdd 1.48fF **FLOATING
C14901 divbuf_1/a_30720_n1600# vdd 1.48fF **FLOATING
C14902 divbuf_1/a_30240_n1600# vdd 1.48fF **FLOATING
C14903 divbuf_1/a_29760_n1600# vdd 1.48fF **FLOATING
C14904 divbuf_1/a_29280_n1600# vdd 1.48fF **FLOATING
C14905 divbuf_1/a_28800_n1600# vdd 1.48fF **FLOATING
C14906 divbuf_1/a_28320_n1600# vdd 1.48fF **FLOATING
C14907 divbuf_1/a_27840_n1600# vdd 1.48fF **FLOATING
C14908 divbuf_1/a_27360_n1600# vdd 1.48fF **FLOATING
C14909 divbuf_1/a_26880_n1600# vdd 1.48fF **FLOATING
C14910 divbuf_1/a_26400_n1600# vdd 1.48fF **FLOATING
C14911 divbuf_1/a_25920_n1600# vdd 1.48fF **FLOATING
C14912 divbuf_1/a_25440_n1600# vdd 1.48fF **FLOATING
C14913 divbuf_1/a_24960_n1600# vdd 1.48fF **FLOATING
C14914 divbuf_1/a_24480_n1600# vdd 1.48fF **FLOATING
C14915 divbuf_1/a_24000_n1600# vdd 1.48fF **FLOATING
C14916 divbuf_1/a_23520_n1600# vdd 1.48fF **FLOATING
C14917 divbuf_1/a_23040_n1600# vdd 1.48fF **FLOATING
C14918 divbuf_1/a_22560_n1600# vdd 1.48fF **FLOATING
C14919 divbuf_1/a_22080_n1600# vdd 1.48fF **FLOATING
C14920 divbuf_1/a_21600_n1600# vdd 1.48fF **FLOATING
C14921 divbuf_1/a_21120_n1600# vdd 1.48fF **FLOATING
C14922 divbuf_1/a_20640_n1600# vdd 1.48fF **FLOATING
C14923 divbuf_1/a_20160_n1600# vdd 1.48fF **FLOATING
C14924 divbuf_1/a_19680_n1600# vdd 1.48fF **FLOATING
C14925 divbuf_1/a_19200_n1600# vdd 1.48fF **FLOATING
C14926 divbuf_1/a_18720_n1600# vdd 1.48fF **FLOATING
C14927 divbuf_1/a_18240_n1600# vdd 1.48fF **FLOATING
C14928 divbuf_1/a_17760_n1600# vdd 1.48fF **FLOATING
C14929 divbuf_1/a_17280_n1600# vdd 1.48fF **FLOATING
C14930 divbuf_1/a_16800_n1600# vdd 1.48fF **FLOATING
C14931 divbuf_1/a_16320_n1600# vdd 1.48fF **FLOATING
C14932 divbuf_1/a_15840_n1600# vdd 1.48fF **FLOATING
C14933 divbuf_1/a_15360_n1600# vdd 1.48fF **FLOATING
C14934 divbuf_1/a_14880_n1600# vdd 1.48fF **FLOATING
C14935 divbuf_1/a_14400_n1600# vdd 1.48fF **FLOATING
C14936 divbuf_1/a_13920_n1600# vdd 1.48fF **FLOATING
C14937 divbuf_1/a_13440_n1600# vdd 1.48fF **FLOATING
C14938 divbuf_1/a_12960_n1600# vdd 1.48fF **FLOATING
C14939 divbuf_1/a_12480_n1600# vdd 1.48fF **FLOATING
C14940 divbuf_1/a_12000_n1600# vdd 1.48fF **FLOATING
C14941 divbuf_1/a_11520_n1600# vdd 1.48fF **FLOATING
C14942 divbuf_1/a_11040_n1600# vdd 1.48fF **FLOATING
C14943 divbuf_1/a_10560_n1600# vdd 1.48fF **FLOATING
C14944 divbuf_1/a_10080_n1600# vdd 1.48fF **FLOATING
C14945 divbuf_1/a_9600_n1600# vdd 1.48fF **FLOATING
C14946 divbuf_1/a_9120_n1600# vdd 1.48fF **FLOATING
C14947 divbuf_1/a_8640_n1600# vdd 1.48fF **FLOATING
C14948 divbuf_1/a_8160_n1600# vdd 1.48fF **FLOATING
C14949 divbuf_1/a_7680_n1600# vdd 1.48fF **FLOATING
C14950 divbuf_1/a_7200_n1600# vdd 1.48fF **FLOATING
C14951 divbuf_1/a_6720_n1600# vdd 1.48fF **FLOATING
C14952 divbuf_1/a_6240_n1600# vdd 1.48fF **FLOATING
C14953 divbuf_1/a_5760_n1600# vdd 1.48fF **FLOATING
C14954 divbuf_1/a_5280_n1600# vdd 1.48fF **FLOATING
C14955 divbuf_1/a_4800_n1600# vdd 1.48fF **FLOATING
C14956 divbuf_1/a_4320_n1600# vdd 1.48fF **FLOATING
C14957 divbuf_1/a_3840_n1600# vdd 1.48fF **FLOATING
C14958 divbuf_1/a_3360_n1600# vdd 1.48fF **FLOATING
C14959 divbuf_1/a_2880_n1600# vdd 1.48fF **FLOATING
C14960 divbuf_1/a_2400_n1600# vdd 1.48fF **FLOATING
C14961 divbuf_1/a_1920_n1600# vdd 1.48fF **FLOATING
C14962 divbuf_1/a_1440_n1600# vdd 1.48fF **FLOATING
C14963 divbuf_1/a_960_n1600# vdd 1.48fF **FLOATING
C14964 divbuf_1/a_480_n1600# vdd 1.48fF **FLOATING
C14965 divbuf_1/a_0_n1600# vdd 1.48fF **FLOATING
C14966 divbuf_1/a_41382_n240# vdd 0.90fF **FLOATING
C14967 divbuf_1/a_40902_n240# vdd 0.90fF **FLOATING
C14968 divbuf_1/a_40412_n240# vdd 0.90fF **FLOATING
C14969 divbuf_1/a_39932_n240# vdd 0.90fF **FLOATING
C14970 divbuf_1/a_39442_n240# vdd 0.90fF **FLOATING
C14971 divbuf_1/a_38962_n240# vdd 0.91fF **FLOATING
C14972 divbuf_1/a_38472_n240# vdd 0.90fF **FLOATING
C14973 divbuf_1/a_37992_n240# vdd 0.90fF **FLOATING
C14974 divbuf_1/a_37502_n240# vdd 0.90fF **FLOATING
C14975 divbuf_1/a_37022_n240# vdd 0.90fF **FLOATING
C14976 divbuf_1/a_36532_n240# vdd 0.90fF **FLOATING
C14977 divbuf_1/a_36052_n240# vdd 0.90fF **FLOATING
C14978 divbuf_1/a_35562_n240# vdd 0.90fF **FLOATING
C14979 divbuf_1/a_35082_n240# vdd 0.91fF **FLOATING
C14980 divbuf_1/a_34592_n240# vdd 0.90fF **FLOATING
C14981 divbuf_1/a_34112_n240# vdd 0.90fF **FLOATING
C14982 divbuf_1/a_33622_n240# vdd 0.90fF **FLOATING
C14983 divbuf_1/a_33142_n240# vdd 0.90fF **FLOATING
C14984 divbuf_1/a_32652_n240# vdd 0.90fF **FLOATING
C14985 divbuf_1/a_32172_n240# vdd 0.90fF **FLOATING
C14986 divbuf_1/a_31682_n240# vdd 0.89fF **FLOATING
C14987 divbuf_1/a_31202_n240# vdd 0.92fF **FLOATING
C14988 divbuf_1/a_30712_n240# vdd 0.90fF **FLOATING
C14989 divbuf_1/a_30232_n240# vdd 0.90fF **FLOATING
C14990 divbuf_1/a_29742_n240# vdd 0.90fF **FLOATING
C14991 divbuf_1/a_29262_n240# vdd 0.90fF **FLOATING
C14992 divbuf_1/a_28772_n240# vdd 0.90fF **FLOATING
C14993 divbuf_1/a_28292_n240# vdd 0.90fF **FLOATING
C14994 divbuf_1/a_27802_n240# vdd 0.89fF **FLOATING
C14995 divbuf_1/a_27322_n240# vdd 0.95fF **FLOATING
C14996 divbuf_1/a_26832_n240# vdd 0.91fF **FLOATING
C14997 divbuf_1/a_26352_n240# vdd 0.91fF **FLOATING
C14998 divbuf_1/a_25862_n240# vdd 0.91fF **FLOATING
C14999 divbuf_1/a_25382_n240# vdd 0.91fF **FLOATING
C15000 divbuf_1/a_24892_n240# vdd 0.91fF **FLOATING
C15001 divbuf_1/a_24412_n240# vdd 0.91fF **FLOATING
C15002 divbuf_1/a_23922_n240# vdd 0.92fF **FLOATING
C15003 divbuf_1/a_23442_n240# vdd 0.94fF **FLOATING
C15004 divbuf_1/a_22952_n240# vdd 0.91fF **FLOATING
C15005 divbuf_1/a_22472_n240# vdd 0.91fF **FLOATING
C15006 divbuf_1/a_21982_n240# vdd 0.91fF **FLOATING
C15007 divbuf_1/a_21502_n240# vdd 0.91fF **FLOATING
C15008 divbuf_1/a_21012_n240# vdd 0.91fF **FLOATING
C15009 divbuf_1/a_20532_n240# vdd 0.91fF **FLOATING
C15010 divbuf_1/a_20042_n240# vdd 0.90fF **FLOATING
C15011 divbuf_1/a_19562_n240# vdd 0.90fF **FLOATING
C15012 divbuf_1/a_19072_n240# vdd 0.90fF **FLOATING
C15013 divbuf_1/a_18582_n240# vdd 0.89fF **FLOATING
C15014 divbuf_1/a_18092_n240# vdd 0.89fF **FLOATING
C15015 divbuf_1/a_17612_n240# vdd 0.89fF **FLOATING
C15016 divbuf_1/a_17122_n240# vdd 0.88fF **FLOATING
C15017 divbuf_1/a_16642_n240# vdd 0.88fF **FLOATING
C15018 divbuf_1/a_16152_n240# vdd 0.88fF **FLOATING
C15019 divbuf_1/a_15672_n240# vdd 0.90fF **FLOATING
C15020 divbuf_1/a_15182_n240# vdd 0.88fF **FLOATING
C15021 divbuf_1/a_14702_n240# vdd 0.88fF **FLOATING
C15022 divbuf_1/a_14222_n240# vdd 0.88fF **FLOATING
C15023 divbuf_1/a_13742_n240# vdd 0.88fF **FLOATING
C15024 divbuf_1/a_13252_n240# vdd 0.88fF **FLOATING
C15025 divbuf_1/a_12772_n240# vdd 0.88fF **FLOATING
C15026 divbuf_1/a_12282_n240# vdd 0.88fF **FLOATING
C15027 divbuf_1/a_11802_n240# vdd 0.88fF **FLOATING
C15028 divbuf_1/a_11312_n240# vdd 0.89fF **FLOATING
C15029 divbuf_1/a_10212_n240# vdd 0.91fF **FLOATING
C15030 divbuf_1/a_9732_n240# vdd 0.91fF **FLOATING
C15031 divbuf_1/a_9242_n240# vdd 0.91fF **FLOATING
C15032 divbuf_1/a_8762_n240# vdd 0.91fF **FLOATING
C15033 divbuf_1/a_8272_n240# vdd 0.91fF **FLOATING
C15034 divbuf_1/a_7792_n240# vdd 0.92fF **FLOATING
C15035 divbuf_1/a_7302_n240# vdd 0.90fF **FLOATING
C15036 divbuf_1/a_6822_n240# vdd 0.90fF **FLOATING
C15037 divbuf_1/a_6332_n240# vdd 0.90fF **FLOATING
C15038 divbuf_1/a_5852_n240# vdd 0.90fF **FLOATING
C15039 divbuf_1/a_5362_n240# vdd 0.90fF **FLOATING
C15040 divbuf_1/a_4882_n240# vdd 0.90fF **FLOATING
C15041 divbuf_1/a_4392_n240# vdd 0.90fF **FLOATING
C15042 divbuf_1/a_3912_n240# vdd 0.90fF **FLOATING
C15043 divbuf_1/a_3422_n240# vdd 0.90fF **FLOATING
C15044 divbuf_1/a_2322_n240# vdd 0.91fF **FLOATING
C15045 divbuf_1/a_1842_n240# vdd 0.91fF **FLOATING
C15046 divbuf_1/a_1352_n240# vdd 0.91fF **FLOATING
C15047 divbuf_1/a_41382_170# vdd 1.07fF **FLOATING
C15048 divbuf_1/a_40902_170# vdd 1.09fF **FLOATING
C15049 divbuf_1/a_40412_170# vdd 1.09fF **FLOATING
C15050 divbuf_1/a_39932_170# vdd 1.09fF **FLOATING
C15051 divbuf_1/a_39442_170# vdd 1.09fF **FLOATING
C15052 divbuf_1/a_38962_170# vdd 1.07fF **FLOATING
C15053 divbuf_1/a_38472_170# vdd 1.09fF **FLOATING
C15054 divbuf_1/a_37992_170# vdd 1.09fF **FLOATING
C15055 divbuf_1/a_37502_170# vdd 1.09fF **FLOATING
C15056 divbuf_1/a_37022_170# vdd 1.09fF **FLOATING
C15057 divbuf_1/a_36532_170# vdd 1.09fF **FLOATING
C15058 divbuf_1/a_36052_170# vdd 1.09fF **FLOATING
C15059 divbuf_1/a_35562_170# vdd 1.09fF **FLOATING
C15060 divbuf_1/a_35082_170# vdd 1.09fF **FLOATING
C15061 divbuf_1/a_34592_170# vdd 1.07fF **FLOATING
C15062 divbuf_1/a_34112_170# vdd 1.09fF **FLOATING
C15063 divbuf_1/a_33622_170# vdd 1.09fF **FLOATING
C15064 divbuf_1/a_33142_170# vdd 1.09fF **FLOATING
C15065 divbuf_1/a_32652_170# vdd 1.09fF **FLOATING
C15066 divbuf_1/a_32172_170# vdd 1.09fF **FLOATING
C15067 divbuf_1/a_31682_170# vdd 1.09fF **FLOATING
C15068 divbuf_1/a_31202_170# vdd 1.09fF **FLOATING
C15069 divbuf_1/a_30712_170# vdd 1.09fF **FLOATING
C15070 divbuf_1/a_30232_170# vdd 1.07fF **FLOATING
C15071 divbuf_1/a_29742_170# vdd 1.09fF **FLOATING
C15072 divbuf_1/a_29262_170# vdd 1.09fF **FLOATING
C15073 divbuf_1/a_28772_170# vdd 1.09fF **FLOATING
C15074 divbuf_1/a_28292_170# vdd 1.09fF **FLOATING
C15075 divbuf_1/a_27802_170# vdd 1.09fF **FLOATING
C15076 divbuf_1/a_27322_170# vdd 1.09fF **FLOATING
C15077 divbuf_1/a_26832_170# vdd 1.09fF **FLOATING
C15078 divbuf_1/a_26352_170# vdd 1.09fF **FLOATING
C15079 divbuf_1/a_25862_170# vdd 1.07fF **FLOATING
C15080 divbuf_1/a_25382_170# vdd 1.09fF **FLOATING
C15081 divbuf_1/a_24892_170# vdd 1.09fF **FLOATING
C15082 divbuf_1/a_24412_170# vdd 1.09fF **FLOATING
C15083 divbuf_1/a_23922_170# vdd 1.09fF **FLOATING
C15084 divbuf_1/a_23442_170# vdd 1.09fF **FLOATING
C15085 divbuf_1/a_22952_170# vdd 1.09fF **FLOATING
C15086 divbuf_1/a_22472_170# vdd 1.07fF **FLOATING
C15087 divbuf_1/a_21982_170# vdd 1.09fF **FLOATING
C15088 divbuf_1/a_21502_170# vdd 1.09fF **FLOATING
C15089 divbuf_1/a_21012_170# vdd 1.09fF **FLOATING
C15090 divbuf_1/a_20532_170# vdd 1.09fF **FLOATING
C15091 divbuf_1/a_20042_170# vdd 1.09fF **FLOATING
C15092 divbuf_1/a_19562_170# vdd 1.09fF **FLOATING
C15093 divbuf_1/a_19072_170# vdd 1.09fF **FLOATING
C15094 divbuf_1/a_18582_170# vdd 1.07fF **FLOATING
C15095 divbuf_1/a_18092_170# vdd 1.09fF **FLOATING
C15096 divbuf_1/a_17612_170# vdd 1.09fF **FLOATING
C15097 divbuf_1/a_17122_170# vdd 1.09fF **FLOATING
C15098 divbuf_1/a_16642_170# vdd 1.09fF **FLOATING
C15099 divbuf_1/a_16152_170# vdd 1.09fF **FLOATING
C15100 divbuf_1/a_15672_170# vdd 1.09fF **FLOATING
C15101 divbuf_1/a_15182_170# vdd 1.09fF **FLOATING
C15102 divbuf_1/a_14702_170# vdd 1.10fF **FLOATING
C15103 divbuf_1/a_14222_170# vdd 1.10fF **FLOATING
C15104 divbuf_1/a_13742_170# vdd 1.09fF **FLOATING
C15105 divbuf_1/a_13252_170# vdd 1.09fF **FLOATING
C15106 divbuf_1/a_12772_170# vdd 1.07fF **FLOATING
C15107 divbuf_1/a_12282_170# vdd 1.09fF **FLOATING
C15108 divbuf_1/a_11802_170# vdd 1.09fF **FLOATING
C15109 divbuf_1/a_11312_170# vdd 1.10fF **FLOATING
C15110 divbuf_1/a_10212_170# vdd 1.09fF **FLOATING
C15111 divbuf_1/a_9732_170# vdd 1.09fF **FLOATING
C15112 divbuf_1/a_9242_170# vdd 1.09fF **FLOATING
C15113 divbuf_1/a_8762_170# vdd 1.09fF **FLOATING
C15114 divbuf_1/a_8272_170# vdd 1.07fF **FLOATING
C15115 divbuf_1/a_7792_170# vdd 1.09fF **FLOATING
C15116 divbuf_1/a_7302_170# vdd 1.09fF **FLOATING
C15117 divbuf_1/a_6822_170# vdd 1.09fF **FLOATING
C15118 divbuf_1/a_6332_170# vdd 1.09fF **FLOATING
C15119 divbuf_1/a_5852_170# vdd 1.09fF **FLOATING
C15120 divbuf_1/a_5362_170# vdd 1.09fF **FLOATING
C15121 divbuf_1/a_4882_170# vdd 1.09fF **FLOATING
C15122 divbuf_1/a_4392_170# vdd 1.07fF **FLOATING
C15123 divbuf_1/a_3912_170# vdd 1.09fF **FLOATING
C15124 divbuf_1/a_3422_170# vdd 1.10fF **FLOATING
C15125 divbuf_1/a_2322_170# vdd 1.09fF **FLOATING
C15126 divbuf_1/a_1842_170# vdd 1.09fF **FLOATING
C15127 divbuf_1/a_1352_170# vdd 1.10fF **FLOATING
C15128 divbuf_1/a_492_n240# vdd 2.46fF **FLOATING
C15129 pd_div_0/divider_0/and_0/Z1 vdd 0.65fF
C15130 pd_div_0/divider_0/and_0/B vdd 2.45fF
C15131 pd_div_0/divider_0/and_0/A vdd 2.35fF
C15132 pd_div_0/divider_0/and_0/out1 vdd 2.99fF
C15133 pd_div_0/divider_0/tspc_2/Z4 vdd 0.86fF
C15134 pd_div_0/bufin vdd 9.36fF
C15135 pd_div_0/divider_0/tspc_2/Z3 vdd 2.26fF
C15136 pd_div_0/divider_0/tspc_2/Z2 vdd 1.46fF
C15137 pd_div_0/divider_0/tspc_2/Z1 vdd 0.99fF
C15138 pd_div_0/divider_0/nor_0/B vdd 6.48fF
C15139 pd_div_0/divider_0/tspc_2/a_630_n680# vdd 1.14fF **FLOATING
C15140 pd_div_0/divider_0/tspc_1/Z4 vdd 0.86fF
C15141 pd_div_0/divider_0/tspc_1/Q vdd 3.12fF
C15142 pd_div_0/divider_0/tspc_1/Z3 vdd 2.26fF
C15143 pd_div_0/divider_0/tspc_1/Z2 vdd 1.46fF
C15144 pd_div_0/divider_0/tspc_1/Z1 vdd 0.99fF
C15145 pd_div_0/divider_0/nor_1/B vdd 7.12fF
C15146 pd_div_0/divider_0/tspc_1/a_630_n680# vdd 1.15fF **FLOATING
C15147 pd_div_0/divider_0/tspc_0/Z4 vdd 0.86fF
C15148 pd_div_0/divider_0/tspc_0/Q vdd 3.14fF
C15149 pd_div_0/divider_0/tspc_0/Z3 vdd 2.26fF
C15150 pd_div_0/divider_0/tspc_0/Z2 vdd 1.46fF
C15151 pd_div_0/divider_0/tspc_0/Z1 vdd 0.99fF
C15152 pd_div_0/divider_0/nor_1/A vdd 7.08fF
C15153 pd_div_0/divider_0/tspc_0/a_630_n680# vdd 1.15fF **FLOATING
C15154 pd_div_0/divider_0/clk vdd 5.70fF
C15155 pd_div_0/divider_0/prescaler_0/Out vdd 4.59fF
C15156 pd_div_0/divider_0/prescaler_0/nand_1/z1 vdd 0.36fF
C15157 pd_div_0/divider_0/prescaler_0/tspc_2/D vdd 2.64fF
C15158 pd_div_0/divider_0/prescaler_0/tspc_0/Q vdd 3.64fF
C15159 pd_div_0/divider_0/prescaler_0/tspc_1/Q vdd 3.61fF
C15160 pd_div_0/divider_0/prescaler_0/nand_0/z1 vdd 0.36fF
C15161 pd_div_0/divider_0/prescaler_0/tspc_0/D vdd 3.12fF
C15162 pd_div_0/divider_0/and_0/OUT vdd 5.67fF
C15163 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.86fF
C15164 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.26fF
C15165 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.46fF
C15166 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C15167 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 1.16fF **FLOATING
C15168 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 2.11fF **FLOATING
C15169 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.86fF
C15170 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.26fF
C15171 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.48fF
C15172 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C15173 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 1.14fF **FLOATING
C15174 pd_div_0/divider_0/prescaler_0/m1_2700_2190# vdd 4.22fF **FLOATING
C15175 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.86fF
C15176 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.26fF
C15177 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.19fF
C15178 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C15179 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 1.47fF **FLOATING
C15180 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 2.11fF **FLOATING
C15181 pd_div_0/divider_0/nor_1/Z1 vdd 1.34fF
C15182 pd_div_0/divider_0/nor_0/Z1 vdd 1.34fF
C15183 pd_div_0/divbuf_0/OUT5 vdd 16.40fF
C15184 pd_div_0/divbuf_0/OUT4 vdd 100.06fF
C15185 pd_div_0/divbuf_0/OUT3 vdd 27.01fF
C15186 pd_div_0/divbuf_0/OUT2 vdd 8.71fF
C15187 pd_div_0/divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C15188 pd_div_0/divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C15189 pd_div_0/divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C15190 pd_div_0/divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C15191 pd_div_0/divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C15192 pd_div_0/divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C15193 pd_div_0/divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C15194 pd_div_0/divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C15195 pd_div_0/divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C15196 pd_div_0/divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C15197 pd_div_0/divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C15198 pd_div_0/divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C15199 pd_div_0/divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C15200 pd_div_0/divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C15201 pd_div_0/divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C15202 pd_div_0/divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C15203 pd_div_0/divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C15204 pd_div_0/divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C15205 pd_div_0/divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C15206 pd_div_0/divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C15207 pd_div_0/divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C15208 pd_div_0/divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C15209 pd_div_0/divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C15210 pd_div_0/divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C15211 pd_div_0/divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C15212 pd_div_0/divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C15213 pd_div_0/divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C15214 pd_div_0/divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C15215 pd_div_0/divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C15216 pd_div_0/divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C15217 pd_div_0/divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C15218 pd_div_0/divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C15219 pd_div_0/divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C15220 pd_div_0/divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C15221 pd_div_0/divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C15222 pd_div_0/divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C15223 pd_div_0/divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C15224 pd_div_0/divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C15225 pd_div_0/divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C15226 pd_div_0/divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C15227 pd_div_0/divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C15228 pd_div_0/divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C15229 pd_div_0/divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C15230 pd_div_0/divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C15231 pd_div_0/divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C15232 pd_div_0/divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C15233 pd_div_0/divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C15234 pd_div_0/divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C15235 pd_div_0/divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C15236 pd_div_0/divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C15237 pd_div_0/divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C15238 pd_div_0/divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C15239 pd_div_0/divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C15240 pd_div_0/divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C15241 pd_div_0/divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C15242 pd_div_0/divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C15243 pd_div_0/divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C15244 pd_div_0/divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C15245 pd_div_0/divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C15246 pd_div_0/divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C15247 pd_div_0/divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C15248 pd_div_0/divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C15249 pd_div_0/divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C15250 pd_div_0/divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C15251 pd_div_0/divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C15252 pd_div_0/divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C15253 pd_div_0/divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C15254 pd_div_0/divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C15255 pd_div_0/divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C15256 pd_div_0/divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C15257 pd_div_0/divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C15258 pd_div_0/divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C15259 pd_div_0/divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C15260 pd_div_0/divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C15261 pd_div_0/divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C15262 pd_div_0/divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C15263 pd_div_0/divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C15264 pd_div_0/divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C15265 pd_div_0/divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C15266 pd_div_0/divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C15267 pd_div_0/divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C15268 pd_div_0/divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C15269 pd_div_0/divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C15270 pd_div_0/divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C15271 pd_div_0/divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C15272 pd_div_0/divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C15273 pd_div_0/divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C15274 pd_div_0/divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C15275 pd_div_0/divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C15276 pd_div_0/divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C15277 pd_div_0/divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C15278 pd_div_0/divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C15279 pd_div_0/divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C15280 pd_div_0/divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C15281 pd_div_0/divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C15282 pd_div_0/divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C15283 pd_div_0/divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C15284 pd_div_0/divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C15285 pd_div_0/divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C15286 pd_div_0/divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C15287 pd_div_0/divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C15288 pd_div_0/divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C15289 pd_div_0/divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C15290 pd_div_0/divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C15291 pd_div_0/divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C15292 pd_div_0/divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C15293 pd_div_0/divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C15294 pd_div_0/divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C15295 pd_div_0/divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C15296 pd_div_0/divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C15297 pd_div_0/divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C15298 pd_div_0/divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C15299 pd_div_0/divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C15300 pd_div_0/divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C15301 pd_div_0/divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C15302 pd_div_0/divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C15303 pd_div_0/divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C15304 pd_div_0/divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C15305 pd_div_0/divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C15306 pd_div_0/divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C15307 pd_div_0/divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C15308 pd_div_0/divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C15309 pd_div_0/divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C15310 pd_div_0/divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C15311 pd_div_0/divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C15312 pd_div_0/divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C15313 pd_div_0/divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C15314 pd_div_0/divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C15315 pd_div_0/divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C15316 pd_div_0/divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C15317 pd_div_0/divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C15318 pd_div_0/divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C15319 pd_div_0/divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C15320 pd_div_0/divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C15321 pd_div_0/divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C15322 pd_div_0/divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C15323 pd_div_0/divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C15324 pd_div_0/divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C15325 pd_div_0/divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C15326 pd_div_0/divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C15327 pd_div_0/divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C15328 pd_div_0/divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C15329 pd_div_0/divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C15330 pd_div_0/divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C15331 pd_div_0/divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C15332 pd_div_0/divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C15333 pd_div_0/divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C15334 pd_div_0/divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C15335 pd_div_0/divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C15336 pd_div_0/divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C15337 pd_div_0/divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C15338 pd_div_0/divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C15339 pd_div_0/divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C15340 pd_div_0/divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C15341 pd_div_0/divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C15342 pd_div_0/divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C15343 pd_div_0/divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C15344 pd_div_0/divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C15345 pd_div_0/divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C15346 pd_div_0/divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C15347 pd_div_0/divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C15348 pd_div_0/divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C15349 pd_div_0/divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C15350 pd_div_0/divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C15351 pd_div_0/divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C15352 pd_div_0/divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C15353 pd_div_0/divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C15354 pd_div_0/divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C15355 pd_div_0/divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C15356 pd_div_0/divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C15357 pd_div_0/divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C15358 pd_div_0/divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C15359 pd_div_0/divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C15360 pd_div_0/divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C15361 pd_div_0/divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C15362 pd_div_0/divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C15363 pd_div_0/divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C15364 pd_div_0/divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C15365 pd_div_0/divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C15366 pd_div_0/divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C15367 pd_div_0/divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C15368 pd_div_0/divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C15369 pd_div_0/divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C15370 pd_div_0/divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C15371 pd_div_0/divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C15372 pd_div_0/divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C15373 pd_div_0/divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C15374 pd_div_0/divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C15375 pd_div_0/divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C15376 pd_div_0/divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C15377 pd_div_0/divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C15378 pd_div_0/divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C15379 pd_div_0/divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C15380 pd_div_0/divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C15381 pd_div_0/divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C15382 pd_div_0/divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C15383 pd_div_0/divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C15384 pd_div_0/divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C15385 pd_div_0/divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C15386 pd_div_0/divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C15387 pd_div_0/divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C15388 pd_div_0/divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C15389 pd_div_0/divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C15390 pd_div_0/divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C15391 pd_div_0/divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C15392 pd_div_0/divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C15393 pd_div_0/divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C15394 pd_div_0/divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C15395 pd_div_0/divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C15396 pd_div_0/divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C15397 pd_div_0/divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C15398 pd_div_0/divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C15399 pd_div_0/divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C15400 pd_div_0/divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C15401 pd_div_0/divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C15402 pd_div_0/divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C15403 pd_div_0/divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C15404 pd_div_0/divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C15405 pd_div_0/divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C15406 pd_div_0/divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C15407 pd_div_0/divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C15408 pd_div_0/divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C15409 pd_div_0/divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C15410 pd_div_0/divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C15411 pd_div_0/divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C15412 pd_div_0/divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C15413 pd_div_0/divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C15414 pd_div_0/divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C15415 pd_div_0/divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C15416 pd_div_0/divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C15417 pd_div_0/divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C15418 pd_div_0/divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C15419 pd_div_0/divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C15420 pd_div_0/divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C15421 pd_div_0/divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C15422 pd_div_0/divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C15423 pd_div_0/divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C15424 pd_div_0/divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C15425 pd_div_0/divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C15426 pd_div_0/divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C15427 pd_div_0/divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C15428 pd_div_0/divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C15429 pd_div_0/divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C15430 pd_div_0/divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C15431 pd_div_0/divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C15432 pd_div_0/divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C15433 pd_div_0/divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C15434 pd_div_0/divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C15435 pd_div_0/divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C15436 pd_div_0/divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C15437 pd_div_0/divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C15438 pd_div_0/divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C15439 pd_div_0/divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C15440 pd_div_0/divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C15441 pd_div_0/divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C15442 pd_div_0/divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C15443 pd_div_0/divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C15444 pd_div_0/divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C15445 pd_div_0/divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C15446 pd_div_0/divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C15447 pd_div_0/divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C15448 pd_div_0/divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C15449 pd_div_0/divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C15450 pd_div_0/divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C15451 pd_div_0/divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C15452 pd_div_0/divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C15453 pd_div_0/divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C15454 pd_div_0/divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C15455 pd_div_0/divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C15456 pd_div_0/divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C15457 pd_div_0/divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C15458 pd_div_0/divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C15459 pd_div_0/divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C15460 pd_div_0/divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C15461 pd_div_0/divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C15462 pd_div_0/divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C15463 pd_div_0/divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C15464 pd_div_0/divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C15465 pd_div_0/divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C15466 pd_div_0/divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C15467 pd_div_0/divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C15468 pd_div_0/divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C15469 pd_div_0/divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C15470 pd_div_0/divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C15471 pd_div_0/divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C15472 pd_div_0/divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C15473 pd_div_0/divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C15474 pd_div_0/divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C15475 pd_div_0/divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C15476 pd_div_0/divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C15477 pd_div_0/divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C15478 pd_div_0/divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C15479 pd_div_0/divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C15480 pd_div_0/divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C15481 pd_div_0/divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C15482 pd_div_0/divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C15483 pd_div_0/divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C15484 pd_div_0/divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C15485 pd_div_0/divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C15486 pd_div_0/divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C15487 pd_div_0/divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C15488 pd_div_0/divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C15489 pd_div_0/divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C15490 pd_div_0/divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C15491 pd_div_0/divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C15492 pd_div_0/divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C15493 pd_div_0/divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C15494 pd_div_0/divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C15495 pd_div_0/divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C15496 pd_div_0/divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C15497 pd_div_0/divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C15498 pd_div_0/divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C15499 pd_div_0/divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C15500 pd_div_0/divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C15501 pd_div_0/divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C15502 pd_div_0/divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C15503 pd_div_0/divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C15504 pd_div_0/divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C15505 pd_div_0/divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C15506 pd_div_0/divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C15507 pd_div_0/divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C15508 pd_div_0/divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C15509 pd_div_0/divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C15510 pd_div_0/divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C15511 pd_div_0/divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C15512 pd_div_0/divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C15513 pd_div_0/divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C15514 pd_div_0/divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C15515 pd_div_0/divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C15516 pd_div_0/divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C15517 pd_div_0/divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C15518 pd_div_0/divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C15519 pd_div_0/divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C15520 pd_div_0/divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C15521 pd_div_0/divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C15522 pd_div_0/divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C15523 pd_div_0/divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C15524 pd_div_0/divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C15525 pd_div_0/divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C15526 pd_div_0/divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C15527 pd_div_0/divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C15528 pd_div_0/divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C15529 pd_div_0/divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C15530 pd_div_0/divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C15531 pd_div_0/divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C15532 pd_div_0/divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C15533 pd_div_0/divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C15534 pd_div_0/divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C15535 pd_div_0/divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C15536 pd_div_0/divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C15537 pd_div_0/divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C15538 pd_div_0/divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C15539 pd_div_0/divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C15540 pd_div_0/divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C15541 pd_div_0/divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C15542 pd_div_0/divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C15543 pd_div_0/divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C15544 pd_div_0/divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C15545 pd_div_0/divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C15546 pd_div_0/divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C15547 pd_div_0/divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C15548 pd_div_0/divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C15549 pd_div_0/divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C15550 pd_div_0/divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C15551 pd_div_0/divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C15552 pd_div_0/divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C15553 pd_div_0/divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C15554 pd_div_0/divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C15555 pd_div_0/divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C15556 pd_div_0/divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C15557 pd_div_0/divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C15558 pd_div_0/divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C15559 pd_div_0/divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C15560 pd_div_0/divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C15561 pd_div_0/divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C15562 pd_div_0/divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C15563 pd_div_0/divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C15564 pd_div_0/divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C15565 pd_div_0/divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C15566 pd_div_0/divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C15567 pd_div_0/divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C15568 pd_div_0/divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C15569 pd_div_0/divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C15570 pd_div_0/divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C15571 pd_div_0/divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C15572 pd_div_0/divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C15573 pd_div_0/divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C15574 pd_div_0/divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C15575 pd_div_0/divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C15576 pd_div_0/divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C15577 pd_div_0/divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C15578 pd_div_0/divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C15579 pd_div_0/divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C15580 pd_div_0/divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C15581 pd_div_0/divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C15582 pd_div_0/divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C15583 pd_div_0/divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C15584 pd_div_0/divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C15585 pd_div_0/divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C15586 pd_div_0/divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C15587 pd_div_0/divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C15588 pd_div_0/divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C15589 pd_div_0/divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C15590 pd_div_0/divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C15591 pd_div_0/divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C15592 pd_div_0/divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C15593 pd_div_0/divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C15594 pd_div_0/divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C15595 pd_div_0/divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C15596 pd_div_0/divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C15597 pd_div_0/divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C15598 pd_div_0/divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C15599 pd_div_0/divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C15600 pd_div_0/divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C15601 pd_div_0/divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C15602 pd_div_0/divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C15603 pd_div_0/divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C15604 pd_div_0/divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C15605 pd_div_0/divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C15606 pd_div_0/divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C15607 pd_div_0/divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C15608 pd_div_0/divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C15609 pd_div_0/divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C15610 pd_div_0/divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C15611 pd_div_0/divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C15612 pd_div_0/divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C15613 pd_div_0/divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C15614 pd_div_0/divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C15615 pd_div_0/divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C15616 pd_div_0/divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C15617 pd_div_0/divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C15618 pd_div_0/divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C15619 pd_div_0/divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C15620 pd_div_0/divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C15621 pd_div_0/divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C15622 pd_div_0/divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C15623 pd_div_0/divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C15624 pd_div_0/divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C15625 pd_div_0/divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C15626 pd_div_0/divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C15627 pd_div_0/divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C15628 pd_div_0/divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C15629 pd_div_0/divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C15630 pd_div_0/divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C15631 pd_div_0/divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C15632 pd_div_0/divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C15633 pd_div_0/divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C15634 pd_div_0/divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C15635 pd_div_0/divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C15636 pd_div_0/divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C15637 pd_div_0/divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C15638 pd_div_0/divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C15639 pd_div_0/divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C15640 pd_div_0/divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C15641 pd_div_0/divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C15642 pd_div_0/divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C15643 pd_div_0/divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C15644 pd_div_0/divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C15645 pd_div_0/divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C15646 pd_div_0/divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C15647 pd_div_0/divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C15648 pd_div_0/divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C15649 pd_div_0/divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C15650 pd_div_0/divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C15651 pd_div_0/divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C15652 pd_div_0/divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C15653 pd_div_0/divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C15654 pd_div_0/divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C15655 pd_div_0/divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C15656 pd_div_0/divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C15657 pd_div_0/divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C15658 pd_div_0/divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C15659 pd_div_0/divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C15660 pd_div_0/divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C15661 pd_div_0/divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C15662 pd_div_0/divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C15663 pd_div_0/divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C15664 pd_div_0/divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C15665 pd_div_0/divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C15666 pd_div_0/divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C15667 pd_div_0/divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C15668 pd_div_0/divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C15669 pd_div_0/divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C15670 pd_div_0/divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C15671 pd_div_0/divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C15672 pd_div_0/divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C15673 pd_div_0/divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C15674 pd_div_0/divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C15675 pd_div_0/divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C15676 pd_div_0/divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C15677 pd_div_0/divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C15678 pd_div_0/divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C15679 pd_div_0/divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C15680 pd_div_0/divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C15681 pd_div_0/divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C15682 pd_div_0/divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C15683 pd_div_0/divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C15684 pd_div_0/divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C15685 pd_div_0/divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C15686 pd_div_0/divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C15687 pd_div_0/divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C15688 pd_div_0/divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C15689 pd_div_0/divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C15690 pd_div_0/divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C15691 pd_div_0/divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C15692 pd_div_0/divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C15693 pd_div_0/divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C15694 pd_div_0/divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C15695 pd_div_0/divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C15696 pd_div_0/divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C15697 pd_div_0/divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C15698 pd_div_0/divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C15699 pd_div_0/divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C15700 pd_div_0/divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C15701 pd_div_0/divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C15702 pd_div_0/divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C15703 pd_div_0/divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C15704 pd_div_0/divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C15705 pd_div_0/divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C15706 pd_div_0/divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C15707 pd_div_0/divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C15708 pd_div_0/divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C15709 pd_div_0/divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C15710 pd_div_0/divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C15711 pd_div_0/divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C15712 pd_div_0/divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C15713 pd_div_0/divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C15714 pd_div_0/divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C15715 pd_div_0/divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C15716 pd_div_0/divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C15717 pd_div_0/divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C15718 pd_div_0/divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C15719 pd_div_0/divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C15720 pd_div_0/divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C15721 pd_div_0/divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C15722 pd_div_0/divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C15723 pd_div_0/divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C15724 pd_div_0/divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C15725 pd_div_0/divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C15726 pd_div_0/divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C15727 pd_div_0/divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C15728 pd_div_0/divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C15729 pd_div_0/divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C15730 pd_div_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C15731 pd_div_0/pd_0/and_pd_0/Z1 vdd 0.39fF
C15732 pd_div_0/pd_0/and_pd_0/Out1 vdd 2.22fF
C15733 pd_div_0/pd_0/tspc_r_1/z5 vdd 1.10fF
C15734 pd_div_0/pd_0/tspc_r_1/Z4 vdd 1.07fF
C15735 pd_div_0/pd_0/tspc_r_1/Qbar vdd 0.88fF
C15736 pd_div_0/pd_0/tspc_r_1/Z2 vdd 1.22fF
C15737 pd_div_0/pd_0/tspc_r_1/Z1 vdd 0.67fF
C15738 pd_div_0/pd_0/UP vdd 2.30fF
C15739 pd_div_0/pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C15740 pd_div_0/pd_0/tspc_r_1/Z3 vdd 2.12fF
C15741 pd_div_0/pd_0/REF vdd 1.86fF
C15742 pd_div_0/pd_0/tspc_r_0/z5 vdd 1.10fF
C15743 pd_div_0/pd_0/tspc_r_0/Z4 vdd 1.07fF
C15744 pd_div_0/pd_0/R vdd 3.05fF
C15745 pd_div_0/pd_0/tspc_r_0/Qbar vdd 0.79fF
C15746 pd_div_0/pd_0/tspc_r_0/Z2 vdd 1.22fF
C15747 pd_div_0/pd_0/tspc_r_0/Z1 vdd 0.67fF
C15748 pd_div_0/pd_0/DOWN vdd 3.17fF
C15749 pd_div_0/pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C15750 pd_div_0/pd_0/tspc_r_0/Z3 vdd 2.12fF
C15751 pd_div_0/div vdd 8.07fF
C15752 divbuf_0/OUT vdd 3.28fF
C15753 divbuf_0/OUT5 vdd 16.40fF
C15754 divbuf_0/OUT4 vdd 100.06fF
C15755 divbuf_0/OUT3 vdd 27.01fF
C15756 divbuf_0/OUT2 vdd 8.71fF
C15757 divbuf_0/IN vdd 0.89fF
C15758 divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C15759 divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C15760 divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C15761 divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C15762 divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C15763 divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C15764 divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C15765 divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C15766 divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C15767 divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C15768 divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C15769 divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C15770 divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C15771 divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C15772 divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C15773 divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C15774 divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C15775 divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C15776 divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C15777 divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C15778 divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C15779 divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C15780 divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C15781 divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C15782 divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C15783 divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C15784 divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C15785 divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C15786 divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C15787 divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C15788 divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C15789 divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C15790 divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C15791 divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C15792 divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C15793 divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C15794 divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C15795 divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C15796 divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C15797 divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C15798 divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C15799 divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C15800 divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C15801 divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C15802 divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C15803 divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C15804 divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C15805 divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C15806 divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C15807 divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C15808 divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C15809 divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C15810 divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C15811 divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C15812 divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C15813 divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C15814 divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C15815 divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C15816 divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C15817 divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C15818 divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C15819 divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C15820 divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C15821 divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C15822 divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C15823 divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C15824 divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C15825 divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C15826 divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C15827 divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C15828 divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C15829 divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C15830 divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C15831 divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C15832 divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C15833 divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C15834 divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C15835 divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C15836 divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C15837 divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C15838 divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C15839 divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C15840 divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C15841 divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C15842 divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C15843 divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C15844 divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C15845 divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C15846 divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C15847 divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C15848 divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C15849 divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C15850 divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C15851 divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C15852 divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C15853 divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C15854 divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C15855 divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C15856 divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C15857 divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C15858 divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C15859 divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C15860 divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C15861 divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C15862 divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C15863 divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C15864 divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C15865 divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C15866 divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C15867 divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C15868 divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C15869 divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C15870 divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C15871 divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C15872 divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C15873 divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C15874 divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C15875 divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C15876 divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C15877 divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C15878 divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C15879 divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C15880 divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C15881 divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C15882 divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C15883 divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C15884 divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C15885 divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C15886 divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C15887 divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C15888 divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C15889 divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C15890 divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C15891 divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C15892 divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C15893 divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C15894 divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C15895 divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C15896 divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C15897 divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C15898 divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C15899 divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C15900 divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C15901 divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C15902 divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C15903 divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C15904 divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C15905 divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C15906 divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C15907 divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C15908 divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C15909 divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C15910 divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C15911 divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C15912 divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C15913 divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C15914 divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C15915 divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C15916 divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C15917 divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C15918 divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C15919 divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C15920 divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C15921 divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C15922 divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C15923 divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C15924 divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C15925 divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C15926 divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C15927 divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C15928 divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C15929 divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C15930 divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C15931 divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C15932 divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C15933 divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C15934 divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C15935 divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C15936 divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C15937 divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C15938 divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C15939 divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C15940 divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C15941 divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C15942 divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C15943 divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C15944 divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C15945 divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C15946 divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C15947 divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C15948 divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C15949 divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C15950 divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C15951 divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C15952 divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C15953 divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C15954 divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C15955 divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C15956 divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C15957 divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C15958 divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C15959 divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C15960 divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C15961 divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C15962 divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C15963 divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C15964 divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C15965 divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C15966 divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C15967 divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C15968 divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C15969 divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C15970 divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C15971 divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C15972 divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C15973 divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C15974 divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C15975 divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C15976 divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C15977 divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C15978 divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C15979 divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C15980 divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C15981 divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C15982 divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C15983 divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C15984 divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C15985 divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C15986 divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C15987 divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C15988 divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C15989 divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C15990 divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C15991 divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C15992 divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C15993 divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C15994 divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C15995 divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C15996 divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C15997 divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C15998 divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C15999 divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C16000 divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C16001 divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C16002 divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C16003 divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C16004 divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C16005 divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C16006 divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C16007 divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C16008 divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C16009 divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C16010 divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C16011 divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C16012 divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C16013 divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C16014 divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C16015 divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C16016 divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C16017 divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C16018 divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C16019 divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C16020 divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C16021 divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C16022 divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C16023 divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C16024 divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C16025 divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C16026 divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C16027 divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C16028 divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C16029 divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C16030 divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C16031 divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C16032 divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C16033 divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C16034 divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C16035 divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C16036 divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C16037 divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C16038 divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C16039 divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C16040 divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C16041 divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C16042 divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C16043 divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C16044 divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C16045 divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C16046 divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C16047 divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C16048 divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C16049 divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C16050 divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C16051 divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C16052 divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C16053 divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C16054 divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C16055 divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C16056 divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C16057 divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C16058 divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C16059 divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C16060 divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C16061 divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C16062 divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C16063 divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C16064 divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C16065 divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C16066 divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C16067 divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C16068 divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C16069 divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C16070 divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C16071 divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C16072 divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C16073 divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C16074 divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C16075 divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C16076 divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C16077 divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C16078 divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C16079 divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C16080 divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C16081 divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C16082 divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C16083 divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C16084 divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C16085 divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C16086 divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C16087 divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C16088 divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C16089 divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C16090 divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C16091 divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C16092 divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C16093 divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C16094 divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C16095 divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C16096 divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C16097 divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C16098 divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C16099 divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C16100 divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C16101 divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C16102 divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C16103 divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C16104 divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C16105 divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C16106 divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C16107 divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C16108 divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C16109 divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C16110 divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C16111 divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C16112 divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C16113 divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C16114 divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C16115 divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C16116 divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C16117 divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C16118 divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C16119 divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C16120 divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C16121 divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C16122 divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C16123 divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C16124 divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C16125 divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C16126 divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C16127 divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C16128 divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C16129 divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C16130 divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C16131 divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C16132 divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C16133 divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C16134 divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C16135 divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C16136 divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C16137 divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C16138 divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C16139 divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C16140 divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C16141 divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C16142 divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C16143 divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C16144 divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C16145 divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C16146 divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C16147 divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C16148 divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C16149 divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C16150 divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C16151 divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C16152 divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C16153 divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C16154 divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C16155 divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C16156 divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C16157 divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C16158 divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C16159 divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C16160 divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C16161 divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C16162 divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C16163 divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C16164 divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C16165 divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C16166 divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C16167 divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C16168 divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C16169 divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C16170 divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C16171 divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C16172 divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C16173 divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C16174 divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C16175 divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C16176 divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C16177 divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C16178 divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C16179 divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C16180 divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C16181 divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C16182 divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C16183 divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C16184 divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C16185 divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C16186 divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C16187 divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C16188 divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C16189 divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C16190 divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C16191 divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C16192 divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C16193 divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C16194 divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C16195 divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C16196 divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C16197 divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C16198 divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C16199 divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C16200 divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C16201 divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C16202 divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C16203 divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C16204 divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C16205 divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C16206 divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C16207 divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C16208 divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C16209 divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C16210 divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C16211 divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C16212 divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C16213 divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C16214 divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C16215 divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C16216 divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C16217 divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C16218 divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C16219 divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C16220 divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C16221 divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C16222 divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C16223 divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C16224 divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C16225 divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C16226 divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C16227 divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C16228 divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C16229 divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C16230 divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C16231 divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C16232 divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C16233 divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C16234 divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C16235 divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C16236 divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C16237 divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C16238 divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C16239 divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C16240 divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C16241 divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C16242 divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C16243 divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C16244 divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C16245 divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C16246 divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C16247 divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C16248 divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C16249 divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C16250 divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C16251 divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C16252 divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C16253 divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C16254 divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C16255 divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C16256 divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C16257 divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C16258 divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C16259 divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C16260 divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C16261 divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C16262 divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C16263 divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C16264 divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C16265 divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C16266 divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C16267 divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C16268 divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C16269 divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C16270 divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C16271 divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C16272 divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C16273 divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C16274 divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C16275 divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C16276 divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C16277 divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C16278 divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C16279 divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C16280 divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C16281 divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C16282 divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C16283 divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C16284 divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C16285 divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C16286 divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C16287 divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C16288 divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C16289 divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C16290 divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C16291 divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C16292 divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C16293 divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C16294 divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C16295 divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C16296 divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C16297 divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C16298 divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C16299 divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C16300 divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C16301 divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C16302 ro_complete_0/cbank_2/v vdd 17.84fF
C16303 ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C16304 ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C16305 ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C16306 ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C16307 ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C16308 ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C16309 ro_complete_0/cbank_1/v vdd 16.34fF
C16310 ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C16311 ro_complete_0/a0 vdd 7.88fF
C16312 ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C16313 ro_complete_0/a1 vdd 5.39fF
C16314 ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C16315 ro_complete_0/a3 vdd 6.85fF
C16316 ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C16317 ro_complete_0/a2 vdd 5.48fF
C16318 ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C16319 ro_complete_0/a4 vdd 5.36fF
C16320 ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C16321 ro_complete_0/a5 vdd 5.19fF
C16322 ro_complete_0/cbank_0/v vdd 14.98fF
C16323 ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C16324 ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C16325 ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C16326 ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C16327 ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C16328 ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C16329 ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C16330 ro_div_0/divider_0/and_0/Z1 vdd 0.65fF
C16331 ro_div_0/divider_0/and_0/B vdd 2.45fF
C16332 ro_div_0/divider_0/and_0/A vdd 2.35fF
C16333 ro_div_0/divider_0/and_0/out1 vdd 2.99fF
C16334 ro_div_0/divider_0/tspc_2/Z4 vdd 0.86fF
C16335 ro_div_0/divbuf_0/IN vdd 9.54fF
C16336 ro_div_0/divider_0/tspc_2/Z3 vdd 2.26fF
C16337 ro_div_0/divider_0/tspc_2/Z2 vdd 1.46fF
C16338 ro_div_0/divider_0/tspc_2/Z1 vdd 0.99fF
C16339 ro_div_0/divider_0/nor_0/B vdd 6.48fF
C16340 ro_div_0/divider_0/tspc_2/a_630_n680# vdd 1.14fF **FLOATING
C16341 ro_div_0/divider_0/tspc_1/Z4 vdd 0.86fF
C16342 ro_div_0/divider_0/tspc_1/Q vdd 3.12fF
C16343 ro_div_0/divider_0/tspc_1/Z3 vdd 2.26fF
C16344 ro_div_0/divider_0/tspc_1/Z2 vdd 1.46fF
C16345 ro_div_0/divider_0/tspc_1/Z1 vdd 0.99fF
C16346 ro_div_0/divider_0/nor_1/B vdd 7.12fF
C16347 ro_div_0/divider_0/tspc_1/a_630_n680# vdd 1.15fF **FLOATING
C16348 ro_div_0/divider_0/tspc_0/Z4 vdd 0.86fF
C16349 ro_div_0/divider_0/tspc_0/Q vdd 3.14fF
C16350 ro_div_0/divider_0/tspc_0/Z3 vdd 2.26fF
C16351 ro_div_0/divider_0/tspc_0/Z2 vdd 1.46fF
C16352 ro_div_0/divider_0/tspc_0/Z1 vdd 0.99fF
C16353 ro_div_0/divider_0/nor_1/A vdd 7.08fF
C16354 ro_div_0/divider_0/tspc_0/a_630_n680# vdd 1.15fF **FLOATING
C16355 ro_div_0/divider_0/clk vdd 23.42fF
C16356 ro_div_0/divider_0/prescaler_0/Out vdd 4.59fF
C16357 ro_div_0/divider_0/prescaler_0/nand_1/z1 vdd 0.36fF
C16358 ro_div_0/divider_0/prescaler_0/tspc_2/D vdd 2.64fF
C16359 ro_div_0/divider_0/prescaler_0/tspc_0/Q vdd 3.64fF
C16360 ro_div_0/divider_0/prescaler_0/tspc_1/Q vdd 3.61fF
C16361 ro_div_0/divider_0/prescaler_0/nand_0/z1 vdd 0.36fF
C16362 ro_div_0/divider_0/prescaler_0/tspc_0/D vdd 3.12fF
C16363 ro_div_0/divider_0/and_0/OUT vdd 5.67fF
C16364 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 vdd 0.86fF
C16365 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 vdd 2.26fF
C16366 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 vdd 1.46fF
C16367 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 vdd 0.99fF
C16368 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdd 1.16fF **FLOATING
C16369 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdd 2.11fF **FLOATING
C16370 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 vdd 0.86fF
C16371 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 vdd 2.26fF
C16372 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 vdd 1.48fF
C16373 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 vdd 0.99fF
C16374 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdd 1.14fF **FLOATING
C16375 ro_div_0/divider_0/prescaler_0/m1_2700_2190# vdd 4.22fF **FLOATING
C16376 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 vdd 0.86fF
C16377 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 vdd 2.26fF
C16378 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 vdd 1.19fF
C16379 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 vdd 0.99fF
C16380 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdd 1.47fF **FLOATING
C16381 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdd 2.11fF **FLOATING
C16382 ro_div_0/divider_0/nor_1/Z1 vdd 1.34fF
C16383 ro_div_0/divider_0/nor_0/Z1 vdd 1.34fF
C16384 ro_div_0/divbuf_0/OUT vdd 3.35fF
C16385 ro_div_0/divbuf_0/OUT5 vdd 16.40fF
C16386 ro_div_0/divbuf_0/OUT4 vdd 100.06fF
C16387 ro_div_0/divbuf_0/OUT3 vdd 27.01fF
C16388 ro_div_0/divbuf_0/OUT2 vdd 8.71fF
C16389 ro_div_0/divbuf_0/a_60990_n1540# vdd 1.57fF **FLOATING
C16390 ro_div_0/divbuf_0/a_60510_n1540# vdd 1.62fF **FLOATING
C16391 ro_div_0/divbuf_0/a_60030_n1540# vdd 1.62fF **FLOATING
C16392 ro_div_0/divbuf_0/a_59550_n1540# vdd 1.62fF **FLOATING
C16393 ro_div_0/divbuf_0/a_59070_n1540# vdd 1.62fF **FLOATING
C16394 ro_div_0/divbuf_0/a_58590_n1540# vdd 1.62fF **FLOATING
C16395 ro_div_0/divbuf_0/a_58110_n1540# vdd 1.62fF **FLOATING
C16396 ro_div_0/divbuf_0/a_57630_n1540# vdd 1.62fF **FLOATING
C16397 ro_div_0/divbuf_0/a_57150_n1540# vdd 1.62fF **FLOATING
C16398 ro_div_0/divbuf_0/a_56670_n1540# vdd 1.62fF **FLOATING
C16399 ro_div_0/divbuf_0/a_56190_n1540# vdd 1.62fF **FLOATING
C16400 ro_div_0/divbuf_0/a_55710_n1540# vdd 1.62fF **FLOATING
C16401 ro_div_0/divbuf_0/a_55230_n1540# vdd 1.62fF **FLOATING
C16402 ro_div_0/divbuf_0/a_54750_n1540# vdd 1.62fF **FLOATING
C16403 ro_div_0/divbuf_0/a_54270_n1540# vdd 1.62fF **FLOATING
C16404 ro_div_0/divbuf_0/a_53790_n1540# vdd 1.62fF **FLOATING
C16405 ro_div_0/divbuf_0/a_53310_n1540# vdd 1.62fF **FLOATING
C16406 ro_div_0/divbuf_0/a_52830_n1540# vdd 1.62fF **FLOATING
C16407 ro_div_0/divbuf_0/a_52350_n1540# vdd 1.62fF **FLOATING
C16408 ro_div_0/divbuf_0/a_51870_n1540# vdd 1.62fF **FLOATING
C16409 ro_div_0/divbuf_0/a_51390_n1540# vdd 1.62fF **FLOATING
C16410 ro_div_0/divbuf_0/a_50910_n1540# vdd 1.62fF **FLOATING
C16411 ro_div_0/divbuf_0/a_50430_n1540# vdd 1.62fF **FLOATING
C16412 ro_div_0/divbuf_0/a_49950_n1540# vdd 1.62fF **FLOATING
C16413 ro_div_0/divbuf_0/a_49470_n1540# vdd 1.62fF **FLOATING
C16414 ro_div_0/divbuf_0/a_48990_n1540# vdd 1.62fF **FLOATING
C16415 ro_div_0/divbuf_0/a_48510_n1540# vdd 1.62fF **FLOATING
C16416 ro_div_0/divbuf_0/a_48030_n1540# vdd 1.62fF **FLOATING
C16417 ro_div_0/divbuf_0/a_47550_n1540# vdd 1.62fF **FLOATING
C16418 ro_div_0/divbuf_0/a_47070_n1540# vdd 1.62fF **FLOATING
C16419 ro_div_0/divbuf_0/a_46590_n1540# vdd 1.62fF **FLOATING
C16420 ro_div_0/divbuf_0/a_46110_n1540# vdd 1.62fF **FLOATING
C16421 ro_div_0/divbuf_0/a_45630_n1540# vdd 1.62fF **FLOATING
C16422 ro_div_0/divbuf_0/a_45150_n1540# vdd 1.62fF **FLOATING
C16423 ro_div_0/divbuf_0/a_44670_n1540# vdd 1.62fF **FLOATING
C16424 ro_div_0/divbuf_0/a_44190_n1540# vdd 1.62fF **FLOATING
C16425 ro_div_0/divbuf_0/a_43710_n1540# vdd 1.62fF **FLOATING
C16426 ro_div_0/divbuf_0/a_43230_n1540# vdd 1.62fF **FLOATING
C16427 ro_div_0/divbuf_0/a_42750_n1540# vdd 1.62fF **FLOATING
C16428 ro_div_0/divbuf_0/a_42270_n1540# vdd 1.62fF **FLOATING
C16429 ro_div_0/divbuf_0/a_41790_n1540# vdd 1.62fF **FLOATING
C16430 ro_div_0/divbuf_0/a_41310_n1540# vdd 1.62fF **FLOATING
C16431 ro_div_0/divbuf_0/a_40830_n1540# vdd 1.62fF **FLOATING
C16432 ro_div_0/divbuf_0/a_40350_n1540# vdd 1.62fF **FLOATING
C16433 ro_div_0/divbuf_0/a_39870_n1540# vdd 1.62fF **FLOATING
C16434 ro_div_0/divbuf_0/a_39390_n1540# vdd 1.62fF **FLOATING
C16435 ro_div_0/divbuf_0/a_38910_n1540# vdd 1.62fF **FLOATING
C16436 ro_div_0/divbuf_0/a_38430_n1540# vdd 1.62fF **FLOATING
C16437 ro_div_0/divbuf_0/a_37950_n1540# vdd 1.62fF **FLOATING
C16438 ro_div_0/divbuf_0/a_37470_n1540# vdd 1.62fF **FLOATING
C16439 ro_div_0/divbuf_0/a_36990_n1540# vdd 1.62fF **FLOATING
C16440 ro_div_0/divbuf_0/a_36510_n1540# vdd 1.62fF **FLOATING
C16441 ro_div_0/divbuf_0/a_36030_n1540# vdd 1.62fF **FLOATING
C16442 ro_div_0/divbuf_0/a_35550_n1540# vdd 1.62fF **FLOATING
C16443 ro_div_0/divbuf_0/a_35070_n1540# vdd 1.62fF **FLOATING
C16444 ro_div_0/divbuf_0/a_34590_n1540# vdd 1.62fF **FLOATING
C16445 ro_div_0/divbuf_0/a_34110_n1540# vdd 1.62fF **FLOATING
C16446 ro_div_0/divbuf_0/a_33630_n1540# vdd 1.62fF **FLOATING
C16447 ro_div_0/divbuf_0/a_33150_n1540# vdd 1.62fF **FLOATING
C16448 ro_div_0/divbuf_0/a_32670_n1540# vdd 1.62fF **FLOATING
C16449 ro_div_0/divbuf_0/a_32190_n1540# vdd 1.62fF **FLOATING
C16450 ro_div_0/divbuf_0/a_31710_n1540# vdd 1.62fF **FLOATING
C16451 ro_div_0/divbuf_0/a_31230_n1540# vdd 1.62fF **FLOATING
C16452 ro_div_0/divbuf_0/a_30750_n1540# vdd 1.62fF **FLOATING
C16453 ro_div_0/divbuf_0/a_30270_n1540# vdd 1.62fF **FLOATING
C16454 ro_div_0/divbuf_0/a_29790_n1540# vdd 1.62fF **FLOATING
C16455 ro_div_0/divbuf_0/a_29310_n1540# vdd 1.62fF **FLOATING
C16456 ro_div_0/divbuf_0/a_28830_n1540# vdd 1.62fF **FLOATING
C16457 ro_div_0/divbuf_0/a_28350_n1540# vdd 1.62fF **FLOATING
C16458 ro_div_0/divbuf_0/a_27870_n1540# vdd 1.62fF **FLOATING
C16459 ro_div_0/divbuf_0/a_27390_n1540# vdd 1.62fF **FLOATING
C16460 ro_div_0/divbuf_0/a_26910_n1540# vdd 1.62fF **FLOATING
C16461 ro_div_0/divbuf_0/a_26430_n1540# vdd 1.62fF **FLOATING
C16462 ro_div_0/divbuf_0/a_25950_n1540# vdd 1.62fF **FLOATING
C16463 ro_div_0/divbuf_0/a_25470_n1540# vdd 1.62fF **FLOATING
C16464 ro_div_0/divbuf_0/a_24990_n1540# vdd 1.62fF **FLOATING
C16465 ro_div_0/divbuf_0/a_24510_n1540# vdd 1.62fF **FLOATING
C16466 ro_div_0/divbuf_0/a_24030_n1540# vdd 1.62fF **FLOATING
C16467 ro_div_0/divbuf_0/a_23550_n1540# vdd 1.62fF **FLOATING
C16468 ro_div_0/divbuf_0/a_23070_n1540# vdd 1.62fF **FLOATING
C16469 ro_div_0/divbuf_0/a_22590_n1540# vdd 1.62fF **FLOATING
C16470 ro_div_0/divbuf_0/a_22110_n1540# vdd 1.62fF **FLOATING
C16471 ro_div_0/divbuf_0/a_21630_n1540# vdd 1.62fF **FLOATING
C16472 ro_div_0/divbuf_0/a_21150_n1540# vdd 1.62fF **FLOATING
C16473 ro_div_0/divbuf_0/a_20670_n1540# vdd 1.62fF **FLOATING
C16474 ro_div_0/divbuf_0/a_20190_n1540# vdd 1.62fF **FLOATING
C16475 ro_div_0/divbuf_0/a_19710_n1540# vdd 1.62fF **FLOATING
C16476 ro_div_0/divbuf_0/a_19230_n1540# vdd 1.62fF **FLOATING
C16477 ro_div_0/divbuf_0/a_18750_n1540# vdd 1.62fF **FLOATING
C16478 ro_div_0/divbuf_0/a_18270_n1540# vdd 1.62fF **FLOATING
C16479 ro_div_0/divbuf_0/a_17790_n1540# vdd 1.62fF **FLOATING
C16480 ro_div_0/divbuf_0/a_17310_n1540# vdd 1.62fF **FLOATING
C16481 ro_div_0/divbuf_0/a_16830_n1540# vdd 1.62fF **FLOATING
C16482 ro_div_0/divbuf_0/a_16350_n1540# vdd 1.62fF **FLOATING
C16483 ro_div_0/divbuf_0/a_15870_n1540# vdd 1.62fF **FLOATING
C16484 ro_div_0/divbuf_0/a_15390_n1540# vdd 1.62fF **FLOATING
C16485 ro_div_0/divbuf_0/a_14910_n1540# vdd 1.62fF **FLOATING
C16486 ro_div_0/divbuf_0/a_14430_n1540# vdd 1.62fF **FLOATING
C16487 ro_div_0/divbuf_0/a_13950_n1540# vdd 1.62fF **FLOATING
C16488 ro_div_0/divbuf_0/a_13470_n1540# vdd 1.62fF **FLOATING
C16489 ro_div_0/divbuf_0/a_12990_n1540# vdd 1.62fF **FLOATING
C16490 ro_div_0/divbuf_0/a_12510_n1540# vdd 1.62fF **FLOATING
C16491 ro_div_0/divbuf_0/a_12030_n1540# vdd 1.62fF **FLOATING
C16492 ro_div_0/divbuf_0/a_11550_n1540# vdd 1.62fF **FLOATING
C16493 ro_div_0/divbuf_0/a_11070_n1540# vdd 1.62fF **FLOATING
C16494 ro_div_0/divbuf_0/a_10590_n1540# vdd 1.62fF **FLOATING
C16495 ro_div_0/divbuf_0/a_10110_n1540# vdd 1.62fF **FLOATING
C16496 ro_div_0/divbuf_0/a_9630_n1540# vdd 1.62fF **FLOATING
C16497 ro_div_0/divbuf_0/a_9150_n1540# vdd 1.62fF **FLOATING
C16498 ro_div_0/divbuf_0/a_8670_n1540# vdd 1.62fF **FLOATING
C16499 ro_div_0/divbuf_0/a_8190_n1540# vdd 1.62fF **FLOATING
C16500 ro_div_0/divbuf_0/a_7710_n1540# vdd 1.62fF **FLOATING
C16501 ro_div_0/divbuf_0/a_7230_n1540# vdd 1.62fF **FLOATING
C16502 ro_div_0/divbuf_0/a_6750_n1540# vdd 1.62fF **FLOATING
C16503 ro_div_0/divbuf_0/a_6270_n1540# vdd 1.62fF **FLOATING
C16504 ro_div_0/divbuf_0/a_5790_n1540# vdd 1.62fF **FLOATING
C16505 ro_div_0/divbuf_0/a_5310_n1540# vdd 1.62fF **FLOATING
C16506 ro_div_0/divbuf_0/a_4830_n1540# vdd 1.62fF **FLOATING
C16507 ro_div_0/divbuf_0/a_4350_n1540# vdd 1.62fF **FLOATING
C16508 ro_div_0/divbuf_0/a_3870_n1540# vdd 1.62fF **FLOATING
C16509 ro_div_0/divbuf_0/a_3390_n1540# vdd 1.62fF **FLOATING
C16510 ro_div_0/divbuf_0/a_2910_n1540# vdd 1.62fF **FLOATING
C16511 ro_div_0/divbuf_0/a_2430_n1540# vdd 1.62fF **FLOATING
C16512 ro_div_0/divbuf_0/a_1950_n1540# vdd 1.62fF **FLOATING
C16513 ro_div_0/divbuf_0/a_1470_n1540# vdd 1.62fF **FLOATING
C16514 ro_div_0/divbuf_0/a_990_n1540# vdd 1.62fF **FLOATING
C16515 ro_div_0/divbuf_0/a_510_n1540# vdd 1.62fF **FLOATING
C16516 ro_div_0/divbuf_0/a_60990_n840# vdd 1.06fF **FLOATING
C16517 ro_div_0/divbuf_0/a_60510_n840# vdd 1.09fF **FLOATING
C16518 ro_div_0/divbuf_0/a_60030_n840# vdd 1.09fF **FLOATING
C16519 ro_div_0/divbuf_0/a_59550_n840# vdd 1.09fF **FLOATING
C16520 ro_div_0/divbuf_0/a_59070_n840# vdd 1.09fF **FLOATING
C16521 ro_div_0/divbuf_0/a_58590_n840# vdd 1.09fF **FLOATING
C16522 ro_div_0/divbuf_0/a_58110_n840# vdd 1.09fF **FLOATING
C16523 ro_div_0/divbuf_0/a_57630_n840# vdd 1.09fF **FLOATING
C16524 ro_div_0/divbuf_0/a_57150_n840# vdd 1.09fF **FLOATING
C16525 ro_div_0/divbuf_0/a_56670_n840# vdd 1.09fF **FLOATING
C16526 ro_div_0/divbuf_0/a_56190_n840# vdd 1.09fF **FLOATING
C16527 ro_div_0/divbuf_0/a_55710_n840# vdd 1.09fF **FLOATING
C16528 ro_div_0/divbuf_0/a_55230_n840# vdd 1.09fF **FLOATING
C16529 ro_div_0/divbuf_0/a_54750_n840# vdd 1.09fF **FLOATING
C16530 ro_div_0/divbuf_0/a_54270_n840# vdd 1.09fF **FLOATING
C16531 ro_div_0/divbuf_0/a_53790_n840# vdd 1.09fF **FLOATING
C16532 ro_div_0/divbuf_0/a_53310_n840# vdd 1.09fF **FLOATING
C16533 ro_div_0/divbuf_0/a_52830_n840# vdd 1.09fF **FLOATING
C16534 ro_div_0/divbuf_0/a_52350_n840# vdd 1.09fF **FLOATING
C16535 ro_div_0/divbuf_0/a_51870_n840# vdd 1.09fF **FLOATING
C16536 ro_div_0/divbuf_0/a_51390_n840# vdd 1.09fF **FLOATING
C16537 ro_div_0/divbuf_0/a_50910_n840# vdd 1.09fF **FLOATING
C16538 ro_div_0/divbuf_0/a_50430_n840# vdd 1.09fF **FLOATING
C16539 ro_div_0/divbuf_0/a_49950_n840# vdd 1.09fF **FLOATING
C16540 ro_div_0/divbuf_0/a_49470_n840# vdd 1.09fF **FLOATING
C16541 ro_div_0/divbuf_0/a_48990_n840# vdd 1.09fF **FLOATING
C16542 ro_div_0/divbuf_0/a_48510_n840# vdd 1.09fF **FLOATING
C16543 ro_div_0/divbuf_0/a_48030_n840# vdd 1.09fF **FLOATING
C16544 ro_div_0/divbuf_0/a_47550_n840# vdd 1.09fF **FLOATING
C16545 ro_div_0/divbuf_0/a_47070_n840# vdd 1.09fF **FLOATING
C16546 ro_div_0/divbuf_0/a_46590_n840# vdd 1.09fF **FLOATING
C16547 ro_div_0/divbuf_0/a_46110_n840# vdd 1.09fF **FLOATING
C16548 ro_div_0/divbuf_0/a_45630_n840# vdd 1.09fF **FLOATING
C16549 ro_div_0/divbuf_0/a_45150_n840# vdd 1.09fF **FLOATING
C16550 ro_div_0/divbuf_0/a_44670_n840# vdd 1.09fF **FLOATING
C16551 ro_div_0/divbuf_0/a_44190_n840# vdd 1.09fF **FLOATING
C16552 ro_div_0/divbuf_0/a_43710_n840# vdd 1.09fF **FLOATING
C16553 ro_div_0/divbuf_0/a_43230_n840# vdd 1.09fF **FLOATING
C16554 ro_div_0/divbuf_0/a_42750_n840# vdd 1.08fF **FLOATING
C16555 ro_div_0/divbuf_0/a_42270_n840# vdd 1.08fF **FLOATING
C16556 ro_div_0/divbuf_0/a_41790_n840# vdd 1.10fF **FLOATING
C16557 ro_div_0/divbuf_0/a_41310_n840# vdd 1.09fF **FLOATING
C16558 ro_div_0/divbuf_0/a_40830_n840# vdd 1.09fF **FLOATING
C16559 ro_div_0/divbuf_0/a_40350_n840# vdd 1.09fF **FLOATING
C16560 ro_div_0/divbuf_0/a_39870_n840# vdd 1.09fF **FLOATING
C16561 ro_div_0/divbuf_0/a_39390_n840# vdd 1.09fF **FLOATING
C16562 ro_div_0/divbuf_0/a_38910_n840# vdd 1.09fF **FLOATING
C16563 ro_div_0/divbuf_0/a_38430_n840# vdd 1.09fF **FLOATING
C16564 ro_div_0/divbuf_0/a_37950_n840# vdd 1.09fF **FLOATING
C16565 ro_div_0/divbuf_0/a_37470_n840# vdd 1.09fF **FLOATING
C16566 ro_div_0/divbuf_0/a_36990_n840# vdd 1.09fF **FLOATING
C16567 ro_div_0/divbuf_0/a_36510_n840# vdd 1.09fF **FLOATING
C16568 ro_div_0/divbuf_0/a_36030_n840# vdd 1.09fF **FLOATING
C16569 ro_div_0/divbuf_0/a_35550_n840# vdd 1.09fF **FLOATING
C16570 ro_div_0/divbuf_0/a_35070_n840# vdd 1.09fF **FLOATING
C16571 ro_div_0/divbuf_0/a_34590_n840# vdd 1.09fF **FLOATING
C16572 ro_div_0/divbuf_0/a_34110_n840# vdd 1.09fF **FLOATING
C16573 ro_div_0/divbuf_0/a_33630_n840# vdd 1.09fF **FLOATING
C16574 ro_div_0/divbuf_0/a_33150_n840# vdd 1.09fF **FLOATING
C16575 ro_div_0/divbuf_0/a_32670_n840# vdd 1.09fF **FLOATING
C16576 ro_div_0/divbuf_0/a_32190_n840# vdd 1.09fF **FLOATING
C16577 ro_div_0/divbuf_0/a_31710_n840# vdd 1.11fF **FLOATING
C16578 ro_div_0/divbuf_0/a_31230_n840# vdd 1.13fF **FLOATING
C16579 ro_div_0/divbuf_0/a_30750_n840# vdd 1.09fF **FLOATING
C16580 ro_div_0/divbuf_0/a_30270_n840# vdd 1.09fF **FLOATING
C16581 ro_div_0/divbuf_0/a_29790_n840# vdd 1.09fF **FLOATING
C16582 ro_div_0/divbuf_0/a_29310_n840# vdd 1.09fF **FLOATING
C16583 ro_div_0/divbuf_0/a_28830_n840# vdd 1.09fF **FLOATING
C16584 ro_div_0/divbuf_0/a_28350_n840# vdd 1.09fF **FLOATING
C16585 ro_div_0/divbuf_0/a_27870_n840# vdd 1.08fF **FLOATING
C16586 ro_div_0/divbuf_0/a_27390_n840# vdd 1.11fF **FLOATING
C16587 ro_div_0/divbuf_0/a_26910_n840# vdd 1.10fF **FLOATING
C16588 ro_div_0/divbuf_0/a_26430_n840# vdd 1.10fF **FLOATING
C16589 ro_div_0/divbuf_0/a_25950_n840# vdd 1.10fF **FLOATING
C16590 ro_div_0/divbuf_0/a_25470_n840# vdd 1.10fF **FLOATING
C16591 ro_div_0/divbuf_0/a_24990_n840# vdd 1.10fF **FLOATING
C16592 ro_div_0/divbuf_0/a_24510_n840# vdd 1.10fF **FLOATING
C16593 ro_div_0/divbuf_0/a_24030_n840# vdd 1.09fF **FLOATING
C16594 ro_div_0/divbuf_0/a_23550_n840# vdd 1.11fF **FLOATING
C16595 ro_div_0/divbuf_0/a_23070_n840# vdd 1.10fF **FLOATING
C16596 ro_div_0/divbuf_0/a_22590_n840# vdd 1.10fF **FLOATING
C16597 ro_div_0/divbuf_0/a_22110_n840# vdd 1.10fF **FLOATING
C16598 ro_div_0/divbuf_0/a_21630_n840# vdd 1.10fF **FLOATING
C16599 ro_div_0/divbuf_0/a_21150_n840# vdd 1.10fF **FLOATING
C16600 ro_div_0/divbuf_0/a_20670_n840# vdd 1.10fF **FLOATING
C16601 ro_div_0/divbuf_0/a_20190_n840# vdd 1.09fF **FLOATING
C16602 ro_div_0/divbuf_0/a_19710_n840# vdd 1.09fF **FLOATING
C16603 ro_div_0/divbuf_0/a_19230_n840# vdd 1.09fF **FLOATING
C16604 ro_div_0/divbuf_0/a_18750_n840# vdd 1.09fF **FLOATING
C16605 ro_div_0/divbuf_0/a_18270_n840# vdd 1.08fF **FLOATING
C16606 ro_div_0/divbuf_0/a_17790_n840# vdd 1.08fF **FLOATING
C16607 ro_div_0/divbuf_0/a_17310_n840# vdd 1.07fF **FLOATING
C16608 ro_div_0/divbuf_0/a_16830_n840# vdd 1.07fF **FLOATING
C16609 ro_div_0/divbuf_0/a_16350_n840# vdd 1.07fF **FLOATING
C16610 ro_div_0/divbuf_0/a_15870_n840# vdd 1.07fF **FLOATING
C16611 ro_div_0/divbuf_0/a_15390_n840# vdd 1.08fF **FLOATING
C16612 ro_div_0/divbuf_0/a_14910_n840# vdd 1.07fF **FLOATING
C16613 ro_div_0/divbuf_0/a_14430_n840# vdd 1.07fF **FLOATING
C16614 ro_div_0/divbuf_0/a_13950_n840# vdd 1.07fF **FLOATING
C16615 ro_div_0/divbuf_0/a_13470_n840# vdd 1.07fF **FLOATING
C16616 ro_div_0/divbuf_0/a_12990_n840# vdd 1.10fF **FLOATING
C16617 ro_div_0/divbuf_0/a_12510_n840# vdd 1.08fF **FLOATING
C16618 ro_div_0/divbuf_0/a_12030_n840# vdd 1.07fF **FLOATING
C16619 ro_div_0/divbuf_0/a_11550_n840# vdd 1.07fF **FLOATING
C16620 ro_div_0/divbuf_0/a_11070_n840# vdd 1.08fF **FLOATING
C16621 ro_div_0/divbuf_0/a_10590_n840# vdd 1.10fF **FLOATING
C16622 ro_div_0/divbuf_0/a_10110_n840# vdd 1.10fF **FLOATING
C16623 ro_div_0/divbuf_0/a_9630_n840# vdd 1.10fF **FLOATING
C16624 ro_div_0/divbuf_0/a_9150_n840# vdd 1.10fF **FLOATING
C16625 ro_div_0/divbuf_0/a_8670_n840# vdd 1.10fF **FLOATING
C16626 ro_div_0/divbuf_0/a_8190_n840# vdd 1.12fF **FLOATING
C16627 ro_div_0/divbuf_0/a_7710_n840# vdd 1.10fF **FLOATING
C16628 ro_div_0/divbuf_0/a_7230_n840# vdd 1.09fF **FLOATING
C16629 ro_div_0/divbuf_0/a_6750_n840# vdd 1.09fF **FLOATING
C16630 ro_div_0/divbuf_0/a_6270_n840# vdd 1.09fF **FLOATING
C16631 ro_div_0/divbuf_0/a_5790_n840# vdd 1.09fF **FLOATING
C16632 ro_div_0/divbuf_0/a_5310_n840# vdd 1.09fF **FLOATING
C16633 ro_div_0/divbuf_0/a_4830_n840# vdd 1.09fF **FLOATING
C16634 ro_div_0/divbuf_0/a_4350_n840# vdd 1.09fF **FLOATING
C16635 ro_div_0/divbuf_0/a_3870_n840# vdd 1.09fF **FLOATING
C16636 ro_div_0/divbuf_0/a_3390_n840# vdd 1.09fF **FLOATING
C16637 ro_div_0/divbuf_0/a_2910_n840# vdd 1.10fF **FLOATING
C16638 ro_div_0/divbuf_0/a_2430_n840# vdd 1.10fF **FLOATING
C16639 ro_div_0/divbuf_0/a_1950_n840# vdd 1.10fF **FLOATING
C16640 ro_div_0/divbuf_0/a_1470_n840# vdd 1.10fF **FLOATING
C16641 ro_div_0/divbuf_0/a_990_n840# vdd 1.08fF **FLOATING
C16642 ro_div_0/divbuf_0/a_510_n840# vdd 1.07fF **FLOATING
C16643 ro_div_0/divbuf_0/a_60480_n1600# vdd 1.48fF **FLOATING
C16644 ro_div_0/divbuf_0/a_60000_n1600# vdd 1.48fF **FLOATING
C16645 ro_div_0/divbuf_0/a_59520_n1600# vdd 1.48fF **FLOATING
C16646 ro_div_0/divbuf_0/a_59040_n1600# vdd 1.48fF **FLOATING
C16647 ro_div_0/divbuf_0/a_58560_n1600# vdd 1.48fF **FLOATING
C16648 ro_div_0/divbuf_0/a_58080_n1600# vdd 1.48fF **FLOATING
C16649 ro_div_0/divbuf_0/a_57600_n1600# vdd 1.48fF **FLOATING
C16650 ro_div_0/divbuf_0/a_57120_n1600# vdd 1.48fF **FLOATING
C16651 ro_div_0/divbuf_0/a_56640_n1600# vdd 1.48fF **FLOATING
C16652 ro_div_0/divbuf_0/a_56160_n1600# vdd 1.48fF **FLOATING
C16653 ro_div_0/divbuf_0/a_55680_n1600# vdd 1.48fF **FLOATING
C16654 ro_div_0/divbuf_0/a_55200_n1600# vdd 1.48fF **FLOATING
C16655 ro_div_0/divbuf_0/a_54720_n1600# vdd 1.48fF **FLOATING
C16656 ro_div_0/divbuf_0/a_54240_n1600# vdd 1.48fF **FLOATING
C16657 ro_div_0/divbuf_0/a_53760_n1600# vdd 1.48fF **FLOATING
C16658 ro_div_0/divbuf_0/a_53280_n1600# vdd 1.48fF **FLOATING
C16659 ro_div_0/divbuf_0/a_52800_n1600# vdd 1.48fF **FLOATING
C16660 ro_div_0/divbuf_0/a_52320_n1600# vdd 1.48fF **FLOATING
C16661 ro_div_0/divbuf_0/a_51840_n1600# vdd 1.48fF **FLOATING
C16662 ro_div_0/divbuf_0/a_51360_n1600# vdd 1.48fF **FLOATING
C16663 ro_div_0/divbuf_0/a_50880_n1600# vdd 1.48fF **FLOATING
C16664 ro_div_0/divbuf_0/a_50400_n1600# vdd 1.48fF **FLOATING
C16665 ro_div_0/divbuf_0/a_49920_n1600# vdd 1.48fF **FLOATING
C16666 ro_div_0/divbuf_0/a_49440_n1600# vdd 1.48fF **FLOATING
C16667 ro_div_0/divbuf_0/a_48960_n1600# vdd 1.48fF **FLOATING
C16668 ro_div_0/divbuf_0/a_48480_n1600# vdd 1.48fF **FLOATING
C16669 ro_div_0/divbuf_0/a_48000_n1600# vdd 1.48fF **FLOATING
C16670 ro_div_0/divbuf_0/a_47520_n1600# vdd 1.48fF **FLOATING
C16671 ro_div_0/divbuf_0/a_47040_n1600# vdd 1.48fF **FLOATING
C16672 ro_div_0/divbuf_0/a_46560_n1600# vdd 1.48fF **FLOATING
C16673 ro_div_0/divbuf_0/a_46080_n1600# vdd 1.48fF **FLOATING
C16674 ro_div_0/divbuf_0/a_45600_n1600# vdd 1.48fF **FLOATING
C16675 ro_div_0/divbuf_0/a_45120_n1600# vdd 1.48fF **FLOATING
C16676 ro_div_0/divbuf_0/a_44640_n1600# vdd 1.48fF **FLOATING
C16677 ro_div_0/divbuf_0/a_44160_n1600# vdd 1.48fF **FLOATING
C16678 ro_div_0/divbuf_0/a_43680_n1600# vdd 1.48fF **FLOATING
C16679 ro_div_0/divbuf_0/a_43200_n1600# vdd 1.48fF **FLOATING
C16680 ro_div_0/divbuf_0/a_42720_n1600# vdd 1.48fF **FLOATING
C16681 ro_div_0/divbuf_0/a_42240_n1600# vdd 1.48fF **FLOATING
C16682 ro_div_0/divbuf_0/a_41760_n1600# vdd 1.48fF **FLOATING
C16683 ro_div_0/divbuf_0/a_41280_n1600# vdd 1.48fF **FLOATING
C16684 ro_div_0/divbuf_0/a_40800_n1600# vdd 1.48fF **FLOATING
C16685 ro_div_0/divbuf_0/a_40320_n1600# vdd 1.48fF **FLOATING
C16686 ro_div_0/divbuf_0/a_39840_n1600# vdd 1.48fF **FLOATING
C16687 ro_div_0/divbuf_0/a_39360_n1600# vdd 1.48fF **FLOATING
C16688 ro_div_0/divbuf_0/a_38880_n1600# vdd 1.48fF **FLOATING
C16689 ro_div_0/divbuf_0/a_38400_n1600# vdd 1.48fF **FLOATING
C16690 ro_div_0/divbuf_0/a_37920_n1600# vdd 1.48fF **FLOATING
C16691 ro_div_0/divbuf_0/a_37440_n1600# vdd 1.48fF **FLOATING
C16692 ro_div_0/divbuf_0/a_36960_n1600# vdd 1.48fF **FLOATING
C16693 ro_div_0/divbuf_0/a_36480_n1600# vdd 1.48fF **FLOATING
C16694 ro_div_0/divbuf_0/a_36000_n1600# vdd 1.48fF **FLOATING
C16695 ro_div_0/divbuf_0/a_35520_n1600# vdd 1.48fF **FLOATING
C16696 ro_div_0/divbuf_0/a_35040_n1600# vdd 1.48fF **FLOATING
C16697 ro_div_0/divbuf_0/a_34560_n1600# vdd 1.48fF **FLOATING
C16698 ro_div_0/divbuf_0/a_34080_n1600# vdd 1.48fF **FLOATING
C16699 ro_div_0/divbuf_0/a_33600_n1600# vdd 1.48fF **FLOATING
C16700 ro_div_0/divbuf_0/a_33120_n1600# vdd 1.48fF **FLOATING
C16701 ro_div_0/divbuf_0/a_32640_n1600# vdd 1.48fF **FLOATING
C16702 ro_div_0/divbuf_0/a_32160_n1600# vdd 1.48fF **FLOATING
C16703 ro_div_0/divbuf_0/a_31680_n1600# vdd 1.48fF **FLOATING
C16704 ro_div_0/divbuf_0/a_31200_n1600# vdd 1.48fF **FLOATING
C16705 ro_div_0/divbuf_0/a_30720_n1600# vdd 1.48fF **FLOATING
C16706 ro_div_0/divbuf_0/a_30240_n1600# vdd 1.48fF **FLOATING
C16707 ro_div_0/divbuf_0/a_29760_n1600# vdd 1.48fF **FLOATING
C16708 ro_div_0/divbuf_0/a_29280_n1600# vdd 1.48fF **FLOATING
C16709 ro_div_0/divbuf_0/a_28800_n1600# vdd 1.48fF **FLOATING
C16710 ro_div_0/divbuf_0/a_28320_n1600# vdd 1.48fF **FLOATING
C16711 ro_div_0/divbuf_0/a_27840_n1600# vdd 1.48fF **FLOATING
C16712 ro_div_0/divbuf_0/a_27360_n1600# vdd 1.48fF **FLOATING
C16713 ro_div_0/divbuf_0/a_26880_n1600# vdd 1.48fF **FLOATING
C16714 ro_div_0/divbuf_0/a_26400_n1600# vdd 1.48fF **FLOATING
C16715 ro_div_0/divbuf_0/a_25920_n1600# vdd 1.48fF **FLOATING
C16716 ro_div_0/divbuf_0/a_25440_n1600# vdd 1.48fF **FLOATING
C16717 ro_div_0/divbuf_0/a_24960_n1600# vdd 1.48fF **FLOATING
C16718 ro_div_0/divbuf_0/a_24480_n1600# vdd 1.48fF **FLOATING
C16719 ro_div_0/divbuf_0/a_24000_n1600# vdd 1.48fF **FLOATING
C16720 ro_div_0/divbuf_0/a_23520_n1600# vdd 1.48fF **FLOATING
C16721 ro_div_0/divbuf_0/a_23040_n1600# vdd 1.48fF **FLOATING
C16722 ro_div_0/divbuf_0/a_22560_n1600# vdd 1.48fF **FLOATING
C16723 ro_div_0/divbuf_0/a_22080_n1600# vdd 1.48fF **FLOATING
C16724 ro_div_0/divbuf_0/a_21600_n1600# vdd 1.48fF **FLOATING
C16725 ro_div_0/divbuf_0/a_21120_n1600# vdd 1.48fF **FLOATING
C16726 ro_div_0/divbuf_0/a_20640_n1600# vdd 1.48fF **FLOATING
C16727 ro_div_0/divbuf_0/a_20160_n1600# vdd 1.48fF **FLOATING
C16728 ro_div_0/divbuf_0/a_19680_n1600# vdd 1.48fF **FLOATING
C16729 ro_div_0/divbuf_0/a_19200_n1600# vdd 1.48fF **FLOATING
C16730 ro_div_0/divbuf_0/a_18720_n1600# vdd 1.48fF **FLOATING
C16731 ro_div_0/divbuf_0/a_18240_n1600# vdd 1.48fF **FLOATING
C16732 ro_div_0/divbuf_0/a_17760_n1600# vdd 1.48fF **FLOATING
C16733 ro_div_0/divbuf_0/a_17280_n1600# vdd 1.48fF **FLOATING
C16734 ro_div_0/divbuf_0/a_16800_n1600# vdd 1.48fF **FLOATING
C16735 ro_div_0/divbuf_0/a_16320_n1600# vdd 1.48fF **FLOATING
C16736 ro_div_0/divbuf_0/a_15840_n1600# vdd 1.48fF **FLOATING
C16737 ro_div_0/divbuf_0/a_15360_n1600# vdd 1.48fF **FLOATING
C16738 ro_div_0/divbuf_0/a_14880_n1600# vdd 1.48fF **FLOATING
C16739 ro_div_0/divbuf_0/a_14400_n1600# vdd 1.48fF **FLOATING
C16740 ro_div_0/divbuf_0/a_13920_n1600# vdd 1.48fF **FLOATING
C16741 ro_div_0/divbuf_0/a_13440_n1600# vdd 1.48fF **FLOATING
C16742 ro_div_0/divbuf_0/a_12960_n1600# vdd 1.48fF **FLOATING
C16743 ro_div_0/divbuf_0/a_12480_n1600# vdd 1.48fF **FLOATING
C16744 ro_div_0/divbuf_0/a_12000_n1600# vdd 1.48fF **FLOATING
C16745 ro_div_0/divbuf_0/a_11520_n1600# vdd 1.48fF **FLOATING
C16746 ro_div_0/divbuf_0/a_11040_n1600# vdd 1.48fF **FLOATING
C16747 ro_div_0/divbuf_0/a_10560_n1600# vdd 1.48fF **FLOATING
C16748 ro_div_0/divbuf_0/a_10080_n1600# vdd 1.48fF **FLOATING
C16749 ro_div_0/divbuf_0/a_9600_n1600# vdd 1.48fF **FLOATING
C16750 ro_div_0/divbuf_0/a_9120_n1600# vdd 1.48fF **FLOATING
C16751 ro_div_0/divbuf_0/a_8640_n1600# vdd 1.48fF **FLOATING
C16752 ro_div_0/divbuf_0/a_8160_n1600# vdd 1.48fF **FLOATING
C16753 ro_div_0/divbuf_0/a_7680_n1600# vdd 1.48fF **FLOATING
C16754 ro_div_0/divbuf_0/a_7200_n1600# vdd 1.48fF **FLOATING
C16755 ro_div_0/divbuf_0/a_6720_n1600# vdd 1.48fF **FLOATING
C16756 ro_div_0/divbuf_0/a_6240_n1600# vdd 1.48fF **FLOATING
C16757 ro_div_0/divbuf_0/a_5760_n1600# vdd 1.48fF **FLOATING
C16758 ro_div_0/divbuf_0/a_5280_n1600# vdd 1.48fF **FLOATING
C16759 ro_div_0/divbuf_0/a_4800_n1600# vdd 1.48fF **FLOATING
C16760 ro_div_0/divbuf_0/a_4320_n1600# vdd 1.48fF **FLOATING
C16761 ro_div_0/divbuf_0/a_3840_n1600# vdd 1.48fF **FLOATING
C16762 ro_div_0/divbuf_0/a_3360_n1600# vdd 1.48fF **FLOATING
C16763 ro_div_0/divbuf_0/a_2880_n1600# vdd 1.48fF **FLOATING
C16764 ro_div_0/divbuf_0/a_2400_n1600# vdd 1.48fF **FLOATING
C16765 ro_div_0/divbuf_0/a_1920_n1600# vdd 1.48fF **FLOATING
C16766 ro_div_0/divbuf_0/a_1440_n1600# vdd 1.48fF **FLOATING
C16767 ro_div_0/divbuf_0/a_960_n1600# vdd 1.48fF **FLOATING
C16768 ro_div_0/divbuf_0/a_480_n1600# vdd 1.48fF **FLOATING
C16769 ro_div_0/divbuf_0/a_0_n1600# vdd 1.48fF **FLOATING
C16770 ro_div_0/divbuf_0/a_41382_n240# vdd 0.90fF **FLOATING
C16771 ro_div_0/divbuf_0/a_40902_n240# vdd 0.90fF **FLOATING
C16772 ro_div_0/divbuf_0/a_40412_n240# vdd 0.90fF **FLOATING
C16773 ro_div_0/divbuf_0/a_39932_n240# vdd 0.90fF **FLOATING
C16774 ro_div_0/divbuf_0/a_39442_n240# vdd 0.90fF **FLOATING
C16775 ro_div_0/divbuf_0/a_38962_n240# vdd 0.91fF **FLOATING
C16776 ro_div_0/divbuf_0/a_38472_n240# vdd 0.90fF **FLOATING
C16777 ro_div_0/divbuf_0/a_37992_n240# vdd 0.90fF **FLOATING
C16778 ro_div_0/divbuf_0/a_37502_n240# vdd 0.90fF **FLOATING
C16779 ro_div_0/divbuf_0/a_37022_n240# vdd 0.90fF **FLOATING
C16780 ro_div_0/divbuf_0/a_36532_n240# vdd 0.90fF **FLOATING
C16781 ro_div_0/divbuf_0/a_36052_n240# vdd 0.90fF **FLOATING
C16782 ro_div_0/divbuf_0/a_35562_n240# vdd 0.90fF **FLOATING
C16783 ro_div_0/divbuf_0/a_35082_n240# vdd 0.91fF **FLOATING
C16784 ro_div_0/divbuf_0/a_34592_n240# vdd 0.90fF **FLOATING
C16785 ro_div_0/divbuf_0/a_34112_n240# vdd 0.90fF **FLOATING
C16786 ro_div_0/divbuf_0/a_33622_n240# vdd 0.90fF **FLOATING
C16787 ro_div_0/divbuf_0/a_33142_n240# vdd 0.90fF **FLOATING
C16788 ro_div_0/divbuf_0/a_32652_n240# vdd 0.90fF **FLOATING
C16789 ro_div_0/divbuf_0/a_32172_n240# vdd 0.90fF **FLOATING
C16790 ro_div_0/divbuf_0/a_31682_n240# vdd 0.89fF **FLOATING
C16791 ro_div_0/divbuf_0/a_31202_n240# vdd 0.92fF **FLOATING
C16792 ro_div_0/divbuf_0/a_30712_n240# vdd 0.90fF **FLOATING
C16793 ro_div_0/divbuf_0/a_30232_n240# vdd 0.90fF **FLOATING
C16794 ro_div_0/divbuf_0/a_29742_n240# vdd 0.90fF **FLOATING
C16795 ro_div_0/divbuf_0/a_29262_n240# vdd 0.90fF **FLOATING
C16796 ro_div_0/divbuf_0/a_28772_n240# vdd 0.90fF **FLOATING
C16797 ro_div_0/divbuf_0/a_28292_n240# vdd 0.90fF **FLOATING
C16798 ro_div_0/divbuf_0/a_27802_n240# vdd 0.89fF **FLOATING
C16799 ro_div_0/divbuf_0/a_27322_n240# vdd 0.95fF **FLOATING
C16800 ro_div_0/divbuf_0/a_26832_n240# vdd 0.91fF **FLOATING
C16801 ro_div_0/divbuf_0/a_26352_n240# vdd 0.91fF **FLOATING
C16802 ro_div_0/divbuf_0/a_25862_n240# vdd 0.91fF **FLOATING
C16803 ro_div_0/divbuf_0/a_25382_n240# vdd 0.91fF **FLOATING
C16804 ro_div_0/divbuf_0/a_24892_n240# vdd 0.91fF **FLOATING
C16805 ro_div_0/divbuf_0/a_24412_n240# vdd 0.91fF **FLOATING
C16806 ro_div_0/divbuf_0/a_23922_n240# vdd 0.92fF **FLOATING
C16807 ro_div_0/divbuf_0/a_23442_n240# vdd 0.94fF **FLOATING
C16808 ro_div_0/divbuf_0/a_22952_n240# vdd 0.91fF **FLOATING
C16809 ro_div_0/divbuf_0/a_22472_n240# vdd 0.91fF **FLOATING
C16810 ro_div_0/divbuf_0/a_21982_n240# vdd 0.91fF **FLOATING
C16811 ro_div_0/divbuf_0/a_21502_n240# vdd 0.91fF **FLOATING
C16812 ro_div_0/divbuf_0/a_21012_n240# vdd 0.91fF **FLOATING
C16813 ro_div_0/divbuf_0/a_20532_n240# vdd 0.91fF **FLOATING
C16814 ro_div_0/divbuf_0/a_20042_n240# vdd 0.90fF **FLOATING
C16815 ro_div_0/divbuf_0/a_19562_n240# vdd 0.90fF **FLOATING
C16816 ro_div_0/divbuf_0/a_19072_n240# vdd 0.90fF **FLOATING
C16817 ro_div_0/divbuf_0/a_18582_n240# vdd 0.89fF **FLOATING
C16818 ro_div_0/divbuf_0/a_18092_n240# vdd 0.89fF **FLOATING
C16819 ro_div_0/divbuf_0/a_17612_n240# vdd 0.89fF **FLOATING
C16820 ro_div_0/divbuf_0/a_17122_n240# vdd 0.88fF **FLOATING
C16821 ro_div_0/divbuf_0/a_16642_n240# vdd 0.88fF **FLOATING
C16822 ro_div_0/divbuf_0/a_16152_n240# vdd 0.88fF **FLOATING
C16823 ro_div_0/divbuf_0/a_15672_n240# vdd 0.90fF **FLOATING
C16824 ro_div_0/divbuf_0/a_15182_n240# vdd 0.88fF **FLOATING
C16825 ro_div_0/divbuf_0/a_14702_n240# vdd 0.88fF **FLOATING
C16826 ro_div_0/divbuf_0/a_14222_n240# vdd 0.88fF **FLOATING
C16827 ro_div_0/divbuf_0/a_13742_n240# vdd 0.88fF **FLOATING
C16828 ro_div_0/divbuf_0/a_13252_n240# vdd 0.88fF **FLOATING
C16829 ro_div_0/divbuf_0/a_12772_n240# vdd 0.88fF **FLOATING
C16830 ro_div_0/divbuf_0/a_12282_n240# vdd 0.88fF **FLOATING
C16831 ro_div_0/divbuf_0/a_11802_n240# vdd 0.88fF **FLOATING
C16832 ro_div_0/divbuf_0/a_11312_n240# vdd 0.89fF **FLOATING
C16833 ro_div_0/divbuf_0/a_10212_n240# vdd 0.91fF **FLOATING
C16834 ro_div_0/divbuf_0/a_9732_n240# vdd 0.91fF **FLOATING
C16835 ro_div_0/divbuf_0/a_9242_n240# vdd 0.91fF **FLOATING
C16836 ro_div_0/divbuf_0/a_8762_n240# vdd 0.91fF **FLOATING
C16837 ro_div_0/divbuf_0/a_8272_n240# vdd 0.91fF **FLOATING
C16838 ro_div_0/divbuf_0/a_7792_n240# vdd 0.92fF **FLOATING
C16839 ro_div_0/divbuf_0/a_7302_n240# vdd 0.90fF **FLOATING
C16840 ro_div_0/divbuf_0/a_6822_n240# vdd 0.90fF **FLOATING
C16841 ro_div_0/divbuf_0/a_6332_n240# vdd 0.90fF **FLOATING
C16842 ro_div_0/divbuf_0/a_5852_n240# vdd 0.90fF **FLOATING
C16843 ro_div_0/divbuf_0/a_5362_n240# vdd 0.90fF **FLOATING
C16844 ro_div_0/divbuf_0/a_4882_n240# vdd 0.90fF **FLOATING
C16845 ro_div_0/divbuf_0/a_4392_n240# vdd 0.90fF **FLOATING
C16846 ro_div_0/divbuf_0/a_3912_n240# vdd 0.90fF **FLOATING
C16847 ro_div_0/divbuf_0/a_3422_n240# vdd 0.90fF **FLOATING
C16848 ro_div_0/divbuf_0/a_2322_n240# vdd 0.91fF **FLOATING
C16849 ro_div_0/divbuf_0/a_1842_n240# vdd 0.91fF **FLOATING
C16850 ro_div_0/divbuf_0/a_1352_n240# vdd 0.91fF **FLOATING
C16851 ro_div_0/divbuf_0/a_41382_170# vdd 1.07fF **FLOATING
C16852 ro_div_0/divbuf_0/a_40902_170# vdd 1.09fF **FLOATING
C16853 ro_div_0/divbuf_0/a_40412_170# vdd 1.09fF **FLOATING
C16854 ro_div_0/divbuf_0/a_39932_170# vdd 1.09fF **FLOATING
C16855 ro_div_0/divbuf_0/a_39442_170# vdd 1.09fF **FLOATING
C16856 ro_div_0/divbuf_0/a_38962_170# vdd 1.07fF **FLOATING
C16857 ro_div_0/divbuf_0/a_38472_170# vdd 1.09fF **FLOATING
C16858 ro_div_0/divbuf_0/a_37992_170# vdd 1.09fF **FLOATING
C16859 ro_div_0/divbuf_0/a_37502_170# vdd 1.09fF **FLOATING
C16860 ro_div_0/divbuf_0/a_37022_170# vdd 1.09fF **FLOATING
C16861 ro_div_0/divbuf_0/a_36532_170# vdd 1.09fF **FLOATING
C16862 ro_div_0/divbuf_0/a_36052_170# vdd 1.09fF **FLOATING
C16863 ro_div_0/divbuf_0/a_35562_170# vdd 1.09fF **FLOATING
C16864 ro_div_0/divbuf_0/a_35082_170# vdd 1.09fF **FLOATING
C16865 ro_div_0/divbuf_0/a_34592_170# vdd 1.07fF **FLOATING
C16866 ro_div_0/divbuf_0/a_34112_170# vdd 1.09fF **FLOATING
C16867 ro_div_0/divbuf_0/a_33622_170# vdd 1.09fF **FLOATING
C16868 ro_div_0/divbuf_0/a_33142_170# vdd 1.09fF **FLOATING
C16869 ro_div_0/divbuf_0/a_32652_170# vdd 1.09fF **FLOATING
C16870 ro_div_0/divbuf_0/a_32172_170# vdd 1.09fF **FLOATING
C16871 ro_div_0/divbuf_0/a_31682_170# vdd 1.09fF **FLOATING
C16872 ro_div_0/divbuf_0/a_31202_170# vdd 1.09fF **FLOATING
C16873 ro_div_0/divbuf_0/a_30712_170# vdd 1.09fF **FLOATING
C16874 ro_div_0/divbuf_0/a_30232_170# vdd 1.07fF **FLOATING
C16875 ro_div_0/divbuf_0/a_29742_170# vdd 1.09fF **FLOATING
C16876 ro_div_0/divbuf_0/a_29262_170# vdd 1.09fF **FLOATING
C16877 ro_div_0/divbuf_0/a_28772_170# vdd 1.09fF **FLOATING
C16878 ro_div_0/divbuf_0/a_28292_170# vdd 1.09fF **FLOATING
C16879 ro_div_0/divbuf_0/a_27802_170# vdd 1.09fF **FLOATING
C16880 ro_div_0/divbuf_0/a_27322_170# vdd 1.09fF **FLOATING
C16881 ro_div_0/divbuf_0/a_26832_170# vdd 1.09fF **FLOATING
C16882 ro_div_0/divbuf_0/a_26352_170# vdd 1.09fF **FLOATING
C16883 ro_div_0/divbuf_0/a_25862_170# vdd 1.07fF **FLOATING
C16884 ro_div_0/divbuf_0/a_25382_170# vdd 1.09fF **FLOATING
C16885 ro_div_0/divbuf_0/a_24892_170# vdd 1.09fF **FLOATING
C16886 ro_div_0/divbuf_0/a_24412_170# vdd 1.09fF **FLOATING
C16887 ro_div_0/divbuf_0/a_23922_170# vdd 1.09fF **FLOATING
C16888 ro_div_0/divbuf_0/a_23442_170# vdd 1.09fF **FLOATING
C16889 ro_div_0/divbuf_0/a_22952_170# vdd 1.09fF **FLOATING
C16890 ro_div_0/divbuf_0/a_22472_170# vdd 1.07fF **FLOATING
C16891 ro_div_0/divbuf_0/a_21982_170# vdd 1.09fF **FLOATING
C16892 ro_div_0/divbuf_0/a_21502_170# vdd 1.09fF **FLOATING
C16893 ro_div_0/divbuf_0/a_21012_170# vdd 1.09fF **FLOATING
C16894 ro_div_0/divbuf_0/a_20532_170# vdd 1.09fF **FLOATING
C16895 ro_div_0/divbuf_0/a_20042_170# vdd 1.09fF **FLOATING
C16896 ro_div_0/divbuf_0/a_19562_170# vdd 1.09fF **FLOATING
C16897 ro_div_0/divbuf_0/a_19072_170# vdd 1.09fF **FLOATING
C16898 ro_div_0/divbuf_0/a_18582_170# vdd 1.07fF **FLOATING
C16899 ro_div_0/divbuf_0/a_18092_170# vdd 1.09fF **FLOATING
C16900 ro_div_0/divbuf_0/a_17612_170# vdd 1.09fF **FLOATING
C16901 ro_div_0/divbuf_0/a_17122_170# vdd 1.09fF **FLOATING
C16902 ro_div_0/divbuf_0/a_16642_170# vdd 1.09fF **FLOATING
C16903 ro_div_0/divbuf_0/a_16152_170# vdd 1.09fF **FLOATING
C16904 ro_div_0/divbuf_0/a_15672_170# vdd 1.09fF **FLOATING
C16905 ro_div_0/divbuf_0/a_15182_170# vdd 1.09fF **FLOATING
C16906 ro_div_0/divbuf_0/a_14702_170# vdd 1.10fF **FLOATING
C16907 ro_div_0/divbuf_0/a_14222_170# vdd 1.10fF **FLOATING
C16908 ro_div_0/divbuf_0/a_13742_170# vdd 1.09fF **FLOATING
C16909 ro_div_0/divbuf_0/a_13252_170# vdd 1.09fF **FLOATING
C16910 ro_div_0/divbuf_0/a_12772_170# vdd 1.07fF **FLOATING
C16911 ro_div_0/divbuf_0/a_12282_170# vdd 1.09fF **FLOATING
C16912 ro_div_0/divbuf_0/a_11802_170# vdd 1.09fF **FLOATING
C16913 ro_div_0/divbuf_0/a_11312_170# vdd 1.10fF **FLOATING
C16914 ro_div_0/divbuf_0/a_10212_170# vdd 1.09fF **FLOATING
C16915 ro_div_0/divbuf_0/a_9732_170# vdd 1.09fF **FLOATING
C16916 ro_div_0/divbuf_0/a_9242_170# vdd 1.09fF **FLOATING
C16917 ro_div_0/divbuf_0/a_8762_170# vdd 1.09fF **FLOATING
C16918 ro_div_0/divbuf_0/a_8272_170# vdd 1.07fF **FLOATING
C16919 ro_div_0/divbuf_0/a_7792_170# vdd 1.09fF **FLOATING
C16920 ro_div_0/divbuf_0/a_7302_170# vdd 1.09fF **FLOATING
C16921 ro_div_0/divbuf_0/a_6822_170# vdd 1.09fF **FLOATING
C16922 ro_div_0/divbuf_0/a_6332_170# vdd 1.09fF **FLOATING
C16923 ro_div_0/divbuf_0/a_5852_170# vdd 1.09fF **FLOATING
C16924 ro_div_0/divbuf_0/a_5362_170# vdd 1.09fF **FLOATING
C16925 ro_div_0/divbuf_0/a_4882_170# vdd 1.09fF **FLOATING
C16926 ro_div_0/divbuf_0/a_4392_170# vdd 1.07fF **FLOATING
C16927 ro_div_0/divbuf_0/a_3912_170# vdd 1.09fF **FLOATING
C16928 ro_div_0/divbuf_0/a_3422_170# vdd 1.10fF **FLOATING
C16929 ro_div_0/divbuf_0/a_2322_170# vdd 1.09fF **FLOATING
C16930 ro_div_0/divbuf_0/a_1842_170# vdd 1.09fF **FLOATING
C16931 ro_div_0/divbuf_0/a_1352_170# vdd 1.10fF **FLOATING
C16932 ro_div_0/divbuf_0/a_492_n240# vdd 2.46fF **FLOATING
C16933 ro_div_0/ro_complete_0/cbank_2/v vdd 17.84fF
C16934 ro_div_0/ro_complete_0/cbank_2/switch_5/vin vdd 0.78fF
C16935 ro_div_0/ro_complete_0/cbank_2/switch_4/vin vdd 1.50fF
C16936 ro_div_0/ro_complete_0/cbank_2/switch_2/vin vdd 1.30fF
C16937 ro_div_0/ro_complete_0/cbank_2/switch_3/vin vdd 0.56fF
C16938 ro_div_0/ro_complete_0/cbank_2/switch_1/vin vdd 1.14fF
C16939 ro_div_0/ro_complete_0/cbank_2/switch_0/vin vdd 1.02fF
C16940 ro_div_0/ro_complete_0/cbank_1/switch_5/vin vdd 0.78fF
C16941 ro_div_0/ro_complete_0/a0 vdd 7.88fF
C16942 ro_div_0/ro_complete_0/cbank_1/switch_4/vin vdd 1.50fF
C16943 ro_div_0/ro_complete_0/a1 vdd 5.39fF
C16944 ro_div_0/ro_complete_0/cbank_1/switch_2/vin vdd 1.30fF
C16945 ro_div_0/ro_complete_0/a3 vdd 6.85fF
C16946 ro_div_0/ro_complete_0/cbank_1/switch_3/vin vdd 0.56fF
C16947 ro_div_0/ro_complete_0/a2 vdd 5.48fF
C16948 ro_div_0/ro_complete_0/cbank_1/switch_1/vin vdd 1.14fF
C16949 ro_div_0/ro_complete_0/a4 vdd 5.36fF
C16950 ro_div_0/ro_complete_0/cbank_1/switch_0/vin vdd 1.02fF
C16951 ro_div_0/ro_complete_0/a5 vdd 5.19fF
C16952 ro_div_0/ro_complete_0/cbank_0/v vdd 14.98fF
C16953 ro_div_0/ro_complete_0/cbank_0/switch_5/vin vdd 0.78fF
C16954 ro_div_0/ro_complete_0/cbank_0/switch_4/vin vdd 1.50fF
C16955 ro_div_0/ro_complete_0/cbank_0/switch_2/vin vdd 1.30fF
C16956 ro_div_0/ro_complete_0/cbank_0/switch_3/vin vdd 0.56fF
C16957 ro_div_0/ro_complete_0/cbank_0/switch_1/vin vdd 1.14fF
C16958 ro_div_0/ro_complete_0/cbank_0/switch_0/vin vdd 1.02fF
C16959 ro_div_0/ro_complete_0/ro_var_extend_0/vcont vdd 0.27fF
C16960 filter_0/v vdd 85.69fF
C16961 filter_0/a_4216_n5230# vdd 418.47fF **FLOATING
C16962 filter_0/a_4216_n2998# vdd 1.03fF **FLOATING
C16963 cp_0/down vdd 3.06fF
C16964 cp_0/out vdd 12.02fF
C16965 cp_0/upbar vdd 6.89fF
C16966 cp_0/a_7110_n2840# vdd 0.17fF **FLOATING
C16967 cp_0/a_3060_n2840# vdd 1.71fF **FLOATING
C16968 cp_0/a_7110_0# vdd 0.17fF **FLOATING
C16969 cp_0/a_6370_0# vdd 0.40fF **FLOATING
C16970 cp_0/a_3060_0# vdd 4.16fF **FLOATING
C16971 cp_0/a_1710_0# vdd 6.63fF **FLOATING
C16972 cp_0/a_10_n50# vdd 3.15fF **FLOATING
C16973 pd_0/and_pd_0/Z1 vdd 0.39fF
C16974 pd_0/and_pd_0/Out1 vdd 2.22fF
C16975 pd_0/tspc_r_1/z5 vdd 1.10fF
C16976 pd_0/tspc_r_1/Z4 vdd 1.07fF
C16977 pd_0/tspc_r_1/Qbar vdd 0.88fF
C16978 pd_0/tspc_r_1/Z2 vdd 1.22fF
C16979 pd_0/tspc_r_1/Z1 vdd 0.67fF
C16980 pd_0/UP vdd 2.21fF
C16981 pd_0/tspc_r_1/Qbar1 vdd 1.34fF
C16982 pd_0/tspc_r_1/Z3 vdd 2.12fF
C16983 pd_0/REF vdd 1.80fF
C16984 pd_0/tspc_r_0/z5 vdd 1.10fF
C16985 pd_0/tspc_r_0/Z4 vdd 1.07fF
C16986 pd_0/R vdd 3.05fF
C16987 pd_0/tspc_r_0/Qbar vdd 0.79fF
C16988 pd_0/tspc_r_0/Z2 vdd 1.22fF
C16989 pd_0/tspc_r_0/Z1 vdd 0.67fF
C16990 pd_0/DOWN vdd 3.08fF
C16991 pd_0/tspc_r_0/Qbar1 vdd 1.34fF
C16992 pd_0/tspc_r_0/Z3 vdd 2.12fF
C16993 pd_0/DIV vdd 1.82fF
C16994 ashish_0/Gnd vdd 0.54fF
C16995 ashish_0/vop vdd 16.42fF
C16996 ashish_0/von vdd 16.41fF
C16997 ashish_0/a_150_n710# vdd 1.54fF **FLOATING
.ends
