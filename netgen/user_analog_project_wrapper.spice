* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_0/divbuf_0/a_17790_n1540# pll_full_0/divbuf_0/a_18270_n1540# 0.11fF
C1 pll_full_0/divbuf_0/a_48510_n840# pll_full_0/divbuf_0/a_48510_n1540# 0.01fF
C2 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/a_24892_n240# 0.05fF
C3 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/a_30232_n240# 0.04fF
C4 divbuf_2/a_8762_170# divbuf_2/a_8762_n240# 0.01fF
C5 divbuf_2/a_28772_170# divbuf_2/a_29262_170# 0.07fF
C6 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36030_n1540# 0.19fF
C7 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C8 pd_div_0/divbuf_0/a_5790_n840# pd_div_0/divbuf_0/a_5790_n1540# 0.01fF
C9 pd_div_0/divbuf_0/a_36030_n840# pd_div_0/divbuf_0/a_36510_n840# 0.07fF
C10 pll_full_0/divbuf_1/a_11070_n840# pll_full_0/divbuf_1/a_11070_n1540# 0.01fF
C11 pll_full_0/divbuf_1/a_41310_n840# pll_full_0/divbuf_1/a_41790_n840# 0.07fF
C12 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41310_n1540# 0.19fF
C13 divbuf_2/a_19562_170# divbuf_2/OUT4 0.19fF
C14 divbuf_2/a_1440_n1600# divbuf_2/a_1470_n1540# 0.19fF
C15 divbuf_2/a_1470_n840# divbuf_2/a_1950_n840# 0.07fF
C16 divbuf_1/a_25382_170# divbuf_1/OUT4 0.19fF
C17 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C18 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n840# 0.04fF
C19 gnd pll_full_0/divider_0/tspc_1/Z2 0.16fF
C20 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15390_n840# 0.04fF
C21 divbuf_2/a_54270_n1540# divbuf_2/a_54750_n1540# 0.11fF
C22 divbuf_1/a_18582_170# divbuf_1/a_19072_170# 0.07fF
C23 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C24 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C25 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z3 0.45fF
C26 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C27 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/Out 0.08fF
C28 divbuf_1/a_33600_n1600# divbuf_1/a_34080_n1600# 0.26fF
C29 divbuf_1/a_24412_n240# divbuf_1/a_24510_n840# 0.03fF
C30 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35520_n1600# 0.26fF
C31 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/a_25950_n840# 0.03fF
C32 divbuf_3/a_24480_n1600# divbuf_3/a_24960_n1600# 0.26fF
C33 divbuf_3/a_15182_n240# divbuf_3/a_15390_n840# 0.02fF
C34 ro_div_0/divbuf_0/a_58110_n840# ro_div_0/divbuf_0/a_58110_n1540# 0.01fF
C35 ro_div_0/divbuf_0/a_27390_n1540# ro_div_0/divbuf_0/a_27870_n1540# 0.11fF
C36 divbuf_3/a_16830_n1540# divbuf_3/a_17310_n1540# 0.11fF
C37 divbuf_3/a_47550_n840# divbuf_3/a_47550_n1540# 0.01fF
C38 divbuf_0/a_37992_170# divbuf_0/a_38472_170# 0.07fF
C39 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/a_32652_170# 0.07fF
C40 divbuf_2/a_20532_n240# divbuf_2/OUT4 0.04fF
C41 divbuf_2/a_51840_n1600# divbuf_2/a_51870_n840# 0.04fF
C42 divbuf_1/a_25920_n1600# divbuf_1/a_25950_n1540# 0.19fF
C43 divbuf_1/a_29742_n240# divbuf_1/OUT4 0.04fF
C44 divbuf_0/a_10590_n840# divbuf_0/a_11070_n840# 0.07fF
C45 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n1540# 0.19fF
C46 divbuf_0/a_37992_170# divbuf_0/OUT4 0.19fF
C47 pll_full_0/divbuf_0/a_4830_n840# pll_full_0/divbuf_0/a_5310_n840# 0.07fF
C48 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/OUT4 0.19fF
C49 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_4830_n1540# 0.19fF
C50 divbuf_1/a_23520_n1600# divbuf_1/a_23550_n840# 0.04fF
C51 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/OUT2 0.23fF
C52 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_24990_n840# 0.04fF
C53 divbuf_0/OUT3 divbuf_0/OUT4 0.36fF
C54 pll_full_0/divbuf_0/a_57630_n1540# pll_full_0/divbuf_0/a_58110_n1540# 0.11fF
C55 divbuf_3/a_14400_n1600# divbuf_3/a_14430_n840# 0.04fF
C56 divbuf_1/a_17790_n1540# divbuf_1/a_18270_n1540# 0.11fF
C57 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_23040_n1600# 0.26fF
C58 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_13470_n840# 0.02fF
C59 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_28320_n1600# 0.26fF
C60 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/a_18750_n840# 0.02fF
C61 divbuf_2/a_29742_n240# divbuf_2/a_30232_n240# 0.04fF
C62 pd_div_0/divbuf_0/a_14910_n1540# pd_div_0/divbuf_0/a_15390_n1540# 0.11fF
C63 pd_div_0/divbuf_0/a_45630_n840# pd_div_0/divbuf_0/a_45630_n1540# 0.01fF
C64 pll_full_0/divbuf_1/a_20190_n1540# pll_full_0/divbuf_1/a_20670_n1540# 0.11fF
C65 pll_full_0/divbuf_1/a_50910_n840# pll_full_0/divbuf_1/a_50910_n1540# 0.01fF
C66 divbuf_2/a_11070_n840# divbuf_2/a_11070_n1540# 0.01fF
C67 divbuf_2/a_41310_n840# divbuf_2/a_41790_n840# 0.07fF
C68 divbuf_2/a_41280_n1600# divbuf_2/a_41310_n1540# 0.19fF
C69 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/a_22472_n240# 0.01fF
C70 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/a_1842_n240# 0.04fF
C71 divbuf_0/a_38962_n240# divbuf_0/OUT4 0.04fF
C72 divbuf_3/a_11802_170# divbuf_3/a_11802_n240# 0.01fF
C73 divbuf_3/a_31202_170# divbuf_3/a_31682_170# 0.07fF
C74 divbuf_1/a_40412_170# divbuf_1/a_40902_170# 0.07fF
C75 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C76 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55230_n840# 0.04fF
C77 divbuf_1/a_12960_n1600# divbuf_1/a_12990_n1540# 0.19fF
C78 divbuf_1/a_12990_n840# divbuf_1/a_13470_n840# 0.07fF
C79 ro_div_0/ro_complete_0/cbank_1/switch_2/vin ro_div_0/divider_0/clk 1.30fF
C80 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C81 ro_div_0/divbuf_0/a_14430_n840# ro_div_0/divbuf_0/a_14910_n840# 0.07fF
C82 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14430_n1540# 0.19fF
C83 ro_div_0/divider_0/prescaler_0/tspc_2/D gnd 0.05fF
C84 divbuf_3/a_3870_n840# divbuf_3/a_4350_n840# 0.07fF
C85 divbuf_3/a_24412_170# divbuf_3/OUT4 0.19fF
C86 divbuf_3/a_3840_n1600# divbuf_3/a_3870_n1540# 0.19fF
C87 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12510_n840# 0.04fF
C88 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_17790_n840# 0.04fF
C89 divbuf_3/a_56670_n1540# divbuf_3/a_57150_n1540# 0.11fF
C90 divbuf_0/a_38962_n240# divbuf_0/a_39442_n240# 0.05fF
C91 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/a_33622_n240# 0.05fF
C92 divbuf_1/a_35550_n840# divbuf_1/a_35550_n1540# 0.01fF
C93 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n1540# 0.19fF
C94 divbuf_0/a_50430_n840# divbuf_0/a_50910_n840# 0.07fF
C95 divbuf_0/a_20190_n840# divbuf_0/a_20190_n1540# 0.01fF
C96 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_44670_n1540# 0.19fF
C97 pll_full_0/divbuf_0/a_14430_n840# pll_full_0/divbuf_0/a_14430_n1540# 0.01fF
C98 pll_full_0/divbuf_0/a_44670_n840# pll_full_0/divbuf_0/a_45150_n840# 0.07fF
C99 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/a_29742_170# 0.07fF
C100 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/a_15182_n240# 0.01fF
C101 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/a_35082_170# 0.07fF
C102 divbuf_3/a_25382_n240# divbuf_3/OUT4 0.04fF
C103 divbuf_3/a_54240_n1600# divbuf_3/a_54270_n840# 0.04fF
C104 divbuf_1/a_57630_n1540# divbuf_1/a_58110_n1540# 0.11fF
C105 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/OUT4 0.19fF
C106 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_1950_n1540# 0.19fF
C107 pd_div_0/divbuf_0/a_1950_n840# pd_div_0/divbuf_0/a_2430_n840# 0.07fF
C108 divbuf_0/a_6332_170# divbuf_0/a_5852_170# 0.07fF
C109 pll_full_0/divbuf_1/a_7230_n840# pll_full_0/divbuf_1/a_7710_n840# 0.07fF
C110 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/OUT4 0.19fF
C111 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7230_n1540# 0.19fF
C112 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C113 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C114 divbuf_2/a_27840_n1600# divbuf_2/a_28320_n1600# 0.26fF
C115 divbuf_2/a_18582_n240# divbuf_2/a_18750_n840# 0.02fF
C116 pd_div_0/divbuf_0/a_54750_n1540# pd_div_0/divbuf_0/a_55230_n1540# 0.11fF
C117 pll_full_0/divbuf_1/a_60030_n1540# pll_full_0/divbuf_1/a_60510_n1540# 0.11fF
C118 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/a_1470_n840# 0.03fF
C119 divbuf_2/a_20190_n1540# divbuf_2/a_20670_n1540# 0.11fF
C120 divbuf_2/a_50910_n840# divbuf_2/a_50910_n1540# 0.01fF
C121 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_1440_n1600# 0.26fF
C122 divbuf_3/a_32172_n240# divbuf_3/a_32652_n240# 0.05fF
C123 divbuf_1/a_52830_n840# divbuf_1/a_53310_n840# 0.07fF
C124 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54270_n1540# 0.19fF
C125 ro_div_0/divbuf_0/a_54270_n840# ro_div_0/divbuf_0/a_54750_n840# 0.07fF
C126 ro_div_0/divbuf_0/a_24030_n840# ro_div_0/divbuf_0/a_24030_n1540# 0.01fF
C127 divbuf_3/a_13470_n840# divbuf_3/a_13470_n1540# 0.01fF
C128 divbuf_3/a_43710_n840# divbuf_3/a_44190_n840# 0.07fF
C129 divbuf_3/a_43680_n1600# divbuf_3/a_43710_n1540# 0.19fF
C130 divbuf_3/a_23520_n1600# divbuf_3/OUT4 0.00fF
C131 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C132 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52350_n840# 0.04fF
C133 ro_div_0/divider_0/tspc_0/Z2 ro_div_0/divider_0/tspc_0/Z3 0.16fF
C134 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/B 0.18fF
C135 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_3/vin 0.20fF
C136 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C137 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_57630_n840# 0.04fF
C138 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C139 divbuf_2/a_17760_n1600# divbuf_2/a_17790_n840# 0.04fF
C140 divbuf_0/a_27802_n240# divbuf_0/a_27870_n840# 0.04fF
C141 divbuf_0/a_36960_n1600# divbuf_0/a_37440_n1600# 0.26fF
C142 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31680_n1600# 0.26fF
C143 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/a_22110_n840# 0.03fF
C144 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/a_630_n680# 0.12fF
C145 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_11550_n840# 0.02fF
C146 divbuf_0/a_60030_n840# divbuf_0/a_60030_n1540# 0.01fF
C147 divbuf_0/a_29310_n1540# divbuf_0/a_29790_n1540# 0.11fF
C148 pll_full_0/divbuf_0/a_23550_n1540# pll_full_0/divbuf_0/a_24030_n1540# 0.11fF
C149 pll_full_0/divbuf_0/a_54270_n840# pll_full_0/divbuf_0/a_54270_n1540# 0.01fF
C150 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/a_30712_n240# 0.05fF
C151 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_510_n840# 0.00fF
C152 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/a_36052_n240# 0.04fF
C153 divbuf_2/a_15182_170# divbuf_2/a_15182_n240# 0.01fF
C154 divbuf_2/a_34592_170# divbuf_2/a_35082_170# 0.07fF
C155 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C156 pd_div_0/divbuf_0/a_11550_n840# pd_div_0/divbuf_0/a_11550_n1540# 0.01fF
C157 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/a_42270_n840# 0.07fF
C158 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_41790_n1540# 0.19fF
C159 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47070_n1540# 0.19fF
C160 pll_full_0/divbuf_1/a_16830_n840# pll_full_0/divbuf_1/a_16830_n1540# 0.01fF
C161 pll_full_0/divbuf_1/a_47070_n840# pll_full_0/divbuf_1/a_47550_n840# 0.07fF
C162 divbuf_2/a_7230_n840# divbuf_2/a_7710_n840# 0.07fF
C163 divbuf_2/a_31202_170# divbuf_2/OUT4 0.19fF
C164 divbuf_2/a_7200_n1600# divbuf_2/a_7230_n1540# 0.19fF
C165 divbuf_1/a_40412_170# divbuf_1/OUT4 0.19fF
C166 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z4 0.15fF
C167 pd_div_0/divider_0/tspc_1/Z4 gnd 0.44fF
C168 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/Out 0.11fF
C169 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/clk 0.11fF
C170 divbuf_0/a_5852_170# divbuf_0/OUT3 0.19fF
C171 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n840# 0.04fF
C172 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21150_n840# 0.04fF
C173 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/OUT2 0.19fF
C174 divbuf_2/a_60030_n1540# divbuf_2/a_60510_n1540# 0.11fF
C175 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/a_31710_n840# 0.05fF
C176 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_41280_n1600# 0.26fF
C177 divbuf_1/a_39360_n1600# divbuf_1/a_39840_n1600# 0.26fF
C178 divbuf_1/a_30232_n240# divbuf_1/a_30270_n840# 0.05fF
C179 divbuf_3/a_30240_n1600# divbuf_3/a_30720_n1600# 0.26fF
C180 divbuf_3/a_21012_n240# divbuf_3/a_21150_n840# 0.03fF
C181 ro_div_0/divbuf_0/a_33150_n1540# ro_div_0/divbuf_0/a_33630_n1540# 0.11fF
C182 divbuf_3/a_22590_n1540# divbuf_3/a_23070_n1540# 0.11fF
C183 divbuf_3/a_53310_n840# divbuf_3/a_53310_n1540# 0.01fF
C184 divbuf_0/a_24412_170# divbuf_0/a_24412_n240# 0.01fF
C185 divbuf_0/a_3912_n240# divbuf_0/a_4392_n240# 0.05fF
C186 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/a_38472_170# 0.07fF
C187 divbuf_2/a_32172_n240# divbuf_2/OUT4 0.04fF
C188 divbuf_2/a_57600_n1600# divbuf_2/a_57630_n840# 0.04fF
C189 divbuf_1/a_31680_n1600# divbuf_1/a_31710_n1540# 0.19fF
C190 divbuf_1/a_41382_n240# divbuf_1/OUT4 0.04fF
C191 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n1540# 0.19fF
C192 divbuf_0/a_10212_n240# divbuf_0/OUT3 0.04fF
C193 divbuf_0/a_16350_n840# divbuf_0/a_16830_n840# 0.07fF
C194 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/a_11070_n840# 0.07fF
C195 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/OUT4 0.19fF
C196 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_10590_n1540# 0.19fF
C197 divbuf_1/a_29280_n1600# divbuf_1/a_29310_n840# 0.04fF
C198 divbuf_1/a_23550_n1540# divbuf_1/a_24030_n1540# 0.11fF
C199 pd_div_0/pd_0/DOWN pd_div_0/pd_0/R 0.36fF
C200 pd_div_0/div pd_div_0/pd_0/tspc_r_0/z5 0.04fF
C201 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z4 0.20fF
C202 pd_div_0/pd_0/tspc_r_0/Z1 pd_div_0/pd_0/tspc_r_0/Z2 0.71fF
C203 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_30750_n840# 0.04fF
C204 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/OUT4 0.19fF
C205 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C206 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 0.36fF
C207 divbuf_3/a_20160_n1600# divbuf_3/a_20190_n840# 0.04fF
C208 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28800_n1600# 0.26fF
C209 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/a_19230_n840# 0.02fF
C210 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_34080_n1600# 0.26fF
C211 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/a_24510_n840# 0.03fF
C212 divbuf_2/a_35562_n240# divbuf_2/a_36052_n240# 0.04fF
C213 pd_div_0/divbuf_0/a_20670_n1540# pd_div_0/divbuf_0/a_21150_n1540# 0.11fF
C214 pd_div_0/divbuf_0/a_51390_n840# pd_div_0/divbuf_0/a_51390_n1540# 0.01fF
C215 pll_full_0/divbuf_1/a_25950_n1540# pll_full_0/divbuf_1/a_26430_n1540# 0.11fF
C216 pll_full_0/divbuf_1/a_56670_n840# pll_full_0/divbuf_1/a_56670_n1540# 0.01fF
C217 divbuf_2/a_47040_n1600# divbuf_2/a_47070_n1540# 0.19fF
C218 divbuf_2/a_16830_n840# divbuf_2/a_16830_n1540# 0.01fF
C219 divbuf_2/a_47070_n840# divbuf_2/a_47550_n840# 0.07fF
C220 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/a_28292_n240# 0.01fF
C221 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/a_8272_n240# 0.05fF
C222 divbuf_0/a_9120_n1600# divbuf_0/OUT3 0.00fF
C223 divbuf_3/a_17612_170# divbuf_3/a_17612_n240# 0.01fF
C224 divbuf_3/a_37022_170# divbuf_3/a_37502_170# 0.07fF
C225 divbuf_1/a_6332_n240# divbuf_1/a_6822_n240# 0.04fF
C226 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C227 divbuf_1/a_18750_n840# divbuf_1/a_19230_n840# 0.07fF
C228 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20190_n1540# 0.19fF
C229 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C230 ro_div_0/divbuf_0/a_20190_n840# ro_div_0/divbuf_0/a_20670_n840# 0.07fF
C231 divbuf_3/a_9630_n840# divbuf_3/a_10110_n840# 0.07fF
C232 divbuf_3/a_36052_170# divbuf_3/OUT4 0.19fF
C233 divbuf_3/a_9600_n1600# divbuf_3/a_9630_n1540# 0.19fF
C234 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18270_n840# 0.04fF
C235 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/OUT2 0.19fF
C236 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_23550_n840# 0.04fF
C237 divbuf_3/a_60990_n1540# divbuf_3/OUT5 0.19fF
C238 divbuf_0/a_2880_n1600# divbuf_0/a_3360_n1600# 0.26fF
C239 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/a_39442_n240# 0.05fF
C240 divbuf_1/a_41310_n840# divbuf_1/a_41310_n1540# 0.01fF
C241 divbuf_0/a_56190_n840# divbuf_0/a_56670_n840# 0.07fF
C242 divbuf_0/a_25950_n840# divbuf_0/a_25950_n1540# 0.01fF
C243 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n1540# 0.19fF
C244 pll_full_0/divbuf_0/a_20190_n840# pll_full_0/divbuf_0/a_20190_n1540# 0.01fF
C245 pll_full_0/divbuf_0/a_50430_n840# pll_full_0/divbuf_0/a_50910_n840# 0.07fF
C246 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50430_n1540# 0.19fF
C247 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/a_35562_170# 0.07fF
C248 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/a_15672_n240# 0.01fF
C249 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/a_21012_n240# 0.01fF
C250 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/a_40902_170# 0.07fF
C251 divbuf_3/a_37022_n240# divbuf_3/OUT4 0.04fF
C252 divbuf_3/a_60000_n1600# divbuf_3/a_60030_n840# 0.04fF
C253 divbuf_1/OUT3 divbuf_1/OUT4 0.36fF
C254 divbuf_1/a_492_n240# divbuf_1/OUT2 0.42fF
C255 pd_div_0/div pd_div_0/bufin 0.26fF
C256 pd_div_0/divbuf_0/a_7710_n840# pd_div_0/divbuf_0/a_8190_n840# 0.07fF
C257 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/OUT4 0.19fF
C258 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_7710_n1540# 0.19fF
C259 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/Out 0.11fF
C260 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/a_630_n680# 0.01fF
C261 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C262 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C263 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/OUT3 0.07fF
C264 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_12990_n1540# 0.19fF
C265 pll_full_0/divbuf_1/a_12990_n840# pll_full_0/divbuf_1/a_13470_n840# 0.07fF
C266 divbuf_2/a_33600_n1600# divbuf_2/a_34080_n1600# 0.26fF
C267 divbuf_2/a_24412_n240# divbuf_2/a_24510_n840# 0.03fF
C268 pd_div_0/divbuf_0/a_60510_n1540# pd_div_0/divbuf_0/a_60990_n1540# 0.11fF
C269 pd_0/R pd_0/REF 0.61fF
C270 divbuf_0/a_13742_n240# divbuf_0/a_13470_n840# 0.01fF
C271 divbuf_2/a_25950_n1540# divbuf_2/a_26430_n1540# 0.11fF
C272 divbuf_2/a_56670_n840# divbuf_2/a_56670_n1540# 0.01fF
C273 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_7200_n1600# 0.26fF
C274 divbuf_3/a_37992_n240# divbuf_3/a_38472_n240# 0.05fF
C275 divbuf_1/a_5280_n1600# divbuf_1/a_5760_n1600# 0.26fF
C276 divbuf_1/a_58590_n840# divbuf_1/a_59070_n840# 0.07fF
C277 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60030_n1540# 0.19fF
C278 ro_div_0/divbuf_0/a_60030_n840# ro_div_0/divbuf_0/a_60510_n840# 0.07fF
C279 ro_div_0/divbuf_0/a_29790_n840# ro_div_0/divbuf_0/a_29790_n1540# 0.01fF
C280 divbuf_3/a_35040_n1600# divbuf_3/OUT4 0.00fF
C281 divbuf_3/a_19230_n840# divbuf_3/a_19230_n1540# 0.01fF
C282 divbuf_3/a_49470_n840# divbuf_3/a_49950_n840# 0.07fF
C283 divbuf_3/a_49440_n1600# divbuf_3/a_49470_n1540# 0.19fF
C284 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C285 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58110_n840# 0.04fF
C286 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C287 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C288 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C289 divbuf_2/a_2322_170# divbuf_2/OUT2 0.19fF
C290 divbuf_2/a_23520_n1600# divbuf_2/a_23550_n840# 0.04fF
C291 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z3 0.05fF
C292 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C293 divbuf_0/a_33622_n240# divbuf_0/a_33630_n840# 0.06fF
C294 divbuf_0/a_42720_n1600# divbuf_0/a_43200_n1600# 0.26fF
C295 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C296 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_37440_n1600# 0.26fF
C297 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/a_27870_n840# 0.04fF
C298 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_17310_n840# 0.00fF
C299 divbuf_1/a_16152_n240# divbuf_1/a_15870_n840# 0.01fF
C300 divbuf_0/a_35070_n1540# divbuf_0/a_35550_n1540# 0.11fF
C301 pll_full_0/divbuf_0/a_29310_n1540# pll_full_0/divbuf_0/a_29790_n1540# 0.11fF
C302 pll_full_0/divbuf_0/a_60030_n840# pll_full_0/divbuf_0/a_60030_n1540# 0.01fF
C303 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/a_36532_n240# 0.05fF
C304 divbuf_2/a_21012_170# divbuf_2/a_21012_n240# 0.01fF
C305 divbuf_2/a_40412_170# divbuf_2/a_40902_170# 0.07fF
C306 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_47550_n1540# 0.19fF
C307 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C308 pd_div_0/divbuf_0/a_17310_n840# pd_div_0/divbuf_0/a_17310_n1540# 0.01fF
C309 pd_div_0/divbuf_0/a_47550_n840# pd_div_0/divbuf_0/a_48030_n840# 0.07fF
C310 pll_full_0/divbuf_1/a_22590_n840# pll_full_0/divbuf_1/a_22590_n1540# 0.01fF
C311 pll_full_0/divbuf_1/a_52830_n840# pll_full_0/divbuf_1/a_53310_n840# 0.07fF
C312 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_52830_n1540# 0.19fF
C313 divbuf_2/a_3422_n240# divbuf_2/OUT3 0.07fF
C314 divbuf_2/a_12960_n1600# divbuf_2/a_12990_n1540# 0.19fF
C315 divbuf_2/a_12990_n840# divbuf_2/a_13470_n840# 0.07fF
C316 divbuf_1/a_12772_n240# divbuf_1/OUT4 0.04fF
C317 gnd pd_div_0/divider_0/tspc_2/Z3 0.27fF
C318 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C319 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/a_15182_170# 0.07fF
C320 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n840# 0.04fF
C321 divbuf_0/a_21012_170# divbuf_0/OUT4 0.19fF
C322 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_26910_n840# 0.04fF
C323 divbuf_3/a_1352_170# divbuf_3/a_1842_170# 0.07fF
C324 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_47040_n1600# 0.26fF
C325 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/a_37470_n840# 0.05fF
C326 divbuf_1/a_45120_n1600# divbuf_1/a_45600_n1600# 0.26fF
C327 divbuf_1/a_36052_n240# divbuf_1/a_36030_n840# 0.05fF
C328 divbuf_3/a_36000_n1600# divbuf_3/a_36480_n1600# 0.26fF
C329 divbuf_3/a_26832_n240# divbuf_3/a_26910_n840# 0.04fF
C330 ro_div_0/divbuf_0/a_38910_n1540# ro_div_0/divbuf_0/a_39390_n1540# 0.11fF
C331 divbuf_3/a_28350_n1540# divbuf_3/a_28830_n1540# 0.11fF
C332 divbuf_3/a_59070_n840# divbuf_3/a_59070_n1540# 0.01fF
C333 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/OUT4 0.03fF
C334 divbuf_0/a_30232_170# divbuf_0/a_30232_n240# 0.01fF
C335 divbuf_0/a_9732_n240# divbuf_0/a_10212_n240# 0.05fF
C336 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/a_4392_n240# 0.05fF
C337 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/a_24412_n240# 0.01fF
C338 divbuf_2/a_2880_n1600# divbuf_2/OUT2 0.00fF
C339 divbuf_1/a_11040_n1600# divbuf_1/OUT4 0.00fF
C340 divbuf_1/a_37440_n1600# divbuf_1/a_37470_n1540# 0.19fF
C341 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/a_14702_n240# 0.01fF
C342 divbuf_0/a_22110_n840# divbuf_0/a_22590_n840# 0.07fF
C343 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n1540# 0.19fF
C344 divbuf_0/a_21982_n240# divbuf_0/OUT4 0.04fF
C345 pll_full_0/divbuf_0/a_16350_n840# pll_full_0/divbuf_0/a_16830_n840# 0.07fF
C346 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C347 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16350_n1540# 0.19fF
C348 divbuf_1/a_35040_n1600# divbuf_1/a_35070_n840# 0.04fF
C349 divbuf_1/a_29310_n1540# divbuf_1/a_29790_n1540# 0.11fF
C350 pd_div_0/pd_0/tspc_r_0/Z4 pd_div_0/pd_0/tspc_r_1/Z4 0.02fF
C351 pd_div_0/pd_0/DOWN pd_div_0/pd_0/and_pd_0/Out1 0.12fF
C352 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z1 0.17fF
C353 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/UP 0.11fF
C354 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36510_n840# 0.04fF
C355 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/OUT4 0.19fF
C356 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 0.61fF
C357 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/a_5852_170# 0.07fF
C358 divbuf_3/a_7302_170# divbuf_3/OUT3 0.19fF
C359 divbuf_3/a_25920_n1600# divbuf_3/a_25950_n840# 0.04fF
C360 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/a_24990_n840# 0.03fF
C361 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34560_n1600# 0.26fF
C362 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39840_n1600# 0.26fF
C363 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/a_30270_n840# 0.05fF
C364 pd_div_0/divbuf_0/a_26430_n1540# pd_div_0/divbuf_0/a_26910_n1540# 0.11fF
C365 pd_div_0/divbuf_0/a_57150_n840# pd_div_0/divbuf_0/a_57150_n1540# 0.01fF
C366 pll_full_0/divbuf_1/a_31710_n1540# pll_full_0/divbuf_1/a_32190_n1540# 0.11fF
C367 divbuf_2/a_22590_n840# divbuf_2/a_22590_n1540# 0.01fF
C368 divbuf_2/a_52830_n840# divbuf_2/a_53310_n840# 0.07fF
C369 divbuf_2/a_52800_n1600# divbuf_2/a_52830_n1540# 0.19fF
C370 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/a_34112_n240# 0.01fF
C371 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_14702_n240# 0.05fF
C372 divbuf_0/a_20160_n1600# divbuf_0/OUT4 0.00fF
C373 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C374 divbuf_3/a_23442_170# divbuf_3/a_23442_n240# 0.01fF
C375 divbuf_1/a_12772_n240# divbuf_1/a_13252_n240# 0.05fF
C376 divbuf_1/a_24510_n840# divbuf_1/a_24990_n840# 0.07fF
C377 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C378 ro_div_0/divbuf_0/a_25950_n840# ro_div_0/divbuf_0/a_26430_n840# 0.07fF
C379 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_25950_n1540# 0.19fF
C380 divbuf_3/a_15390_n840# divbuf_3/a_15870_n840# 0.07fF
C381 divbuf_3/a_8272_n240# divbuf_3/OUT3 0.04fF
C382 divbuf_3/a_15360_n1600# divbuf_3/a_15390_n1540# 0.19fF
C383 pd_div_0/divbuf_0/a_4882_170# pd_div_0/divbuf_0/OUT3 0.19fF
C384 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24030_n840# 0.04fF
C385 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z2 0.14fF
C386 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/OUT4 0.19fF
C387 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29310_n840# 0.04fF
C388 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C389 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C390 divbuf_0/a_8640_n1600# divbuf_0/a_9120_n1600# 0.26fF
C391 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_3360_n1600# 0.26fF
C392 divbuf_1/a_47070_n840# divbuf_1/a_47070_n1540# 0.01fF
C393 divbuf_0/a_31710_n840# divbuf_0/a_31710_n1540# 0.01fF
C394 divbuf_0/a_990_n1540# divbuf_0/a_1470_n1540# 0.11fF
C395 divbuf_0/a_510_n840# divbuf_0/OUT2 0.02fF
C396 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56190_n1540# 0.19fF
C397 pll_full_0/divbuf_0/a_25950_n840# pll_full_0/divbuf_0/a_25950_n1540# 0.01fF
C398 pll_full_0/divbuf_0/a_56190_n840# pll_full_0/divbuf_0/a_56670_n840# 0.07fF
C399 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/a_21502_n240# 0.01fF
C400 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/a_41382_170# 0.07fF
C401 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/a_26832_n240# 0.01fF
C402 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/a_6822_n240# 0.04fF
C403 divbuf_2/a_5362_170# divbuf_2/a_5852_170# 0.07fF
C404 divbuf_1/a_8272_170# divbuf_1/OUT3 0.19fF
C405 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C406 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13470_n1540# 0.19fF
C407 pd_div_0/divbuf_0/a_13470_n840# pd_div_0/divbuf_0/a_13950_n840# 0.07fF
C408 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_0/Z3 0.38fF
C409 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C410 pll_full_0/divbuf_1/a_18750_n840# pll_full_0/divbuf_1/a_19230_n840# 0.07fF
C411 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C412 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_18750_n1540# 0.19fF
C413 divbuf_2/a_39360_n1600# divbuf_2/a_39840_n1600# 0.26fF
C414 divbuf_2/a_30232_n240# divbuf_2/a_30270_n840# 0.05fF
C415 divbuf_1/a_17612_170# divbuf_1/a_18092_170# 0.07fF
C416 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_13470_n840# 0.01fF
C417 divbuf_2/a_31710_n1540# divbuf_2/a_32190_n1540# 0.11fF
C418 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12960_n1600# 0.26fF
C419 divbuf_3/a_1920_n1600# divbuf_3/a_2400_n1600# 0.26fF
C420 divbuf_1/a_11040_n1600# divbuf_1/a_11520_n1600# 0.26fF
C421 divbuf_1/a_3390_n1540# divbuf_1/a_3870_n1540# 0.11fF
C422 ro_div_0/divbuf_0/a_35550_n840# ro_div_0/divbuf_0/a_35550_n1540# 0.01fF
C423 ro_div_0/divbuf_0/a_4830_n1540# ro_div_0/divbuf_0/a_5310_n1540# 0.11fF
C424 divbuf_3/a_24990_n840# divbuf_3/a_24990_n1540# 0.01fF
C425 divbuf_3/a_55230_n840# divbuf_3/a_55710_n840# 0.07fF
C426 divbuf_3/a_55200_n1600# divbuf_3/a_55230_n1540# 0.19fF
C427 divbuf_1/a_20042_170# divbuf_1/OUT4 0.19fF
C428 divbuf_0/a_13742_170# divbuf_0/a_14222_170# 0.07fF
C429 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C430 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C431 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C432 divbuf_2/a_14222_170# divbuf_2/OUT4 0.19fF
C433 divbuf_2/a_29280_n1600# divbuf_2/a_29310_n840# 0.04fF
C434 divbuf_0/a_48480_n1600# divbuf_0/a_48960_n1600# 0.26fF
C435 divbuf_0/a_39442_n240# divbuf_0/a_39390_n840# 0.04fF
C436 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C437 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_43200_n1600# 0.26fF
C438 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/OUT3 0.19fF
C439 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/a_33630_n840# 0.06fF
C440 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2430_n840# 0.04fF
C441 divbuf_3/a_12772_n240# divbuf_3/a_12510_n840# 0.01fF
C442 divbuf_1/a_960_n1600# divbuf_1/a_990_n840# 0.04fF
C443 divbuf_0/a_40830_n1540# divbuf_0/a_41310_n1540# 0.11fF
C444 pll_full_0/divbuf_0/a_35070_n1540# pll_full_0/divbuf_0/a_35550_n1540# 0.11fF
C445 pd_div_0/divbuf_0/a_0_n1600# pd_div_0/divbuf_0/a_480_n1600# 0.26fF
C446 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5760_n1600# 0.26fF
C447 divbuf_2/a_26832_170# divbuf_2/a_26832_n240# 0.01fF
C448 divbuf_2/a_6332_n240# divbuf_2/a_6822_n240# 0.04fF
C449 pd_div_0/divbuf_0/a_23070_n840# pd_div_0/divbuf_0/a_23070_n1540# 0.01fF
C450 pd_div_0/divbuf_0/a_53310_n840# pd_div_0/divbuf_0/a_53790_n840# 0.07fF
C451 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53310_n1540# 0.19fF
C452 divbuf_0/a_14702_170# divbuf_0/a_14702_n240# 0.01fF
C453 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_58590_n1540# 0.19fF
C454 pll_full_0/divbuf_1/a_28350_n840# pll_full_0/divbuf_1/a_28350_n1540# 0.01fF
C455 pll_full_0/divbuf_1/a_58590_n840# pll_full_0/divbuf_1/a_59070_n840# 0.07fF
C456 divbuf_2/a_18750_n840# divbuf_2/a_19230_n840# 0.07fF
C457 divbuf_2/a_15182_n240# divbuf_2/OUT4 0.04fF
C458 divbuf_2/a_18720_n1600# divbuf_2/a_18750_n1540# 0.19fF
C459 divbuf_1/a_24412_n240# divbuf_1/OUT4 0.04fF
C460 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/clk 0.51fF
C461 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/a_5852_n240# 0.01fF
C462 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n840# 0.04fF
C463 divbuf_0/a_32652_170# divbuf_0/OUT4 0.19fF
C464 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/OUT4 0.19fF
C465 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_32670_n840# 0.04fF
C466 divbuf_3/a_7792_170# divbuf_3/a_8272_170# 0.07fF
C467 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/OUT4 0.19fF
C468 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52800_n1600# 0.26fF
C469 divbuf_3/a_41760_n1600# divbuf_3/a_42240_n1600# 0.26fF
C470 divbuf_3/a_32652_n240# divbuf_3/a_32670_n840# 0.06fF
C471 divbuf_1/a_50880_n1600# divbuf_1/a_51360_n1600# 0.26fF
C472 ro_div_0/divbuf_0/a_44670_n1540# ro_div_0/divbuf_0/a_45150_n1540# 0.11fF
C473 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_15870_n840# 0.01fF
C474 divbuf_3/a_34110_n1540# divbuf_3/a_34590_n1540# 0.11fF
C475 divbuf_0/a_36052_170# divbuf_0/a_36052_n240# 0.01fF
C476 divbuf_0/a_16152_n240# divbuf_0/a_16642_n240# 0.04fF
C477 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/a_10212_n240# 0.05fF
C478 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/a_30232_n240# 0.01fF
C479 divbuf_2/a_13440_n1600# divbuf_2/OUT4 0.00fF
C480 divbuf_1/a_43200_n1600# divbuf_1/a_43230_n1540# 0.19fF
C481 divbuf_1/a_22560_n1600# divbuf_1/OUT4 0.01fF
C482 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n1540# 0.19fF
C483 divbuf_0/a_27870_n840# divbuf_0/a_28350_n840# 0.07fF
C484 divbuf_0/a_33622_n240# divbuf_0/OUT4 0.04fF
C485 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C486 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22110_n1540# 0.19fF
C487 pll_full_0/divbuf_0/a_22110_n840# pll_full_0/divbuf_0/a_22590_n840# 0.07fF
C488 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42270_n840# 0.04fF
C489 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/OUT4 0.19fF
C490 divbuf_1/a_40800_n1600# divbuf_1/a_40830_n840# 0.04fF
C491 divbuf_1/a_35070_n1540# divbuf_1/a_35550_n1540# 0.11fF
C492 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/a_14222_170# 0.07fF
C493 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/a_12282_170# 0.07fF
C494 divbuf_3/a_19072_170# divbuf_3/OUT4 0.19fF
C495 divbuf_3/a_31680_n1600# divbuf_3/a_31710_n840# 0.04fF
C496 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_40320_n1600# 0.26fF
C497 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/a_30750_n840# 0.05fF
C498 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45600_n1600# 0.26fF
C499 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/a_36030_n840# 0.05fF
C500 divbuf_2/a_5280_n1600# divbuf_2/a_5760_n1600# 0.26fF
C501 pd_div_0/divbuf_0/a_32190_n1540# pd_div_0/divbuf_0/a_32670_n1540# 0.11fF
C502 pll_full_0/divbuf_1/a_37470_n1540# pll_full_0/divbuf_1/a_37950_n1540# 0.11fF
C503 divbuf_2/a_58560_n1600# divbuf_2/a_58590_n1540# 0.19fF
C504 divbuf_2/a_28350_n840# divbuf_2/a_28350_n1540# 0.01fF
C505 divbuf_2/a_58590_n840# divbuf_2/a_59070_n840# 0.07fF
C506 divbuf_1/a_38472_170# divbuf_1/a_38472_n240# 0.01fF
C507 divbuf_1/a_18582_n240# divbuf_1/a_19072_n240# 0.04fF
C508 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/a_20532_n240# 0.04fF
C509 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/a_39932_n240# 0.01fF
C510 divbuf_0/a_31680_n1600# divbuf_0/OUT4 0.00fF
C511 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C512 divbuf_3/a_8762_n240# divbuf_3/a_9242_n240# 0.05fF
C513 divbuf_3/a_29262_170# divbuf_3/a_29262_n240# 0.01fF
C514 divbuf_1/a_30270_n840# divbuf_1/a_30750_n840# 0.07fF
C515 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C516 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_31710_n1540# 0.19fF
C517 ro_div_0/divbuf_0/a_31710_n840# ro_div_0/divbuf_0/a_32190_n840# 0.07fF
C518 ro_div_0/divbuf_0/a_1470_n840# ro_div_0/divbuf_0/a_1470_n1540# 0.01fF
C519 divbuf_3/a_21150_n840# divbuf_3/a_21630_n840# 0.07fF
C520 divbuf_3/a_20042_n240# divbuf_3/OUT4 0.04fF
C521 divbuf_3/a_21120_n1600# divbuf_3/a_21150_n1540# 0.19fF
C522 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/OUT4 0.19fF
C523 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_29790_n840# 0.04fF
C524 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/nor_1/A 1.21fF
C525 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C526 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/OUT4 0.19fF
C527 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35070_n840# 0.04fF
C528 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C529 divbuf_2/a_16152_n240# divbuf_2/a_15870_n840# 0.01fF
C530 ashish_0/a_150_0# ashish_0/Gnd 1.74fF
C531 ashish_0/a_150_n710# ashish_0/vop 9.14fF
C532 divbuf_0/a_4882_n240# divbuf_0/a_4830_n840# 0.04fF
C533 divbuf_0/a_14400_n1600# divbuf_0/a_14880_n1600# 0.26fF
C534 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_9120_n1600# 0.26fF
C535 divbuf_1/a_52830_n840# divbuf_1/a_52830_n1540# 0.01fF
C536 divbuf_0/a_37470_n840# divbuf_0/a_37470_n1540# 0.01fF
C537 divbuf_0/a_6750_n1540# divbuf_0/a_7230_n1540# 0.11fF
C538 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/OUT2 0.02fF
C539 pll_full_0/divbuf_0/a_990_n1540# pll_full_0/divbuf_0/a_1470_n1540# 0.11fF
C540 pll_full_0/divbuf_0/a_31710_n840# pll_full_0/divbuf_0/a_31710_n1540# 0.01fF
C541 divbuf_2/a_11802_170# divbuf_2/a_12282_170# 0.07fF
C542 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/a_7302_n240# 0.05fF
C543 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/a_27322_n240# 0.01fF
C544 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/a_32652_n240# 0.01fF
C545 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_13252_n240# 0.05fF
C546 divbuf_1/a_5362_170# divbuf_1/OUT3 0.19fF
C547 pd_div_0/divbuf_0/a_19230_n840# pd_div_0/divbuf_0/a_19710_n840# 0.07fF
C548 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C549 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19230_n1540# 0.19fF
C550 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C551 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24510_n1540# 0.19fF
C552 pll_full_0/divbuf_1/a_24510_n840# pll_full_0/divbuf_1/a_24990_n840# 0.07fF
C553 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/a_3912_170# 0.07fF
C554 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C555 divbuf_2/a_45120_n1600# divbuf_2/a_45600_n1600# 0.26fF
C556 divbuf_2/a_36052_n240# divbuf_2/a_36030_n840# 0.05fF
C557 divbuf_1/a_7792_170# divbuf_1/a_8272_170# 0.07fF
C558 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n840# 0.04fF
C559 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C560 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C561 divbuf_2/a_37470_n1540# divbuf_2/a_37950_n1540# 0.11fF
C562 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/a_8670_n840# 0.03fF
C563 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18720_n1600# 0.26fF
C564 divbuf_3/a_7680_n1600# divbuf_3/a_8160_n1600# 0.26fF
C565 divbuf_1/a_16800_n1600# divbuf_1/a_17280_n1600# 0.26fF
C566 divbuf_1/a_7302_n240# divbuf_1/a_7230_n840# 0.03fF
C567 divbuf_1/a_9150_n1540# divbuf_1/a_9630_n1540# 0.11fF
C568 ro_div_0/divbuf_0/a_41310_n840# ro_div_0/divbuf_0/a_41310_n1540# 0.01fF
C569 ro_div_0/divbuf_0/a_10590_n1540# ro_div_0/divbuf_0/a_11070_n1540# 0.11fF
C570 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_510_n840# 0.00fF
C571 divbuf_3/a_30750_n840# divbuf_3/a_30750_n1540# 0.01fF
C572 divbuf_1/a_35082_170# divbuf_1/OUT4 0.19fF
C573 divbuf_0/a_21012_170# divbuf_0/a_21502_170# 0.07fF
C574 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C575 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/a_8762_n240# 0.01fF
C576 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/a_17122_170# 0.07fF
C577 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C578 divbuf_2/a_25862_170# divbuf_2/OUT4 0.19fF
C579 divbuf_2/a_35040_n1600# divbuf_2/a_35070_n840# 0.04fF
C580 pd_div_0/divider_0/tspc_1/Q gnd 0.33fF
C581 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C582 divbuf_0/a_5362_170# divbuf_0/OUT3 0.19fF
C583 divbuf_0/a_54240_n1600# divbuf_0/a_54720_n1600# 0.26fF
C584 gnd pll_full_0/divider_0/tspc_1/Z4 0.44fF
C585 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C586 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C587 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/a_39390_n840# 0.04fF
C588 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48960_n1600# 0.26fF
C589 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/OUT3 0.19fF
C590 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8190_n840# 0.04fF
C591 divbuf_0/a_46590_n1540# divbuf_0/a_47070_n1540# 0.11fF
C592 divbuf_1/a_6720_n1600# divbuf_1/a_6750_n840# 0.04fF
C593 pll_full_0/divbuf_0/a_40830_n1540# pll_full_0/divbuf_0/a_41310_n1540# 0.11fF
C594 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_6240_n1600# 0.26fF
C595 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11520_n1600# 0.26fF
C596 divbuf_2/a_32652_170# divbuf_2/a_32652_n240# 0.01fF
C597 divbuf_2/a_12772_n240# divbuf_2/a_13252_n240# 0.05fF
C598 divbuf_1/a_36052_n240# divbuf_1/OUT4 0.04fF
C599 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59070_n1540# 0.19fF
C600 pd_div_0/divbuf_0/a_28830_n840# pd_div_0/divbuf_0/a_28830_n1540# 0.01fF
C601 pd_div_0/divbuf_0/a_59070_n840# pd_div_0/divbuf_0/a_59550_n840# 0.07fF
C602 pll_full_0/divbuf_1/a_3390_n1540# pll_full_0/divbuf_1/a_3870_n1540# 0.11fF
C603 pll_full_0/divbuf_1/a_34110_n840# pll_full_0/divbuf_1/a_34110_n1540# 0.01fF
C604 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/a_16642_n240# 0.01fF
C605 divbuf_2/a_26832_n240# divbuf_2/OUT4 0.04fF
C606 divbuf_2/a_24480_n1600# divbuf_2/a_24510_n1540# 0.19fF
C607 divbuf_2/a_24510_n840# divbuf_2/a_24990_n840# 0.07fF
C608 divbuf_1/a_20042_170# divbuf_1/a_20532_170# 0.07fF
C609 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/a_25382_170# 0.07fF
C610 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n840# 0.04fF
C611 divbuf_0/a_4882_n240# divbuf_0/OUT3 0.04fF
C612 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/OUT4 0.19fF
C613 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38430_n840# 0.04fF
C614 divbuf_3/a_14222_170# divbuf_3/a_14702_170# 0.07fF
C615 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58560_n1600# 0.26fF
C616 divbuf_3/a_38472_n240# divbuf_3/a_38430_n840# 0.04fF
C617 divbuf_3/a_47520_n1600# divbuf_3/a_48000_n1600# 0.26fF
C618 divbuf_1/a_56640_n1600# divbuf_1/a_57120_n1600# 0.26fF
C619 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_16350_n840# 0.00fF
C620 ro_div_0/divbuf_0/a_50430_n1540# ro_div_0/divbuf_0/a_50910_n1540# 0.11fF
C621 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_990_n840# 0.04fF
C622 divbuf_3/a_39870_n1540# divbuf_3/a_40350_n1540# 0.11fF
C623 divbuf_2/a_492_n240# divbuf_2/a_510_n840# 0.00fF
C624 divbuf_0/a_21982_n240# divbuf_0/a_22472_n240# 0.04fF
C625 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_16642_n240# 0.04fF
C626 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/a_36052_n240# 0.01fF
C627 divbuf_2/a_24960_n1600# divbuf_2/OUT4 0.00fF
C628 divbuf_1/a_34080_n1600# divbuf_1/OUT4 0.01fF
C629 divbuf_1/a_18750_n840# divbuf_1/a_18750_n1540# 0.01fF
C630 divbuf_1/a_48960_n1600# divbuf_1/a_48990_n1540# 0.19fF
C631 divbuf_1/a_22472_170# divbuf_1/a_22472_n240# 0.01fF
C632 divbuf_0/a_33630_n840# divbuf_0/a_34110_n840# 0.07fF
C633 divbuf_0/a_3390_n840# divbuf_0/a_3390_n1540# 0.01fF
C634 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n1540# 0.19fF
C635 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C636 pll_full_0/divbuf_0/a_27870_n840# pll_full_0/divbuf_0/a_28350_n840# 0.07fF
C637 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_27870_n1540# 0.19fF
C638 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48030_n840# 0.04fF
C639 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C640 divbuf_1/a_46560_n1600# divbuf_1/a_46590_n840# 0.04fF
C641 divbuf_1/a_40830_n1540# divbuf_1/a_41310_n1540# 0.11fF
C642 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/a_9732_170# 0.07fF
C643 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/a_18092_170# 0.07fF
C644 divbuf_3/a_30712_170# divbuf_3/OUT4 0.19fF
C645 divbuf_3/a_37440_n1600# divbuf_3/a_37470_n840# 0.04fF
C646 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/a_36510_n840# 0.05fF
C647 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_46080_n1600# 0.26fF
C648 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_51360_n1600# 0.26fF
C649 divbuf_2/a_11040_n1600# divbuf_2/a_11520_n1600# 0.26fF
C650 pd_div_0/divbuf_0/a_37950_n1540# pd_div_0/divbuf_0/a_38430_n1540# 0.11fF
C651 pll_full_0/divbuf_1/a_43230_n1540# pll_full_0/divbuf_1/a_43710_n1540# 0.11fF
C652 divbuf_2/a_3390_n1540# divbuf_2/a_3870_n1540# 0.11fF
C653 divbuf_2/a_34110_n840# divbuf_2/a_34110_n1540# 0.01fF
C654 divbuf_1/a_24412_n240# divbuf_1/a_24892_n240# 0.05fF
C655 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/a_26352_n240# 0.04fF
C656 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C657 divbuf_3/a_15182_n240# divbuf_3/a_15672_n240# 0.04fF
C658 divbuf_3/a_35082_170# divbuf_3/a_35082_n240# 0.01fF
C659 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37470_n1540# 0.19fF
C660 ro_div_0/divbuf_0/a_37470_n840# ro_div_0/divbuf_0/a_37950_n840# 0.07fF
C661 ro_div_0/divbuf_0/a_7230_n840# ro_div_0/divbuf_0/a_7230_n1540# 0.01fF
C662 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C663 divbuf_1/a_5790_n840# divbuf_1/a_5790_n1540# 0.01fF
C664 divbuf_1/a_36030_n840# divbuf_1/a_36510_n840# 0.07fF
C665 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/a_11802_n240# 0.01fF
C666 divbuf_3/a_26910_n840# divbuf_3/a_27390_n840# 0.07fF
C667 divbuf_3/a_31682_n240# divbuf_3/OUT4 0.04fF
C668 divbuf_3/a_26880_n1600# divbuf_3/a_26910_n1540# 0.19fF
C669 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/OUT4 0.19fF
C670 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_35550_n840# 0.04fF
C671 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z3 0.65fF
C672 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/OUT4 0.19fF
C673 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_40830_n840# 0.04fF
C674 divbuf_2/a_960_n1600# divbuf_2/a_990_n840# 0.04fF
C675 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C676 divbuf_0/a_20160_n1600# divbuf_0/a_20640_n1600# 0.26fF
C677 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14880_n1600# 0.26fF
C678 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/a_4830_n840# 0.04fF
C679 divbuf_1/a_58590_n840# divbuf_1/a_58590_n1540# 0.01fF
C680 divbuf_0/a_43230_n840# divbuf_0/a_43230_n1540# 0.01fF
C681 divbuf_0/a_12510_n1540# divbuf_0/a_12990_n1540# 0.11fF
C682 pll_full_0/divbuf_0/a_6750_n1540# pll_full_0/divbuf_0/a_7230_n1540# 0.11fF
C683 pll_full_0/divbuf_0/a_37470_n840# pll_full_0/divbuf_0/a_37470_n1540# 0.01fF
C684 divbuf_2/a_17612_170# divbuf_2/a_18092_170# 0.07fF
C685 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_13742_n240# 0.04fF
C686 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/a_33142_n240# 0.01fF
C687 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/a_38472_n240# 0.01fF
C688 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/a_19072_n240# 0.04fF
C689 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C690 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_24990_n1540# 0.19fF
C691 pd_div_0/divbuf_0/a_24990_n840# pd_div_0/divbuf_0/a_25470_n840# 0.07fF
C692 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C693 pll_full_0/divbuf_1/a_30270_n840# pll_full_0/divbuf_1/a_30750_n840# 0.07fF
C694 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30270_n1540# 0.19fF
C695 divbuf_2/a_50880_n1600# divbuf_2/a_51360_n1600# 0.26fF
C696 divbuf_1/a_4392_170# divbuf_1/a_3912_170# 0.07fF
C697 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/a_10212_170# 0.07fF
C698 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n840# 0.04fF
C699 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C700 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4350_n840# 0.04fF
C701 divbuf_2/a_43230_n1540# divbuf_2/a_43710_n1540# 0.11fF
C702 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_14910_n840# 0.02fF
C703 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24480_n1600# 0.26fF
C704 divbuf_0/a_510_n1540# divbuf_0/OUT 0.11fF
C705 divbuf_3/a_13440_n1600# divbuf_3/a_13920_n1600# 0.26fF
C706 divbuf_3/a_3912_n240# divbuf_3/a_3870_n840# 0.04fF
C707 divbuf_1/a_22560_n1600# divbuf_1/a_23040_n1600# 0.26fF
C708 divbuf_1/a_13252_n240# divbuf_1/a_13470_n840# 0.02fF
C709 ro_div_0/divbuf_0/a_47070_n840# ro_div_0/divbuf_0/a_47070_n1540# 0.01fF
C710 ro_div_0/divbuf_0/a_16350_n1540# ro_div_0/divbuf_0/a_16830_n1540# 0.11fF
C711 divbuf_3/a_5790_n1540# divbuf_3/a_6270_n1540# 0.11fF
C712 divbuf_3/a_36510_n840# divbuf_3/a_36510_n1540# 0.01fF
C713 divbuf_1/a_7302_n240# divbuf_1/OUT3 0.04fF
C714 divbuf_1/a_14880_n1600# divbuf_1/a_14910_n1540# 0.19fF
C715 divbuf_0/a_26832_170# divbuf_0/a_27322_170# 0.07fF
C716 divbuf_0/a_8272_170# divbuf_0/a_8272_n240# 0.01fF
C717 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C718 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/a_21502_170# 0.07fF
C719 divbuf_2/a_37502_170# divbuf_2/OUT4 0.19fF
C720 divbuf_2/a_40800_n1600# divbuf_2/a_40830_n840# 0.04fF
C721 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C722 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/Out 0.05fF
C723 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/clk 0.11fF
C724 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C725 divbuf_0/a_60000_n1600# divbuf_0/a_60480_n1600# 0.26fF
C726 gnd pll_full_0/divider_0/tspc_2/Z3 0.27fF
C727 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C728 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54720_n1600# 0.26fF
C729 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_13950_n840# 0.04fF
C730 divbuf_0/a_52350_n1540# divbuf_0/a_52830_n1540# 0.11fF
C731 divbuf_3/a_3360_n1600# divbuf_3/a_3390_n840# 0.04fF
C732 divbuf_1/a_12480_n1600# divbuf_1/a_12510_n840# 0.04fF
C733 pll_full_0/divbuf_0/a_46590_n1540# pll_full_0/divbuf_0/a_47070_n1540# 0.11fF
C734 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_12000_n1600# 0.26fF
C735 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_17280_n1600# 0.26fF
C736 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/a_7230_n840# 0.03fF
C737 divbuf_2/a_38472_170# divbuf_2/a_38472_n240# 0.01fF
C738 divbuf_2/a_18582_n240# divbuf_2/a_19072_n240# 0.04fF
C739 pd_div_0/divbuf_0/a_3870_n1540# pd_div_0/divbuf_0/a_4350_n1540# 0.11fF
C740 pd_div_0/divbuf_0/a_34590_n840# pd_div_0/divbuf_0/a_34590_n1540# 0.01fF
C741 pll_full_0/divbuf_1/a_9150_n1540# pll_full_0/divbuf_1/a_9630_n1540# 0.11fF
C742 pll_full_0/divbuf_1/a_39870_n840# pll_full_0/divbuf_1/a_39870_n1540# 0.01fF
C743 divbuf_2/a_38472_n240# divbuf_2/OUT4 0.04fF
C744 divbuf_2/a_30270_n840# divbuf_2/a_30750_n840# 0.07fF
C745 divbuf_2/a_30240_n1600# divbuf_2/a_30270_n1540# 0.19fF
C746 divbuf_1/a_25862_170# divbuf_1/a_26352_170# 0.07fF
C747 divbuf_1/a_15672_170# divbuf_1/a_15672_n240# 0.01fF
C748 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/a_31202_170# 0.07fF
C749 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n840# 0.04fF
C750 divbuf_0/a_16642_n240# divbuf_0/OUT4 0.04fF
C751 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C752 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44190_n840# 0.04fF
C753 divbuf_3/a_20042_170# divbuf_3/a_20532_170# 0.07fF
C754 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Z3 0.29fF
C755 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3390_n1540# 0.19fF
C756 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/OUT4 0.19fF
C757 ro_div_0/divbuf_0/a_3390_n840# ro_div_0/divbuf_0/a_3870_n840# 0.07fF
C758 ro_div_0/divider_0/tspc_1/a_630_n680# gnd 0.62fF
C759 divbuf_3/a_53280_n1600# divbuf_3/a_53760_n1600# 0.26fF
C760 divbuf_3/a_1842_170# divbuf_3/OUT2 0.19fF
C761 divbuf_1/a_1920_n1600# divbuf_1/a_1950_n1540# 0.19fF
C762 divbuf_1/a_1950_n840# divbuf_1/a_2430_n840# 0.07fF
C763 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1470_n840# 0.04fF
C764 ro_div_0/divbuf_0/a_56190_n1540# ro_div_0/divbuf_0/a_56670_n1540# 0.11fF
C765 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_6750_n840# 0.04fF
C766 divbuf_3/a_45630_n1540# divbuf_3/a_46110_n1540# 0.11fF
C767 divbuf_1/a_24510_n840# divbuf_1/a_24510_n1540# 0.01fF
C768 divbuf_1/a_54720_n1600# divbuf_1/a_54750_n1540# 0.19fF
C769 divbuf_0/a_27802_n240# divbuf_0/a_28292_n240# 0.04fF
C770 pll_full_0/divbuf_0/a_21982_n240# pll_full_0/divbuf_0/a_22472_n240# 0.04fF
C771 divbuf_2/a_36480_n1600# divbuf_2/OUT4 0.00fF
C772 divbuf_1/a_28292_170# divbuf_1/a_28292_n240# 0.01fF
C773 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n1540# 0.19fF
C774 divbuf_0/a_39390_n840# divbuf_0/a_39870_n840# 0.07fF
C775 divbuf_0/a_9150_n840# divbuf_0/a_9150_n1540# 0.01fF
C776 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_33630_n1540# 0.19fF
C777 pll_full_0/divbuf_0/a_3390_n840# pll_full_0/divbuf_0/a_3390_n1540# 0.01fF
C778 pll_full_0/divbuf_0/a_33630_n840# pll_full_0/divbuf_0/a_34110_n840# 0.07fF
C779 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_53790_n840# 0.04fF
C780 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C781 divbuf_3/a_2322_n240# divbuf_3/OUT3 0.04fF
C782 divbuf_3/a_43200_n1600# divbuf_3/a_43230_n840# 0.04fF
C783 divbuf_1/a_52320_n1600# divbuf_1/a_52350_n840# 0.04fF
C784 divbuf_1/a_46590_n1540# divbuf_1/a_47070_n1540# 0.11fF
C785 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/a_1842_n240# 0.01fF
C786 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/a_18582_170# 0.07fF
C787 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/a_3422_n240# 0.01fF
C788 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/a_23922_170# 0.07fF
C789 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51840_n1600# 0.26fF
C790 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/OUT3 0.19fF
C791 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z1 0.01fF
C792 io_clamp_high[0] io_analog[4] 0.53fF
C793 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/OUT3 0.19fF
C794 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_57120_n1600# 0.26fF
C795 divbuf_2/a_16800_n1600# divbuf_2/a_17280_n1600# 0.26fF
C796 divbuf_2/a_7302_n240# divbuf_2/a_7230_n840# 0.03fF
C797 pd_div_0/divbuf_0/a_43710_n1540# pd_div_0/divbuf_0/a_44190_n1540# 0.11fF
C798 pll_full_0/divbuf_1/a_48990_n1540# pll_full_0/divbuf_1/a_49470_n1540# 0.11fF
C799 divbuf_2/a_9150_n1540# divbuf_2/a_9630_n1540# 0.11fF
C800 divbuf_2/a_39870_n840# divbuf_2/a_39870_n1540# 0.01fF
C801 divbuf_1/a_30232_n240# divbuf_1/a_30712_n240# 0.05fF
C802 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/a_32172_n240# 0.04fF
C803 divbuf_3/a_40902_170# divbuf_3/a_40902_n240# 0.01fF
C804 divbuf_3/a_21012_n240# divbuf_3/a_21502_n240# 0.04fF
C805 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C806 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43230_n1540# 0.19fF
C807 ro_div_0/divbuf_0/a_43230_n840# ro_div_0/divbuf_0/a_43710_n840# 0.07fF
C808 ro_div_0/divbuf_0/a_12990_n840# ro_div_0/divbuf_0/a_12990_n1540# 0.01fF
C809 divbuf_1/a_11550_n840# divbuf_1/a_11550_n1540# 0.01fF
C810 divbuf_1/a_41790_n840# divbuf_1/a_42270_n840# 0.07fF
C811 divbuf_3/a_2430_n840# divbuf_3/a_2430_n1540# 0.01fF
C812 divbuf_3/a_32670_n840# divbuf_3/a_33150_n840# 0.07fF
C813 divbuf_3/a_32640_n1600# divbuf_3/a_32670_n1540# 0.19fF
C814 divbuf_3/a_2400_n1600# divbuf_3/OUT2 0.00fF
C815 divbuf_1/a_18092_170# divbuf_1/OUT4 0.19fF
C816 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/OUT4 0.19fF
C817 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41310_n840# 0.04fF
C818 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/Out 0.21fF
C819 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C820 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C821 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_46590_n840# 0.04fF
C822 divbuf_2/a_6720_n1600# divbuf_2/a_6750_n840# 0.04fF
C823 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C824 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C825 divbuf_0/a_16642_n240# divbuf_0/a_16830_n840# 0.02fF
C826 divbuf_0/a_25920_n1600# divbuf_0/a_26400_n1600# 0.26fF
C827 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20640_n1600# 0.26fF
C828 divbuf_0/a_48990_n840# divbuf_0/a_48990_n1540# 0.01fF
C829 divbuf_0/a_18270_n1540# divbuf_0/a_18750_n1540# 0.11fF
C830 pll_full_0/divbuf_0/a_12510_n1540# pll_full_0/divbuf_0/a_12990_n1540# 0.11fF
C831 pll_full_0/divbuf_0/a_43230_n840# pll_full_0/divbuf_0/a_43230_n1540# 0.01fF
C832 divbuf_2/a_3422_170# divbuf_2/a_3422_n240# 0.01fF
C833 divbuf_2/a_23442_170# divbuf_2/a_23922_170# 0.07fF
C834 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/a_38962_n240# 0.01fF
C835 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/a_19562_n240# 0.04fF
C836 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/a_24892_n240# 0.05fF
C837 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C838 pd_div_0/divbuf_0/a_30750_n840# pd_div_0/divbuf_0/a_31230_n840# 0.07fF
C839 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/a_510_n1540# 0.01fF
C840 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_30750_n1540# 0.19fF
C841 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C842 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C843 divbuf_0/a_12282_170# divbuf_0/a_12772_170# 0.07fF
C844 divbuf_0/a_19562_170# divbuf_0/a_19562_n240# 0.01fF
C845 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36030_n1540# 0.19fF
C846 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C847 pll_full_0/divbuf_1/a_5790_n840# pll_full_0/divbuf_1/a_5790_n1540# 0.01fF
C848 pll_full_0/divbuf_1/a_36030_n840# pll_full_0/divbuf_1/a_36510_n840# 0.07fF
C849 divbuf_2/a_8762_170# divbuf_2/OUT3 0.19fF
C850 divbuf_2/a_56640_n1600# divbuf_2/a_57120_n1600# 0.26fF
C851 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C852 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n840# 0.04fF
C853 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C854 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C855 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10110_n840# 0.04fF
C856 divbuf_2/a_48990_n1540# divbuf_2/a_49470_n1540# 0.11fF
C857 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/a_20670_n840# 0.03fF
C858 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_30240_n1600# 0.26fF
C859 divbuf_3/a_19200_n1600# divbuf_3/a_19680_n1600# 0.26fF
C860 divbuf_3/a_9732_n240# divbuf_3/a_9630_n840# 0.03fF
C861 divbuf_1/a_28320_n1600# divbuf_1/a_28800_n1600# 0.26fF
C862 divbuf_1/a_19072_n240# divbuf_1/a_19230_n840# 0.02fF
C863 ro_div_0/divbuf_0/a_52830_n840# ro_div_0/divbuf_0/a_52830_n1540# 0.01fF
C864 ro_div_0/divbuf_0/a_22110_n1540# ro_div_0/divbuf_0/a_22590_n1540# 0.11fF
C865 divbuf_3/a_11550_n1540# divbuf_3/a_12030_n1540# 0.11fF
C866 divbuf_3/a_42270_n840# divbuf_3/a_42270_n1540# 0.01fF
C867 divbuf_1/a_19072_n240# divbuf_1/OUT4 0.04fF
C868 divbuf_1/a_20640_n1600# divbuf_1/a_20670_n1540# 0.19fF
C869 divbuf_0/a_32652_170# divbuf_0/a_33142_170# 0.07fF
C870 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/a_13742_n240# 0.01fF
C871 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/a_27322_170# 0.07fF
C872 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/a_6332_n240# 0.01fF
C873 divbuf_2/a_9732_n240# divbuf_2/OUT3 0.04fF
C874 divbuf_2/a_46560_n1600# divbuf_2/a_46590_n840# 0.04fF
C875 gnd pd_div_0/divider_0/and_0/B 0.66fF
C876 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n1540# 0.19fF
C877 divbuf_0/a_27322_170# divbuf_0/OUT4 0.19fF
C878 divbuf_0/a_5310_n840# divbuf_0/a_5790_n840# 0.07fF
C879 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/OUT4 0.19fF
C880 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60480_n1600# 0.26fF
C881 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_19710_n840# 0.04fF
C882 divbuf_0/a_58110_n1540# divbuf_0/a_58590_n1540# 0.11fF
C883 pll_full_0/divbuf_0/a_52350_n1540# pll_full_0/divbuf_0/a_52830_n1540# 0.11fF
C884 divbuf_3/a_9120_n1600# divbuf_3/a_9150_n840# 0.04fF
C885 divbuf_1/a_18240_n1600# divbuf_1/a_18270_n840# 0.04fF
C886 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17760_n1600# 0.26fF
C887 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/a_7710_n840# 0.03fF
C888 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_23040_n1600# 0.26fF
C889 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_13470_n840# 0.02fF
C890 divbuf_2/a_24412_n240# divbuf_2/a_24892_n240# 0.05fF
C891 pd_div_0/divbuf_0/a_9630_n1540# pd_div_0/divbuf_0/a_10110_n1540# 0.11fF
C892 pd_div_0/divbuf_0/a_40350_n840# pd_div_0/divbuf_0/a_40350_n1540# 0.01fF
C893 pll_full_0/divbuf_1/a_14910_n1540# pll_full_0/divbuf_1/a_15390_n1540# 0.11fF
C894 pll_full_0/divbuf_1/a_45630_n840# pll_full_0/divbuf_1/a_45630_n1540# 0.01fF
C895 divbuf_2/a_36000_n1600# divbuf_2/a_36030_n1540# 0.19fF
C896 divbuf_2/a_8640_n1600# divbuf_2/OUT3 0.00fF
C897 divbuf_2/a_5790_n840# divbuf_2/a_5790_n1540# 0.01fF
C898 divbuf_2/a_36030_n840# divbuf_2/a_36510_n840# 0.07fF
C899 divbuf_1/a_35082_170# divbuf_1/a_35562_170# 0.07fF
C900 divbuf_1/a_9242_170# divbuf_1/a_9242_n240# 0.01fF
C901 divbuf_0/a_28292_n240# divbuf_0/OUT4 0.04fF
C902 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/a_37022_170# 0.07fF
C903 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n840# 0.04fF
C904 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_480_n1600# 0.00fF
C905 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C906 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_49950_n840# 0.04fF
C907 divbuf_3/a_5852_170# divbuf_3/a_5852_n240# 0.01fF
C908 divbuf_3/a_25862_170# divbuf_3/a_26352_170# 0.07fF
C909 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9150_n1540# 0.19fF
C910 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/OUT4 0.19fF
C911 ro_div_0/divbuf_0/a_9150_n840# ro_div_0/divbuf_0/a_9630_n840# 0.07fF
C912 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 0.63fF
C913 divbuf_3/a_13742_170# divbuf_3/OUT4 0.19fF
C914 divbuf_3/a_59040_n1600# divbuf_3/a_59520_n1600# 0.26fF
C915 divbuf_1/a_7710_n840# divbuf_1/a_8190_n840# 0.07fF
C916 divbuf_1/a_7680_n1600# divbuf_1/a_7710_n1540# 0.19fF
C917 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7230_n840# 0.04fF
C918 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12510_n840# 0.04fF
C919 divbuf_3/a_51390_n1540# divbuf_3/a_51870_n1540# 0.11fF
C920 divbuf_1/a_30270_n840# divbuf_1/a_30270_n1540# 0.01fF
C921 divbuf_1/a_60480_n1600# divbuf_1/a_60510_n1540# 0.19fF
C922 divbuf_0/a_33622_n240# divbuf_0/a_34112_n240# 0.04fF
C923 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/a_28292_n240# 0.04fF
C924 divbuf_0/a_45150_n840# divbuf_0/a_45630_n840# 0.07fF
C925 divbuf_0/a_14910_n840# divbuf_0/a_14910_n1540# 0.01fF
C926 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n1540# 0.19fF
C927 pll_full_0/divbuf_0/a_9150_n840# pll_full_0/divbuf_0/a_9150_n1540# 0.01fF
C928 pll_full_0/divbuf_0/a_39390_n840# pll_full_0/divbuf_0/a_39870_n840# 0.07fF
C929 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39390_n1540# 0.19fF
C930 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_59550_n840# 0.04fF
C931 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C932 divbuf_3/a_14702_n240# divbuf_3/OUT4 0.04fF
C933 divbuf_3/a_48960_n1600# divbuf_3/a_48990_n840# 0.04fF
C934 divbuf_1/a_58080_n1600# divbuf_1/a_58110_n840# 0.04fF
C935 divbuf_1/a_52350_n1540# divbuf_1/a_52830_n1540# 0.11fF
C936 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/a_24412_170# 0.07fF
C937 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/a_9242_n240# 0.01fF
C938 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/a_29742_170# 0.07fF
C939 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/OUT3 0.19fF
C940 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57600_n1600# 0.26fF
C941 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C942 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z2 0.30fF
C943 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z4 0.15fF
C944 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/OUT4 0.19fF
C945 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_1950_n1540# 0.19fF
C946 pll_full_0/divbuf_1/a_1950_n840# pll_full_0/divbuf_1/a_2430_n840# 0.07fF
C947 divbuf_2/a_22560_n1600# divbuf_2/a_23040_n1600# 0.26fF
C948 divbuf_2/a_13252_n240# divbuf_2/a_13470_n840# 0.02fF
C949 pd_div_0/divbuf_0/a_49470_n1540# pd_div_0/divbuf_0/a_49950_n1540# 0.11fF
C950 divbuf_0/a_1842_n240# divbuf_0/a_1950_n840# 0.03fF
C951 pll_full_0/divbuf_1/a_54750_n1540# pll_full_0/divbuf_1/a_55230_n1540# 0.11fF
C952 divbuf_2/a_14910_n1540# divbuf_2/a_15390_n1540# 0.11fF
C953 divbuf_2/a_45630_n840# divbuf_2/a_45630_n1540# 0.01fF
C954 divbuf_1/a_36052_n240# divbuf_1/a_36532_n240# 0.05fF
C955 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/a_37992_n240# 0.04fF
C956 divbuf_3/a_26832_n240# divbuf_3/a_27322_n240# 0.04fF
C957 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_48990_n1540# 0.19fF
C958 ro_div_0/divbuf_0/a_48990_n840# ro_div_0/divbuf_0/a_49470_n840# 0.07fF
C959 ro_div_0/divbuf_0/a_18750_n840# ro_div_0/divbuf_0/a_18750_n1540# 0.01fF
C960 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C961 divbuf_3/a_12960_n1600# divbuf_3/OUT4 0.00fF
C962 divbuf_3/a_8190_n840# divbuf_3/a_8190_n1540# 0.01fF
C963 divbuf_3/a_38430_n840# divbuf_3/a_38910_n840# 0.07fF
C964 divbuf_3/a_38400_n1600# divbuf_3/a_38430_n1540# 0.19fF
C965 divbuf_1/a_47550_n840# divbuf_1/a_48030_n840# 0.07fF
C966 divbuf_1/a_6332_170# divbuf_1/OUT3 0.19fF
C967 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C968 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47070_n840# 0.04fF
C969 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z3 0.38fF
C970 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z2 1.07fF
C971 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z4 0.12fF
C972 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C973 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52350_n840# 0.04fF
C974 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/a_5852_170# 0.07fF
C975 divbuf_2/a_12480_n1600# divbuf_2/a_12510_n840# 0.04fF
C976 divbuf_0/a_22472_n240# divbuf_0/a_22590_n840# 0.03fF
C977 divbuf_0/a_31680_n1600# divbuf_0/a_32160_n1600# 0.26fF
C978 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_26400_n1600# 0.26fF
C979 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_16830_n840# 0.02fF
C980 divbuf_0/a_54750_n840# divbuf_0/a_54750_n1540# 0.01fF
C981 divbuf_0/a_24030_n1540# divbuf_0/a_24510_n1540# 0.11fF
C982 pll_full_0/divbuf_0/a_18270_n1540# pll_full_0/divbuf_0/a_18750_n1540# 0.11fF
C983 pll_full_0/divbuf_0/a_48990_n840# pll_full_0/divbuf_0/a_48990_n1540# 0.01fF
C984 divbuf_2/a_9242_170# divbuf_2/a_9242_n240# 0.01fF
C985 divbuf_2/a_29262_170# divbuf_2/a_29742_170# 0.07fF
C986 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/a_25382_n240# 0.04fF
C987 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/a_30712_n240# 0.05fF
C988 divbuf_1/a_26352_170# divbuf_1/OUT4 0.19fF
C989 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36510_n1540# 0.19fF
C990 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C991 pd_div_0/divbuf_0/a_6270_n840# pd_div_0/divbuf_0/a_6270_n1540# 0.01fF
C992 pd_div_0/divbuf_0/a_36510_n840# pd_div_0/divbuf_0/a_36990_n840# 0.07fF
C993 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C994 pll_full_0/divbuf_1/a_11550_n840# pll_full_0/divbuf_1/a_11550_n1540# 0.01fF
C995 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/a_42270_n840# 0.07fF
C996 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_41790_n1540# 0.19fF
C997 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/a_1842_170# 0.07fF
C998 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C999 divbuf_2/a_20532_170# divbuf_2/OUT4 0.19fF
C1000 divbuf_2/a_1920_n1600# divbuf_2/a_1950_n1540# 0.19fF
C1001 divbuf_2/a_1950_n840# divbuf_2/a_2430_n840# 0.07fF
C1002 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1003 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1004 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1005 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n840# 0.04fF
C1006 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z4 0.15fF
C1007 gnd pll_full_0/divider_0/tspc_1/Q 0.33fF
C1008 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/Out 0.11fF
C1009 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C1010 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_15870_n840# 0.04fF
C1011 divbuf_2/a_54750_n1540# divbuf_2/a_55230_n1540# 0.11fF
C1012 divbuf_1/a_24892_n240# divbuf_1/a_24990_n840# 0.03fF
C1013 divbuf_1/a_34080_n1600# divbuf_1/a_34560_n1600# 0.26fF
C1014 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/a_26430_n840# 0.04fF
C1015 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_36000_n1600# 0.26fF
C1016 divbuf_3/a_24960_n1600# divbuf_3/a_25440_n1600# 0.26fF
C1017 divbuf_3/a_15672_n240# divbuf_3/a_15870_n840# 0.02fF
C1018 ro_div_0/divbuf_0/a_58590_n840# ro_div_0/divbuf_0/a_58590_n1540# 0.01fF
C1019 ro_div_0/divbuf_0/a_27870_n1540# ro_div_0/divbuf_0/a_28350_n1540# 0.11fF
C1020 divbuf_3/a_17310_n1540# divbuf_3/a_17790_n1540# 0.11fF
C1021 divbuf_3/a_48030_n840# divbuf_3/a_48030_n1540# 0.01fF
C1022 divbuf_1/a_30712_n240# divbuf_1/OUT4 0.04fF
C1023 divbuf_1/a_26400_n1600# divbuf_1/a_26430_n1540# 0.19fF
C1024 divbuf_0/a_38472_170# divbuf_0/a_38962_170# 0.07fF
C1025 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/a_33142_170# 0.07fF
C1026 divbuf_2/a_21502_n240# divbuf_2/OUT4 0.04fF
C1027 divbuf_2/a_52320_n1600# divbuf_2/a_52350_n840# 0.04fF
C1028 divbuf_0/a_11070_n840# divbuf_0/a_11550_n840# 0.07fF
C1029 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n1540# 0.19fF
C1030 divbuf_0/a_38962_170# divbuf_0/OUT4 0.19fF
C1031 pll_full_0/divbuf_0/a_5310_n840# pll_full_0/divbuf_0/a_5790_n840# 0.07fF
C1032 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1033 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5310_n1540# 0.19fF
C1034 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25470_n840# 0.04fF
C1035 divbuf_0/OUT4 divbuf_0/OUT5 0.26fF
C1036 pll_full_0/divbuf_0/a_58110_n1540# pll_full_0/divbuf_0/a_58590_n1540# 0.11fF
C1037 divbuf_3/a_14880_n1600# divbuf_3/a_14910_n840# 0.04fF
C1038 divbuf_1/a_24000_n1600# divbuf_1/a_24030_n840# 0.04fF
C1039 divbuf_1/a_18270_n1540# divbuf_1/a_18750_n1540# 0.11fF
C1040 divbuf_2/a_30232_n240# divbuf_2/a_30712_n240# 0.05fF
C1041 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_13950_n840# 0.02fF
C1042 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23520_n1600# 0.26fF
C1043 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28800_n1600# 0.26fF
C1044 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/a_19230_n840# 0.02fF
C1045 pd_div_0/divbuf_0/a_15390_n1540# pd_div_0/divbuf_0/a_15870_n1540# 0.11fF
C1046 pd_div_0/divbuf_0/a_46110_n840# pd_div_0/divbuf_0/a_46110_n1540# 0.01fF
C1047 pll_full_0/divbuf_1/a_20670_n1540# pll_full_0/divbuf_1/a_21150_n1540# 0.11fF
C1048 pll_full_0/divbuf_1/a_51390_n840# pll_full_0/divbuf_1/a_51390_n1540# 0.01fF
C1049 divbuf_2/a_19680_n1600# divbuf_2/OUT4 0.00fF
C1050 divbuf_2/a_11550_n840# divbuf_2/a_11550_n1540# 0.01fF
C1051 divbuf_2/a_41790_n840# divbuf_2/a_42270_n840# 0.07fF
C1052 divbuf_2/a_41760_n1600# divbuf_2/a_41790_n1540# 0.19fF
C1053 divbuf_1/a_40902_170# divbuf_1/a_41382_170# 0.07fF
C1054 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_960_n1600# 0.00fF
C1055 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/a_22952_n240# 0.01fF
C1056 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/a_2322_n240# 0.05fF
C1057 divbuf_0/a_39932_n240# divbuf_0/OUT4 0.04fF
C1058 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1059 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_55710_n840# 0.04fF
C1060 divbuf_3/a_12282_170# divbuf_3/a_12282_n240# 0.01fF
C1061 divbuf_3/a_31682_170# divbuf_3/a_32172_170# 0.07fF
C1062 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_14910_n1540# 0.19fF
C1063 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C1064 ro_div_0/divbuf_0/a_14910_n840# ro_div_0/divbuf_0/a_15390_n840# 0.07fF
C1065 ro_div_0/divider_0/prescaler_0/nand_1/z1 gnd 0.16fF
C1066 divbuf_3/a_4350_n840# divbuf_3/a_4830_n840# 0.07fF
C1067 divbuf_3/a_25382_170# divbuf_3/OUT4 0.19fF
C1068 divbuf_3/a_4320_n1600# divbuf_3/a_4350_n1540# 0.19fF
C1069 divbuf_1/a_13440_n1600# divbuf_1/a_13470_n1540# 0.19fF
C1070 divbuf_1/a_13470_n840# divbuf_1/a_13950_n840# 0.07fF
C1071 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_12990_n840# 0.04fF
C1072 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18270_n840# 0.04fF
C1073 divbuf_3/a_57150_n1540# divbuf_3/a_57630_n1540# 0.11fF
C1074 divbuf_1/a_36030_n840# divbuf_1/a_36030_n1540# 0.01fF
C1075 divbuf_0/a_39442_n240# divbuf_0/a_39932_n240# 0.04fF
C1076 pll_full_0/divbuf_0/a_33622_n240# pll_full_0/divbuf_0/a_34112_n240# 0.04fF
C1077 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n1540# 0.19fF
C1078 divbuf_0/a_50910_n840# divbuf_0/a_51390_n840# 0.07fF
C1079 divbuf_0/a_20670_n840# divbuf_0/a_20670_n1540# 0.01fF
C1080 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45150_n1540# 0.19fF
C1081 pll_full_0/divbuf_0/a_14910_n840# pll_full_0/divbuf_0/a_14910_n1540# 0.01fF
C1082 pll_full_0/divbuf_0/a_45150_n840# pll_full_0/divbuf_0/a_45630_n840# 0.07fF
C1083 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/a_30232_170# 0.07fF
C1084 divbuf_3/a_26352_n240# divbuf_3/OUT4 0.04fF
C1085 divbuf_3/a_54720_n1600# divbuf_3/a_54750_n840# 0.04fF
C1086 divbuf_1/a_58110_n1540# divbuf_1/a_58590_n1540# 0.11fF
C1087 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/a_35562_170# 0.07fF
C1088 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/a_15672_n240# 0.01fF
C1089 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1090 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2430_n1540# 0.19fF
C1091 pd_div_0/divbuf_0/a_2430_n840# pd_div_0/divbuf_0/a_2910_n840# 0.07fF
C1092 pll_full_0/divbuf_1/a_7710_n840# pll_full_0/divbuf_1/a_8190_n840# 0.07fF
C1093 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1094 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_7710_n1540# 0.19fF
C1095 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/z5 0.03fF
C1096 divbuf_2/a_28320_n1600# divbuf_2/a_28800_n1600# 0.26fF
C1097 divbuf_2/a_19072_n240# divbuf_2/a_19230_n840# 0.02fF
C1098 pd_div_0/divbuf_0/a_55230_n1540# pd_div_0/divbuf_0/a_55710_n1540# 0.11fF
C1099 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C1100 pll_full_0/divbuf_1/a_60510_n1540# pll_full_0/divbuf_1/a_60990_n1540# 0.11fF
C1101 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/a_1950_n840# 0.03fF
C1102 divbuf_2/a_20670_n1540# divbuf_2/a_21150_n1540# 0.11fF
C1103 divbuf_2/a_51390_n840# divbuf_2/a_51390_n1540# 0.01fF
C1104 divbuf_1/a_0_n1600# divbuf_1/a_480_n1600# 0.26fF
C1105 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1920_n1600# 0.26fF
C1106 divbuf_3/a_32652_n240# divbuf_3/a_33142_n240# 0.04fF
C1107 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_54750_n1540# 0.19fF
C1108 ro_div_0/divbuf_0/a_54750_n840# ro_div_0/divbuf_0/a_55230_n840# 0.07fF
C1109 ro_div_0/divbuf_0/a_24510_n840# ro_div_0/divbuf_0/a_24510_n1540# 0.01fF
C1110 divbuf_3/a_13950_n840# divbuf_3/a_13950_n1540# 0.01fF
C1111 divbuf_3/a_44190_n840# divbuf_3/a_44670_n840# 0.07fF
C1112 divbuf_3/a_44160_n1600# divbuf_3/a_44190_n1540# 0.19fF
C1113 divbuf_3/a_24480_n1600# divbuf_3/OUT4 0.00fF
C1114 divbuf_1/a_53310_n840# divbuf_1/a_53790_n840# 0.07fF
C1115 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1116 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_52830_n840# 0.04fF
C1117 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C1118 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1119 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58110_n840# 0.04fF
C1120 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1121 divbuf_2/a_18240_n1600# divbuf_2/a_18270_n840# 0.04fF
C1122 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/nor_1/B 0.06fF
C1123 divbuf_0/a_28292_n240# divbuf_0/a_28350_n840# 0.04fF
C1124 divbuf_0/a_37440_n1600# divbuf_0/a_37920_n1600# 0.26fF
C1125 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C1126 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1127 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_32160_n1600# 0.26fF
C1128 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/a_22590_n840# 0.03fF
C1129 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12030_n840# 0.02fF
C1130 divbuf_0/a_60510_n840# divbuf_0/a_60510_n1540# 0.01fF
C1131 divbuf_0/a_29790_n1540# divbuf_0/a_30270_n1540# 0.11fF
C1132 pll_full_0/divbuf_0/a_24030_n1540# pll_full_0/divbuf_0/a_24510_n1540# 0.11fF
C1133 pll_full_0/divbuf_0/a_54750_n840# pll_full_0/divbuf_0/a_54750_n1540# 0.01fF
C1134 divbuf_2/a_35082_170# divbuf_2/a_35562_170# 0.07fF
C1135 divbuf_2/a_15672_170# divbuf_2/a_15672_n240# 0.01fF
C1136 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/a_31202_n240# 0.04fF
C1137 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/a_36532_n240# 0.05fF
C1138 divbuf_1/a_1842_n240# divbuf_1/OUT2 0.04fF
C1139 divbuf_1/a_41382_170# divbuf_1/OUT4 0.19fF
C1140 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C1141 pd_div_0/divbuf_0/a_12030_n840# pd_div_0/divbuf_0/a_12030_n1540# 0.01fF
C1142 pd_div_0/divbuf_0/a_42270_n840# pd_div_0/divbuf_0/a_42750_n840# 0.07fF
C1143 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42270_n1540# 0.19fF
C1144 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_47550_n1540# 0.19fF
C1145 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1146 pll_full_0/divbuf_1/a_17310_n840# pll_full_0/divbuf_1/a_17310_n1540# 0.01fF
C1147 pll_full_0/divbuf_1/a_47550_n840# pll_full_0/divbuf_1/a_48030_n840# 0.07fF
C1148 divbuf_2/a_7710_n840# divbuf_2/a_8190_n840# 0.07fF
C1149 divbuf_2/a_32172_170# divbuf_2/OUT4 0.19fF
C1150 divbuf_2/a_7680_n1600# divbuf_2/a_7710_n1540# 0.19fF
C1151 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/prescaler_0/Out 0.28fF
C1152 ro_div_0/ro_complete_0/cbank_1/switch_4/vin ro_div_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1153 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/a_6822_170# 0.07fF
C1154 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n840# 0.04fF
C1155 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_21630_n840# 0.04fF
C1156 divbuf_2/a_60510_n1540# divbuf_2/a_60990_n1540# 0.11fF
C1157 divbuf_1/a_39840_n1600# divbuf_1/a_40320_n1600# 0.26fF
C1158 divbuf_1/a_30712_n240# divbuf_1/a_30750_n840# 0.05fF
C1159 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/a_32190_n840# 0.06fF
C1160 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41760_n1600# 0.26fF
C1161 divbuf_3/a_30720_n1600# divbuf_3/a_31200_n1600# 0.26fF
C1162 divbuf_3/a_21502_n240# divbuf_3/a_21630_n840# 0.03fF
C1163 ro_div_0/divbuf_0/a_33630_n1540# ro_div_0/divbuf_0/a_34110_n1540# 0.11fF
C1164 divbuf_3/a_23070_n1540# divbuf_3/a_23550_n1540# 0.11fF
C1165 divbuf_3/a_53790_n840# divbuf_3/a_53790_n1540# 0.01fF
C1166 divbuf_1/a_32160_n1600# divbuf_1/a_32190_n1540# 0.19fF
C1167 divbuf_1/a_1440_n1600# divbuf_1/OUT2 0.01fF
C1168 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/OUT2 0.02fF
C1169 divbuf_0/a_24892_170# divbuf_0/a_24892_n240# 0.01fF
C1170 divbuf_0/a_4392_n240# divbuf_0/a_4882_n240# 0.04fF
C1171 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/OUT4 0.03fF
C1172 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/a_38962_170# 0.07fF
C1173 divbuf_2/a_33142_n240# divbuf_2/OUT4 0.04fF
C1174 divbuf_2/a_58080_n1600# divbuf_2/a_58110_n840# 0.04fF
C1175 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n1540# 0.19fF
C1176 divbuf_0/a_11312_n240# divbuf_0/OUT4 0.07fF
C1177 divbuf_0/a_16830_n840# divbuf_0/a_17310_n840# 0.07fF
C1178 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1179 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11070_n1540# 0.19fF
C1180 pll_full_0/divbuf_0/a_11070_n840# pll_full_0/divbuf_0/a_11550_n840# 0.07fF
C1181 divbuf_1/a_29760_n1600# divbuf_1/a_29790_n840# 0.04fF
C1182 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/tspc_r_0/z5 0.20fF
C1183 ro_div_0/divbuf_0/a_1842_170# ro_div_0/divbuf_0/OUT2 0.19fF
C1184 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31230_n840# 0.04fF
C1185 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1186 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 0.26fF
C1187 divbuf_3/a_20640_n1600# divbuf_3/a_20670_n840# 0.04fF
C1188 divbuf_1/a_24030_n1540# divbuf_1/a_24510_n1540# 0.11fF
C1189 divbuf_2/a_36052_n240# divbuf_2/a_36532_n240# 0.05fF
C1190 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_29280_n1600# 0.26fF
C1191 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/a_19710_n840# 0.03fF
C1192 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/a_24990_n840# 0.03fF
C1193 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34560_n1600# 0.26fF
C1194 pd_div_0/divbuf_0/a_21150_n1540# pd_div_0/divbuf_0/a_21630_n1540# 0.11fF
C1195 pd_div_0/divbuf_0/a_51870_n840# pd_div_0/divbuf_0/a_51870_n1540# 0.01fF
C1196 pll_full_0/divbuf_1/a_26430_n1540# pll_full_0/divbuf_1/a_26910_n1540# 0.11fF
C1197 pll_full_0/divbuf_1/a_57150_n840# pll_full_0/divbuf_1/a_57150_n1540# 0.01fF
C1198 divbuf_2/a_47520_n1600# divbuf_2/a_47550_n1540# 0.19fF
C1199 divbuf_2/a_31200_n1600# divbuf_2/OUT4 0.00fF
C1200 divbuf_2/a_17310_n840# divbuf_2/a_17310_n1540# 0.01fF
C1201 divbuf_2/a_47550_n840# divbuf_2/a_48030_n840# 0.07fF
C1202 divbuf_1/a_6822_n240# divbuf_1/a_7302_n240# 0.05fF
C1203 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/a_28772_n240# 0.01fF
C1204 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/a_8762_n240# 0.04fF
C1205 divbuf_0/a_10080_n1600# divbuf_0/OUT3 0.00fF
C1206 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1207 divbuf_3/a_18092_170# divbuf_3/a_18092_n240# 0.01fF
C1208 divbuf_3/a_37502_170# divbuf_3/a_37992_170# 0.07fF
C1209 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_20670_n1540# 0.19fF
C1210 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1211 ro_div_0/divbuf_0/a_20670_n840# ro_div_0/divbuf_0/a_21150_n840# 0.07fF
C1212 ro_div_0/divider_0/and_0/Z1 gnd 0.32fF
C1213 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C1214 divbuf_3/a_10110_n840# divbuf_3/a_10590_n840# 0.07fF
C1215 divbuf_3/a_37022_170# divbuf_3/OUT4 0.19fF
C1216 divbuf_3/a_10080_n1600# divbuf_3/a_10110_n1540# 0.19fF
C1217 divbuf_1/a_19230_n840# divbuf_1/a_19710_n840# 0.07fF
C1218 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_18750_n840# 0.04fF
C1219 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/OUT3 0.23fF
C1220 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24030_n840# 0.04fF
C1221 divbuf_3/OUT2 divbuf_3/OUT3 0.36fF
C1222 divbuf_1/a_41790_n840# divbuf_1/a_41790_n1540# 0.01fF
C1223 divbuf_0/a_3360_n1600# divbuf_0/a_3840_n1600# 0.26fF
C1224 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/a_39932_n240# 0.04fF
C1225 divbuf_2/a_10590_n840# divbuf_2/OUT4 0.03fF
C1226 divbuf_0/a_56670_n840# divbuf_0/a_57150_n840# 0.07fF
C1227 divbuf_0/a_26430_n840# divbuf_0/a_26430_n1540# 0.01fF
C1228 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n1540# 0.19fF
C1229 pll_full_0/divbuf_0/a_20670_n840# pll_full_0/divbuf_0/a_20670_n1540# 0.01fF
C1230 pll_full_0/divbuf_0/a_50910_n840# pll_full_0/divbuf_0/a_51390_n840# 0.07fF
C1231 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_50910_n1540# 0.19fF
C1232 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/a_16152_n240# 0.01fF
C1233 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/a_36052_170# 0.07fF
C1234 divbuf_3/a_37992_n240# divbuf_3/OUT4 0.04fF
C1235 divbuf_3/a_60480_n1600# divbuf_3/a_60510_n840# 0.04fF
C1236 divbuf_1/OUT4 divbuf_1/OUT5 0.26fF
C1237 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/a_21502_n240# 0.01fF
C1238 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/a_41382_170# 0.07fF
C1239 pd_div_0/divbuf_0/a_8190_n840# pd_div_0/divbuf_0/a_8670_n840# 0.07fF
C1240 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1241 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8190_n1540# 0.19fF
C1242 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1243 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1244 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/nor_0/B 0.22fF
C1245 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C1246 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C1247 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13470_n1540# 0.19fF
C1248 pll_full_0/divbuf_1/a_13470_n840# pll_full_0/divbuf_1/a_13950_n840# 0.07fF
C1249 divbuf_2/a_24892_n240# divbuf_2/a_24990_n840# 0.03fF
C1250 divbuf_2/a_34080_n1600# divbuf_2/a_34560_n1600# 0.26fF
C1251 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C1252 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C1253 divbuf_0/a_14222_n240# divbuf_0/a_13950_n840# 0.01fF
C1254 divbuf_2/a_26430_n1540# divbuf_2/a_26910_n1540# 0.11fF
C1255 divbuf_2/a_57150_n840# divbuf_2/a_57150_n1540# 0.01fF
C1256 divbuf_1/a_5760_n1600# divbuf_1/a_6240_n1600# 0.26fF
C1257 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7680_n1600# 0.26fF
C1258 divbuf_3/a_38472_n240# divbuf_3/a_38962_n240# 0.04fF
C1259 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/a_60510_n1540# 0.19fF
C1260 ro_div_0/divbuf_0/a_60510_n840# ro_div_0/divbuf_0/a_60990_n840# 0.07fF
C1261 ro_div_0/divbuf_0/a_30270_n840# ro_div_0/divbuf_0/a_30270_n1540# 0.01fF
C1262 divbuf_3/a_36000_n1600# divbuf_3/OUT4 0.00fF
C1263 divbuf_3/a_19710_n840# divbuf_3/a_19710_n1540# 0.01fF
C1264 divbuf_3/a_49950_n840# divbuf_3/a_50430_n840# 0.07fF
C1265 divbuf_3/a_49920_n1600# divbuf_3/a_49950_n1540# 0.19fF
C1266 divbuf_1/a_59070_n840# divbuf_1/a_59550_n840# 0.07fF
C1267 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1268 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_58590_n840# 0.04fF
C1269 divbuf_2/a_3422_170# divbuf_2/OUT3 0.23fF
C1270 divbuf_2/a_24000_n1600# divbuf_2/a_24030_n840# 0.04fF
C1271 divbuf_0/a_34112_n240# divbuf_0/a_34110_n840# 0.06fF
C1272 divbuf_0/a_43200_n1600# divbuf_0/a_43680_n1600# 0.26fF
C1273 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37920_n1600# 0.26fF
C1274 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/a_28350_n840# 0.04fF
C1275 divbuf_1/a_16642_n240# divbuf_1/a_16350_n840# 0.00fF
C1276 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_17790_n840# 0.00fF
C1277 divbuf_0/a_35550_n1540# divbuf_0/a_36030_n1540# 0.11fF
C1278 pll_full_0/divbuf_0/a_29790_n1540# pll_full_0/divbuf_0/a_30270_n1540# 0.11fF
C1279 pll_full_0/divbuf_0/a_60510_n840# pll_full_0/divbuf_0/a_60510_n1540# 0.01fF
C1280 divbuf_2/a_21502_170# divbuf_2/a_21502_n240# 0.01fF
C1281 divbuf_2/a_40902_170# divbuf_2/a_41382_170# 0.07fF
C1282 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/a_37022_n240# 0.04fF
C1283 pll_full_0/divbuf_1/a_0_n1600# pll_full_0/divbuf_1/a_480_n1600# 0.26fF
C1284 divbuf_1/a_13742_n240# divbuf_1/OUT4 0.04fF
C1285 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48030_n1540# 0.19fF
C1286 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C1287 pd_div_0/divbuf_0/a_17790_n840# pd_div_0/divbuf_0/a_17790_n1540# 0.01fF
C1288 pd_div_0/divbuf_0/a_48030_n840# pd_div_0/divbuf_0/a_48510_n840# 0.07fF
C1289 pll_full_0/divbuf_1/a_23070_n840# pll_full_0/divbuf_1/a_23070_n1540# 0.01fF
C1290 pll_full_0/divbuf_1/a_53310_n840# pll_full_0/divbuf_1/a_53790_n840# 0.07fF
C1291 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53310_n1540# 0.19fF
C1292 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_0_n1600# 0.26fF
C1293 divbuf_2/a_4392_n240# divbuf_2/OUT3 0.04fF
C1294 divbuf_2/a_13440_n1600# divbuf_2/a_13470_n1540# 0.19fF
C1295 divbuf_2/a_13470_n840# divbuf_2/a_13950_n840# 0.07fF
C1296 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/B 0.01fF
C1297 gnd pd_div_0/divider_0/tspc_2/Z4 0.44fF
C1298 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/Out 0.91fF
C1299 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/a_15672_170# 0.07fF
C1300 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n840# 0.04fF
C1301 divbuf_0/a_21982_170# divbuf_0/OUT4 0.19fF
C1302 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C1303 gnd pll_full_0/divider_0/and_0/B 0.66fF
C1304 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1305 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27390_n840# 0.04fF
C1306 divbuf_3/a_1842_170# divbuf_3/a_2322_170# 0.07fF
C1307 divbuf_1/a_36532_n240# divbuf_1/a_36510_n840# 0.05fF
C1308 divbuf_1/a_45600_n1600# divbuf_1/a_46080_n1600# 0.26fF
C1309 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47520_n1600# 0.26fF
C1310 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/OUT3 0.19fF
C1311 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/a_37950_n840# 0.04fF
C1312 divbuf_3/a_36480_n1600# divbuf_3/a_36960_n1600# 0.26fF
C1313 divbuf_3/a_27322_n240# divbuf_3/a_27390_n840# 0.04fF
C1314 ro_div_0/divbuf_0/a_39390_n1540# ro_div_0/divbuf_0/a_39870_n1540# 0.11fF
C1315 divbuf_3/a_28830_n1540# divbuf_3/a_29310_n1540# 0.11fF
C1316 divbuf_3/a_59550_n840# divbuf_3/a_59550_n1540# 0.01fF
C1317 divbuf_1/a_12000_n1600# divbuf_1/OUT4 0.00fF
C1318 divbuf_1/a_37920_n1600# divbuf_1/a_37950_n1540# 0.19fF
C1319 divbuf_0/a_30712_170# divbuf_0/a_30712_n240# 0.01fF
C1320 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/a_4882_n240# 0.04fF
C1321 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/a_24892_n240# 0.01fF
C1322 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/a_15182_n240# 0.01fF
C1323 divbuf_0/a_22590_n840# divbuf_0/a_23070_n840# 0.07fF
C1324 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n1540# 0.19fF
C1325 divbuf_0/a_22952_n240# divbuf_0/OUT4 0.04fF
C1326 pll_full_0/divbuf_0/a_16830_n840# pll_full_0/divbuf_0/a_17310_n840# 0.07fF
C1327 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/OUT4 0.07fF
C1328 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_16830_n1540# 0.19fF
C1329 divbuf_1/a_35520_n1600# divbuf_1/a_35550_n840# 0.04fF
C1330 pd_div_0/pd_0/tspc_r_0/z5 pd_div_0/pd_0/tspc_r_1/z5 0.02fF
C1331 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z2 0.25fF
C1332 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_36990_n840# 0.04fF
C1333 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1334 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/a_6332_170# 0.07fF
C1335 divbuf_3/a_8272_170# divbuf_3/OUT3 0.19fF
C1336 divbuf_3/a_26400_n1600# divbuf_3/a_26430_n840# 0.04fF
C1337 divbuf_1/a_29790_n1540# divbuf_1/a_30270_n1540# 0.11fF
C1338 divbuf_2/a_0_n1600# divbuf_2/a_480_n1600# 0.26fF
C1339 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/a_25470_n840# 0.03fF
C1340 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_35040_n1600# 0.26fF
C1341 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_40320_n1600# 0.26fF
C1342 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/a_30750_n840# 0.05fF
C1343 pd_div_0/divbuf_0/a_26910_n1540# pd_div_0/divbuf_0/a_27390_n1540# 0.11fF
C1344 pd_div_0/divbuf_0/a_57630_n840# pd_div_0/divbuf_0/a_57630_n1540# 0.01fF
C1345 pll_full_0/divbuf_1/a_32190_n1540# pll_full_0/divbuf_1/a_32670_n1540# 0.11fF
C1346 divbuf_2/a_23070_n840# divbuf_2/a_23070_n1540# 0.01fF
C1347 divbuf_2/a_53310_n840# divbuf_2/a_53790_n840# 0.07fF
C1348 divbuf_2/a_53280_n1600# divbuf_2/a_53310_n1540# 0.19fF
C1349 divbuf_1/a_13252_n240# divbuf_1/a_13742_n240# 0.04fF
C1350 divbuf_0/a_21120_n1600# divbuf_0/OUT4 0.00fF
C1351 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/a_34592_n240# 0.01fF
C1352 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_15182_n240# 0.05fF
C1353 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C1354 divbuf_3/a_3422_n240# divbuf_3/a_3912_n240# 0.04fF
C1355 divbuf_3/a_23922_170# divbuf_3/a_23922_n240# 0.01fF
C1356 divbuf_1/a_24990_n840# divbuf_1/a_25470_n840# 0.07fF
C1357 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26430_n1540# 0.19fF
C1358 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1359 ro_div_0/divbuf_0/a_26430_n840# ro_div_0/divbuf_0/a_26910_n840# 0.07fF
C1360 divbuf_3/a_15870_n840# divbuf_3/a_16350_n840# 0.07fF
C1361 divbuf_3/a_9242_n240# divbuf_3/OUT3 0.04fF
C1362 divbuf_3/a_15840_n1600# divbuf_3/a_15870_n1540# 0.19fF
C1363 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24510_n840# 0.04fF
C1364 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z1 0.03fF
C1365 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1366 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_29790_n840# 0.04fF
C1367 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C1368 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C1369 divbuf_1/a_47550_n840# divbuf_1/a_47550_n1540# 0.01fF
C1370 divbuf_0/a_9120_n1600# divbuf_0/a_9600_n1600# 0.26fF
C1371 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3840_n1600# 0.26fF
C1372 divbuf_0/a_60480_n1600# divbuf_0/OUT5 0.26fF
C1373 divbuf_0/a_32190_n840# divbuf_0/a_32190_n1540# 0.01fF
C1374 divbuf_0/a_1470_n1540# divbuf_0/a_1950_n1540# 0.11fF
C1375 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_56670_n1540# 0.19fF
C1376 pll_full_0/divbuf_0/a_26430_n840# pll_full_0/divbuf_0/a_26430_n1540# 0.01fF
C1377 pll_full_0/divbuf_0/a_56670_n840# pll_full_0/divbuf_0/a_57150_n840# 0.07fF
C1378 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/a_21982_n240# 0.01fF
C1379 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/a_7302_n240# 0.05fF
C1380 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/a_27322_n240# 0.01fF
C1381 divbuf_2/a_5852_170# divbuf_2/a_6332_170# 0.07fF
C1382 divbuf_2/a_39840_n1600# divbuf_2/a_40320_n1600# 0.26fF
C1383 divbuf_2/a_30712_n240# divbuf_2/a_30750_n840# 0.05fF
C1384 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C1385 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_13950_n1540# 0.19fF
C1386 pd_div_0/divbuf_0/a_13950_n840# pd_div_0/divbuf_0/a_14430_n840# 0.07fF
C1387 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/and_0/A 0.01fF
C1388 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/out1 0.31fF
C1389 pll_full_0/divbuf_1/a_19230_n840# pll_full_0/divbuf_1/a_19710_n840# 0.07fF
C1390 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1391 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19230_n1540# 0.19fF
C1392 divbuf_1/a_18092_170# divbuf_1/a_18582_170# 0.07fF
C1393 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_13950_n840# 0.01fF
C1394 divbuf_2/a_32190_n1540# divbuf_2/a_32670_n1540# 0.11fF
C1395 divbuf_1/a_11520_n1600# divbuf_1/a_12000_n1600# 0.26fF
C1396 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/a_3390_n840# 0.05fF
C1397 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_13440_n1600# 0.26fF
C1398 divbuf_3/a_2400_n1600# divbuf_3/a_2880_n1600# 0.26fF
C1399 ro_div_0/divbuf_0/a_36030_n840# ro_div_0/divbuf_0/a_36030_n1540# 0.01fF
C1400 ro_div_0/divbuf_0/a_5310_n1540# ro_div_0/divbuf_0/a_5790_n1540# 0.11fF
C1401 divbuf_3/a_25470_n840# divbuf_3/a_25470_n1540# 0.01fF
C1402 divbuf_3/a_55710_n840# divbuf_3/a_56190_n840# 0.07fF
C1403 divbuf_3/a_55680_n1600# divbuf_3/a_55710_n1540# 0.19fF
C1404 divbuf_1/a_3870_n1540# divbuf_1/a_4350_n1540# 0.11fF
C1405 divbuf_1/a_21012_170# divbuf_1/OUT4 0.19fF
C1406 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/a_11802_170# 0.07fF
C1407 divbuf_2/a_15182_170# divbuf_2/OUT4 0.19fF
C1408 divbuf_2/a_29760_n1600# divbuf_2/a_29790_n840# 0.04fF
C1409 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1410 ro_div_0/ro_complete_0/cbank_0/switch_2/vin ro_div_0/ro_complete_0/a3 0.09fF
C1411 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C1412 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/a1 0.14fF
C1413 divbuf_0/a_48960_n1600# divbuf_0/a_49440_n1600# 0.26fF
C1414 divbuf_0/a_39932_n240# divbuf_0/a_39870_n840# 0.04fF
C1415 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43680_n1600# 0.26fF
C1416 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/OUT3 0.19fF
C1417 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/a_34110_n840# 0.06fF
C1418 divbuf_1/a_1440_n1600# divbuf_1/a_1470_n840# 0.04fF
C1419 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_2910_n840# 0.04fF
C1420 divbuf_0/a_41310_n1540# divbuf_0/a_41790_n1540# 0.11fF
C1421 pll_full_0/divbuf_0/a_35550_n1540# pll_full_0/divbuf_0/a_36030_n1540# 0.11fF
C1422 divbuf_3/a_13252_n240# divbuf_3/a_12990_n840# 0.01fF
C1423 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_960_n1600# 0.26fF
C1424 divbuf_2/a_6822_n240# divbuf_2/a_7302_n240# 0.05fF
C1425 divbuf_2/a_27322_170# divbuf_2/a_27322_n240# 0.01fF
C1426 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_6240_n1600# 0.26fF
C1427 divbuf_1/a_25382_n240# divbuf_1/OUT4 0.04fF
C1428 pd_div_0/divbuf_0/a_23550_n840# pd_div_0/divbuf_0/a_23550_n1540# 0.01fF
C1429 pd_div_0/divbuf_0/a_53790_n840# pd_div_0/divbuf_0/a_54270_n840# 0.07fF
C1430 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_53790_n1540# 0.19fF
C1431 divbuf_0/a_15182_170# divbuf_0/a_15182_n240# 0.01fF
C1432 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59070_n1540# 0.19fF
C1433 pll_full_0/divbuf_1/a_28830_n840# pll_full_0/divbuf_1/a_28830_n1540# 0.01fF
C1434 pll_full_0/divbuf_1/a_59070_n840# pll_full_0/divbuf_1/a_59550_n840# 0.07fF
C1435 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/a_11312_n240# 0.01fF
C1436 divbuf_2/a_19230_n840# divbuf_2/a_19710_n840# 0.07fF
C1437 divbuf_2/a_16152_n240# divbuf_2/OUT4 0.04fF
C1438 divbuf_2/a_19200_n1600# divbuf_2/a_19230_n1540# 0.19fF
C1439 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/tspc_0/Z3 0.45fF
C1440 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_3912_n240# 0.01fF
C1441 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n840# 0.04fF
C1442 divbuf_0/a_33622_170# divbuf_0/OUT4 0.19fF
C1443 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1444 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33150_n840# 0.04fF
C1445 divbuf_3/a_8272_170# divbuf_3/a_8762_170# 0.07fF
C1446 divbuf_1/a_51360_n1600# divbuf_1/a_51840_n1600# 0.26fF
C1447 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1448 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_53280_n1600# 0.26fF
C1449 divbuf_3/a_42240_n1600# divbuf_3/a_42720_n1600# 0.26fF
C1450 divbuf_3/a_33142_n240# divbuf_3/a_33150_n840# 0.06fF
C1451 ro_div_0/divbuf_0/a_45150_n1540# ro_div_0/divbuf_0/a_45630_n1540# 0.11fF
C1452 divbuf_3/a_34590_n1540# divbuf_3/a_35070_n1540# 0.11fF
C1453 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11070_n840# 0.02fF
C1454 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_16350_n840# 0.00fF
C1455 divbuf_1/a_43680_n1600# divbuf_1/a_43710_n1540# 0.19fF
C1456 divbuf_1/a_23520_n1600# divbuf_1/OUT4 0.00fF
C1457 divbuf_0/a_36532_170# divbuf_0/a_36532_n240# 0.01fF
C1458 divbuf_0/a_16642_n240# divbuf_0/a_17122_n240# 0.05fF
C1459 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/a_30712_n240# 0.01fF
C1460 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n1540# 0.19fF
C1461 divbuf_0/a_28350_n840# divbuf_0/a_28830_n840# 0.07fF
C1462 divbuf_0/a_34592_n240# divbuf_0/OUT4 0.04fF
C1463 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1464 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_22590_n1540# 0.19fF
C1465 pll_full_0/divbuf_0/a_22590_n840# pll_full_0/divbuf_0/a_23070_n840# 0.07fF
C1466 divbuf_1/a_41280_n1600# divbuf_1/a_41310_n840# 0.04fF
C1467 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/a_14702_170# 0.07fF
C1468 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/divider_0/clk 1.30fF
C1469 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_42750_n840# 0.04fF
C1470 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1471 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/OUT2 0.04fF
C1472 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/a_12772_170# 0.07fF
C1473 divbuf_3/a_20042_170# divbuf_3/OUT4 0.19fF
C1474 divbuf_3/a_32160_n1600# divbuf_3/a_32190_n840# 0.04fF
C1475 divbuf_1/a_35550_n1540# divbuf_1/a_36030_n1540# 0.11fF
C1476 divbuf_2/a_5760_n1600# divbuf_2/a_6240_n1600# 0.26fF
C1477 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40800_n1600# 0.26fF
C1478 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/a_31230_n840# 0.05fF
C1479 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/a_36510_n840# 0.05fF
C1480 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_46080_n1600# 0.26fF
C1481 pd_div_0/divbuf_0/a_32670_n1540# pd_div_0/divbuf_0/a_33150_n1540# 0.11fF
C1482 pll_full_0/divbuf_1/a_37950_n1540# pll_full_0/divbuf_1/a_38430_n1540# 0.11fF
C1483 divbuf_2/a_59040_n1600# divbuf_2/a_59070_n1540# 0.19fF
C1484 divbuf_2/a_28830_n840# divbuf_2/a_28830_n1540# 0.01fF
C1485 divbuf_2/a_59070_n840# divbuf_2/a_59550_n840# 0.07fF
C1486 divbuf_1/a_38962_170# divbuf_1/a_38962_n240# 0.01fF
C1487 divbuf_1/a_19072_n240# divbuf_1/a_19562_n240# 0.04fF
C1488 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/a_21012_n240# 0.05fF
C1489 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/a_40412_n240# 0.01fF
C1490 divbuf_0/a_32640_n1600# divbuf_0/OUT4 0.00fF
C1491 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C1492 divbuf_3/a_9242_n240# divbuf_3/a_9732_n240# 0.04fF
C1493 divbuf_3/a_29742_170# divbuf_3/a_29742_n240# 0.01fF
C1494 divbuf_1/a_30750_n840# divbuf_1/a_31230_n840# 0.07fF
C1495 divbuf_1/a_510_n840# divbuf_1/a_510_n1540# 0.01fF
C1496 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/OUT2 0.01fF
C1497 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32190_n1540# 0.19fF
C1498 ro_div_0/divbuf_0/a_32190_n840# ro_div_0/divbuf_0/a_32670_n840# 0.07fF
C1499 ro_div_0/divbuf_0/a_1950_n840# ro_div_0/divbuf_0/a_1950_n1540# 0.01fF
C1500 divbuf_3/a_21630_n840# divbuf_3/a_22110_n840# 0.07fF
C1501 divbuf_3/a_21012_n240# divbuf_3/OUT4 0.04fF
C1502 divbuf_3/a_21600_n1600# divbuf_3/a_21630_n1540# 0.19fF
C1503 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C1504 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z4 0.21fF
C1505 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/tspc_1/Z3 0.16fF
C1506 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/nor_1/A 0.01fF
C1507 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1508 divbuf_2/a_16642_n240# divbuf_2/a_16350_n840# 0.00fF
C1509 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1510 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30270_n840# 0.04fF
C1511 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1512 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_35550_n840# 0.04fF
C1513 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Qbar1 0.38fF
C1514 divbuf_1/a_53310_n840# divbuf_1/a_53310_n1540# 0.01fF
C1515 ashish_0/von ashish_0/Gnd 0.33fF
C1516 divbuf_0/a_5362_n240# divbuf_0/a_5310_n840# 0.04fF
C1517 divbuf_0/a_14880_n1600# divbuf_0/a_15360_n1600# 0.26fF
C1518 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9600_n1600# 0.26fF
C1519 divbuf_0/a_37950_n840# divbuf_0/a_37950_n1540# 0.01fF
C1520 divbuf_0/a_7230_n1540# divbuf_0/a_7710_n1540# 0.11fF
C1521 pll_full_0/divbuf_0/a_1470_n1540# pll_full_0/divbuf_0/a_1950_n1540# 0.11fF
C1522 pll_full_0/divbuf_0/a_32190_n840# pll_full_0/divbuf_0/a_32190_n1540# 0.01fF
C1523 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/OUT5 0.26fF
C1524 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/a_7792_n240# 0.04fF
C1525 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/a_27802_n240# 0.01fF
C1526 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_13742_n240# 0.04fF
C1527 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/a_33142_n240# 0.01fF
C1528 divbuf_3/a_19200_n1600# divbuf_3/OUT4 0.00fF
C1529 divbuf_2/a_12282_170# divbuf_2/a_12772_170# 0.07fF
C1530 divbuf_2/a_36532_n240# divbuf_2/a_36510_n840# 0.05fF
C1531 divbuf_2/a_45600_n1600# divbuf_2/a_46080_n1600# 0.26fF
C1532 pd_div_0/divbuf_0/a_19710_n840# pd_div_0/divbuf_0/a_20190_n840# 0.07fF
C1533 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1534 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_19710_n1540# 0.19fF
C1535 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/and_0/B 0.29fF
C1536 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1537 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_24990_n1540# 0.19fF
C1538 pll_full_0/divbuf_1/a_24990_n840# pll_full_0/divbuf_1/a_25470_n840# 0.07fF
C1539 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n840# 0.04fF
C1540 divbuf_0/a_17612_170# divbuf_0/OUT4 0.19fF
C1541 divbuf_2/a_37950_n1540# divbuf_2/a_38430_n1540# 0.11fF
C1542 divbuf_1/a_17280_n1600# divbuf_1/a_17760_n1600# 0.26fF
C1543 divbuf_1/a_7792_n240# divbuf_1/a_7710_n840# 0.03fF
C1544 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/a_9150_n840# 0.03fF
C1545 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_19200_n1600# 0.26fF
C1546 divbuf_3/a_8160_n1600# divbuf_3/a_8640_n1600# 0.26fF
C1547 pd_div_0/div pd_div_0/divbuf_0/a_510_n840# 0.07fF
C1548 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/a_41790_n1540# 0.01fF
C1549 ro_div_0/divbuf_0/a_11070_n1540# ro_div_0/divbuf_0/a_11550_n1540# 0.11fF
C1550 divbuf_3/a_510_n1540# divbuf_3/a_990_n1540# 0.11fF
C1551 divbuf_3/a_31230_n840# divbuf_3/a_31230_n1540# 0.01fF
C1552 divbuf_1/a_9630_n1540# divbuf_1/a_10110_n1540# 0.11fF
C1553 divbuf_2/a_26832_170# divbuf_2/OUT4 0.19fF
C1554 divbuf_2/a_35520_n1600# divbuf_2/a_35550_n840# 0.04fF
C1555 divbuf_1/a_36052_170# divbuf_1/OUT4 0.19fF
C1556 divbuf_0/a_21502_170# divbuf_0/a_21982_170# 0.07fF
C1557 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/a_17612_170# 0.07fF
C1558 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.44fF
C1559 pd_div_0/divider_0/tspc_0/a_630_n680# gnd 0.62fF
C1560 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/tspc_0/Z3 0.06fF
C1561 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1562 ro_div_0/ro_complete_0/cbank_0/switch_5/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C1563 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_12282_170# 0.07fF
C1564 divbuf_0/a_54720_n1600# divbuf_0/a_55200_n1600# 0.26fF
C1565 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1566 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1567 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1568 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/a_39870_n840# 0.04fF
C1569 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_49440_n1600# 0.26fF
C1570 divbuf_1/a_7200_n1600# divbuf_1/a_7230_n840# 0.04fF
C1571 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_8670_n840# 0.04fF
C1572 divbuf_0/a_47070_n1540# divbuf_0/a_47550_n1540# 0.11fF
C1573 pll_full_0/divbuf_0/a_41310_n1540# pll_full_0/divbuf_0/a_41790_n1540# 0.11fF
C1574 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6720_n1600# 0.26fF
C1575 divbuf_2/a_13252_n240# divbuf_2/a_13742_n240# 0.04fF
C1576 divbuf_2/a_33142_170# divbuf_2/a_33142_n240# 0.01fF
C1577 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_12000_n1600# 0.26fF
C1578 divbuf_1/a_37022_n240# divbuf_1/OUT4 0.04fF
C1579 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_59550_n1540# 0.19fF
C1580 pd_div_0/divbuf_0/a_29310_n840# pd_div_0/divbuf_0/a_29310_n1540# 0.01fF
C1581 pd_div_0/divbuf_0/a_59550_n840# pd_div_0/divbuf_0/a_60030_n840# 0.07fF
C1582 pll_full_0/divbuf_1/a_3870_n1540# pll_full_0/divbuf_1/a_4350_n1540# 0.11fF
C1583 pll_full_0/divbuf_1/a_34590_n840# pll_full_0/divbuf_1/a_34590_n1540# 0.01fF
C1584 pll_full_0/divbuf_0/a_17122_170# pll_full_0/divbuf_0/a_17122_n240# 0.01fF
C1585 divbuf_2/a_27802_n240# divbuf_2/OUT4 0.04fF
C1586 divbuf_2/a_24960_n1600# divbuf_2/a_24990_n1540# 0.19fF
C1587 divbuf_2/a_24990_n840# divbuf_2/a_25470_n840# 0.07fF
C1588 divbuf_1/a_20532_170# divbuf_1/a_21012_170# 0.07fF
C1589 divbuf_0/a_5852_n240# divbuf_0/OUT3 0.04fF
C1590 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/a_25862_170# 0.07fF
C1591 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n840# 0.04fF
C1592 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1593 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_38910_n840# 0.04fF
C1594 divbuf_3/a_14702_170# divbuf_3/a_15182_170# 0.07fF
C1595 divbuf_1/a_57120_n1600# divbuf_1/a_57600_n1600# 0.26fF
C1596 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/a_1842_170# 0.07fF
C1597 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1598 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_59040_n1600# 0.26fF
C1599 divbuf_3/a_38962_n240# divbuf_3/a_38910_n840# 0.04fF
C1600 divbuf_3/a_48000_n1600# divbuf_3/a_48480_n1600# 0.26fF
C1601 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_16830_n840# 0.00fF
C1602 ro_div_0/divbuf_0/a_50910_n1540# ro_div_0/divbuf_0/a_51390_n1540# 0.11fF
C1603 divbuf_3/a_40350_n1540# divbuf_3/a_40830_n1540# 0.11fF
C1604 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1470_n840# 0.04fF
C1605 divbuf_1/a_35040_n1600# divbuf_1/OUT4 0.00fF
C1606 divbuf_1/a_19230_n840# divbuf_1/a_19230_n1540# 0.01fF
C1607 divbuf_1/a_49440_n1600# divbuf_1/a_49470_n1540# 0.19fF
C1608 divbuf_0/a_22472_n240# divbuf_0/a_22952_n240# 0.05fF
C1609 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_17122_n240# 0.05fF
C1610 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/a_36532_n240# 0.01fF
C1611 divbuf_1/a_22952_170# divbuf_1/a_22952_n240# 0.01fF
C1612 divbuf_0/a_34110_n840# divbuf_0/a_34590_n840# 0.07fF
C1613 divbuf_0/a_3870_n840# divbuf_0/a_3870_n1540# 0.01fF
C1614 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n1540# 0.19fF
C1615 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1616 pll_full_0/divbuf_0/a_28350_n840# pll_full_0/divbuf_0/a_28830_n840# 0.07fF
C1617 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28350_n1540# 0.19fF
C1618 divbuf_1/a_47040_n1600# divbuf_1/a_47070_n840# 0.04fF
C1619 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/a_10212_170# 0.07fF
C1620 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48510_n840# 0.04fF
C1621 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1622 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/a_18582_170# 0.07fF
C1623 divbuf_3/a_31682_170# divbuf_3/OUT4 0.19fF
C1624 divbuf_3/a_37920_n1600# divbuf_3/a_37950_n840# 0.04fF
C1625 divbuf_1/a_41310_n1540# divbuf_1/a_41790_n1540# 0.11fF
C1626 divbuf_2/a_11520_n1600# divbuf_2/a_12000_n1600# 0.26fF
C1627 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/a_36990_n840# 0.05fF
C1628 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46560_n1600# 0.26fF
C1629 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51840_n1600# 0.26fF
C1630 pd_div_0/divbuf_0/a_38430_n1540# pd_div_0/divbuf_0/a_38910_n1540# 0.11fF
C1631 pll_full_0/divbuf_1/a_43710_n1540# pll_full_0/divbuf_1/a_44190_n1540# 0.11fF
C1632 divbuf_2/a_3870_n1540# divbuf_2/a_4350_n1540# 0.11fF
C1633 divbuf_2/a_34590_n840# divbuf_2/a_34590_n1540# 0.01fF
C1634 divbuf_1/a_24892_n240# divbuf_1/a_25382_n240# 0.04fF
C1635 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/a_26832_n240# 0.05fF
C1636 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C1637 divbuf_3/a_15672_n240# divbuf_3/a_16152_n240# 0.05fF
C1638 divbuf_3/a_35562_170# divbuf_3/a_35562_n240# 0.01fF
C1639 divbuf_1/a_6270_n840# divbuf_1/a_6270_n1540# 0.01fF
C1640 divbuf_1/a_36510_n840# divbuf_1/a_36990_n840# 0.07fF
C1641 pd_div_0/divbuf_0/a_12282_170# pd_div_0/divbuf_0/a_12282_n240# 0.01fF
C1642 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_37950_n1540# 0.19fF
C1643 ro_div_0/divbuf_0/a_37950_n840# ro_div_0/divbuf_0/a_38430_n840# 0.07fF
C1644 ro_div_0/divbuf_0/a_7710_n840# ro_div_0/divbuf_0/a_7710_n1540# 0.01fF
C1645 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C1646 divbuf_3/a_32652_n240# divbuf_3/OUT4 0.04fF
C1647 divbuf_3/a_27390_n840# divbuf_3/a_27870_n840# 0.07fF
C1648 divbuf_3/a_27360_n1600# divbuf_3/a_27390_n1540# 0.19fF
C1649 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C1650 divbuf_2/a_1440_n1600# divbuf_2/a_1470_n840# 0.04fF
C1651 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1652 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36030_n840# 0.04fF
C1653 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1654 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41310_n840# 0.04fF
C1655 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_8272_170# 0.07fF
C1656 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1657 divbuf_1/a_59070_n840# divbuf_1/a_59070_n1540# 0.01fF
C1658 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C1659 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C1660 divbuf_0/a_11312_n240# divbuf_0/a_11550_n840# 0.02fF
C1661 divbuf_0/a_20640_n1600# divbuf_0/a_21120_n1600# 0.26fF
C1662 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_15360_n1600# 0.26fF
C1663 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/a_5310_n840# 0.04fF
C1664 divbuf_0/a_43710_n840# divbuf_0/a_43710_n1540# 0.01fF
C1665 divbuf_0/a_12990_n1540# divbuf_0/a_13470_n1540# 0.11fF
C1666 pll_full_0/divbuf_0/a_7230_n1540# pll_full_0/divbuf_0/a_7710_n1540# 0.11fF
C1667 pll_full_0/divbuf_0/a_37950_n840# pll_full_0/divbuf_0/a_37950_n1540# 0.01fF
C1668 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_14222_n240# 0.05fF
C1669 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/a_33622_n240# 0.01fF
C1670 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/a_38962_n240# 0.01fF
C1671 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/a_19562_n240# 0.04fF
C1672 divbuf_2/a_18092_170# divbuf_2/a_18582_170# 0.07fF
C1673 divbuf_2/a_51360_n1600# divbuf_2/a_51840_n1600# 0.26fF
C1674 divbuf_1/a_6822_170# divbuf_1/OUT3 0.19fF
C1675 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1676 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25470_n1540# 0.19fF
C1677 pd_div_0/divbuf_0/a_25470_n840# pd_div_0/divbuf_0/a_25950_n840# 0.07fF
C1678 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1679 pll_full_0/divbuf_1/a_30750_n840# pll_full_0/divbuf_1/a_31230_n840# 0.07fF
C1680 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/a_510_n1540# 0.01fF
C1681 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_30750_n1540# 0.19fF
C1682 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1683 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1684 divbuf_1/a_4392_170# divbuf_1/a_4882_170# 0.07fF
C1685 divbuf_0/a_10560_n1600# divbuf_0/a_10590_n840# 0.04fF
C1686 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1687 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_4830_n840# 0.04fF
C1688 divbuf_2/a_43710_n1540# divbuf_2/a_44190_n1540# 0.11fF
C1689 divbuf_1/a_13742_n240# divbuf_1/a_13950_n840# 0.02fF
C1690 divbuf_1/a_23040_n1600# divbuf_1/a_23520_n1600# 0.26fF
C1691 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_15390_n840# 0.02fF
C1692 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24960_n1600# 0.26fF
C1693 divbuf_3/a_13920_n1600# divbuf_3/a_14400_n1600# 0.26fF
C1694 divbuf_3/a_4392_n240# divbuf_3/a_4350_n840# 0.04fF
C1695 ro_div_0/divbuf_0/a_47550_n840# ro_div_0/divbuf_0/a_47550_n1540# 0.01fF
C1696 ro_div_0/divbuf_0/a_16830_n1540# ro_div_0/divbuf_0/a_17310_n1540# 0.11fF
C1697 divbuf_3/a_6270_n1540# divbuf_3/a_6750_n1540# 0.11fF
C1698 divbuf_3/a_36990_n840# divbuf_3/a_36990_n1540# 0.01fF
C1699 divbuf_2/a_38472_170# divbuf_2/OUT4 0.19fF
C1700 divbuf_2/a_41280_n1600# divbuf_2/a_41310_n840# 0.04fF
C1701 divbuf_1/a_8272_n240# divbuf_1/OUT3 0.04fF
C1702 divbuf_1/a_15360_n1600# divbuf_1/a_15390_n1540# 0.19fF
C1703 divbuf_0/a_27322_170# divbuf_0/a_27802_170# 0.07fF
C1704 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/a_21982_170# 0.07fF
C1705 gnd pll_full_0/divider_0/tspc_2/Z4 0.44fF
C1706 divbuf_1/a_14702_170# divbuf_1/a_14222_170# 0.07fF
C1707 pd_div_0/divider_0/prescaler_0/tspc_2/D pd_div_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1708 divbuf_0/a_14222_170# divbuf_0/OUT4 0.19fF
C1709 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_55200_n1600# 0.26fF
C1710 divbuf_1/a_12960_n1600# divbuf_1/a_12990_n840# 0.04fF
C1711 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14430_n840# 0.04fF
C1712 divbuf_0/a_52830_n1540# divbuf_0/a_53310_n1540# 0.11fF
C1713 pll_full_0/divbuf_0/a_47070_n1540# pll_full_0/divbuf_0/a_47550_n1540# 0.11fF
C1714 divbuf_3/a_3840_n1600# divbuf_3/a_3870_n840# 0.04fF
C1715 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12480_n1600# 0.26fF
C1716 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17760_n1600# 0.26fF
C1717 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/a_7710_n840# 0.03fF
C1718 divbuf_2/a_38962_170# divbuf_2/a_38962_n240# 0.01fF
C1719 divbuf_2/a_19072_n240# divbuf_2/a_19562_n240# 0.04fF
C1720 divbuf_2/a_39442_n240# divbuf_2/OUT4 0.04fF
C1721 divbuf_2/a_30750_n840# divbuf_2/a_31230_n840# 0.07fF
C1722 divbuf_2/a_510_n840# divbuf_2/a_510_n1540# 0.01fF
C1723 divbuf_2/a_30720_n1600# divbuf_2/a_30750_n1540# 0.19fF
C1724 pd_div_0/divbuf_0/a_4350_n1540# pd_div_0/divbuf_0/a_4830_n1540# 0.11fF
C1725 pd_div_0/divbuf_0/a_35070_n840# pd_div_0/divbuf_0/a_35070_n1540# 0.01fF
C1726 pll_full_0/divbuf_1/a_9630_n1540# pll_full_0/divbuf_1/a_10110_n1540# 0.11fF
C1727 pll_full_0/divbuf_1/a_40350_n840# pll_full_0/divbuf_1/a_40350_n1540# 0.01fF
C1728 divbuf_1/a_26352_170# divbuf_1/a_26832_170# 0.07fF
C1729 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/a_31682_170# 0.07fF
C1730 divbuf_0/a_50400_n1600# divbuf_0/a_50430_n840# 0.04fF
C1731 divbuf_0/a_17612_n240# divbuf_0/OUT4 0.04fF
C1732 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C1733 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_44670_n840# 0.04fF
C1734 divbuf_3/a_20532_170# divbuf_3/a_21012_170# 0.07fF
C1735 divbuf_1/a_2400_n1600# divbuf_1/a_2430_n1540# 0.19fF
C1736 divbuf_1/a_2430_n840# divbuf_1/a_2910_n840# 0.07fF
C1737 pd_div_0/pd_0/R pd_div_0/pd_0/UP 0.45fF
C1738 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_3870_n1540# 0.19fF
C1739 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1740 ro_div_0/divbuf_0/a_3870_n840# ro_div_0/divbuf_0/a_4350_n840# 0.07fF
C1741 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C1742 divbuf_3/a_53760_n1600# divbuf_3/a_54240_n1600# 0.26fF
C1743 divbuf_3/a_2322_170# divbuf_3/OUT3 0.07fF
C1744 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_1950_n840# 0.04fF
C1745 ro_div_0/divbuf_0/a_56670_n1540# ro_div_0/divbuf_0/a_57150_n1540# 0.11fF
C1746 divbuf_3/a_46110_n1540# divbuf_3/a_46590_n1540# 0.11fF
C1747 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7230_n840# 0.04fF
C1748 divbuf_1/a_24990_n840# divbuf_1/a_24990_n1540# 0.01fF
C1749 divbuf_1/a_55200_n1600# divbuf_1/a_55230_n1540# 0.19fF
C1750 divbuf_0/a_492_n240# divbuf_0/a_510_n840# 0.00fF
C1751 divbuf_0/a_28292_n240# divbuf_0/a_28772_n240# 0.05fF
C1752 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/a_22952_n240# 0.05fF
C1753 divbuf_1/a_28772_170# divbuf_1/a_28772_n240# 0.01fF
C1754 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n1540# 0.19fF
C1755 divbuf_0/a_39870_n840# divbuf_0/a_40350_n840# 0.07fF
C1756 divbuf_0/a_9630_n840# divbuf_0/a_9630_n1540# 0.01fF
C1757 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34110_n1540# 0.19fF
C1758 pll_full_0/divbuf_0/a_3870_n840# pll_full_0/divbuf_0/a_3870_n1540# 0.01fF
C1759 pll_full_0/divbuf_0/a_34110_n840# pll_full_0/divbuf_0/a_34590_n840# 0.07fF
C1760 divbuf_1/a_52800_n1600# divbuf_1/a_52830_n840# 0.04fF
C1761 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/a_19072_170# 0.07fF
C1762 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54270_n840# 0.04fF
C1763 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1764 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/a_3912_n240# 0.01fF
C1765 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/a_24412_170# 0.07fF
C1766 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C1767 divbuf_3/a_3912_n240# divbuf_3/OUT3 0.04fF
C1768 divbuf_3/a_43680_n1600# divbuf_3/a_43710_n840# 0.04fF
C1769 divbuf_1/a_47070_n1540# divbuf_1/a_47550_n1540# 0.11fF
C1770 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_52320_n1600# 0.26fF
C1771 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1772 divbuf_0/a_8762_170# divbuf_0/a_9242_170# 0.07fF
C1773 divbuf_2/a_17280_n1600# divbuf_2/a_17760_n1600# 0.26fF
C1774 divbuf_2/a_7792_n240# divbuf_2/a_7710_n840# 0.03fF
C1775 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/OUT3 0.19fF
C1776 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57600_n1600# 0.26fF
C1777 pd_div_0/divbuf_0/a_44190_n1540# pd_div_0/divbuf_0/a_44670_n1540# 0.11fF
C1778 pll_full_0/divbuf_1/a_49470_n1540# pll_full_0/divbuf_1/a_49950_n1540# 0.11fF
C1779 divbuf_2/a_9630_n1540# divbuf_2/a_10110_n1540# 0.11fF
C1780 divbuf_2/a_40350_n840# divbuf_2/a_40350_n1540# 0.01fF
C1781 divbuf_1/a_30712_n240# divbuf_1/a_31202_n240# 0.04fF
C1782 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/a_32652_n240# 0.05fF
C1783 divbuf_3/a_41382_170# divbuf_3/a_41382_n240# 0.01fF
C1784 divbuf_3/a_21502_n240# divbuf_3/a_21982_n240# 0.05fF
C1785 divbuf_1/a_12030_n840# divbuf_1/a_12030_n1540# 0.01fF
C1786 divbuf_1/a_42270_n840# divbuf_1/a_42750_n840# 0.07fF
C1787 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C1788 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_43710_n1540# 0.19fF
C1789 ro_div_0/divbuf_0/a_43710_n840# ro_div_0/divbuf_0/a_44190_n840# 0.07fF
C1790 ro_div_0/divbuf_0/a_13470_n840# ro_div_0/divbuf_0/a_13470_n1540# 0.01fF
C1791 divbuf_3/a_2910_n840# divbuf_3/a_2910_n1540# 0.01fF
C1792 divbuf_3/a_33150_n840# divbuf_3/a_33630_n840# 0.07fF
C1793 divbuf_3/a_33120_n1600# divbuf_3/a_33150_n1540# 0.19fF
C1794 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/Out 0.04fF
C1795 divbuf_2/a_7200_n1600# divbuf_2/a_7230_n840# 0.04fF
C1796 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/OUT4 0.19fF
C1797 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_41790_n840# 0.04fF
C1798 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1799 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47070_n840# 0.04fF
C1800 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C1801 divbuf_0/a_17122_n240# divbuf_0/a_17310_n840# 0.02fF
C1802 divbuf_0/a_26400_n1600# divbuf_0/a_26880_n1600# 0.26fF
C1803 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_21120_n1600# 0.26fF
C1804 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11550_n840# 0.02fF
C1805 divbuf_0/a_49470_n840# divbuf_0/a_49470_n1540# 0.01fF
C1806 divbuf_0/a_18750_n1540# divbuf_0/a_19230_n1540# 0.11fF
C1807 pll_full_0/divbuf_0/a_12990_n1540# pll_full_0/divbuf_0/a_13470_n1540# 0.11fF
C1808 pll_full_0/divbuf_0/a_43710_n840# pll_full_0/divbuf_0/a_43710_n1540# 0.01fF
C1809 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/a_39442_n240# 0.01fF
C1810 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/a_20042_n240# 0.05fF
C1811 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/a_25382_n240# 0.04fF
C1812 divbuf_2/a_3912_170# divbuf_2/a_3912_n240# 0.01fF
C1813 divbuf_2/a_23922_170# divbuf_2/a_24412_170# 0.07fF
C1814 divbuf_2/a_9732_170# divbuf_2/OUT3 0.19fF
C1815 divbuf_2/a_57120_n1600# divbuf_2/a_57600_n1600# 0.26fF
C1816 divbuf_1/a_3422_170# divbuf_1/OUT3 0.23fF
C1817 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1818 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/a_990_n1540# 0.01fF
C1819 pd_div_0/divbuf_0/a_31230_n840# pd_div_0/divbuf_0/a_31710_n840# 0.07fF
C1820 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31230_n1540# 0.19fF
C1821 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36510_n1540# 0.19fF
C1822 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C1823 pll_full_0/divbuf_1/a_6270_n840# pll_full_0/divbuf_1/a_6270_n1540# 0.01fF
C1824 pll_full_0/divbuf_1/a_36510_n840# pll_full_0/divbuf_1/a_36990_n840# 0.07fF
C1825 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/a_14702_170# 0.07fF
C1826 divbuf_0/a_10212_170# divbuf_0/OUT3 0.19fF
C1827 divbuf_0/a_16320_n1600# divbuf_0/a_16350_n840# 0.04fF
C1828 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1829 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1830 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C1831 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_10590_n840# 0.04fF
C1832 divbuf_2/a_49470_n1540# divbuf_2/a_49950_n1540# 0.11fF
C1833 divbuf_1/a_28800_n1600# divbuf_1/a_29280_n1600# 0.26fF
C1834 divbuf_1/a_19562_n240# divbuf_1/a_19710_n840# 0.03fF
C1835 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/a_21150_n840# 0.03fF
C1836 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30720_n1600# 0.26fF
C1837 divbuf_3/a_19680_n1600# divbuf_3/a_20160_n1600# 0.26fF
C1838 divbuf_3/a_10212_n240# divbuf_3/a_10110_n840# 0.03fF
C1839 ro_div_0/divbuf_0/a_53310_n840# ro_div_0/divbuf_0/a_53310_n1540# 0.01fF
C1840 ro_div_0/divbuf_0/a_22590_n1540# ro_div_0/divbuf_0/a_23070_n1540# 0.11fF
C1841 divbuf_3/a_12030_n1540# divbuf_3/a_12510_n1540# 0.11fF
C1842 divbuf_3/a_42750_n840# divbuf_3/a_42750_n1540# 0.01fF
C1843 divbuf_0/a_33142_170# divbuf_0/a_33622_170# 0.07fF
C1844 divbuf_2/a_10212_n240# divbuf_2/OUT4 0.04fF
C1845 divbuf_2/a_47040_n1600# divbuf_2/a_47070_n840# 0.04fF
C1846 divbuf_1/a_20042_n240# divbuf_1/OUT4 0.04fF
C1847 divbuf_1/a_21120_n1600# divbuf_1/a_21150_n1540# 0.19fF
C1848 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/a_14222_n240# 0.01fF
C1849 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/a_27802_170# 0.07fF
C1850 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/a_6822_n240# 0.01fF
C1851 divbuf_1/a_5852_170# divbuf_1/a_5852_n240# 0.01fF
C1852 divbuf_1/a_16152_170# divbuf_1/a_16152_n240# 0.01fF
C1853 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n1540# 0.19fF
C1854 divbuf_0/a_28292_170# divbuf_0/OUT4 0.19fF
C1855 divbuf_0/a_5790_n840# divbuf_0/a_6270_n840# 0.07fF
C1856 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/OUT4 0.19fF
C1857 divbuf_1/a_18720_n1600# divbuf_1/a_18750_n840# 0.04fF
C1858 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20190_n840# 0.04fF
C1859 divbuf_0/a_58590_n1540# divbuf_0/a_59070_n1540# 0.11fF
C1860 pll_full_0/divbuf_0/a_52830_n1540# pll_full_0/divbuf_0/a_53310_n1540# 0.11fF
C1861 divbuf_3/a_9600_n1600# divbuf_3/a_9630_n840# 0.04fF
C1862 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_18240_n1600# 0.26fF
C1863 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/a_8190_n840# 0.03fF
C1864 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_13950_n840# 0.02fF
C1865 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23520_n1600# 0.26fF
C1866 divbuf_3/a_60990_n840# divbuf_3/OUT5 0.04fF
C1867 divbuf_2/a_24892_n240# divbuf_2/a_25382_n240# 0.04fF
C1868 divbuf_2/a_36480_n1600# divbuf_2/a_36510_n1540# 0.19fF
C1869 divbuf_2/a_9600_n1600# divbuf_2/OUT3 0.00fF
C1870 divbuf_2/a_6270_n840# divbuf_2/a_6270_n1540# 0.01fF
C1871 divbuf_2/a_36510_n840# divbuf_2/a_36990_n840# 0.07fF
C1872 pd_div_0/divbuf_0/a_10110_n1540# pd_div_0/divbuf_0/a_10590_n1540# 0.11fF
C1873 pd_div_0/divbuf_0/a_40830_n840# pd_div_0/divbuf_0/a_40830_n1540# 0.01fF
C1874 pll_full_0/divbuf_1/a_15390_n1540# pll_full_0/divbuf_1/a_15870_n1540# 0.11fF
C1875 pll_full_0/divbuf_1/a_46110_n840# pll_full_0/divbuf_1/a_46110_n1540# 0.01fF
C1876 divbuf_1/a_35562_170# divbuf_1/a_36052_170# 0.07fF
C1877 divbuf_0/a_56160_n1600# divbuf_0/a_56190_n840# 0.04fF
C1878 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/a_37502_170# 0.07fF
C1879 divbuf_0/a_29262_n240# divbuf_0/OUT4 0.04fF
C1880 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C1881 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50430_n840# 0.04fF
C1882 divbuf_3/a_6332_170# divbuf_3/a_6332_n240# 0.01fF
C1883 divbuf_3/a_26352_170# divbuf_3/a_26832_170# 0.07fF
C1884 divbuf_1/a_8190_n840# divbuf_1/a_8670_n840# 0.07fF
C1885 divbuf_1/a_8160_n1600# divbuf_1/a_8190_n1540# 0.19fF
C1886 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/a_6822_170# 0.07fF
C1887 pd_div_0/pd_0/UP pd_div_0/pd_0/and_pd_0/Out1 0.33fF
C1888 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_9630_n1540# 0.19fF
C1889 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/OUT4 0.19fF
C1890 ro_div_0/divbuf_0/a_9630_n840# ro_div_0/divbuf_0/a_10110_n840# 0.07fF
C1891 divbuf_3/a_14702_170# divbuf_3/OUT4 0.19fF
C1892 divbuf_3/a_59520_n1600# divbuf_3/a_60000_n1600# 0.26fF
C1893 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_7710_n840# 0.04fF
C1894 ro_div_0/divbuf_0/a_60990_n1540# ro_div_0/divbuf_0/OUT5 0.19fF
C1895 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_12990_n840# 0.04fF
C1896 divbuf_3/a_51870_n1540# divbuf_3/a_52350_n1540# 0.11fF
C1897 divbuf_1/a_30750_n840# divbuf_1/a_30750_n1540# 0.01fF
C1898 divbuf_0/a_34112_n240# divbuf_0/a_34592_n240# 0.05fF
C1899 pll_full_0/divbuf_0/a_28292_n240# pll_full_0/divbuf_0/a_28772_n240# 0.05fF
C1900 divbuf_0/a_45630_n840# divbuf_0/a_46110_n840# 0.07fF
C1901 divbuf_0/a_15390_n840# divbuf_0/a_15390_n1540# 0.01fF
C1902 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n1540# 0.19fF
C1903 pll_full_0/divbuf_0/a_9630_n840# pll_full_0/divbuf_0/a_9630_n1540# 0.01fF
C1904 pll_full_0/divbuf_0/a_39870_n840# pll_full_0/divbuf_0/a_40350_n840# 0.07fF
C1905 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_39870_n1540# 0.19fF
C1906 divbuf_1/a_58560_n1600# divbuf_1/a_58590_n840# 0.04fF
C1907 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/a_24892_170# 0.07fF
C1908 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60030_n840# 0.04fF
C1909 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C1910 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/a_9732_n240# 0.01fF
C1911 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/a_30232_170# 0.07fF
C1912 divbuf_3/a_15672_n240# divbuf_3/OUT4 0.04fF
C1913 divbuf_3/a_49440_n1600# divbuf_3/a_49470_n840# 0.04fF
C1914 divbuf_1/a_52830_n1540# divbuf_1/a_53310_n1540# 0.11fF
C1915 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/OUT3 0.19fF
C1916 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_58080_n1600# 0.26fF
C1917 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Q 0.51fF
C1918 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z3 0.06fF
C1919 divbuf_2/a_13742_n240# divbuf_2/a_13950_n840# 0.02fF
C1920 divbuf_2/a_23040_n1600# divbuf_2/a_23520_n1600# 0.26fF
C1921 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/OUT4 0.19fF
C1922 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2430_n1540# 0.19fF
C1923 pll_full_0/divbuf_1/a_2430_n840# pll_full_0/divbuf_1/a_2910_n840# 0.07fF
C1924 pd_div_0/divbuf_0/a_49950_n1540# pd_div_0/divbuf_0/a_50430_n1540# 0.11fF
C1925 divbuf_0/a_2322_n240# divbuf_0/a_2430_n840# 0.03fF
C1926 pll_full_0/divbuf_1/a_55230_n1540# pll_full_0/divbuf_1/a_55710_n1540# 0.11fF
C1927 divbuf_2/a_15390_n1540# divbuf_2/a_15870_n1540# 0.11fF
C1928 divbuf_2/a_46110_n840# divbuf_2/a_46110_n1540# 0.01fF
C1929 divbuf_1/a_36532_n240# divbuf_1/a_37022_n240# 0.04fF
C1930 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/a_38472_n240# 0.05fF
C1931 divbuf_3/a_27322_n240# divbuf_3/a_27802_n240# 0.05fF
C1932 divbuf_1/a_48030_n840# divbuf_1/a_48510_n840# 0.07fF
C1933 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49470_n1540# 0.19fF
C1934 ro_div_0/divbuf_0/a_49470_n840# ro_div_0/divbuf_0/a_49950_n840# 0.07fF
C1935 ro_div_0/divbuf_0/a_19230_n840# ro_div_0/divbuf_0/a_19230_n1540# 0.01fF
C1936 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C1937 divbuf_3/a_8670_n840# divbuf_3/a_8670_n1540# 0.01fF
C1938 divbuf_3/a_38910_n840# divbuf_3/a_39390_n840# 0.07fF
C1939 divbuf_3/a_38880_n1600# divbuf_3/a_38910_n1540# 0.19fF
C1940 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z4 0.22fF
C1941 ro_div_0/divider_0/tspc_2/Z2 ro_div_0/divider_0/tspc_2/Z3 0.16fF
C1942 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C1943 divbuf_2/a_12960_n1600# divbuf_2/a_12990_n840# 0.04fF
C1944 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C1945 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_47550_n840# 0.04fF
C1946 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C1947 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_52830_n840# 0.04fF
C1948 divbuf_0/a_22952_n240# divbuf_0/a_23070_n840# 0.03fF
C1949 divbuf_0/a_32160_n1600# divbuf_0/a_32640_n1600# 0.26fF
C1950 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1951 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26880_n1600# 0.26fF
C1952 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_17310_n840# 0.02fF
C1953 divbuf_0/a_55230_n840# divbuf_0/a_55230_n1540# 0.01fF
C1954 divbuf_0/a_24510_n1540# divbuf_0/a_24990_n1540# 0.11fF
C1955 pll_full_0/divbuf_0/a_18750_n1540# pll_full_0/divbuf_0/a_19230_n1540# 0.11fF
C1956 pll_full_0/divbuf_0/a_49470_n840# pll_full_0/divbuf_0/a_49470_n1540# 0.01fF
C1957 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/a_25862_n240# 0.05fF
C1958 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/a_31202_n240# 0.04fF
C1959 divbuf_2/a_9732_170# divbuf_2/a_9732_n240# 0.01fF
C1960 divbuf_2/a_29742_170# divbuf_2/a_30232_170# 0.07fF
C1961 divbuf_2/a_21502_170# divbuf_2/OUT4 0.19fF
C1962 divbuf_2/a_2400_n1600# divbuf_2/a_2430_n1540# 0.19fF
C1963 divbuf_2/a_2430_n840# divbuf_2/a_2910_n840# 0.07fF
C1964 divbuf_1/a_27322_170# divbuf_1/OUT4 0.19fF
C1965 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_36990_n1540# 0.19fF
C1966 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/OUT3 0.01fF
C1967 pd_div_0/divbuf_0/a_6750_n840# pd_div_0/divbuf_0/a_6750_n1540# 0.01fF
C1968 pd_div_0/divbuf_0/a_36990_n840# pd_div_0/divbuf_0/a_37470_n840# 0.07fF
C1969 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C1970 pll_full_0/divbuf_1/a_12030_n840# pll_full_0/divbuf_1/a_12030_n1540# 0.01fF
C1971 pll_full_0/divbuf_1/a_42270_n840# pll_full_0/divbuf_1/a_42750_n840# 0.07fF
C1972 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42270_n1540# 0.19fF
C1973 gnd pll_full_0/divider_0/tspc_0/a_630_n680# 0.62fF
C1974 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1975 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/and_0/A 0.80fF
C1976 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1977 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1978 divbuf_0/a_22080_n1600# divbuf_0/a_22110_n840# 0.04fF
C1979 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/Out 0.28fF
C1980 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16350_n840# 0.04fF
C1981 divbuf_2/a_55230_n1540# divbuf_2/a_55710_n1540# 0.11fF
C1982 divbuf_1/a_25382_n240# divbuf_1/a_25470_n840# 0.03fF
C1983 divbuf_1/a_34560_n1600# divbuf_1/a_35040_n1600# 0.26fF
C1984 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/a_26910_n840# 0.04fF
C1985 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36480_n1600# 0.26fF
C1986 divbuf_3/a_25440_n1600# divbuf_3/a_25920_n1600# 0.26fF
C1987 divbuf_3/a_16152_n240# divbuf_3/a_16350_n840# 0.02fF
C1988 ro_div_0/divbuf_0/a_59070_n840# ro_div_0/divbuf_0/a_59070_n1540# 0.01fF
C1989 ro_div_0/divbuf_0/a_28350_n1540# ro_div_0/divbuf_0/a_28830_n1540# 0.11fF
C1990 divbuf_3/a_17790_n1540# divbuf_3/a_18270_n1540# 0.11fF
C1991 divbuf_3/a_48510_n840# divbuf_3/a_48510_n1540# 0.01fF
C1992 divbuf_0/a_38962_170# divbuf_0/a_39442_170# 0.07fF
C1993 divbuf_2/a_22472_n240# divbuf_2/OUT4 0.04fF
C1994 divbuf_2/a_52800_n1600# divbuf_2/a_52830_n840# 0.04fF
C1995 divbuf_1/a_31682_n240# divbuf_1/OUT4 0.04fF
C1996 divbuf_1/a_26880_n1600# divbuf_1/a_26910_n1540# 0.19fF
C1997 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/OUT2 0.02fF
C1998 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/a_33622_170# 0.07fF
C1999 divbuf_0/a_11550_n840# divbuf_0/a_12030_n840# 0.07fF
C2000 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n1540# 0.19fF
C2001 divbuf_0/a_39932_170# divbuf_0/OUT4 0.19fF
C2002 pll_full_0/divbuf_0/a_5790_n840# pll_full_0/divbuf_0/a_6270_n840# 0.07fF
C2003 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2004 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_5790_n1540# 0.19fF
C2005 divbuf_1/a_24480_n1600# divbuf_1/a_24510_n840# 0.04fF
C2006 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/OUT3 0.19fF
C2007 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_25950_n840# 0.04fF
C2008 pll_full_0/divbuf_0/a_58590_n1540# pll_full_0/divbuf_0/a_59070_n1540# 0.11fF
C2009 divbuf_3/a_15360_n1600# divbuf_3/a_15390_n840# 0.04fF
C2010 divbuf_1/a_18750_n1540# divbuf_1/a_19230_n1540# 0.11fF
C2011 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_14430_n840# 0.02fF
C2012 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_24000_n1600# 0.26fF
C2013 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_29280_n1600# 0.26fF
C2014 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/a_19710_n840# 0.03fF
C2015 divbuf_2/a_30712_n240# divbuf_2/a_31202_n240# 0.04fF
C2016 divbuf_2/a_20640_n1600# divbuf_2/OUT4 0.00fF
C2017 divbuf_2/a_12030_n840# divbuf_2/a_12030_n1540# 0.01fF
C2018 divbuf_2/a_42270_n840# divbuf_2/a_42750_n840# 0.07fF
C2019 divbuf_2/a_42240_n1600# divbuf_2/a_42270_n1540# 0.19fF
C2020 pd_div_0/divbuf_0/a_15870_n1540# pd_div_0/divbuf_0/a_16350_n1540# 0.11fF
C2021 pd_div_0/divbuf_0/a_46590_n840# pd_div_0/divbuf_0/a_46590_n1540# 0.01fF
C2022 pll_full_0/divbuf_1/a_21150_n1540# pll_full_0/divbuf_1/a_21630_n1540# 0.11fF
C2023 pll_full_0/divbuf_1/a_51870_n840# pll_full_0/divbuf_1/a_51870_n1540# 0.01fF
C2024 divbuf_0/a_480_n1600# divbuf_0/IN 0.00fF
C2025 divbuf_0/a_40902_n240# divbuf_0/OUT4 0.04fF
C2026 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/a_23442_n240# 0.01fF
C2027 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56190_n840# 0.04fF
C2028 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2029 divbuf_3/a_12772_170# divbuf_3/a_12772_n240# 0.01fF
C2030 divbuf_3/a_32172_170# divbuf_3/a_32652_170# 0.07fF
C2031 divbuf_1/a_13920_n1600# divbuf_1/a_13950_n1540# 0.19fF
C2032 divbuf_1/a_13950_n840# divbuf_1/a_14430_n840# 0.07fF
C2033 ro_div_0/ro_complete_0/cbank_1/switch_4/vin ro_div_0/divider_0/clk 1.30fF
C2034 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15390_n1540# 0.19fF
C2035 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C2036 ro_div_0/divbuf_0/a_15390_n840# ro_div_0/divbuf_0/a_15870_n840# 0.07fF
C2037 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C2038 divbuf_3/a_4830_n840# divbuf_3/a_5310_n840# 0.07fF
C2039 divbuf_3/a_26352_170# divbuf_3/OUT4 0.19fF
C2040 divbuf_3/a_4800_n1600# divbuf_3/a_4830_n1540# 0.19fF
C2041 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13470_n840# 0.04fF
C2042 ro_complete_0/a5 ro_complete_0/cbank_0/switch_0/vin 0.09fF
C2043 divbuf_0/a_17122_170# divbuf_0/a_17612_170# 0.07fF
C2044 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_18750_n840# 0.04fF
C2045 divbuf_3/a_57630_n1540# divbuf_3/a_58110_n1540# 0.11fF
C2046 divbuf_2/a_990_n840# divbuf_2/OUT2 0.02fF
C2047 divbuf_1/a_36510_n840# divbuf_1/a_36510_n1540# 0.01fF
C2048 divbuf_0/a_39932_n240# divbuf_0/a_40412_n240# 0.05fF
C2049 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/a_34592_n240# 0.05fF
C2050 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n1540# 0.19fF
C2051 divbuf_0/a_51390_n840# divbuf_0/a_51870_n840# 0.07fF
C2052 divbuf_0/a_21150_n840# divbuf_0/a_21150_n1540# 0.01fF
C2053 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_45630_n1540# 0.19fF
C2054 pll_full_0/divbuf_0/a_15390_n840# pll_full_0/divbuf_0/a_15390_n1540# 0.01fF
C2055 pll_full_0/divbuf_0/a_45630_n840# pll_full_0/divbuf_0/a_46110_n840# 0.07fF
C2056 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/a_30712_170# 0.07fF
C2057 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/a_16152_n240# 0.01fF
C2058 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/a_36052_170# 0.07fF
C2059 divbuf_3/a_27322_n240# divbuf_3/OUT4 0.04fF
C2060 divbuf_3/a_55200_n1600# divbuf_3/a_55230_n840# 0.04fF
C2061 divbuf_1/a_58590_n1540# divbuf_1/a_59070_n1540# 0.11fF
C2062 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2063 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_2910_n1540# 0.19fF
C2064 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/a_3390_n840# 0.07fF
C2065 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/and_0/B 0.78fF
C2066 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C2067 ro_div_0/divider_0/tspc_1/Z3 ro_div_0/divider_0/tspc_1/Z4 0.65fF
C2068 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/a3 0.09fF
C2069 ro_complete_0/a1 ro_complete_0/cbank_0/switch_3/vin 0.14fF
C2070 pll_full_0/divbuf_1/a_8190_n840# pll_full_0/divbuf_1/a_8670_n840# 0.07fF
C2071 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2072 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8190_n1540# 0.19fF
C2073 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C2074 divbuf_2/a_28800_n1600# divbuf_2/a_29280_n1600# 0.26fF
C2075 divbuf_2/a_19562_n240# divbuf_2/a_19710_n840# 0.03fF
C2076 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C2077 pd_div_0/divbuf_0/a_55710_n1540# pd_div_0/divbuf_0/a_56190_n1540# 0.11fF
C2078 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/a_2430_n840# 0.03fF
C2079 divbuf_2/a_21150_n1540# divbuf_2/a_21630_n1540# 0.11fF
C2080 divbuf_2/a_51870_n840# divbuf_2/a_51870_n1540# 0.01fF
C2081 divbuf_1/a_480_n1600# divbuf_1/a_960_n1600# 0.26fF
C2082 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_2400_n1600# 0.26fF
C2083 divbuf_3/a_33142_n240# divbuf_3/a_33622_n240# 0.05fF
C2084 divbuf_1/a_53790_n840# divbuf_1/a_54270_n840# 0.07fF
C2085 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55230_n1540# 0.19fF
C2086 ro_div_0/divbuf_0/a_55230_n840# ro_div_0/divbuf_0/a_55710_n840# 0.07fF
C2087 ro_div_0/divbuf_0/a_24990_n840# ro_div_0/divbuf_0/a_24990_n1540# 0.01fF
C2088 divbuf_3/a_44640_n1600# divbuf_3/a_44670_n1540# 0.19fF
C2089 divbuf_3/a_14430_n840# divbuf_3/a_14430_n1540# 0.01fF
C2090 divbuf_3/a_44670_n840# divbuf_3/a_45150_n840# 0.07fF
C2091 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2092 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53310_n840# 0.04fF
C2093 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C2094 divbuf_2/a_18720_n1600# divbuf_2/a_18750_n840# 0.04fF
C2095 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2096 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_58590_n840# 0.04fF
C2097 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C2098 divbuf_0/a_28772_n240# divbuf_0/a_28830_n840# 0.04fF
C2099 divbuf_0/a_37920_n1600# divbuf_0/a_38400_n1600# 0.26fF
C2100 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32640_n1600# 0.26fF
C2101 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/a_23070_n840# 0.03fF
C2102 divbuf_1/a_11312_n240# divbuf_1/a_11070_n840# 0.02fF
C2103 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_12510_n840# 0.01fF
C2104 divbuf_0/a_60990_n840# divbuf_0/a_60990_n1540# 0.01fF
C2105 divbuf_0/a_30270_n1540# divbuf_0/a_30750_n1540# 0.11fF
C2106 pll_full_0/divbuf_0/a_24510_n1540# pll_full_0/divbuf_0/a_24990_n1540# 0.11fF
C2107 pll_full_0/divbuf_0/a_55230_n840# pll_full_0/divbuf_0/a_55230_n1540# 0.01fF
C2108 divbuf_3/a_1352_n240# divbuf_3/a_1470_n840# 0.03fF
C2109 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/a_31682_n240# 0.05fF
C2110 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/a_37022_n240# 0.04fF
C2111 divbuf_2/a_16152_170# divbuf_2/a_16152_n240# 0.01fF
C2112 divbuf_2/a_35562_170# divbuf_2/a_36052_170# 0.07fF
C2113 divbuf_0/a_5362_170# divbuf_0/a_5362_n240# 0.01fF
C2114 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/a_3422_n240# 0.01fF
C2115 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/a_20042_170# 0.07fF
C2116 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C2117 divbuf_2/a_8190_n840# divbuf_2/a_8670_n840# 0.07fF
C2118 divbuf_2/a_33142_170# divbuf_2/OUT4 0.19fF
C2119 divbuf_2/a_8160_n1600# divbuf_2/a_8190_n1540# 0.19fF
C2120 divbuf_1/a_2322_n240# divbuf_1/OUT3 0.04fF
C2121 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C2122 pd_div_0/divbuf_0/a_12510_n840# pd_div_0/divbuf_0/a_12510_n1540# 0.01fF
C2123 pd_div_0/divbuf_0/a_42750_n840# pd_div_0/divbuf_0/a_43230_n840# 0.07fF
C2124 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_42750_n1540# 0.19fF
C2125 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48030_n1540# 0.19fF
C2126 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C2127 pll_full_0/divbuf_1/a_17790_n840# pll_full_0/divbuf_1/a_17790_n1540# 0.01fF
C2128 pll_full_0/divbuf_1/a_48030_n840# pll_full_0/divbuf_1/a_48510_n840# 0.07fF
C2129 divbuf_1/a_9732_170# divbuf_1/a_9242_170# 0.07fF
C2130 pd_div_0/divider_0/and_0/OUT gnd 0.32fF
C2131 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C2132 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/a_7302_170# 0.07fF
C2133 divbuf_0/a_27840_n1600# divbuf_0/a_27870_n840# 0.04fF
C2134 divbuf_0/a_11312_170# divbuf_0/OUT4 0.23fF
C2135 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C2136 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/Out 0.91fF
C2137 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22110_n840# 0.04fF
C2138 divbuf_1/a_40320_n1600# divbuf_1/a_40800_n1600# 0.26fF
C2139 divbuf_1/a_31202_n240# divbuf_1/a_31230_n840# 0.05fF
C2140 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/a_32670_n840# 0.06fF
C2141 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_42240_n1600# 0.26fF
C2142 divbuf_3/a_31200_n1600# divbuf_3/a_31680_n1600# 0.26fF
C2143 divbuf_3/a_21982_n240# divbuf_3/a_22110_n840# 0.03fF
C2144 ro_div_0/divbuf_0/a_34110_n1540# ro_div_0/divbuf_0/a_34590_n1540# 0.11fF
C2145 divbuf_3/a_23550_n1540# divbuf_3/a_24030_n1540# 0.11fF
C2146 divbuf_3/a_54270_n840# divbuf_3/a_54270_n1540# 0.01fF
C2147 divbuf_0/a_25382_170# divbuf_0/a_25382_n240# 0.01fF
C2148 divbuf_0/a_4882_n240# divbuf_0/a_5362_n240# 0.05fF
C2149 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/a_39442_170# 0.07fF
C2150 divbuf_2/a_34112_n240# divbuf_2/OUT4 0.04fF
C2151 divbuf_2/a_58560_n1600# divbuf_2/a_58590_n840# 0.04fF
C2152 divbuf_1/a_32640_n1600# divbuf_1/a_32670_n1540# 0.19fF
C2153 divbuf_1/a_2400_n1600# divbuf_1/OUT2 0.00fF
C2154 divbuf_1/a_1842_170# divbuf_1/a_1842_n240# 0.01fF
C2155 divbuf_1/a_492_n240# divbuf_1/a_960_n1600# 0.00fF
C2156 divbuf_1/a_6822_170# divbuf_1/a_6822_n240# 0.01fF
C2157 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n1540# 0.19fF
C2158 divbuf_0/a_12282_n240# divbuf_0/OUT4 0.04fF
C2159 divbuf_0/a_17310_n840# divbuf_0/a_17790_n840# 0.07fF
C2160 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2161 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_11550_n1540# 0.19fF
C2162 pll_full_0/divbuf_0/a_11550_n840# pll_full_0/divbuf_0/a_12030_n840# 0.07fF
C2163 divbuf_1/a_30240_n1600# divbuf_1/a_30270_n840# 0.04fF
C2164 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_31710_n840# 0.04fF
C2165 ro_div_0/divider_0/nor_1/Z1 gnd 0.01fF
C2166 divbuf_3/a_21120_n1600# divbuf_3/a_21150_n840# 0.04fF
C2167 divbuf_1/a_24510_n1540# divbuf_1/a_24990_n1540# 0.11fF
C2168 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29760_n1600# 0.26fF
C2169 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/a_20190_n840# 0.03fF
C2170 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/a_25470_n840# 0.03fF
C2171 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_35040_n1600# 0.26fF
C2172 divbuf_2/a_36532_n240# divbuf_2/a_37022_n240# 0.04fF
C2173 divbuf_2/a_48000_n1600# divbuf_2/a_48030_n1540# 0.19fF
C2174 divbuf_2/a_32160_n1600# divbuf_2/OUT4 0.00fF
C2175 divbuf_2/a_17790_n840# divbuf_2/a_17790_n1540# 0.01fF
C2176 divbuf_2/a_48030_n840# divbuf_2/a_48510_n840# 0.07fF
C2177 pd_div_0/divbuf_0/a_21630_n1540# pd_div_0/divbuf_0/a_22110_n1540# 0.11fF
C2178 pd_div_0/divbuf_0/a_52350_n840# pd_div_0/divbuf_0/a_52350_n1540# 0.01fF
C2179 pll_full_0/divbuf_1/a_26910_n1540# pll_full_0/divbuf_1/a_27390_n1540# 0.11fF
C2180 pll_full_0/divbuf_1/a_57630_n840# pll_full_0/divbuf_1/a_57630_n1540# 0.01fF
C2181 divbuf_1/a_7302_n240# divbuf_1/a_7792_n240# 0.04fF
C2182 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/a_29262_n240# 0.01fF
C2183 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/a_9242_n240# 0.05fF
C2184 divbuf_0/a_11040_n1600# divbuf_0/OUT3 0.00fF
C2185 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2186 divbuf_3/a_18582_170# divbuf_3/a_18582_n240# 0.01fF
C2187 divbuf_3/a_37992_170# divbuf_3/a_38472_170# 0.07fF
C2188 divbuf_1/a_19710_n840# divbuf_1/a_20190_n840# 0.07fF
C2189 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21150_n1540# 0.19fF
C2190 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2191 ro_div_0/divbuf_0/a_21150_n840# ro_div_0/divbuf_0/a_21630_n840# 0.07fF
C2192 divbuf_3/a_10590_n840# divbuf_3/a_11070_n840# 0.07fF
C2193 divbuf_3/a_37992_170# divbuf_3/OUT4 0.19fF
C2194 divbuf_3/a_10560_n1600# divbuf_3/a_10590_n1540# 0.19fF
C2195 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19230_n840# 0.04fF
C2196 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a2 0.09fF
C2197 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/OUT3 0.19fF
C2198 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24510_n840# 0.04fF
C2199 divbuf_3/OUT3 divbuf_3/OUT4 0.36fF
C2200 divbuf_1/a_42270_n840# divbuf_1/a_42270_n1540# 0.01fF
C2201 divbuf_0/a_3840_n1600# divbuf_0/a_4320_n1600# 0.26fF
C2202 pll_full_0/divbuf_0/a_39932_n240# pll_full_0/divbuf_0/a_40412_n240# 0.05fF
C2203 divbuf_0/a_57150_n840# divbuf_0/a_57630_n840# 0.07fF
C2204 divbuf_0/a_26910_n840# divbuf_0/a_26910_n1540# 0.01fF
C2205 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n1540# 0.19fF
C2206 pll_full_0/divbuf_0/a_21150_n840# pll_full_0/divbuf_0/a_21150_n1540# 0.01fF
C2207 pll_full_0/divbuf_0/a_51390_n840# pll_full_0/divbuf_0/a_51870_n840# 0.07fF
C2208 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51390_n1540# 0.19fF
C2209 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/a_16642_n240# 0.01fF
C2210 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/a_36532_170# 0.07fF
C2211 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/a_21982_n240# 0.01fF
C2212 divbuf_3/a_38962_n240# divbuf_3/OUT4 0.04fF
C2213 pd_div_0/divbuf_0/a_8670_n840# pd_div_0/divbuf_0/a_9150_n840# 0.07fF
C2214 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2215 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_8670_n1540# 0.19fF
C2216 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C2217 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z2 0.14fF
C2218 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/and_0/B 0.31fF
C2219 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C2220 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C2221 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_13950_n1540# 0.19fF
C2222 pll_full_0/divbuf_1/a_13950_n840# pll_full_0/divbuf_1/a_14430_n840# 0.07fF
C2223 divbuf_2/a_25382_n240# divbuf_2/a_25470_n840# 0.03fF
C2224 divbuf_2/a_34560_n1600# divbuf_2/a_35040_n1600# 0.26fF
C2225 divbuf_2/a_26910_n1540# divbuf_2/a_27390_n1540# 0.11fF
C2226 divbuf_2/a_57630_n840# divbuf_2/a_57630_n1540# 0.01fF
C2227 divbuf_0/a_14702_n240# divbuf_0/a_14430_n840# 0.01fF
C2228 divbuf_1/a_6240_n1600# divbuf_1/a_6720_n1600# 0.26fF
C2229 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_8160_n1600# 0.26fF
C2230 divbuf_3/a_38962_n240# divbuf_3/a_39442_n240# 0.05fF
C2231 divbuf_1/a_59550_n840# divbuf_1/a_60030_n840# 0.07fF
C2232 ro_div_0/divbuf_0/a_30750_n840# ro_div_0/divbuf_0/a_30750_n1540# 0.01fF
C2233 divbuf_3/a_20190_n840# divbuf_3/a_20190_n1540# 0.01fF
C2234 divbuf_3/a_50430_n840# divbuf_3/a_50910_n840# 0.07fF
C2235 divbuf_3/a_50400_n1600# divbuf_3/a_50430_n1540# 0.19fF
C2236 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2237 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59070_n840# 0.04fF
C2238 divbuf_2/a_4392_170# divbuf_2/OUT3 0.19fF
C2239 divbuf_2/a_24480_n1600# divbuf_2/a_24510_n840# 0.04fF
C2240 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_4392_170# 0.07fF
C2241 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/nor_1/A 0.55fF
C2242 divbuf_0/a_34592_n240# divbuf_0/a_34590_n840# 0.06fF
C2243 divbuf_0/a_43680_n1600# divbuf_0/a_44160_n1600# 0.26fF
C2244 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C2245 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_38400_n1600# 0.26fF
C2246 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/a_28830_n840# 0.04fF
C2247 divbuf_1/a_17122_n240# divbuf_1/a_16830_n840# 0.00fF
C2248 divbuf_0/a_36030_n1540# divbuf_0/a_36510_n1540# 0.11fF
C2249 pll_full_0/divbuf_0/a_30270_n1540# pll_full_0/divbuf_0/a_30750_n1540# 0.11fF
C2250 pll_full_0/divbuf_0/a_60990_n840# pll_full_0/divbuf_0/a_60990_n1540# 0.01fF
C2251 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/a_37502_n240# 0.05fF
C2252 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_960_n1600# 0.26fF
C2253 divbuf_2/a_21982_170# divbuf_2/a_21982_n240# 0.01fF
C2254 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48510_n1540# 0.19fF
C2255 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C2256 pd_div_0/divbuf_0/a_18270_n840# pd_div_0/divbuf_0/a_18270_n1540# 0.01fF
C2257 pd_div_0/divbuf_0/a_48510_n840# pd_div_0/divbuf_0/a_48990_n840# 0.07fF
C2258 divbuf_2/a_5362_n240# divbuf_2/OUT3 0.04fF
C2259 divbuf_2/a_13920_n1600# divbuf_2/a_13950_n1540# 0.19fF
C2260 divbuf_2/a_13950_n840# divbuf_2/a_14430_n840# 0.07fF
C2261 divbuf_1/a_14702_n240# divbuf_1/OUT4 0.04fF
C2262 pll_full_0/divbuf_1/a_23550_n840# pll_full_0/divbuf_1/a_23550_n1540# 0.01fF
C2263 pll_full_0/divbuf_1/a_53790_n840# pll_full_0/divbuf_1/a_54270_n840# 0.07fF
C2264 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_53790_n1540# 0.19fF
C2265 ro_div_0/ro_complete_0/cbank_2/switch_2/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C2266 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/a_16152_170# 0.07fF
C2267 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_7792_n240# 0.01fF
C2268 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z3 0.05fF
C2269 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z1 0.03fF
C2270 divbuf_0/a_33600_n1600# divbuf_0/a_33630_n840# 0.04fF
C2271 divbuf_0/a_22952_170# divbuf_0/OUT4 0.19fF
C2272 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z3 0.45fF
C2273 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_27870_n840# 0.04fF
C2274 divbuf_1/a_37022_n240# divbuf_1/a_36990_n840# 0.05fF
C2275 divbuf_1/a_46080_n1600# divbuf_1/a_46560_n1600# 0.26fF
C2276 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_48000_n1600# 0.26fF
C2277 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/OUT3 0.19fF
C2278 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/a_38430_n840# 0.04fF
C2279 divbuf_3/a_36960_n1600# divbuf_3/a_37440_n1600# 0.26fF
C2280 divbuf_3/a_27802_n240# divbuf_3/a_27870_n840# 0.04fF
C2281 ro_div_0/divbuf_0/a_39870_n1540# ro_div_0/divbuf_0/a_40350_n1540# 0.11fF
C2282 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11070_n840# 0.02fF
C2283 divbuf_3/a_29310_n1540# divbuf_3/a_29790_n1540# 0.11fF
C2284 divbuf_3/a_60030_n840# divbuf_3/a_60030_n1540# 0.01fF
C2285 divbuf_0/a_31202_170# divbuf_0/a_31202_n240# 0.01fF
C2286 divbuf_0/a_11312_n240# divbuf_0/a_11802_n240# 0.04fF
C2287 pll_full_0/divbuf_0/a_4882_n240# pll_full_0/divbuf_0/a_5362_n240# 0.05fF
C2288 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/a_25382_n240# 0.01fF
C2289 divbuf_1/a_12960_n1600# divbuf_1/OUT4 0.00fF
C2290 divbuf_1/a_38400_n1600# divbuf_1/a_38430_n1540# 0.19fF
C2291 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/a_15672_n240# 0.01fF
C2292 divbuf_0/a_23070_n840# divbuf_0/a_23550_n840# 0.07fF
C2293 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n1540# 0.19fF
C2294 divbuf_0/a_23922_n240# divbuf_0/OUT4 0.04fF
C2295 pll_full_0/divbuf_0/a_17310_n840# pll_full_0/divbuf_0/a_17790_n840# 0.07fF
C2296 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2297 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17310_n1540# 0.19fF
C2298 divbuf_1/a_36000_n1600# divbuf_1/a_36030_n840# 0.04fF
C2299 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/tspc_r_1/Qbar 0.01fF
C2300 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37470_n840# 0.04fF
C2301 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2302 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 gnd 0.17fF
C2303 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/a_6822_170# 0.07fF
C2304 divbuf_3/a_9242_170# divbuf_3/OUT3 0.19fF
C2305 divbuf_3/a_26880_n1600# divbuf_3/a_26910_n840# 0.04fF
C2306 divbuf_1/a_30270_n1540# divbuf_1/a_30750_n1540# 0.11fF
C2307 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/a_25950_n840# 0.03fF
C2308 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35520_n1600# 0.26fF
C2309 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40800_n1600# 0.26fF
C2310 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/a_31230_n840# 0.05fF
C2311 divbuf_2/a_480_n1600# divbuf_2/a_960_n1600# 0.26fF
C2312 divbuf_2/a_23550_n840# divbuf_2/a_23550_n1540# 0.01fF
C2313 divbuf_2/a_53790_n840# divbuf_2/a_54270_n840# 0.07fF
C2314 divbuf_2/a_53760_n1600# divbuf_2/a_53790_n1540# 0.19fF
C2315 pd_div_0/divbuf_0/a_27390_n1540# pd_div_0/divbuf_0/a_27870_n1540# 0.11fF
C2316 pd_div_0/divbuf_0/a_58110_n840# pd_div_0/divbuf_0/a_58110_n1540# 0.01fF
C2317 pll_full_0/divbuf_1/a_32670_n1540# pll_full_0/divbuf_1/a_33150_n1540# 0.11fF
C2318 divbuf_1/a_13742_n240# divbuf_1/a_14222_n240# 0.05fF
C2319 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/a_35082_n240# 0.01fF
C2320 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_15672_n240# 0.04fF
C2321 divbuf_0/a_22080_n1600# divbuf_0/OUT4 0.01fF
C2322 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C2323 divbuf_3/a_3912_n240# divbuf_3/a_4392_n240# 0.05fF
C2324 divbuf_3/a_24412_170# divbuf_3/a_24412_n240# 0.01fF
C2325 divbuf_1/a_25470_n840# divbuf_1/a_25950_n840# 0.07fF
C2326 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_26910_n1540# 0.19fF
C2327 ro_div_0/divbuf_0/a_31682_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2328 ro_div_0/divbuf_0/a_26910_n840# ro_div_0/divbuf_0/a_27390_n840# 0.07fF
C2329 divbuf_3/a_16350_n840# divbuf_3/a_16830_n840# 0.07fF
C2330 divbuf_3/a_10212_n240# divbuf_3/OUT3 0.04fF
C2331 divbuf_3/a_16320_n1600# divbuf_3/a_16350_n1540# 0.19fF
C2332 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2333 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_24990_n840# 0.04fF
C2334 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_0/a_630_n680# 0.04fF
C2335 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2336 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30270_n840# 0.04fF
C2337 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C2338 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C2339 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C2340 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C2341 divbuf_2/a_11312_n240# divbuf_2/a_11070_n840# 0.02fF
C2342 divbuf_0/a_9600_n1600# divbuf_0/a_10080_n1600# 0.26fF
C2343 divbuf_1/a_48030_n840# divbuf_1/a_48030_n1540# 0.01fF
C2344 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_4320_n1600# 0.26fF
C2345 divbuf_0/a_510_n840# divbuf_0/OUT 0.07fF
C2346 divbuf_0/a_32670_n840# divbuf_0/a_32670_n1540# 0.01fF
C2347 divbuf_0/a_1950_n1540# divbuf_0/a_2430_n1540# 0.11fF
C2348 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57150_n1540# 0.19fF
C2349 pll_full_0/divbuf_0/a_26910_n840# pll_full_0/divbuf_0/a_26910_n1540# 0.01fF
C2350 pll_full_0/divbuf_0/a_57150_n840# pll_full_0/divbuf_0/a_57630_n840# 0.07fF
C2351 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/a_1842_n240# 0.04fF
C2352 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/a_22472_n240# 0.01fF
C2353 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/a_7792_n240# 0.04fF
C2354 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/a_27802_n240# 0.01fF
C2355 divbuf_3/a_9120_n1600# divbuf_3/OUT3 0.00fF
C2356 divbuf_2/a_6332_170# divbuf_2/a_6822_170# 0.07fF
C2357 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14430_n1540# 0.19fF
C2358 pd_div_0/divbuf_0/a_14430_n840# pd_div_0/divbuf_0/a_14910_n840# 0.07fF
C2359 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C2360 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/clk 0.04fF
C2361 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C2362 pll_full_0/divbuf_1/a_19710_n840# pll_full_0/divbuf_1/a_20190_n840# 0.07fF
C2363 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2364 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_19710_n1540# 0.19fF
C2365 divbuf_2/a_40320_n1600# divbuf_2/a_40800_n1600# 0.26fF
C2366 divbuf_2/a_31202_n240# divbuf_2/a_31230_n840# 0.05fF
C2367 divbuf_1/a_5852_170# divbuf_1/OUT3 0.19fF
C2368 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C2369 divbuf_2/a_32670_n1540# divbuf_2/a_33150_n1540# 0.11fF
C2370 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_14430_n840# 0.01fF
C2371 divbuf_1/a_12000_n1600# divbuf_1/a_12480_n1600# 0.26fF
C2372 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/a_3870_n840# 0.04fF
C2373 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13920_n1600# 0.26fF
C2374 divbuf_3/a_2880_n1600# divbuf_3/a_3360_n1600# 0.26fF
C2375 divbuf_1/a_4350_n1540# divbuf_1/a_4830_n1540# 0.11fF
C2376 ro_div_0/divbuf_0/a_36510_n840# ro_div_0/divbuf_0/a_36510_n1540# 0.01fF
C2377 ro_div_0/divbuf_0/a_5790_n1540# ro_div_0/divbuf_0/a_6270_n1540# 0.11fF
C2378 divbuf_3/a_56160_n1600# divbuf_3/a_56190_n1540# 0.19fF
C2379 divbuf_3/a_25950_n840# divbuf_3/a_25950_n1540# 0.01fF
C2380 divbuf_3/a_56190_n840# divbuf_3/a_56670_n840# 0.07fF
C2381 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/a_12282_170# 0.07fF
C2382 divbuf_2/a_16152_170# divbuf_2/OUT4 0.19fF
C2383 divbuf_2/a_30240_n1600# divbuf_2/a_30270_n840# 0.04fF
C2384 divbuf_1/a_21982_170# divbuf_1/OUT4 0.19fF
C2385 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/a1 0.14fF
C2386 divbuf_0/a_49440_n1600# divbuf_0/a_49920_n1600# 0.26fF
C2387 divbuf_0/a_40412_n240# divbuf_0/a_40350_n840# 0.04fF
C2388 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C2389 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C2390 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_44160_n1600# 0.26fF
C2391 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/a_34590_n840# 0.06fF
C2392 divbuf_1/a_1920_n1600# divbuf_1/a_1950_n840# 0.04fF
C2393 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3390_n840# 0.04fF
C2394 divbuf_0/a_41790_n1540# divbuf_0/a_42270_n1540# 0.11fF
C2395 pll_full_0/divbuf_0/a_36030_n1540# pll_full_0/divbuf_0/a_36510_n1540# 0.11fF
C2396 divbuf_3/a_13742_n240# divbuf_3/a_13470_n840# 0.01fF
C2397 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_1440_n1600# 0.26fF
C2398 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6720_n1600# 0.26fF
C2399 divbuf_2/a_7302_n240# divbuf_2/a_7792_n240# 0.04fF
C2400 divbuf_2/a_27802_170# divbuf_2/a_27802_n240# 0.01fF
C2401 pd_div_0/divbuf_0/a_24030_n840# pd_div_0/divbuf_0/a_24030_n1540# 0.01fF
C2402 pd_div_0/divbuf_0/a_54270_n840# pd_div_0/divbuf_0/a_54750_n840# 0.07fF
C2403 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54270_n1540# 0.19fF
C2404 divbuf_0/a_15672_170# divbuf_0/a_15672_n240# 0.01fF
C2405 pll_full_0/divbuf_0/a_1842_170# pll_full_0/divbuf_0/a_1842_n240# 0.01fF
C2406 pll_full_0/divbuf_0/a_11802_170# pll_full_0/divbuf_0/a_11802_n240# 0.01fF
C2407 divbuf_2/a_19710_n840# divbuf_2/a_20190_n840# 0.07fF
C2408 divbuf_2/a_17122_n240# divbuf_2/OUT4 0.04fF
C2409 divbuf_2/a_19680_n1600# divbuf_2/a_19710_n1540# 0.19fF
C2410 divbuf_1/a_26352_n240# divbuf_1/OUT4 0.04fF
C2411 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_59550_n1540# 0.19fF
C2412 pll_full_0/divbuf_1/a_29310_n840# pll_full_0/divbuf_1/a_29310_n1540# 0.01fF
C2413 pll_full_0/divbuf_1/a_59550_n840# pll_full_0/divbuf_1/a_60030_n840# 0.07fF
C2414 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/a_20532_170# 0.07fF
C2415 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/B 0.18fF
C2416 pd_div_0/divider_0/tspc_0/Z2 pd_div_0/divider_0/tspc_0/Z3 0.16fF
C2417 divbuf_0/a_39360_n1600# divbuf_0/a_39390_n840# 0.04fF
C2418 divbuf_0/a_34592_170# divbuf_0/OUT4 0.19fF
C2419 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_33630_n840# 0.04fF
C2420 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2421 divbuf_3/a_8762_170# divbuf_3/a_9242_170# 0.07fF
C2422 divbuf_1/a_51840_n1600# divbuf_1/a_52320_n1600# 0.26fF
C2423 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/OUT2 0.42fF
C2424 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53760_n1600# 0.26fF
C2425 divbuf_3/a_42720_n1600# divbuf_3/a_43200_n1600# 0.26fF
C2426 divbuf_3/a_33622_n240# divbuf_3/a_33630_n840# 0.06fF
C2427 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_11550_n840# 0.02fF
C2428 ro_div_0/divbuf_0/a_45630_n1540# ro_div_0/divbuf_0/a_46110_n1540# 0.11fF
C2429 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_16830_n840# 0.00fF
C2430 divbuf_3/a_35070_n1540# divbuf_3/a_35550_n1540# 0.11fF
C2431 divbuf_0/a_37022_170# divbuf_0/a_37022_n240# 0.01fF
C2432 divbuf_0/a_17122_n240# divbuf_0/a_17612_n240# 0.04fF
C2433 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11802_n240# 0.04fF
C2434 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/a_31202_n240# 0.01fF
C2435 divbuf_1/a_44160_n1600# divbuf_1/a_44190_n1540# 0.19fF
C2436 divbuf_1/a_24480_n1600# divbuf_1/OUT4 0.00fF
C2437 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n1540# 0.19fF
C2438 divbuf_0/a_28830_n840# divbuf_0/a_29310_n840# 0.07fF
C2439 divbuf_0/a_35562_n240# divbuf_0/OUT4 0.04fF
C2440 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2441 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23070_n1540# 0.19fF
C2442 pll_full_0/divbuf_0/a_23070_n840# pll_full_0/divbuf_0/a_23550_n840# 0.07fF
C2443 divbuf_1/a_41760_n1600# divbuf_1/a_41790_n840# 0.04fF
C2444 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43230_n840# 0.04fF
C2445 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C2446 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/a_13252_170# 0.07fF
C2447 divbuf_3/a_21012_170# divbuf_3/OUT4 0.19fF
C2448 divbuf_3/a_32640_n1600# divbuf_3/a_32670_n840# 0.04fF
C2449 divbuf_1/a_36030_n1540# divbuf_1/a_36510_n1540# 0.11fF
C2450 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_41280_n1600# 0.26fF
C2451 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/a_31710_n840# 0.05fF
C2452 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/a_36990_n840# 0.05fF
C2453 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46560_n1600# 0.26fF
C2454 divbuf_2/a_6240_n1600# divbuf_2/a_6720_n1600# 0.26fF
C2455 divbuf_2/a_59520_n1600# divbuf_2/a_59550_n1540# 0.19fF
C2456 divbuf_2/a_29310_n840# divbuf_2/a_29310_n1540# 0.01fF
C2457 divbuf_2/a_59550_n840# divbuf_2/a_60030_n840# 0.07fF
C2458 pd_div_0/divbuf_0/a_33150_n1540# pd_div_0/divbuf_0/a_33630_n1540# 0.11fF
C2459 pll_full_0/divbuf_1/a_38430_n1540# pll_full_0/divbuf_1/a_38910_n1540# 0.11fF
C2460 divbuf_1/a_39442_170# divbuf_1/a_39442_n240# 0.01fF
C2461 divbuf_1/a_19562_n240# divbuf_1/a_20042_n240# 0.05fF
C2462 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/a_21502_n240# 0.04fF
C2463 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/a_40902_n240# 0.01fF
C2464 divbuf_0/a_33600_n1600# divbuf_0/OUT4 0.01fF
C2465 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C2466 divbuf_3/a_9732_n240# divbuf_3/a_10212_n240# 0.05fF
C2467 divbuf_3/a_30232_170# divbuf_3/a_30232_n240# 0.01fF
C2468 divbuf_1/a_990_n840# divbuf_1/a_990_n1540# 0.01fF
C2469 divbuf_1/a_31230_n840# divbuf_1/a_31710_n840# 0.07fF
C2470 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C2471 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_32670_n1540# 0.19fF
C2472 ro_div_0/divbuf_0/a_32670_n840# ro_div_0/divbuf_0/a_33150_n840# 0.07fF
C2473 ro_div_0/divbuf_0/a_2430_n840# ro_div_0/divbuf_0/a_2430_n1540# 0.01fF
C2474 divbuf_3/a_21982_n240# divbuf_3/OUT4 0.04fF
C2475 divbuf_3/a_22080_n1600# divbuf_3/a_22110_n1540# 0.19fF
C2476 divbuf_3/a_22110_n840# divbuf_3/a_22590_n840# 0.07fF
C2477 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2478 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_30750_n840# 0.04fF
C2479 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C2480 ro_div_0/divider_0/tspc_1/Z3 ro_div_0/divider_0/tspc_1/Q 0.05fF
C2481 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2482 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36030_n840# 0.04fF
C2483 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C2484 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C2485 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C2486 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C2487 divbuf_2/a_17122_n240# divbuf_2/a_16830_n840# 0.00fF
C2488 divbuf_0/a_5852_n240# divbuf_0/a_5790_n840# 0.04fF
C2489 divbuf_0/a_15360_n1600# divbuf_0/a_15840_n1600# 0.26fF
C2490 divbuf_1/a_53790_n840# divbuf_1/a_53790_n1540# 0.01fF
C2491 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_10080_n1600# 0.26fF
C2492 divbuf_0/a_38430_n840# divbuf_0/a_38430_n1540# 0.01fF
C2493 divbuf_0/a_7710_n1540# divbuf_0/a_8190_n1540# 0.11fF
C2494 pll_full_0/divbuf_0/a_1950_n1540# pll_full_0/divbuf_0/a_2430_n1540# 0.11fF
C2495 pll_full_0/divbuf_0/a_32670_n840# pll_full_0/divbuf_0/a_32670_n1540# 0.01fF
C2496 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/a_8272_n240# 0.05fF
C2497 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/a_28292_n240# 0.01fF
C2498 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_14222_n240# 0.05fF
C2499 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/a_33622_n240# 0.01fF
C2500 divbuf_3/a_20160_n1600# divbuf_3/OUT4 0.00fF
C2501 divbuf_2/a_12772_170# divbuf_2/a_13252_170# 0.07fF
C2502 pd_div_0/divbuf_0/a_20190_n840# pd_div_0/divbuf_0/a_20670_n840# 0.07fF
C2503 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2504 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20190_n1540# 0.19fF
C2505 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2506 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25470_n1540# 0.19fF
C2507 pll_full_0/divbuf_1/a_25470_n840# pll_full_0/divbuf_1/a_25950_n840# 0.07fF
C2508 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/a_4392_170# 0.07fF
C2509 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C2510 divbuf_2/a_37022_n240# divbuf_2/a_36990_n840# 0.05fF
C2511 divbuf_2/a_46080_n1600# divbuf_2/a_46560_n1600# 0.26fF
C2512 divbuf_0/a_5280_n1600# divbuf_0/a_5310_n840# 0.04fF
C2513 divbuf_0/a_18582_170# divbuf_0/OUT4 0.19fF
C2514 divbuf_2/a_38430_n1540# divbuf_2/a_38910_n1540# 0.11fF
C2515 divbuf_1/a_17760_n1600# divbuf_1/a_18240_n1600# 0.26fF
C2516 divbuf_1/a_8272_n240# divbuf_1/a_8190_n840# 0.03fF
C2517 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/a_9630_n840# 0.03fF
C2518 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19680_n1600# 0.26fF
C2519 divbuf_3/a_8640_n1600# divbuf_3/a_9120_n1600# 0.26fF
C2520 divbuf_1/a_10110_n1540# divbuf_1/a_10590_n1540# 0.11fF
C2521 ro_div_0/divbuf_0/a_42270_n840# ro_div_0/divbuf_0/a_42270_n1540# 0.01fF
C2522 ro_div_0/divbuf_0/a_11550_n1540# ro_div_0/divbuf_0/a_12030_n1540# 0.11fF
C2523 divbuf_3/a_510_n840# divbuf_3/OUT2 0.02fF
C2524 divbuf_3/a_990_n1540# divbuf_3/a_1470_n1540# 0.11fF
C2525 divbuf_3/a_31710_n840# divbuf_3/a_31710_n1540# 0.01fF
C2526 divbuf_0/a_21982_170# divbuf_0/a_22472_170# 0.07fF
C2527 divbuf_0/a_2322_170# divbuf_0/a_2322_n240# 0.01fF
C2528 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/a_18092_170# 0.07fF
C2529 divbuf_2/a_27802_170# divbuf_2/OUT4 0.19fF
C2530 divbuf_2/a_36000_n1600# divbuf_2/a_36030_n840# 0.04fF
C2531 divbuf_1/a_37022_170# divbuf_1/OUT4 0.19fF
C2532 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C2533 gnd pll_full_0/divider_0/and_0/OUT 0.32fF
C2534 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C2535 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/a_630_n680# 0.01fF
C2536 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/Out 0.11fF
C2537 divbuf_0/a_55200_n1600# divbuf_0/a_55680_n1600# 0.26fF
C2538 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C2539 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/a_40350_n840# 0.04fF
C2540 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49920_n1600# 0.26fF
C2541 pll_full_0/divbuf_0/a_3422_170# pll_full_0/divbuf_0/OUT3 0.23fF
C2542 divbuf_1/a_7680_n1600# divbuf_1/a_7710_n840# 0.04fF
C2543 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9150_n840# 0.04fF
C2544 divbuf_0/a_47550_n1540# divbuf_0/a_48030_n1540# 0.11fF
C2545 pll_full_0/divbuf_0/a_41790_n1540# pll_full_0/divbuf_0/a_42270_n1540# 0.11fF
C2546 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_7200_n1600# 0.26fF
C2547 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12480_n1600# 0.26fF
C2548 divbuf_2/a_13742_n240# divbuf_2/a_14222_n240# 0.05fF
C2549 divbuf_2/a_33622_170# divbuf_2/a_33622_n240# 0.01fF
C2550 pd_div_0/divbuf_0/a_29790_n840# pd_div_0/divbuf_0/a_29790_n1540# 0.01fF
C2551 pd_div_0/divbuf_0/a_60030_n840# pd_div_0/divbuf_0/a_60510_n840# 0.07fF
C2552 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60030_n1540# 0.19fF
C2553 pll_full_0/divbuf_1/a_4350_n1540# pll_full_0/divbuf_1/a_4830_n1540# 0.11fF
C2554 pll_full_0/divbuf_1/a_35070_n840# pll_full_0/divbuf_1/a_35070_n1540# 0.01fF
C2555 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/a_17612_n240# 0.01fF
C2556 divbuf_2/a_28772_n240# divbuf_2/OUT4 0.04fF
C2557 divbuf_2/a_25440_n1600# divbuf_2/a_25470_n1540# 0.19fF
C2558 divbuf_2/a_25470_n840# divbuf_2/a_25950_n840# 0.07fF
C2559 divbuf_1/a_37992_n240# divbuf_1/OUT4 0.04fF
C2560 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/a_26352_170# 0.07fF
C2561 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_12772_n240# 0.01fF
C2562 divbuf_3/a_15182_170# divbuf_3/a_15672_170# 0.07fF
C2563 divbuf_1/a_21012_170# divbuf_1/a_21502_170# 0.07fF
C2564 divbuf_1/a_30712_170# divbuf_1/a_30712_n240# 0.01fF
C2565 divbuf_0/a_45120_n1600# divbuf_0/a_45150_n840# 0.04fF
C2566 divbuf_0/a_6822_n240# divbuf_0/OUT3 0.04fF
C2567 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2568 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39390_n840# 0.04fF
C2569 divbuf_1/a_57600_n1600# divbuf_1/a_58080_n1600# 0.26fF
C2570 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/DOWN 0.03fF
C2571 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59520_n1600# 0.26fF
C2572 ro_div_0/divbuf_0/a_15182_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2573 divbuf_3/a_39442_n240# divbuf_3/a_39390_n840# 0.04fF
C2574 divbuf_3/a_48480_n1600# divbuf_3/a_48960_n1600# 0.26fF
C2575 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_17310_n840# 0.00fF
C2576 ro_div_0/divbuf_0/a_51390_n1540# ro_div_0/divbuf_0/a_51870_n1540# 0.11fF
C2577 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_1950_n840# 0.04fF
C2578 divbuf_3/a_40830_n1540# divbuf_3/a_41310_n1540# 0.11fF
C2579 divbuf_0/a_22952_n240# divbuf_0/a_23442_n240# 0.04fF
C2580 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_17612_n240# 0.04fF
C2581 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/a_37022_n240# 0.01fF
C2582 divbuf_1/a_36000_n1600# divbuf_1/OUT4 0.00fF
C2583 divbuf_1/a_19710_n840# divbuf_1/a_19710_n1540# 0.01fF
C2584 divbuf_1/a_49920_n1600# divbuf_1/a_49950_n1540# 0.19fF
C2585 divbuf_1/a_23442_170# divbuf_1/a_23442_n240# 0.01fF
C2586 divbuf_0/a_34590_n840# divbuf_0/a_35070_n840# 0.07fF
C2587 divbuf_0/a_4350_n840# divbuf_0/a_4350_n1540# 0.01fF
C2588 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n1540# 0.19fF
C2589 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2590 pll_full_0/divbuf_0/a_28830_n840# pll_full_0/divbuf_0/a_29310_n840# 0.07fF
C2591 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_28830_n1540# 0.19fF
C2592 divbuf_1/a_47520_n1600# divbuf_1/a_47550_n840# 0.04fF
C2593 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_48990_n840# 0.04fF
C2594 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2595 ro_div_0/divider_0/prescaler_0/Out gnd 0.46fF
C2596 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/a_19072_170# 0.07fF
C2597 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C2598 divbuf_3/a_32652_170# divbuf_3/OUT4 0.19fF
C2599 divbuf_3/a_38400_n1600# divbuf_3/a_38430_n840# 0.04fF
C2600 divbuf_1/a_41790_n1540# divbuf_1/a_42270_n1540# 0.11fF
C2601 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/a_37470_n840# 0.05fF
C2602 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_47040_n1600# 0.26fF
C2603 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C2604 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_52320_n1600# 0.26fF
C2605 divbuf_2/a_12000_n1600# divbuf_2/a_12480_n1600# 0.26fF
C2606 pd_div_0/divbuf_0/a_38910_n1540# pd_div_0/divbuf_0/a_39390_n1540# 0.11fF
C2607 divbuf_2/a_4350_n1540# divbuf_2/a_4830_n1540# 0.11fF
C2608 divbuf_2/a_35070_n840# divbuf_2/a_35070_n1540# 0.01fF
C2609 pll_full_0/divbuf_1/a_44190_n1540# pll_full_0/divbuf_1/a_44670_n1540# 0.11fF
C2610 divbuf_1/a_25382_n240# divbuf_1/a_25862_n240# 0.05fF
C2611 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/a_27322_n240# 0.04fF
C2612 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C2613 divbuf_3/a_16152_n240# divbuf_3/a_16642_n240# 0.04fF
C2614 divbuf_3/a_36052_170# divbuf_3/a_36052_n240# 0.01fF
C2615 divbuf_1/a_6750_n840# divbuf_1/a_6750_n1540# 0.01fF
C2616 divbuf_1/a_36990_n840# divbuf_1/a_37470_n840# 0.07fF
C2617 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38430_n1540# 0.19fF
C2618 ro_div_0/divbuf_0/a_38430_n840# ro_div_0/divbuf_0/a_38910_n840# 0.07fF
C2619 ro_div_0/divbuf_0/a_8190_n840# ro_div_0/divbuf_0/a_8190_n1540# 0.01fF
C2620 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C2621 divbuf_3/a_33622_n240# divbuf_3/OUT4 0.04fF
C2622 divbuf_3/a_27870_n840# divbuf_3/a_28350_n840# 0.07fF
C2623 divbuf_3/a_27840_n1600# divbuf_3/a_27870_n1540# 0.19fF
C2624 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2625 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36510_n840# 0.04fF
C2626 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_2/Z4 0.02fF
C2627 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2628 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_41790_n840# 0.04fF
C2629 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/a_8762_170# 0.07fF
C2630 divbuf_2/a_1920_n1600# divbuf_2/a_1950_n840# 0.04fF
C2631 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C2632 divbuf_0/a_11802_n240# divbuf_0/a_12030_n840# 0.02fF
C2633 divbuf_0/a_21120_n1600# divbuf_0/a_21600_n1600# 0.26fF
C2634 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15840_n1600# 0.26fF
C2635 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/a_5790_n840# 0.04fF
C2636 divbuf_1/a_59550_n840# divbuf_1/a_59550_n1540# 0.01fF
C2637 divbuf_0/a_44190_n840# divbuf_0/a_44190_n1540# 0.01fF
C2638 divbuf_0/a_13470_n1540# divbuf_0/a_13950_n1540# 0.11fF
C2639 pll_full_0/divbuf_0/a_7710_n1540# pll_full_0/divbuf_0/a_8190_n1540# 0.11fF
C2640 pll_full_0/divbuf_0/a_38430_n840# pll_full_0/divbuf_0/a_38430_n1540# 0.01fF
C2641 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_14702_n240# 0.05fF
C2642 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/a_34112_n240# 0.01fF
C2643 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/a_39442_n240# 0.01fF
C2644 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/a_20042_n240# 0.05fF
C2645 divbuf_3/a_31680_n1600# divbuf_3/OUT4 0.00fF
C2646 divbuf_2/a_18582_170# divbuf_2/a_19072_170# 0.07fF
C2647 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_25950_n1540# 0.19fF
C2648 pd_div_0/divbuf_0/a_25950_n840# pd_div_0/divbuf_0/a_26430_n840# 0.07fF
C2649 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2650 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C2651 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2652 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/a_990_n1540# 0.01fF
C2653 pll_full_0/divbuf_1/a_31230_n840# pll_full_0/divbuf_1/a_31710_n840# 0.07fF
C2654 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31230_n1540# 0.19fF
C2655 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C2656 divbuf_2/a_51840_n1600# divbuf_2/a_52320_n1600# 0.26fF
C2657 divbuf_0/a_11040_n1600# divbuf_0/a_11070_n840# 0.04fF
C2658 divbuf_2/a_44190_n1540# divbuf_2/a_44670_n1540# 0.11fF
C2659 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z2 0.14fF
C2660 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5310_n840# 0.04fF
C2661 divbuf_1/a_14222_n240# divbuf_1/a_14430_n840# 0.02fF
C2662 divbuf_1/a_23520_n1600# divbuf_1/a_24000_n1600# 0.26fF
C2663 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_15870_n840# 0.02fF
C2664 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_25440_n1600# 0.26fF
C2665 divbuf_3/a_14400_n1600# divbuf_3/a_14880_n1600# 0.26fF
C2666 divbuf_3/a_4882_n240# divbuf_3/a_4830_n840# 0.04fF
C2667 ro_div_0/divbuf_0/a_48030_n840# ro_div_0/divbuf_0/a_48030_n1540# 0.01fF
C2668 ro_div_0/divbuf_0/a_17310_n1540# ro_div_0/divbuf_0/a_17790_n1540# 0.11fF
C2669 divbuf_3/a_6750_n1540# divbuf_3/a_7230_n1540# 0.11fF
C2670 divbuf_3/a_37470_n840# divbuf_3/a_37470_n1540# 0.01fF
C2671 divbuf_0/a_27802_170# divbuf_0/a_28292_170# 0.07fF
C2672 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/a_22472_170# 0.07fF
C2673 divbuf_2/a_39442_170# divbuf_2/OUT4 0.19fF
C2674 divbuf_2/a_41760_n1600# divbuf_2/a_41790_n840# 0.04fF
C2675 divbuf_1/a_9242_n240# divbuf_1/OUT3 0.04fF
C2676 divbuf_1/a_15840_n1600# divbuf_1/a_15870_n1540# 0.19fF
C2677 ro_div_0/ro_complete_0/a1 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C2678 divbuf_0/a_15182_170# divbuf_0/OUT4 0.19fF
C2679 divbuf_0/a_480_n1600# divbuf_0/a_510_n1540# 0.19fF
C2680 divbuf_0/a_510_n840# divbuf_0/a_990_n840# 0.07fF
C2681 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_0/Z3 0.38fF
C2682 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55680_n1600# 0.26fF
C2683 divbuf_1/a_13440_n1600# divbuf_1/a_13470_n840# 0.04fF
C2684 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_14910_n840# 0.04fF
C2685 divbuf_0/a_53310_n1540# divbuf_0/a_53790_n1540# 0.11fF
C2686 pll_full_0/divbuf_0/a_47550_n1540# pll_full_0/divbuf_0/a_48030_n1540# 0.11fF
C2687 divbuf_3/a_4320_n1600# divbuf_3/a_4350_n840# 0.04fF
C2688 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12960_n1600# 0.26fF
C2689 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_18240_n1600# 0.26fF
C2690 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/a_8190_n840# 0.03fF
C2691 divbuf_2/a_39442_170# divbuf_2/a_39442_n240# 0.01fF
C2692 divbuf_2/a_19562_n240# divbuf_2/a_20042_n240# 0.05fF
C2693 pd_div_0/divbuf_0/a_4830_n1540# pd_div_0/divbuf_0/a_5310_n1540# 0.11fF
C2694 pd_div_0/divbuf_0/a_35550_n840# pd_div_0/divbuf_0/a_35550_n1540# 0.01fF
C2695 pll_full_0/divbuf_1/a_10110_n1540# pll_full_0/divbuf_1/a_10590_n1540# 0.11fF
C2696 pll_full_0/divbuf_1/a_40830_n840# pll_full_0/divbuf_1/a_40830_n1540# 0.01fF
C2697 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_480_n1600# 0.00fF
C2698 divbuf_2/a_40412_n240# divbuf_2/OUT4 0.04fF
C2699 divbuf_2/a_990_n840# divbuf_2/a_990_n1540# 0.01fF
C2700 divbuf_2/a_31230_n840# divbuf_2/a_31710_n840# 0.07fF
C2701 divbuf_2/a_31200_n1600# divbuf_2/a_31230_n1540# 0.19fF
C2702 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/a_32172_170# 0.07fF
C2703 divbuf_3/a_21012_170# divbuf_3/a_21502_170# 0.07fF
C2704 divbuf_1/a_26832_170# divbuf_1/a_27322_170# 0.07fF
C2705 divbuf_0/a_50880_n1600# divbuf_0/a_50910_n840# 0.04fF
C2706 divbuf_0/a_18582_n240# divbuf_0/OUT4 0.04fF
C2707 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C2708 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45150_n840# 0.04fF
C2709 divbuf_1/a_2880_n1600# divbuf_1/a_2910_n1540# 0.19fF
C2710 divbuf_1/a_2910_n840# divbuf_1/a_3390_n840# 0.07fF
C2711 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4350_n1540# 0.19fF
C2712 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2713 ro_div_0/divbuf_0/a_4350_n840# ro_div_0/divbuf_0/a_4830_n840# 0.07fF
C2714 divbuf_3/a_54240_n1600# divbuf_3/a_54720_n1600# 0.26fF
C2715 divbuf_3/a_3912_170# divbuf_3/OUT3 0.19fF
C2716 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2430_n840# 0.04fF
C2717 ro_div_0/divbuf_0/a_57150_n1540# ro_div_0/divbuf_0/a_57630_n1540# 0.11fF
C2718 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_7710_n840# 0.04fF
C2719 divbuf_3/a_46590_n1540# divbuf_3/a_47070_n1540# 0.11fF
C2720 divbuf_0/a_28772_n240# divbuf_0/a_29262_n240# 0.04fF
C2721 pll_full_0/divbuf_0/a_22952_n240# pll_full_0/divbuf_0/a_23442_n240# 0.04fF
C2722 divbuf_1/a_25470_n840# divbuf_1/a_25470_n1540# 0.01fF
C2723 divbuf_1/a_55680_n1600# divbuf_1/a_55710_n1540# 0.19fF
C2724 divbuf_1/a_29262_170# divbuf_1/a_29262_n240# 0.01fF
C2725 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n1540# 0.19fF
C2726 divbuf_0/a_40350_n840# divbuf_0/a_40830_n840# 0.07fF
C2727 divbuf_0/a_10110_n840# divbuf_0/a_10110_n1540# 0.01fF
C2728 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_34590_n1540# 0.19fF
C2729 pll_full_0/divbuf_0/a_4350_n840# pll_full_0/divbuf_0/a_4350_n1540# 0.01fF
C2730 pll_full_0/divbuf_0/a_34590_n840# pll_full_0/divbuf_0/a_35070_n840# 0.07fF
C2731 divbuf_1/a_53280_n1600# divbuf_1/a_53310_n840# 0.04fF
C2732 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/a_19562_170# 0.07fF
C2733 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_54750_n840# 0.04fF
C2734 ro_div_0/divbuf_0/a_26352_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2735 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/a_4392_n240# 0.01fF
C2736 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/a_24892_170# 0.07fF
C2737 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.61fF
C2738 divbuf_3/a_4882_n240# divbuf_3/OUT3 0.04fF
C2739 divbuf_3/a_44160_n1600# divbuf_3/a_44190_n840# 0.04fF
C2740 divbuf_1/a_47550_n1540# divbuf_1/a_48030_n1540# 0.11fF
C2741 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52800_n1600# 0.26fF
C2742 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C2743 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/OUT4 0.07fF
C2744 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_58080_n1600# 0.26fF
C2745 divbuf_2/a_17760_n1600# divbuf_2/a_18240_n1600# 0.26fF
C2746 divbuf_2/a_8272_n240# divbuf_2/a_8190_n840# 0.03fF
C2747 pd_div_0/divbuf_0/a_44670_n1540# pd_div_0/divbuf_0/a_45150_n1540# 0.11fF
C2748 divbuf_2/a_10110_n1540# divbuf_2/a_10590_n1540# 0.11fF
C2749 divbuf_2/a_40830_n840# divbuf_2/a_40830_n1540# 0.01fF
C2750 pll_full_0/divbuf_1/a_49950_n1540# pll_full_0/divbuf_1/a_50430_n1540# 0.11fF
C2751 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/a_33142_n240# 0.04fF
C2752 divbuf_1/a_31202_n240# divbuf_1/a_31682_n240# 0.05fF
C2753 divbuf_3/a_21982_n240# divbuf_3/a_22472_n240# 0.04fF
C2754 divbuf_1/a_12510_n840# divbuf_1/a_12510_n1540# 0.01fF
C2755 divbuf_1/a_42750_n840# divbuf_1/a_43230_n840# 0.07fF
C2756 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_960_n1600# 0.00fF
C2757 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C2758 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44190_n1540# 0.19fF
C2759 ro_div_0/divbuf_0/a_44190_n840# ro_div_0/divbuf_0/a_44670_n840# 0.07fF
C2760 ro_div_0/divbuf_0/a_13950_n840# ro_div_0/divbuf_0/a_13950_n1540# 0.01fF
C2761 divbuf_3/a_33600_n1600# divbuf_3/a_33630_n1540# 0.19fF
C2762 divbuf_3/a_3390_n840# divbuf_3/a_3390_n1540# 0.01fF
C2763 divbuf_3/a_33630_n840# divbuf_3/a_34110_n840# 0.07fF
C2764 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/OUT4 0.19fF
C2765 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42270_n840# 0.04fF
C2766 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/tspc_0/Z3 0.05fF
C2767 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2768 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_47550_n840# 0.04fF
C2769 divbuf_2/a_7680_n1600# divbuf_2/a_7710_n840# 0.04fF
C2770 divbuf_1/a_31202_170# divbuf_1/OUT4 0.19fF
C2771 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C2772 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C2773 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C2774 cp_0/a_1710_0# cp_0/out 0.84fF
C2775 divbuf_0/a_17612_n240# divbuf_0/a_17790_n840# 0.02fF
C2776 divbuf_0/a_26880_n1600# divbuf_0/a_27360_n1600# 0.26fF
C2777 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21600_n1600# 0.26fF
C2778 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_12030_n840# 0.02fF
C2779 divbuf_0/a_49950_n840# divbuf_0/a_49950_n1540# 0.01fF
C2780 divbuf_0/a_19230_n1540# divbuf_0/a_19710_n1540# 0.11fF
C2781 pll_full_0/divbuf_0/a_13470_n1540# pll_full_0/divbuf_0/a_13950_n1540# 0.11fF
C2782 pll_full_0/divbuf_0/a_44190_n840# pll_full_0/divbuf_0/a_44190_n1540# 0.01fF
C2783 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/a_39932_n240# 0.01fF
C2784 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/a_20532_n240# 0.04fF
C2785 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/a_25862_n240# 0.05fF
C2786 divbuf_2/a_4392_170# divbuf_2/a_4392_n240# 0.01fF
C2787 divbuf_2/a_24412_170# divbuf_2/a_24892_170# 0.07fF
C2788 pd_div_0/divbuf_0/a_1470_n840# pd_div_0/divbuf_0/a_1470_n1540# 0.01fF
C2789 pd_div_0/divbuf_0/a_31710_n840# pd_div_0/divbuf_0/a_32190_n840# 0.07fF
C2790 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_31710_n1540# 0.19fF
C2791 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2792 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C2793 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_36990_n1540# 0.19fF
C2794 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/OUT3 0.01fF
C2795 pll_full_0/divbuf_1/a_6750_n840# pll_full_0/divbuf_1/a_6750_n1540# 0.01fF
C2796 pll_full_0/divbuf_1/a_36990_n840# pll_full_0/divbuf_1/a_37470_n840# 0.07fF
C2797 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C2798 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C2799 divbuf_2/a_10212_170# divbuf_2/OUT4 0.07fF
C2800 divbuf_2/a_57600_n1600# divbuf_2/a_58080_n1600# 0.26fF
C2801 divbuf_0/a_16800_n1600# divbuf_0/a_16830_n840# 0.04fF
C2802 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11070_n840# 0.04fF
C2803 divbuf_2/a_49950_n1540# divbuf_2/a_50430_n1540# 0.11fF
C2804 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C2805 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/nor_1/A 1.21fF
C2806 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C2807 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C2808 divbuf_1/a_29280_n1600# divbuf_1/a_29760_n1600# 0.26fF
C2809 divbuf_1/a_20042_n240# divbuf_1/a_20190_n840# 0.03fF
C2810 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/a_21630_n840# 0.03fF
C2811 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_31200_n1600# 0.26fF
C2812 divbuf_3/a_20160_n1600# divbuf_3/a_20640_n1600# 0.26fF
C2813 ro_div_0/divbuf_0/a_53790_n840# ro_div_0/divbuf_0/a_53790_n1540# 0.01fF
C2814 ro_div_0/divbuf_0/a_23070_n1540# ro_div_0/divbuf_0/a_23550_n1540# 0.11fF
C2815 divbuf_3/a_12510_n1540# divbuf_3/a_12990_n1540# 0.11fF
C2816 divbuf_3/a_43230_n840# divbuf_3/a_43230_n1540# 0.01fF
C2817 divbuf_0/a_33622_170# divbuf_0/a_34112_170# 0.07fF
C2818 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/a_28292_170# 0.07fF
C2819 pll_full_0/divbuf_0/a_7302_170# pll_full_0/divbuf_0/a_7302_n240# 0.01fF
C2820 divbuf_2/a_11802_n240# divbuf_2/OUT4 0.04fF
C2821 divbuf_2/a_47520_n1600# divbuf_2/a_47550_n840# 0.04fF
C2822 divbuf_1/a_21012_n240# divbuf_1/OUT4 0.04fF
C2823 divbuf_1/a_21600_n1600# divbuf_1/a_21630_n1540# 0.19fF
C2824 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n1540# 0.19fF
C2825 divbuf_0/a_29262_170# divbuf_0/OUT4 0.19fF
C2826 divbuf_0/a_6270_n840# divbuf_0/a_6750_n840# 0.07fF
C2827 divbuf_1/a_16642_170# divbuf_1/a_16642_n240# 0.01fF
C2828 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2829 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/a_990_n840# 0.07fF
C2830 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_510_n1540# 0.19fF
C2831 divbuf_1/a_19200_n1600# divbuf_1/a_19230_n840# 0.04fF
C2832 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_20670_n840# 0.04fF
C2833 divbuf_0/a_59070_n1540# divbuf_0/a_59550_n1540# 0.11fF
C2834 pll_full_0/divbuf_0/a_53310_n1540# pll_full_0/divbuf_0/a_53790_n1540# 0.11fF
C2835 divbuf_3/a_10080_n1600# divbuf_3/a_10110_n840# 0.04fF
C2836 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18720_n1600# 0.26fF
C2837 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/a_8670_n840# 0.03fF
C2838 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_14430_n840# 0.02fF
C2839 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_24000_n1600# 0.26fF
C2840 divbuf_3/a_510_n1540# divbuf_3/OUT 0.11fF
C2841 divbuf_2/a_25382_n240# divbuf_2/a_25862_n240# 0.05fF
C2842 pd_div_0/divbuf_0/a_10590_n1540# pd_div_0/divbuf_0/a_11070_n1540# 0.11fF
C2843 pd_div_0/divbuf_0/a_41310_n840# pd_div_0/divbuf_0/a_41310_n1540# 0.01fF
C2844 pll_full_0/divbuf_1/a_15870_n1540# pll_full_0/divbuf_1/a_16350_n1540# 0.11fF
C2845 pll_full_0/divbuf_1/a_46590_n840# pll_full_0/divbuf_1/a_46590_n1540# 0.01fF
C2846 divbuf_2/a_36960_n1600# divbuf_2/a_36990_n1540# 0.19fF
C2847 divbuf_2/a_10560_n1600# divbuf_2/OUT3 0.01fF
C2848 divbuf_2/a_6750_n840# divbuf_2/a_6750_n1540# 0.01fF
C2849 divbuf_2/a_36990_n840# divbuf_2/a_37470_n840# 0.07fF
C2850 divbuf_1/a_19200_n1600# divbuf_1/OUT4 0.00fF
C2851 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/a_37992_170# 0.07fF
C2852 divbuf_0/a_56640_n1600# divbuf_0/a_56670_n840# 0.04fF
C2853 divbuf_0/a_30232_n240# divbuf_0/OUT4 0.04fF
C2854 divbuf_3/a_6822_170# divbuf_3/a_6822_n240# 0.01fF
C2855 divbuf_3/a_26832_170# divbuf_3/a_27322_170# 0.07fF
C2856 divbuf_1/a_36052_170# divbuf_1/a_36532_170# 0.07fF
C2857 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C2858 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_50910_n840# 0.04fF
C2859 divbuf_1/a_8670_n840# divbuf_1/a_9150_n840# 0.07fF
C2860 divbuf_1/a_8640_n1600# divbuf_1/a_8670_n1540# 0.19fF
C2861 ro_div_0/ro_complete_0/a2 ro_div_0/divider_0/clk 0.05fF
C2862 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10110_n1540# 0.19fF
C2863 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/OUT4 0.19fF
C2864 ro_div_0/divbuf_0/a_10110_n840# ro_div_0/divbuf_0/a_10590_n840# 0.07fF
C2865 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 gnd 0.16fF
C2866 divbuf_3/a_15672_170# divbuf_3/OUT4 0.19fF
C2867 divbuf_3/a_60000_n1600# divbuf_3/a_60480_n1600# 0.26fF
C2868 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8190_n840# 0.04fF
C2869 ro_div_0/divbuf_0/OUT2 ro_div_0/divbuf_0/OUT3 0.36fF
C2870 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13470_n840# 0.04fF
C2871 divbuf_3/a_52350_n1540# divbuf_3/a_52830_n1540# 0.11fF
C2872 divbuf_0/a_34592_n240# divbuf_0/a_35082_n240# 0.04fF
C2873 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/a_29262_n240# 0.04fF
C2874 divbuf_1/a_31230_n840# divbuf_1/a_31230_n1540# 0.01fF
C2875 divbuf_0/a_46110_n840# divbuf_0/a_46590_n840# 0.07fF
C2876 divbuf_0/a_15870_n840# divbuf_0/a_15870_n1540# 0.01fF
C2877 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n1540# 0.19fF
C2878 pll_full_0/divbuf_0/a_10110_n840# pll_full_0/divbuf_0/a_10110_n1540# 0.01fF
C2879 pll_full_0/divbuf_0/a_40350_n840# pll_full_0/divbuf_0/a_40830_n840# 0.07fF
C2880 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40350_n1540# 0.19fF
C2881 divbuf_1/a_59040_n1600# divbuf_1/a_59070_n840# 0.04fF
C2882 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/a_25382_170# 0.07fF
C2883 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/a_60510_n840# 0.04fF
C2884 ro_div_0/divbuf_0/a_37992_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C2885 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/a_10212_n240# 0.01fF
C2886 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/a_30712_170# 0.07fF
C2887 divbuf_3/a_16642_n240# divbuf_3/OUT4 0.04fF
C2888 divbuf_3/a_49920_n1600# divbuf_3/a_49950_n840# 0.04fF
C2889 divbuf_1/a_53310_n1540# divbuf_1/a_53790_n1540# 0.11fF
C2890 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/OUT3 0.19fF
C2891 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58560_n1600# 0.26fF
C2892 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C2893 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_0/a_630_n680# 0.01fF
C2894 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/OUT4 0.19fF
C2895 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_2910_n1540# 0.19fF
C2896 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/a_3390_n840# 0.07fF
C2897 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C2898 divbuf_2/a_14222_n240# divbuf_2/a_14430_n840# 0.02fF
C2899 divbuf_2/a_23520_n1600# divbuf_2/a_24000_n1600# 0.26fF
C2900 pd_div_0/divbuf_0/a_50430_n1540# pd_div_0/divbuf_0/a_50910_n1540# 0.11fF
C2901 pll_full_0/divbuf_1/a_55710_n1540# pll_full_0/divbuf_1/a_56190_n1540# 0.11fF
C2902 divbuf_2/a_15870_n1540# divbuf_2/a_16350_n1540# 0.11fF
C2903 divbuf_2/a_46590_n840# divbuf_2/a_46590_n1540# 0.01fF
C2904 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/a_38962_n240# 0.04fF
C2905 divbuf_1/a_37022_n240# divbuf_1/a_37502_n240# 0.05fF
C2906 divbuf_3/a_27802_n240# divbuf_3/a_28292_n240# 0.04fF
C2907 divbuf_1/a_48510_n840# divbuf_1/a_48990_n840# 0.07fF
C2908 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_49950_n1540# 0.19fF
C2909 ro_div_0/divbuf_0/a_49950_n840# ro_div_0/divbuf_0/a_50430_n840# 0.07fF
C2910 ro_div_0/divbuf_0/a_19710_n840# ro_div_0/divbuf_0/a_19710_n1540# 0.01fF
C2911 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C2912 divbuf_3/a_9150_n840# divbuf_3/a_9150_n1540# 0.01fF
C2913 divbuf_3/a_39390_n840# divbuf_3/a_39870_n840# 0.07fF
C2914 divbuf_3/a_39360_n1600# divbuf_3/a_39390_n1540# 0.19fF
C2915 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C2916 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48030_n840# 0.04fF
C2917 ro_div_0/divider_0/tspc_2/Z3 ro_div_0/divbuf_0/IN 0.05fF
C2918 ro_div_0/divider_0/tspc_2/Z2 ro_div_0/divider_0/tspc_2/Z4 0.36fF
C2919 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C2920 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53310_n840# 0.04fF
C2921 divbuf_2/a_13440_n1600# divbuf_2/a_13470_n840# 0.04fF
C2922 divbuf_1/a_2322_170# divbuf_1/OUT3 0.07fF
C2923 divbuf_0/a_23442_n240# divbuf_0/a_23550_n840# 0.03fF
C2924 divbuf_0/a_32640_n1600# divbuf_0/a_33120_n1600# 0.26fF
C2925 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_27360_n1600# 0.26fF
C2926 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_17790_n840# 0.02fF
C2927 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C2928 divbuf_0/a_55710_n840# divbuf_0/a_55710_n1540# 0.01fF
C2929 divbuf_0/a_24990_n1540# divbuf_0/a_25470_n1540# 0.11fF
C2930 pll_full_0/divbuf_0/a_19230_n1540# pll_full_0/divbuf_0/a_19710_n1540# 0.11fF
C2931 pll_full_0/divbuf_0/a_49950_n840# pll_full_0/divbuf_0/a_49950_n1540# 0.01fF
C2932 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/a_26352_n240# 0.04fF
C2933 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/a_31682_n240# 0.05fF
C2934 divbuf_2/a_10212_170# divbuf_2/a_10212_n240# 0.01fF
C2935 divbuf_2/a_30232_170# divbuf_2/a_30712_170# 0.07fF
C2936 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C2937 pd_div_0/divbuf_0/a_7230_n840# pd_div_0/divbuf_0/a_7230_n1540# 0.01fF
C2938 pd_div_0/divbuf_0/a_37470_n840# pd_div_0/divbuf_0/a_37950_n840# 0.07fF
C2939 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37470_n1540# 0.19fF
C2940 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C2941 pll_full_0/divbuf_1/a_12510_n840# pll_full_0/divbuf_1/a_12510_n1540# 0.01fF
C2942 pll_full_0/divbuf_1/a_42750_n840# pll_full_0/divbuf_1/a_43230_n840# 0.07fF
C2943 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_42750_n1540# 0.19fF
C2944 divbuf_2/a_22472_170# divbuf_2/OUT4 0.19fF
C2945 divbuf_2/a_2880_n1600# divbuf_2/a_2910_n1540# 0.19fF
C2946 divbuf_2/a_2910_n840# divbuf_2/a_3390_n840# 0.07fF
C2947 divbuf_1/a_28292_170# divbuf_1/OUT4 0.19fF
C2948 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/a0 0.13fF
C2949 divbuf_0/a_22560_n1600# divbuf_0/a_22590_n840# 0.04fF
C2950 divbuf_0/a_2322_170# divbuf_0/OUT2 0.19fF
C2951 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_16830_n840# 0.04fF
C2952 divbuf_2/a_55710_n1540# divbuf_2/a_56190_n1540# 0.11fF
C2953 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z3 0.65fF
C2954 divbuf_1/a_25862_n240# divbuf_1/a_25950_n840# 0.03fF
C2955 divbuf_1/a_35040_n1600# divbuf_1/a_35520_n1600# 0.26fF
C2956 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/a_27390_n840# 0.04fF
C2957 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36960_n1600# 0.26fF
C2958 divbuf_3/a_25920_n1600# divbuf_3/a_26400_n1600# 0.26fF
C2959 divbuf_3/a_16642_n240# divbuf_3/a_16830_n840# 0.02fF
C2960 ro_div_0/divbuf_0/a_59550_n840# ro_div_0/divbuf_0/a_59550_n1540# 0.01fF
C2961 ro_div_0/divbuf_0/a_28830_n1540# ro_div_0/divbuf_0/a_29310_n1540# 0.11fF
C2962 divbuf_3/a_18270_n1540# divbuf_3/a_18750_n1540# 0.11fF
C2963 divbuf_3/a_48990_n840# divbuf_3/a_48990_n1540# 0.01fF
C2964 divbuf_0/a_39442_170# divbuf_0/a_39932_170# 0.07fF
C2965 divbuf_0/a_20042_170# divbuf_0/a_20042_n240# 0.01fF
C2966 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/a_34112_170# 0.07fF
C2967 divbuf_2/a_23442_n240# divbuf_2/OUT4 0.04fF
C2968 divbuf_2/a_53280_n1600# divbuf_2/a_53310_n840# 0.04fF
C2969 divbuf_1/a_32652_n240# divbuf_1/OUT4 0.04fF
C2970 divbuf_1/a_27360_n1600# divbuf_1/a_27390_n1540# 0.19fF
C2971 divbuf_0/a_12030_n840# divbuf_0/a_12510_n840# 0.07fF
C2972 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n1540# 0.19fF
C2973 divbuf_0/a_40902_170# divbuf_0/OUT4 0.19fF
C2974 divbuf_0/a_1352_n240# divbuf_0/OUT2 0.07fF
C2975 pll_full_0/divbuf_0/a_6270_n840# pll_full_0/divbuf_0/a_6750_n840# 0.07fF
C2976 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/OUT4 0.19fF
C2977 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6270_n1540# 0.19fF
C2978 divbuf_1/a_24960_n1600# divbuf_1/a_24990_n840# 0.04fF
C2979 divbuf_1/a_19230_n1540# divbuf_1/a_19710_n1540# 0.11fF
C2980 ro_div_0/divbuf_0/a_7302_170# ro_div_0/divbuf_0/OUT3 0.19fF
C2981 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26430_n840# 0.04fF
C2982 pll_full_0/divbuf_0/a_59070_n1540# pll_full_0/divbuf_0/a_59550_n1540# 0.11fF
C2983 divbuf_3/a_15840_n1600# divbuf_3/a_15870_n840# 0.04fF
C2984 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24480_n1600# 0.26fF
C2985 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_14910_n840# 0.02fF
C2986 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29760_n1600# 0.26fF
C2987 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/a_20190_n840# 0.03fF
C2988 divbuf_2/a_31202_n240# divbuf_2/a_31682_n240# 0.05fF
C2989 pd_div_0/divbuf_0/a_16350_n1540# pd_div_0/divbuf_0/a_16830_n1540# 0.11fF
C2990 pd_div_0/divbuf_0/a_47070_n840# pd_div_0/divbuf_0/a_47070_n1540# 0.01fF
C2991 pll_full_0/divbuf_1/a_21630_n1540# pll_full_0/divbuf_1/a_22110_n1540# 0.11fF
C2992 pll_full_0/divbuf_1/a_52350_n840# pll_full_0/divbuf_1/a_52350_n1540# 0.01fF
C2993 divbuf_2/a_21600_n1600# divbuf_2/OUT4 0.01fF
C2994 divbuf_2/a_12510_n840# divbuf_2/a_12510_n1540# 0.01fF
C2995 divbuf_2/a_42750_n840# divbuf_2/a_43230_n840# 0.07fF
C2996 divbuf_2/a_42720_n1600# divbuf_2/a_42750_n1540# 0.19fF
C2997 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/a_23922_n240# 0.01fF
C2998 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/a_3912_n240# 0.04fF
C2999 divbuf_0/a_960_n1600# divbuf_0/OUT2 0.00fF
C3000 divbuf_0/a_41382_n240# divbuf_0/OUT5 0.04fF
C3001 divbuf_3/a_13252_170# divbuf_3/a_13252_n240# 0.01fF
C3002 divbuf_3/a_32652_170# divbuf_3/a_33142_170# 0.07fF
C3003 divbuf_1/a_1352_n240# divbuf_1/a_1842_n240# 0.04fF
C3004 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3005 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_56670_n840# 0.04fF
C3006 divbuf_1/a_14400_n1600# divbuf_1/a_14430_n1540# 0.19fF
C3007 divbuf_1/a_14430_n840# divbuf_1/a_14910_n840# 0.07fF
C3008 ro_div_0/ro_complete_0/cbank_1/switch_0/vin ro_div_0/divider_0/clk 1.45fF
C3009 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_15870_n1540# 0.19fF
C3010 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C3011 ro_div_0/divbuf_0/a_15870_n840# ro_div_0/divbuf_0/a_16350_n840# 0.07fF
C3012 divbuf_3/a_5310_n840# divbuf_3/a_5790_n840# 0.07fF
C3013 divbuf_3/a_27322_170# divbuf_3/OUT4 0.19fF
C3014 divbuf_3/a_5280_n1600# divbuf_3/a_5310_n1540# 0.19fF
C3015 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_13950_n840# 0.04fF
C3016 divbuf_0/a_17612_170# divbuf_0/a_18092_170# 0.07fF
C3017 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19230_n840# 0.04fF
C3018 divbuf_3/a_58110_n1540# divbuf_3/a_58590_n1540# 0.11fF
C3019 divbuf_0/a_40412_n240# divbuf_0/a_40902_n240# 0.04fF
C3020 pll_full_0/divbuf_0/a_34592_n240# pll_full_0/divbuf_0/a_35082_n240# 0.04fF
C3021 divbuf_1/a_36990_n840# divbuf_1/a_36990_n1540# 0.01fF
C3022 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n1540# 0.19fF
C3023 divbuf_0/a_51870_n840# divbuf_0/a_52350_n840# 0.07fF
C3024 divbuf_0/a_21630_n840# divbuf_0/a_21630_n1540# 0.01fF
C3025 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46110_n1540# 0.19fF
C3026 pll_full_0/divbuf_0/a_15870_n840# pll_full_0/divbuf_0/a_15870_n1540# 0.01fF
C3027 pll_full_0/divbuf_0/a_46110_n840# pll_full_0/divbuf_0/a_46590_n840# 0.07fF
C3028 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/a_31202_170# 0.07fF
C3029 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/a_16642_n240# 0.01fF
C3030 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/a_36532_170# 0.07fF
C3031 divbuf_3/a_28292_n240# divbuf_3/OUT4 0.04fF
C3032 divbuf_3/a_55680_n1600# divbuf_3/a_55710_n840# 0.04fF
C3033 divbuf_1/a_59070_n1540# divbuf_1/a_59550_n1540# 0.11fF
C3034 pd_div_0/divbuf_0/a_3390_n840# pd_div_0/divbuf_0/a_3870_n840# 0.07fF
C3035 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3036 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3390_n1540# 0.19fF
C3037 pll_full_0/divbuf_1/a_8670_n840# pll_full_0/divbuf_1/a_9150_n840# 0.07fF
C3038 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3039 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_8670_n1540# 0.19fF
C3040 divbuf_2/a_29280_n1600# divbuf_2/a_29760_n1600# 0.26fF
C3041 divbuf_2/a_20042_n240# divbuf_2/a_20190_n840# 0.03fF
C3042 pd_div_0/divbuf_0/a_56190_n1540# pd_div_0/divbuf_0/a_56670_n1540# 0.11fF
C3043 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C3044 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C3045 divbuf_2/a_21630_n1540# divbuf_2/a_22110_n1540# 0.11fF
C3046 divbuf_2/a_52350_n840# divbuf_2/a_52350_n1540# 0.01fF
C3047 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2880_n1600# 0.26fF
C3048 divbuf_3/a_33622_n240# divbuf_3/a_34112_n240# 0.04fF
C3049 divbuf_1/a_960_n1600# divbuf_1/a_1440_n1600# 0.26fF
C3050 divbuf_1/a_54270_n840# divbuf_1/a_54750_n840# 0.07fF
C3051 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_55710_n1540# 0.19fF
C3052 ro_div_0/divbuf_0/a_55710_n840# ro_div_0/divbuf_0/a_56190_n840# 0.07fF
C3053 ro_div_0/divbuf_0/a_25470_n840# ro_div_0/divbuf_0/a_25470_n1540# 0.01fF
C3054 divbuf_3/a_45120_n1600# divbuf_3/a_45150_n1540# 0.19fF
C3055 divbuf_3/a_14910_n840# divbuf_3/a_14910_n1540# 0.01fF
C3056 divbuf_3/a_45150_n840# divbuf_3/a_45630_n840# 0.07fF
C3057 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3058 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_53790_n840# 0.04fF
C3059 ro_div_0/divider_0/and_0/A ro_div_0/divider_0/and_0/B 0.18fF
C3060 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C3061 divbuf_0/a_8762_170# divbuf_0/a_8762_n240# 0.01fF
C3062 divbuf_0/a_1352_170# divbuf_0/a_1352_n240# 0.01fF
C3063 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3064 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59070_n840# 0.04fF
C3065 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C3066 divbuf_2/a_19200_n1600# divbuf_2/a_19230_n840# 0.04fF
C3067 divbuf_1/a_14702_170# divbuf_1/OUT4 0.19fF
C3068 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z1 0.01fF
C3069 divbuf_0/a_29262_n240# divbuf_0/a_29310_n840# 0.04fF
C3070 divbuf_0/a_38400_n1600# divbuf_0/a_38880_n1600# 0.26fF
C3071 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_33120_n1600# 0.26fF
C3072 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/a_23550_n840# 0.03fF
C3073 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/A 0.55fF
C3074 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_12990_n840# 0.01fF
C3075 divbuf_1/a_11802_n240# divbuf_1/a_11550_n840# 0.02fF
C3076 divbuf_0/a_30750_n1540# divbuf_0/a_31230_n1540# 0.11fF
C3077 pll_full_0/divbuf_0/a_24990_n1540# pll_full_0/divbuf_0/a_25470_n1540# 0.11fF
C3078 pll_full_0/divbuf_0/a_55710_n840# pll_full_0/divbuf_0/a_55710_n1540# 0.01fF
C3079 divbuf_3/a_1842_n240# divbuf_3/a_1950_n840# 0.03fF
C3080 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/a_32172_n240# 0.04fF
C3081 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/a_37502_n240# 0.05fF
C3082 divbuf_2/a_16642_170# divbuf_2/a_16642_n240# 0.01fF
C3083 divbuf_2/a_36052_170# divbuf_2/a_36532_170# 0.07fF
C3084 pd_div_0/divbuf_0/a_12990_n840# pd_div_0/divbuf_0/a_12990_n1540# 0.01fF
C3085 pd_div_0/divbuf_0/a_43230_n840# pd_div_0/divbuf_0/a_43710_n840# 0.07fF
C3086 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43230_n1540# 0.19fF
C3087 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C3088 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48510_n1540# 0.19fF
C3089 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C3090 pll_full_0/divbuf_1/a_18270_n840# pll_full_0/divbuf_1/a_18270_n1540# 0.01fF
C3091 pll_full_0/divbuf_1/a_48510_n840# pll_full_0/divbuf_1/a_48990_n840# 0.07fF
C3092 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/a_9242_n240# 0.01fF
C3093 divbuf_2/a_8670_n840# divbuf_2/a_9150_n840# 0.07fF
C3094 divbuf_2/a_34112_170# divbuf_2/OUT4 0.19fF
C3095 divbuf_2/a_8640_n1600# divbuf_2/a_8670_n1540# 0.19fF
C3096 divbuf_1/a_3912_n240# divbuf_1/OUT3 0.04fF
C3097 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/Out 0.21fF
C3098 pd_div_0/divider_0/prescaler_0/tspc_0/D gnd 0.05fF
C3099 divbuf_0/a_28320_n1600# divbuf_0/a_28350_n840# 0.04fF
C3100 divbuf_0/a_12282_170# divbuf_0/OUT4 0.19fF
C3101 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3102 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_22590_n840# 0.04fF
C3103 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C3104 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z1 0.03fF
C3105 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/a_33150_n840# 0.06fF
C3106 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42720_n1600# 0.26fF
C3107 divbuf_1/a_40800_n1600# divbuf_1/a_41280_n1600# 0.26fF
C3108 divbuf_1/a_31682_n240# divbuf_1/a_31710_n840# 0.05fF
C3109 divbuf_3/a_31680_n1600# divbuf_3/a_32160_n1600# 0.26fF
C3110 divbuf_3/a_22472_n240# divbuf_3/a_22590_n840# 0.03fF
C3111 ro_div_0/divbuf_0/a_34590_n1540# ro_div_0/divbuf_0/a_35070_n1540# 0.11fF
C3112 divbuf_3/a_24030_n1540# divbuf_3/a_24510_n1540# 0.11fF
C3113 divbuf_3/a_54750_n840# divbuf_3/a_54750_n1540# 0.01fF
C3114 divbuf_0/a_25862_170# divbuf_0/a_25862_n240# 0.01fF
C3115 divbuf_0/a_5362_n240# divbuf_0/a_5852_n240# 0.04fF
C3116 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/a_20042_n240# 0.01fF
C3117 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/a_39932_170# 0.07fF
C3118 divbuf_2/a_35082_n240# divbuf_2/OUT4 0.04fF
C3119 divbuf_2/a_59040_n1600# divbuf_2/a_59070_n840# 0.04fF
C3120 divbuf_1/a_33120_n1600# divbuf_1/a_33150_n1540# 0.19fF
C3121 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n1540# 0.19fF
C3122 divbuf_0/a_13252_n240# divbuf_0/OUT4 0.04fF
C3123 divbuf_0/a_17790_n840# divbuf_0/a_18270_n840# 0.07fF
C3124 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/OUT2 0.07fF
C3125 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3126 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12030_n1540# 0.19fF
C3127 pll_full_0/divbuf_0/a_12030_n840# pll_full_0/divbuf_0/a_12510_n840# 0.07fF
C3128 divbuf_1/a_30720_n1600# divbuf_1/a_30750_n840# 0.04fF
C3129 divbuf_1/a_24990_n1540# divbuf_1/a_25470_n1540# 0.11fF
C3130 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32190_n840# 0.04fF
C3131 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3132 divbuf_3/a_21600_n1600# divbuf_3/a_21630_n840# 0.04fF
C3133 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_30240_n1600# 0.26fF
C3134 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/a_20670_n840# 0.03fF
C3135 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/a_25950_n840# 0.03fF
C3136 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35520_n1600# 0.26fF
C3137 divbuf_2/a_37022_n240# divbuf_2/a_37502_n240# 0.05fF
C3138 pd_div_0/divbuf_0/a_22110_n1540# pd_div_0/divbuf_0/a_22590_n1540# 0.11fF
C3139 pd_div_0/divbuf_0/a_52830_n840# pd_div_0/divbuf_0/a_52830_n1540# 0.01fF
C3140 pll_full_0/divbuf_1/a_27390_n1540# pll_full_0/divbuf_1/a_27870_n1540# 0.11fF
C3141 pll_full_0/divbuf_1/a_58110_n840# pll_full_0/divbuf_1/a_58110_n1540# 0.01fF
C3142 divbuf_2/a_48480_n1600# divbuf_2/a_48510_n1540# 0.19fF
C3143 divbuf_2/a_33120_n1600# divbuf_2/OUT4 0.01fF
C3144 divbuf_2/a_18270_n840# divbuf_2/a_18270_n1540# 0.01fF
C3145 divbuf_2/a_48510_n840# divbuf_2/a_48990_n840# 0.07fF
C3146 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/a_29742_n240# 0.01fF
C3147 ro_div_0/divbuf_0/a_9242_n240# ro_div_0/divbuf_0/a_9732_n240# 0.04fF
C3148 divbuf_0/a_11520_n1600# divbuf_0/OUT4 0.01fF
C3149 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/OUT5 0.04fF
C3150 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C3151 divbuf_3/a_19072_170# divbuf_3/a_19072_n240# 0.01fF
C3152 divbuf_3/a_38472_170# divbuf_3/a_38962_170# 0.07fF
C3153 divbuf_1/a_7792_n240# divbuf_1/a_8272_n240# 0.05fF
C3154 divbuf_1/a_20190_n840# divbuf_1/a_20670_n840# 0.07fF
C3155 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_21630_n1540# 0.19fF
C3156 ro_div_0/divbuf_0/a_21012_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3157 ro_div_0/divbuf_0/a_21630_n840# ro_div_0/divbuf_0/a_22110_n840# 0.07fF
C3158 divbuf_3/a_38962_170# divbuf_3/OUT4 0.19fF
C3159 divbuf_3/a_11040_n1600# divbuf_3/a_11070_n1540# 0.19fF
C3160 divbuf_3/a_11070_n840# divbuf_3/a_11550_n840# 0.07fF
C3161 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_19710_n840# 0.04fF
C3162 io_clamp_low[2] io_analog[6] 0.53fF
C3163 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/OUT3 0.19fF
C3164 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_24990_n840# 0.04fF
C3165 divbuf_3/OUT4 divbuf_3/OUT5 0.26fF
C3166 divbuf_0/a_4320_n1600# divbuf_0/a_4800_n1600# 0.26fF
C3167 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/a_40902_n240# 0.04fF
C3168 divbuf_1/a_42750_n840# divbuf_1/a_42750_n1540# 0.01fF
C3169 divbuf_0/a_57630_n840# divbuf_0/a_58110_n840# 0.07fF
C3170 divbuf_0/a_27390_n840# divbuf_0/a_27390_n1540# 0.01fF
C3171 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n1540# 0.19fF
C3172 pll_full_0/divbuf_0/a_21630_n840# pll_full_0/divbuf_0/a_21630_n1540# 0.01fF
C3173 pll_full_0/divbuf_0/a_51870_n840# pll_full_0/divbuf_0/a_52350_n840# 0.07fF
C3174 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_51870_n1540# 0.19fF
C3175 pd_div_0/div pd_div_0/divbuf_0/a_0_n1600# 0.26fF
C3176 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/a_17122_n240# 0.01fF
C3177 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/a_37022_170# 0.07fF
C3178 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C3179 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/a_1842_n240# 0.04fF
C3180 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/a_22472_n240# 0.01fF
C3181 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_960_n1600# 0.00fF
C3182 divbuf_3/a_39932_n240# divbuf_3/OUT4 0.04fF
C3183 pd_div_0/divbuf_0/a_9150_n840# pd_div_0/divbuf_0/a_9630_n840# 0.07fF
C3184 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3185 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9150_n1540# 0.19fF
C3186 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/Out 0.19fF
C3187 ro_div_0/divider_0/prescaler_0/tspc_0/D ro_div_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C3188 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C3189 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C3190 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14430_n1540# 0.19fF
C3191 pll_full_0/divbuf_1/a_14430_n840# pll_full_0/divbuf_1/a_14910_n840# 0.07fF
C3192 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C3193 divbuf_2/a_25862_n240# divbuf_2/a_25950_n840# 0.03fF
C3194 divbuf_2/a_35040_n1600# divbuf_2/a_35520_n1600# 0.26fF
C3195 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C3196 divbuf_0/a_15182_n240# divbuf_0/a_14910_n840# 0.01fF
C3197 divbuf_2/a_27390_n1540# divbuf_2/a_27870_n1540# 0.11fF
C3198 divbuf_2/a_58110_n840# divbuf_2/a_58110_n1540# 0.01fF
C3199 divbuf_1/a_60990_n840# divbuf_1/OUT5 0.04fF
C3200 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8640_n1600# 0.26fF
C3201 divbuf_3/a_39442_n240# divbuf_3/a_39932_n240# 0.04fF
C3202 divbuf_1/a_6720_n1600# divbuf_1/a_7200_n1600# 0.26fF
C3203 divbuf_1/a_60030_n840# divbuf_1/a_60510_n840# 0.07fF
C3204 ro_div_0/divbuf_0/a_31230_n840# ro_div_0/divbuf_0/a_31230_n1540# 0.01fF
C3205 ro_div_0/divbuf_0/a_510_n1540# ro_div_0/divbuf_0/a_990_n1540# 0.11fF
C3206 divbuf_3/a_20670_n840# divbuf_3/a_20670_n1540# 0.01fF
C3207 divbuf_3/a_50910_n840# divbuf_3/a_51390_n840# 0.07fF
C3208 divbuf_3/a_50880_n1600# divbuf_3/a_50910_n1540# 0.19fF
C3209 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3210 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_59550_n840# 0.04fF
C3211 divbuf_2/a_5362_170# divbuf_2/OUT3 0.19fF
C3212 divbuf_2/a_24960_n1600# divbuf_2/a_24990_n840# 0.04fF
C3213 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z4 0.15fF
C3214 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z2 0.30fF
C3215 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C3216 divbuf_0/a_35082_n240# divbuf_0/a_35070_n840# 0.05fF
C3217 divbuf_0/a_9242_170# divbuf_0/OUT3 0.19fF
C3218 divbuf_0/a_44160_n1600# divbuf_0/a_44640_n1600# 0.26fF
C3219 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38880_n1600# 0.26fF
C3220 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/a_29310_n840# 0.04fF
C3221 divbuf_1/a_17612_n240# divbuf_1/a_17310_n840# 0.00fF
C3222 divbuf_0/a_36510_n1540# divbuf_0/a_36990_n1540# 0.11fF
C3223 pll_full_0/divbuf_0/a_30750_n1540# pll_full_0/divbuf_0/a_31230_n1540# 0.11fF
C3224 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/a_37992_n240# 0.04fF
C3225 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_1440_n1600# 0.26fF
C3226 divbuf_2/a_1352_n240# divbuf_2/a_1842_n240# 0.04fF
C3227 divbuf_2/a_22472_170# divbuf_2/a_22472_n240# 0.01fF
C3228 divbuf_2/a_492_n240# divbuf_2/a_960_n1600# 0.00fF
C3229 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C3230 pd_div_0/divbuf_0/a_18750_n840# pd_div_0/divbuf_0/a_18750_n1540# 0.01fF
C3231 pd_div_0/divbuf_0/a_48990_n840# pd_div_0/divbuf_0/a_49470_n840# 0.07fF
C3232 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_48990_n1540# 0.19fF
C3233 pll_full_0/divbuf_1/a_24030_n840# pll_full_0/divbuf_1/a_24030_n1540# 0.01fF
C3234 pll_full_0/divbuf_1/a_54270_n840# pll_full_0/divbuf_1/a_54750_n840# 0.07fF
C3235 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54270_n1540# 0.19fF
C3236 divbuf_2/a_14400_n1600# divbuf_2/a_14430_n1540# 0.19fF
C3237 divbuf_2/a_14430_n840# divbuf_2/a_14910_n840# 0.07fF
C3238 divbuf_2/a_6332_n240# divbuf_2/OUT3 0.04fF
C3239 divbuf_1/a_15672_n240# divbuf_1/OUT4 0.04fF
C3240 divbuf_1/a_12772_170# divbuf_1/a_13252_170# 0.07fF
C3241 gnd pd_div_0/divider_0/and_0/out1 0.29fF
C3242 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z4 0.12fF
C3243 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z2 1.07fF
C3244 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z3 0.38fF
C3245 ro_div_0/ro_complete_0/cbank_2/switch_4/vin ro_div_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C3246 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/a_16642_170# 0.07fF
C3247 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/a_8272_n240# 0.01fF
C3248 divbuf_0/a_34080_n1600# divbuf_0/a_34110_n840# 0.04fF
C3249 divbuf_0/a_23922_170# divbuf_0/OUT4 0.19fF
C3250 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28350_n840# 0.04fF
C3251 divbuf_3/a_3422_170# divbuf_3/a_3912_170# 0.07fF
C3252 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C3253 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C3254 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/OUT3 0.19fF
C3255 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48480_n1600# 0.26fF
C3256 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/a_38910_n840# 0.04fF
C3257 divbuf_1/a_37502_n240# divbuf_1/a_37470_n840# 0.05fF
C3258 divbuf_1/a_46560_n1600# divbuf_1/a_47040_n1600# 0.26fF
C3259 divbuf_3/a_37440_n1600# divbuf_3/a_37920_n1600# 0.26fF
C3260 divbuf_3/a_28292_n240# divbuf_3/a_28350_n840# 0.04fF
C3261 ro_div_0/divbuf_0/a_40350_n1540# ro_div_0/divbuf_0/a_40830_n1540# 0.11fF
C3262 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_11550_n840# 0.02fF
C3263 divbuf_3/a_29790_n1540# divbuf_3/a_30270_n1540# 0.11fF
C3264 divbuf_3/a_60510_n840# divbuf_3/a_60510_n1540# 0.01fF
C3265 divbuf_0/a_31682_170# divbuf_0/a_31682_n240# 0.01fF
C3266 divbuf_0/a_11802_n240# divbuf_0/a_12282_n240# 0.05fF
C3267 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/a_5852_n240# 0.04fF
C3268 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/a_25862_n240# 0.01fF
C3269 divbuf_1/a_38880_n1600# divbuf_1/a_38910_n1540# 0.19fF
C3270 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/a_16152_n240# 0.01fF
C3271 divbuf_0/a_23550_n840# divbuf_0/a_24030_n840# 0.07fF
C3272 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n1540# 0.19fF
C3273 divbuf_0/a_24892_n240# divbuf_0/OUT4 0.04fF
C3274 pll_full_0/divbuf_0/a_17790_n840# pll_full_0/divbuf_0/a_18270_n840# 0.07fF
C3275 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3276 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_17790_n1540# 0.19fF
C3277 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_37950_n840# 0.04fF
C3278 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3279 divbuf_1/a_36480_n1600# divbuf_1/a_36510_n840# 0.04fF
C3280 divbuf_1/a_30750_n1540# divbuf_1/a_31230_n1540# 0.11fF
C3281 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/z5 0.04fF
C3282 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z4 0.20fF
C3283 pd_div_0/pd_0/tspc_r_1/Z1 pd_div_0/pd_0/tspc_r_1/Z2 0.71fF
C3284 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/a_7302_170# 0.07fF
C3285 divbuf_3/a_10212_170# divbuf_3/OUT3 0.19fF
C3286 divbuf_3/a_27360_n1600# divbuf_3/a_27390_n840# 0.04fF
C3287 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_36000_n1600# 0.26fF
C3288 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/a_26430_n840# 0.04fF
C3289 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_41280_n1600# 0.26fF
C3290 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/a_31710_n840# 0.05fF
C3291 divbuf_2/a_960_n1600# divbuf_2/a_1440_n1600# 0.26fF
C3292 pd_div_0/divbuf_0/a_27870_n1540# pd_div_0/divbuf_0/a_28350_n1540# 0.11fF
C3293 pd_div_0/divbuf_0/a_58590_n840# pd_div_0/divbuf_0/a_58590_n1540# 0.01fF
C3294 pll_full_0/divbuf_1/a_33150_n1540# pll_full_0/divbuf_1/a_33630_n1540# 0.11fF
C3295 divbuf_2/a_24030_n840# divbuf_2/a_24030_n1540# 0.01fF
C3296 divbuf_2/a_54270_n840# divbuf_2/a_54750_n840# 0.07fF
C3297 divbuf_2/a_54240_n1600# divbuf_2/a_54270_n1540# 0.19fF
C3298 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/a_35562_n240# 0.01fF
C3299 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_16152_n240# 0.05fF
C3300 divbuf_0/a_23040_n1600# divbuf_0/OUT4 0.01fF
C3301 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C3302 divbuf_3/a_4392_n240# divbuf_3/a_4882_n240# 0.04fF
C3303 divbuf_3/a_24892_170# divbuf_3/a_24892_n240# 0.01fF
C3304 divbuf_1/a_14222_n240# divbuf_1/a_14702_n240# 0.05fF
C3305 divbuf_1/a_34112_170# divbuf_1/a_34112_n240# 0.01fF
C3306 divbuf_1/a_25950_n840# divbuf_1/a_26430_n840# 0.07fF
C3307 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27390_n1540# 0.19fF
C3308 ro_div_0/divbuf_0/a_27390_n840# ro_div_0/divbuf_0/a_27870_n840# 0.07fF
C3309 ro_div_0/divbuf_0/a_32652_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3310 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C3311 divbuf_3/a_16830_n840# divbuf_3/a_17310_n840# 0.07fF
C3312 divbuf_3/a_11312_n240# divbuf_3/OUT4 0.07fF
C3313 divbuf_3/a_16800_n1600# divbuf_3/a_16830_n1540# 0.19fF
C3314 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3315 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25470_n840# 0.04fF
C3316 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z2 0.01fF
C3317 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3318 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_30750_n840# 0.04fF
C3319 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C3320 divbuf_2/a_11802_n240# divbuf_2/a_11550_n840# 0.02fF
C3321 divbuf_0/a_10080_n1600# divbuf_0/a_10560_n1600# 0.26fF
C3322 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4800_n1600# 0.26fF
C3323 divbuf_1/a_48510_n840# divbuf_1/a_48510_n1540# 0.01fF
C3324 divbuf_0/a_2910_n840# divbuf_0/OUT3 0.03fF
C3325 divbuf_0/a_33150_n840# divbuf_0/a_33150_n1540# 0.01fF
C3326 divbuf_0/a_2430_n1540# divbuf_0/a_2910_n1540# 0.11fF
C3327 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_57630_n1540# 0.19fF
C3328 pll_full_0/divbuf_0/a_27390_n840# pll_full_0/divbuf_0/a_27390_n1540# 0.01fF
C3329 pll_full_0/divbuf_0/a_57630_n840# pll_full_0/divbuf_0/a_58110_n840# 0.07fF
C3330 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/a_2322_n240# 0.05fF
C3331 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/a_22952_n240# 0.01fF
C3332 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/a_8272_n240# 0.05fF
C3333 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/a_28292_n240# 0.01fF
C3334 divbuf_3/a_10080_n1600# divbuf_3/OUT3 0.00fF
C3335 divbuf_2/a_6822_170# divbuf_2/a_7302_170# 0.07fF
C3336 divbuf_1/a_7302_170# divbuf_1/OUT3 0.19fF
C3337 pd_div_0/divbuf_0/a_14910_n840# pd_div_0/divbuf_0/a_15390_n840# 0.07fF
C3338 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C3339 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_14910_n1540# 0.19fF
C3340 ro_div_0/divider_0/prescaler_0/tspc_0/D ro_div_0/divider_0/clk 0.26fF
C3341 pll_full_0/divbuf_1/a_20190_n840# pll_full_0/divbuf_1/a_20670_n840# 0.07fF
C3342 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3343 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20190_n1540# 0.19fF
C3344 divbuf_2/a_40800_n1600# divbuf_2/a_41280_n1600# 0.26fF
C3345 divbuf_2/a_31682_n240# divbuf_2/a_31710_n840# 0.05fF
C3346 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C3347 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_14910_n840# 0.01fF
C3348 divbuf_2/a_33150_n1540# divbuf_2/a_33630_n1540# 0.11fF
C3349 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/a_4350_n840# 0.04fF
C3350 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_14400_n1600# 0.26fF
C3351 divbuf_0/a_41790_n840# divbuf_0/OUT5 0.03fF
C3352 divbuf_3/a_3360_n1600# divbuf_3/a_3840_n1600# 0.26fF
C3353 divbuf_1/a_12480_n1600# divbuf_1/a_12960_n1600# 0.26fF
C3354 divbuf_1/a_4830_n1540# divbuf_1/a_5310_n1540# 0.11fF
C3355 ro_div_0/divbuf_0/a_36990_n840# ro_div_0/divbuf_0/a_36990_n1540# 0.01fF
C3356 ro_div_0/divbuf_0/a_6270_n1540# ro_div_0/divbuf_0/a_6750_n1540# 0.11fF
C3357 divbuf_3/a_56640_n1600# divbuf_3/a_56670_n1540# 0.19fF
C3358 divbuf_3/a_26430_n840# divbuf_3/a_26430_n1540# 0.01fF
C3359 divbuf_3/a_56670_n840# divbuf_3/a_57150_n840# 0.07fF
C3360 divbuf_1/a_22952_170# divbuf_1/OUT4 0.19fF
C3361 divbuf_0/a_14222_170# divbuf_0/a_14702_170# 0.07fF
C3362 divbuf_2/a_17122_170# divbuf_2/OUT4 0.19fF
C3363 divbuf_2/a_30720_n1600# divbuf_2/a_30750_n840# 0.04fF
C3364 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 gnd 0.27fF
C3365 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C3366 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C3367 divbuf_0/a_49920_n1600# divbuf_0/a_50400_n1600# 0.26fF
C3368 divbuf_0/a_40902_n240# divbuf_0/a_40830_n840# 0.03fF
C3369 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C3370 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C3371 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/Out 0.11fF
C3372 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44640_n1600# 0.26fF
C3373 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/a_35070_n840# 0.05fF
C3374 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_3870_n840# 0.04fF
C3375 divbuf_3/a_14222_n240# divbuf_3/a_13950_n840# 0.01fF
C3376 divbuf_1/a_2400_n1600# divbuf_1/a_2430_n840# 0.04fF
C3377 divbuf_0/a_42270_n1540# divbuf_0/a_42750_n1540# 0.11fF
C3378 pll_full_0/divbuf_0/a_36510_n1540# pll_full_0/divbuf_0/a_36990_n1540# 0.11fF
C3379 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1920_n1600# 0.26fF
C3380 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_7200_n1600# 0.26fF
C3381 divbuf_2/a_7792_n240# divbuf_2/a_8272_n240# 0.05fF
C3382 divbuf_2/a_28292_170# divbuf_2/a_28292_n240# 0.01fF
C3383 pd_div_0/divbuf_0/a_24510_n840# pd_div_0/divbuf_0/a_24510_n1540# 0.01fF
C3384 pd_div_0/divbuf_0/a_54750_n840# pd_div_0/divbuf_0/a_55230_n840# 0.07fF
C3385 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_54750_n1540# 0.19fF
C3386 divbuf_0/a_16152_170# divbuf_0/a_16152_n240# 0.01fF
C3387 pll_full_0/divbuf_1/a_29790_n840# pll_full_0/divbuf_1/a_29790_n1540# 0.01fF
C3388 pll_full_0/divbuf_1/a_60030_n840# pll_full_0/divbuf_1/a_60510_n840# 0.07fF
C3389 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60030_n1540# 0.19fF
C3390 pll_full_0/divbuf_0/a_12282_170# pll_full_0/divbuf_0/a_12282_n240# 0.01fF
C3391 divbuf_2/a_20190_n840# divbuf_2/a_20670_n840# 0.07fF
C3392 divbuf_2/a_18092_n240# divbuf_2/OUT4 0.04fF
C3393 divbuf_2/a_20160_n1600# divbuf_2/a_20190_n1540# 0.19fF
C3394 divbuf_1/a_27322_n240# divbuf_1/OUT4 0.04fF
C3395 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/a_21012_170# 0.07fF
C3396 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/a_2322_n240# 0.01fF
C3397 divbuf_0/a_39840_n1600# divbuf_0/a_39870_n840# 0.04fF
C3398 divbuf_0/a_35562_170# divbuf_0/OUT4 0.19fF
C3399 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3400 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34110_n840# 0.04fF
C3401 divbuf_3/a_9242_170# divbuf_3/a_9732_170# 0.07fF
C3402 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_54240_n1600# 0.26fF
C3403 divbuf_3/a_43200_n1600# divbuf_3/a_43680_n1600# 0.26fF
C3404 divbuf_3/a_34112_n240# divbuf_3/a_34110_n840# 0.06fF
C3405 divbuf_1/a_52320_n1600# divbuf_1/a_52800_n1600# 0.26fF
C3406 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12030_n840# 0.02fF
C3407 ro_div_0/divbuf_0/a_46110_n1540# ro_div_0/divbuf_0/a_46590_n1540# 0.11fF
C3408 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_17310_n840# 0.00fF
C3409 divbuf_3/a_35550_n1540# divbuf_3/a_36030_n1540# 0.11fF
C3410 divbuf_0/a_37502_170# divbuf_0/a_37502_n240# 0.01fF
C3411 divbuf_0/a_17612_n240# divbuf_0/a_18092_n240# 0.05fF
C3412 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_12282_n240# 0.05fF
C3413 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/a_31682_n240# 0.01fF
C3414 divbuf_1/a_44640_n1600# divbuf_1/a_44670_n1540# 0.19fF
C3415 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n1540# 0.19fF
C3416 divbuf_0/a_29310_n840# divbuf_0/a_29790_n840# 0.07fF
C3417 divbuf_0/a_36532_n240# divbuf_0/OUT4 0.04fF
C3418 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3419 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_23550_n1540# 0.19fF
C3420 pll_full_0/divbuf_0/a_23550_n840# pll_full_0/divbuf_0/a_24030_n840# 0.07fF
C3421 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_43710_n840# 0.04fF
C3422 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C3423 divbuf_1/a_42240_n1600# divbuf_1/a_42270_n840# 0.04fF
C3424 divbuf_1/a_36510_n1540# divbuf_1/a_36990_n1540# 0.11fF
C3425 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/a_13742_170# 0.07fF
C3426 divbuf_3/a_21982_170# divbuf_3/OUT4 0.19fF
C3427 divbuf_3/a_33120_n1600# divbuf_3/a_33150_n840# 0.04fF
C3428 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41760_n1600# 0.26fF
C3429 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/a_32190_n840# 0.06fF
C3430 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/a_37470_n840# 0.05fF
C3431 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_47040_n1600# 0.26fF
C3432 divbuf_2/a_6720_n1600# divbuf_2/a_7200_n1600# 0.26fF
C3433 pd_div_0/divbuf_0/a_33630_n1540# pd_div_0/divbuf_0/a_34110_n1540# 0.11fF
C3434 pll_full_0/divbuf_1/a_38910_n1540# pll_full_0/divbuf_1/a_39390_n1540# 0.11fF
C3435 divbuf_2/a_29790_n840# divbuf_2/a_29790_n1540# 0.01fF
C3436 divbuf_2/a_60030_n840# divbuf_2/a_60510_n840# 0.07fF
C3437 divbuf_2/a_60000_n1600# divbuf_2/a_60030_n1540# 0.19fF
C3438 divbuf_1/a_39932_170# divbuf_1/a_39932_n240# 0.01fF
C3439 divbuf_1/a_20042_n240# divbuf_1/a_20532_n240# 0.04fF
C3440 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/a_21982_n240# 0.05fF
C3441 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/a_41382_n240# 0.01fF
C3442 divbuf_0/a_34560_n1600# divbuf_0/OUT4 0.01fF
C3443 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C3444 divbuf_3/a_30712_170# divbuf_3/a_30712_n240# 0.01fF
C3445 divbuf_1/a_1470_n840# divbuf_1/a_1470_n1540# 0.01fF
C3446 divbuf_1/a_31710_n840# divbuf_1/a_32190_n840# 0.07fF
C3447 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/a_6822_n240# 0.01fF
C3448 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33150_n1540# 0.19fF
C3449 ro_div_0/divbuf_0/a_33150_n840# ro_div_0/divbuf_0/a_33630_n840# 0.07fF
C3450 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/a_2910_n1540# 0.01fF
C3451 divbuf_3/a_22952_n240# divbuf_3/OUT4 0.04fF
C3452 divbuf_3/a_22560_n1600# divbuf_3/a_22590_n1540# 0.19fF
C3453 divbuf_3/a_22590_n840# divbuf_3/a_23070_n840# 0.07fF
C3454 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3455 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31230_n840# 0.04fF
C3456 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C3457 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3458 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36510_n840# 0.04fF
C3459 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_1/z5 0.02fF
C3460 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C3461 divbuf_2/a_17612_n240# divbuf_2/a_17310_n840# 0.00fF
C3462 divbuf_0/a_6332_n240# divbuf_0/a_6270_n840# 0.04fF
C3463 divbuf_0/a_15840_n1600# divbuf_0/a_16320_n1600# 0.26fF
C3464 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10560_n1600# 0.26fF
C3465 divbuf_1/a_54270_n840# divbuf_1/a_54270_n1540# 0.01fF
C3466 divbuf_0/a_38910_n840# divbuf_0/a_38910_n1540# 0.01fF
C3467 divbuf_0/a_8190_n1540# divbuf_0/a_8670_n1540# 0.11fF
C3468 pll_full_0/divbuf_0/a_2430_n1540# pll_full_0/divbuf_0/a_2910_n1540# 0.11fF
C3469 pll_full_0/divbuf_0/a_33150_n840# pll_full_0/divbuf_0/a_33150_n1540# 0.01fF
C3470 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/OUT3 0.03fF
C3471 divbuf_2/a_13252_170# divbuf_2/a_13742_170# 0.07fF
C3472 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/a_8762_n240# 0.04fF
C3473 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/a_28772_n240# 0.01fF
C3474 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_14702_n240# 0.05fF
C3475 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/a_34112_n240# 0.01fF
C3476 divbuf_3/a_21120_n1600# divbuf_3/OUT4 0.00fF
C3477 pd_div_0/divbuf_0/a_20670_n840# pd_div_0/divbuf_0/a_21150_n840# 0.07fF
C3478 pd_div_0/divbuf_0/a_19072_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3479 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_20670_n1540# 0.19fF
C3480 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C3481 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_25950_n1540# 0.19fF
C3482 pll_full_0/divbuf_1/a_25950_n840# pll_full_0/divbuf_1/a_26430_n840# 0.07fF
C3483 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3484 divbuf_2/a_37502_n240# divbuf_2/a_37470_n840# 0.05fF
C3485 divbuf_2/a_46560_n1600# divbuf_2/a_47040_n1600# 0.26fF
C3486 divbuf_1/a_7792_170# divbuf_1/a_7302_170# 0.07fF
C3487 divbuf_0/a_5760_n1600# divbuf_0/a_5790_n840# 0.04fF
C3488 divbuf_0/a_19562_170# divbuf_0/OUT4 0.19fF
C3489 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C3490 divbuf_2/a_38910_n1540# divbuf_2/a_39390_n1540# 0.11fF
C3491 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/a_10110_n840# 0.03fF
C3492 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_20160_n1600# 0.26fF
C3493 divbuf_3/a_9120_n1600# divbuf_3/a_9600_n1600# 0.26fF
C3494 divbuf_1/a_18240_n1600# divbuf_1/a_18720_n1600# 0.26fF
C3495 divbuf_1/a_8762_n240# divbuf_1/a_8670_n840# 0.03fF
C3496 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/OUT5 0.03fF
C3497 divbuf_1/a_10590_n1540# divbuf_1/a_11070_n1540# 0.11fF
C3498 ro_div_0/divbuf_0/a_42750_n840# ro_div_0/divbuf_0/a_42750_n1540# 0.01fF
C3499 ro_div_0/divbuf_0/a_12030_n1540# ro_div_0/divbuf_0/a_12510_n1540# 0.11fF
C3500 divbuf_3/a_1470_n1540# divbuf_3/a_1950_n1540# 0.11fF
C3501 divbuf_3/a_32190_n840# divbuf_3/a_32190_n1540# 0.01fF
C3502 divbuf_3/a_60480_n1600# divbuf_3/OUT5 0.26fF
C3503 divbuf_1/a_37992_170# divbuf_1/OUT4 0.19fF
C3504 divbuf_0/a_22472_170# divbuf_0/a_22952_170# 0.07fF
C3505 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/a_18582_170# 0.07fF
C3506 divbuf_2/a_28772_170# divbuf_2/OUT4 0.19fF
C3507 divbuf_2/a_36480_n1600# divbuf_2/a_36510_n840# 0.04fF
C3508 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/nor_0/B 0.22fF
C3509 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C3510 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C3511 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C3512 divbuf_0/a_55680_n1600# divbuf_0/a_56160_n1600# 0.26fF
C3513 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z3 0.38fF
C3514 gnd pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C3515 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/a_40830_n840# 0.03fF
C3516 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_50400_n1600# 0.26fF
C3517 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/OUT3 0.19fF
C3518 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_9630_n840# 0.04fF
C3519 divbuf_0/a_48030_n1540# divbuf_0/a_48510_n1540# 0.11fF
C3520 divbuf_1/a_8160_n1600# divbuf_1/a_8190_n840# 0.04fF
C3521 pll_full_0/divbuf_0/a_42270_n1540# pll_full_0/divbuf_0/a_42750_n1540# 0.11fF
C3522 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7680_n1600# 0.26fF
C3523 ro_div_0/divbuf_0/a_60990_n840# ro_div_0/divbuf_0/OUT5 0.04fF
C3524 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12960_n1600# 0.26fF
C3525 divbuf_2/a_14222_n240# divbuf_2/a_14702_n240# 0.05fF
C3526 divbuf_2/a_34112_170# divbuf_2/a_34112_n240# 0.01fF
C3527 divbuf_1/a_38962_n240# divbuf_1/OUT4 0.04fF
C3528 pd_div_0/divbuf_0/a_30270_n840# pd_div_0/divbuf_0/a_30270_n1540# 0.01fF
C3529 pd_div_0/divbuf_0/a_60510_n840# pd_div_0/divbuf_0/a_60990_n840# 0.07fF
C3530 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/a_60510_n1540# 0.19fF
C3531 pll_full_0/divbuf_1/a_4830_n1540# pll_full_0/divbuf_1/a_5310_n1540# 0.11fF
C3532 pll_full_0/divbuf_1/a_35550_n840# pll_full_0/divbuf_1/a_35550_n1540# 0.01fF
C3533 pll_full_0/divbuf_0/a_18092_170# pll_full_0/divbuf_0/a_18092_n240# 0.01fF
C3534 divbuf_2/a_25920_n1600# divbuf_2/a_25950_n1540# 0.19fF
C3535 divbuf_2/a_25950_n840# divbuf_2/a_26430_n840# 0.07fF
C3536 divbuf_2/a_29742_n240# divbuf_2/OUT4 0.04fF
C3537 divbuf_1/a_21502_170# divbuf_1/a_21982_170# 0.07fF
C3538 divbuf_1/a_31202_170# divbuf_1/a_31202_n240# 0.01fF
C3539 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/a_26832_170# 0.07fF
C3540 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/a_13252_n240# 0.01fF
C3541 divbuf_0/a_45600_n1600# divbuf_0/a_45630_n840# 0.04fF
C3542 divbuf_0/a_7792_n240# divbuf_0/OUT3 0.04fF
C3543 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3544 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_39870_n840# 0.04fF
C3545 divbuf_3/a_15672_170# divbuf_3/a_16152_170# 0.07fF
C3546 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_60000_n1600# 0.26fF
C3547 ro_div_0/divbuf_0/a_16152_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3548 divbuf_3/a_39932_n240# divbuf_3/a_39870_n840# 0.04fF
C3549 divbuf_3/a_48960_n1600# divbuf_3/a_49440_n1600# 0.26fF
C3550 divbuf_1/a_58080_n1600# divbuf_1/a_58560_n1600# 0.26fF
C3551 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z1 0.09fF
C3552 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z2 0.19fF
C3553 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_17790_n840# 0.00fF
C3554 ro_div_0/divbuf_0/a_51870_n1540# ro_div_0/divbuf_0/a_52350_n1540# 0.11fF
C3555 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2430_n840# 0.04fF
C3556 divbuf_3/a_41310_n1540# divbuf_3/a_41790_n1540# 0.11fF
C3557 divbuf_0/a_23442_n240# divbuf_0/a_23922_n240# 0.05fF
C3558 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_18092_n240# 0.05fF
C3559 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/a_37502_n240# 0.01fF
C3560 divbuf_1/a_20190_n840# divbuf_1/a_20190_n1540# 0.01fF
C3561 divbuf_1/a_50400_n1600# divbuf_1/a_50430_n1540# 0.19fF
C3562 divbuf_1/a_23922_170# divbuf_1/a_23922_n240# 0.01fF
C3563 divbuf_0/a_35070_n840# divbuf_0/a_35550_n840# 0.07fF
C3564 divbuf_0/a_4830_n840# divbuf_0/a_4830_n1540# 0.01fF
C3565 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n1540# 0.19fF
C3566 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3567 pll_full_0/divbuf_0/a_29310_n840# pll_full_0/divbuf_0/a_29790_n840# 0.07fF
C3568 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29310_n1540# 0.19fF
C3569 ro_div_0/ro_complete_0/cbank_1/switch_5/vin ro_div_0/divider_0/clk 1.30fF
C3570 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49470_n840# 0.04fF
C3571 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3572 divbuf_3/a_33622_170# divbuf_3/OUT4 0.19fF
C3573 divbuf_3/a_38880_n1600# divbuf_3/a_38910_n840# 0.04fF
C3574 divbuf_1/a_48000_n1600# divbuf_1/a_48030_n840# 0.04fF
C3575 divbuf_1/a_42270_n1540# divbuf_1/a_42750_n1540# 0.11fF
C3576 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/a_11802_170# 0.07fF
C3577 ro_div_0/divider_0/tspc_0/Z2 gnd 0.16fF
C3578 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/a_19562_170# 0.07fF
C3579 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/a_37950_n840# 0.04fF
C3580 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47520_n1600# 0.26fF
C3581 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52800_n1600# 0.26fF
C3582 divbuf_2/a_12480_n1600# divbuf_2/a_12960_n1600# 0.26fF
C3583 pd_div_0/divbuf_0/a_39390_n1540# pd_div_0/divbuf_0/a_39870_n1540# 0.11fF
C3584 pll_full_0/divbuf_1/a_44670_n1540# pll_full_0/divbuf_1/a_45150_n1540# 0.11fF
C3585 divbuf_2/a_4830_n1540# divbuf_2/a_5310_n1540# 0.11fF
C3586 divbuf_2/a_35550_n840# divbuf_2/a_35550_n1540# 0.01fF
C3587 divbuf_1/a_25862_n240# divbuf_1/a_26352_n240# 0.04fF
C3588 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/a_27802_n240# 0.05fF
C3589 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C3590 divbuf_3/a_16642_n240# divbuf_3/a_17122_n240# 0.05fF
C3591 divbuf_3/a_36532_170# divbuf_3/a_36532_n240# 0.01fF
C3592 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_38910_n1540# 0.19fF
C3593 ro_div_0/divbuf_0/a_38910_n840# ro_div_0/divbuf_0/a_39390_n840# 0.07fF
C3594 ro_div_0/divbuf_0/a_8670_n840# ro_div_0/divbuf_0/a_8670_n1540# 0.01fF
C3595 divbuf_0/a_1842_170# divbuf_0/a_1842_n240# 0.01fF
C3596 divbuf_1/a_7230_n840# divbuf_1/a_7230_n1540# 0.01fF
C3597 divbuf_1/a_37470_n840# divbuf_1/a_37950_n840# 0.07fF
C3598 divbuf_3/a_34592_n240# divbuf_3/OUT4 0.04fF
C3599 divbuf_3/a_28350_n840# divbuf_3/a_28830_n840# 0.07fF
C3600 divbuf_3/a_28320_n1600# divbuf_3/a_28350_n1540# 0.19fF
C3601 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3602 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_36990_n840# 0.04fF
C3603 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/clk 0.45fF
C3604 divbuf_0/a_9732_170# divbuf_0/a_10212_170# 0.07fF
C3605 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3606 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42270_n840# 0.04fF
C3607 divbuf_2/a_2400_n1600# divbuf_2/a_2430_n840# 0.04fF
C3608 divbuf_0/a_12282_n240# divbuf_0/a_12510_n840# 0.02fF
C3609 divbuf_0/a_21600_n1600# divbuf_0/a_22080_n1600# 0.26fF
C3610 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_16320_n1600# 0.26fF
C3611 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/a_6270_n840# 0.04fF
C3612 divbuf_1/a_60030_n840# divbuf_1/a_60030_n1540# 0.01fF
C3613 divbuf_0/a_44670_n840# divbuf_0/a_44670_n1540# 0.01fF
C3614 divbuf_0/a_13950_n1540# divbuf_0/a_14430_n1540# 0.11fF
C3615 pll_full_0/divbuf_0/a_8190_n1540# pll_full_0/divbuf_0/a_8670_n1540# 0.11fF
C3616 pll_full_0/divbuf_0/a_38910_n840# pll_full_0/divbuf_0/a_38910_n1540# 0.01fF
C3617 divbuf_2/a_19072_170# divbuf_2/a_19562_170# 0.07fF
C3618 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_15182_n240# 0.05fF
C3619 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/a_34592_n240# 0.01fF
C3620 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/a_39932_n240# 0.01fF
C3621 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/a_20532_n240# 0.04fF
C3622 divbuf_3/a_32640_n1600# divbuf_3/OUT4 0.00fF
C3623 pd_div_0/divbuf_0/a_26430_n840# pd_div_0/divbuf_0/a_26910_n840# 0.07fF
C3624 pd_div_0/divbuf_0/a_30712_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3625 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26430_n1540# 0.19fF
C3626 pll_full_0/divbuf_1/a_1470_n840# pll_full_0/divbuf_1/a_1470_n1540# 0.01fF
C3627 pll_full_0/divbuf_1/a_31710_n840# pll_full_0/divbuf_1/a_32190_n840# 0.07fF
C3628 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_31710_n1540# 0.19fF
C3629 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3630 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C3631 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C3632 divbuf_2/a_52320_n1600# divbuf_2/a_52800_n1600# 0.26fF
C3633 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z1 0.03fF
C3634 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_5362_170# 0.07fF
C3635 divbuf_0/a_11520_n1600# divbuf_0/a_11550_n840# 0.04fF
C3636 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C3637 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_1/A 1.21fF
C3638 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_5790_n840# 0.04fF
C3639 divbuf_2/a_44670_n1540# divbuf_2/a_45150_n1540# 0.11fF
C3640 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_16350_n840# 0.02fF
C3641 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25920_n1600# 0.26fF
C3642 divbuf_3/a_14880_n1600# divbuf_3/a_15360_n1600# 0.26fF
C3643 divbuf_3/a_5362_n240# divbuf_3/a_5310_n840# 0.04fF
C3644 divbuf_1/a_24000_n1600# divbuf_1/a_24480_n1600# 0.26fF
C3645 divbuf_1/a_14702_n240# divbuf_1/a_14910_n840# 0.02fF
C3646 ro_div_0/divbuf_0/a_48510_n840# ro_div_0/divbuf_0/a_48510_n1540# 0.01fF
C3647 ro_div_0/divbuf_0/a_17790_n1540# ro_div_0/divbuf_0/a_18270_n1540# 0.11fF
C3648 divbuf_3/a_7230_n1540# divbuf_3/a_7710_n1540# 0.11fF
C3649 divbuf_3/a_37950_n840# divbuf_3/a_37950_n1540# 0.01fF
C3650 divbuf_1/a_10212_n240# divbuf_1/OUT3 0.04fF
C3651 divbuf_1/a_16320_n1600# divbuf_1/a_16350_n1540# 0.19fF
C3652 divbuf_0/a_28292_170# divbuf_0/a_28772_170# 0.07fF
C3653 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/a_22952_170# 0.07fF
C3654 divbuf_2/a_40412_170# divbuf_2/OUT4 0.19fF
C3655 divbuf_2/a_42240_n1600# divbuf_2/a_42270_n840# 0.04fF
C3656 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/out1 0.31fF
C3657 gnd pd_div_0/divider_0/tspc_2/a_630_n680# 0.61fF
C3658 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/and_0/A 0.01fF
C3659 divbuf_0/a_990_n840# divbuf_0/a_1470_n840# 0.07fF
C3660 divbuf_0/a_16152_170# divbuf_0/OUT4 0.19fF
C3661 divbuf_0/a_960_n1600# divbuf_0/a_990_n1540# 0.19fF
C3662 gnd pll_full_0/divider_0/and_0/out1 0.29fF
C3663 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_56160_n1600# 0.26fF
C3664 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15390_n840# 0.04fF
C3665 divbuf_0/a_53790_n1540# divbuf_0/a_54270_n1540# 0.11fF
C3666 divbuf_3/a_4800_n1600# divbuf_3/a_4830_n840# 0.04fF
C3667 divbuf_1/a_13920_n1600# divbuf_1/a_13950_n840# 0.04fF
C3668 pll_full_0/divbuf_0/a_48030_n1540# pll_full_0/divbuf_0/a_48510_n1540# 0.11fF
C3669 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_13440_n1600# 0.26fF
C3670 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/a_3390_n840# 0.05fF
C3671 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18720_n1600# 0.26fF
C3672 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/a_8670_n840# 0.03fF
C3673 divbuf_2/a_39932_170# divbuf_2/a_39932_n240# 0.01fF
C3674 divbuf_2/a_20042_n240# divbuf_2/a_20532_n240# 0.04fF
C3675 divbuf_1/a_9120_n1600# divbuf_1/OUT3 0.00fF
C3676 pd_div_0/divbuf_0/a_5310_n1540# pd_div_0/divbuf_0/a_5790_n1540# 0.11fF
C3677 pd_div_0/divbuf_0/a_36030_n840# pd_div_0/divbuf_0/a_36030_n1540# 0.01fF
C3678 pll_full_0/divbuf_1/a_10590_n1540# pll_full_0/divbuf_1/a_11070_n1540# 0.11fF
C3679 pll_full_0/divbuf_1/a_41310_n840# pll_full_0/divbuf_1/a_41310_n1540# 0.01fF
C3680 divbuf_2/a_1470_n840# divbuf_2/a_1470_n1540# 0.01fF
C3681 divbuf_2/a_31710_n840# divbuf_2/a_32190_n840# 0.07fF
C3682 divbuf_2/a_31680_n1600# divbuf_2/a_31710_n1540# 0.19fF
C3683 divbuf_2/a_41382_n240# divbuf_2/OUT4 0.04fF
C3684 divbuf_1/a_27322_170# divbuf_1/a_27802_170# 0.07fF
C3685 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/a_32652_170# 0.07fF
C3686 divbuf_0/a_51360_n1600# divbuf_0/a_51390_n840# 0.04fF
C3687 divbuf_0/a_19562_n240# divbuf_0/OUT4 0.04fF
C3688 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C3689 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_45630_n840# 0.04fF
C3690 divbuf_3/a_21502_170# divbuf_3/a_21982_170# 0.07fF
C3691 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Qbar 0.03fF
C3692 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_4830_n1540# 0.19fF
C3693 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3694 ro_div_0/divbuf_0/a_4830_n840# ro_div_0/divbuf_0/a_5310_n840# 0.07fF
C3695 divbuf_3/a_54720_n1600# divbuf_3/a_55200_n1600# 0.26fF
C3696 divbuf_3/a_4882_170# divbuf_3/OUT3 0.19fF
C3697 divbuf_1/a_3390_n840# divbuf_1/a_3870_n840# 0.07fF
C3698 divbuf_1/a_3360_n1600# divbuf_1/a_3390_n1540# 0.19fF
C3699 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_2910_n840# 0.04fF
C3700 ro_div_0/divbuf_0/a_57630_n1540# ro_div_0/divbuf_0/a_58110_n1540# 0.11fF
C3701 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8190_n840# 0.04fF
C3702 divbuf_3/a_47070_n1540# divbuf_3/a_47550_n1540# 0.11fF
C3703 divbuf_1/a_56160_n1600# divbuf_1/a_56190_n1540# 0.19fF
C3704 divbuf_1/a_25950_n840# divbuf_1/a_25950_n1540# 0.01fF
C3705 divbuf_0/a_29262_n240# divbuf_0/a_29742_n240# 0.05fF
C3706 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/a_23922_n240# 0.05fF
C3707 divbuf_1/a_29742_170# divbuf_1/a_29742_n240# 0.01fF
C3708 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n1540# 0.19fF
C3709 divbuf_0/a_40830_n840# divbuf_0/a_41310_n840# 0.07fF
C3710 divbuf_0/a_10590_n840# divbuf_0/a_10590_n1540# 0.01fF
C3711 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35070_n1540# 0.19fF
C3712 pll_full_0/divbuf_0/a_4830_n840# pll_full_0/divbuf_0/a_4830_n1540# 0.01fF
C3713 pll_full_0/divbuf_0/a_35070_n840# pll_full_0/divbuf_0/a_35550_n840# 0.07fF
C3714 divbuf_3/a_492_n240# divbuf_3/a_480_n1600# 0.00fF
C3715 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55230_n840# 0.04fF
C3716 ro_div_0/divbuf_0/a_27322_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3717 divbuf_3/a_5852_n240# divbuf_3/OUT3 0.04fF
C3718 divbuf_3/a_44640_n1600# divbuf_3/a_44670_n840# 0.04fF
C3719 divbuf_1/a_53760_n1600# divbuf_1/a_53790_n840# 0.04fF
C3720 divbuf_1/a_48030_n1540# divbuf_1/a_48510_n1540# 0.11fF
C3721 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/a_20042_170# 0.07fF
C3722 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/a_4882_n240# 0.01fF
C3723 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/a_25382_170# 0.07fF
C3724 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_53280_n1600# 0.26fF
C3725 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C3726 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3727 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58560_n1600# 0.26fF
C3728 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C3729 divbuf_2/a_18240_n1600# divbuf_2/a_18720_n1600# 0.26fF
C3730 divbuf_2/a_8762_n240# divbuf_2/a_8670_n840# 0.03fF
C3731 pd_div_0/divbuf_0/a_45150_n1540# pd_div_0/divbuf_0/a_45630_n1540# 0.11fF
C3732 pll_full_0/divbuf_1/a_50430_n1540# pll_full_0/divbuf_1/a_50910_n1540# 0.11fF
C3733 divbuf_2/a_10590_n1540# divbuf_2/a_11070_n1540# 0.11fF
C3734 divbuf_2/a_41310_n840# divbuf_2/a_41310_n1540# 0.01fF
C3735 divbuf_1/a_31682_n240# divbuf_1/a_32172_n240# 0.04fF
C3736 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/a_33622_n240# 0.05fF
C3737 divbuf_3/a_22472_n240# divbuf_3/a_22952_n240# 0.05fF
C3738 ro_div_0/divbuf_0/a_44670_n840# ro_div_0/divbuf_0/a_45150_n840# 0.07fF
C3739 ro_div_0/divbuf_0/a_14430_n840# ro_div_0/divbuf_0/a_14430_n1540# 0.01fF
C3740 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_44670_n1540# 0.19fF
C3741 divbuf_1/a_12990_n840# divbuf_1/a_12990_n1540# 0.01fF
C3742 divbuf_1/a_43230_n840# divbuf_1/a_43710_n840# 0.07fF
C3743 divbuf_3/a_34080_n1600# divbuf_3/a_34110_n1540# 0.19fF
C3744 divbuf_3/a_3870_n840# divbuf_3/a_3870_n1540# 0.01fF
C3745 divbuf_3/a_34110_n840# divbuf_3/a_34590_n840# 0.07fF
C3746 divbuf_1/a_32172_170# divbuf_1/OUT4 0.19fF
C3747 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/OUT2 0.04fF
C3748 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/OUT4 0.19fF
C3749 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_42750_n840# 0.04fF
C3750 divbuf_0/a_3912_170# divbuf_0/a_4392_170# 0.07fF
C3751 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3752 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48030_n840# 0.04fF
C3753 divbuf_2/a_8160_n1600# divbuf_2/a_8190_n840# 0.04fF
C3754 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C3755 cp_0/a_1710_0# cp_0/down 0.32fF
C3756 divbuf_0/a_18092_n240# divbuf_0/a_18270_n840# 0.02fF
C3757 divbuf_0/a_27360_n1600# divbuf_0/a_27840_n1600# 0.26fF
C3758 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_22080_n1600# 0.26fF
C3759 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12510_n840# 0.02fF
C3760 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/a_1470_n840# 0.03fF
C3761 divbuf_0/a_50430_n840# divbuf_0/a_50430_n1540# 0.01fF
C3762 divbuf_0/a_19710_n1540# divbuf_0/a_20190_n1540# 0.11fF
C3763 pll_full_0/divbuf_0/a_13950_n1540# pll_full_0/divbuf_0/a_14430_n1540# 0.11fF
C3764 pll_full_0/divbuf_0/a_44670_n840# pll_full_0/divbuf_0/a_44670_n1540# 0.01fF
C3765 divbuf_2/a_4882_170# divbuf_2/a_4882_n240# 0.01fF
C3766 divbuf_2/a_24892_170# divbuf_2/a_25382_170# 0.07fF
C3767 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/a_40412_n240# 0.01fF
C3768 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/a_21012_n240# 0.05fF
C3769 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/a_26352_n240# 0.04fF
C3770 divbuf_1/a_9242_170# divbuf_1/OUT3 0.19fF
C3771 pd_div_0/divbuf_0/a_1950_n840# pd_div_0/divbuf_0/a_1950_n1540# 0.01fF
C3772 pd_div_0/divbuf_0/a_32190_n840# pd_div_0/divbuf_0/a_32670_n840# 0.07fF
C3773 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32190_n1540# 0.19fF
C3774 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/OUT2 0.01fF
C3775 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C3776 pll_full_0/divbuf_1/a_7230_n840# pll_full_0/divbuf_1/a_7230_n1540# 0.01fF
C3777 pll_full_0/divbuf_1/a_37470_n840# pll_full_0/divbuf_1/a_37950_n840# 0.07fF
C3778 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37470_n1540# 0.19fF
C3779 divbuf_2/a_11802_170# divbuf_2/OUT4 0.19fF
C3780 divbuf_2/a_58080_n1600# divbuf_2/a_58560_n1600# 0.26fF
C3781 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/nor_1/A 0.01fF
C3782 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/tspc_1/Z3 0.16fF
C3783 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z4 0.21fF
C3784 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C3785 ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C3786 divbuf_0/a_17280_n1600# divbuf_0/a_17310_n840# 0.04fF
C3787 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z3 0.65fF
C3788 gnd pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.27fF
C3789 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_11550_n840# 0.04fF
C3790 divbuf_2/a_50430_n1540# divbuf_2/a_50910_n1540# 0.11fF
C3791 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/a_22110_n840# 0.03fF
C3792 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31680_n1600# 0.26fF
C3793 divbuf_3/a_20640_n1600# divbuf_3/a_21120_n1600# 0.26fF
C3794 divbuf_3/a_11312_n240# divbuf_3/a_11550_n840# 0.02fF
C3795 divbuf_1/a_29760_n1600# divbuf_1/a_30240_n1600# 0.26fF
C3796 divbuf_1/a_20532_n240# divbuf_1/a_20670_n840# 0.03fF
C3797 ro_div_0/divbuf_0/a_54270_n840# ro_div_0/divbuf_0/a_54270_n1540# 0.01fF
C3798 ro_div_0/divbuf_0/a_23550_n1540# ro_div_0/divbuf_0/a_24030_n1540# 0.11fF
C3799 divbuf_3/a_12990_n1540# divbuf_3/a_13470_n1540# 0.11fF
C3800 divbuf_3/a_43710_n840# divbuf_3/a_43710_n1540# 0.01fF
C3801 divbuf_1/a_21982_n240# divbuf_1/OUT4 0.04fF
C3802 divbuf_1/a_22080_n1600# divbuf_1/a_22110_n1540# 0.19fF
C3803 divbuf_0/a_34112_170# divbuf_0/a_34592_170# 0.07fF
C3804 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/a_28772_170# 0.07fF
C3805 divbuf_2/a_12772_n240# divbuf_2/OUT4 0.04fF
C3806 divbuf_2/a_48000_n1600# divbuf_2/a_48030_n840# 0.04fF
C3807 divbuf_1/a_17122_170# divbuf_1/a_17122_n240# 0.01fF
C3808 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/and_0/B 0.29fF
C3809 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n1540# 0.19fF
C3810 divbuf_0/a_30232_170# divbuf_0/OUT4 0.19fF
C3811 divbuf_0/a_6750_n840# divbuf_0/a_7230_n840# 0.07fF
C3812 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_990_n1540# 0.19fF
C3813 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/a_1470_n840# 0.07fF
C3814 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/OUT2 0.19fF
C3815 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21150_n840# 0.04fF
C3816 divbuf_0/a_59550_n1540# divbuf_0/a_60030_n1540# 0.11fF
C3817 pll_full_0/divbuf_0/a_53790_n1540# pll_full_0/divbuf_0/a_54270_n1540# 0.11fF
C3818 divbuf_3/a_10560_n1600# divbuf_3/a_10590_n840# 0.04fF
C3819 divbuf_1/a_19680_n1600# divbuf_1/a_19710_n840# 0.04fF
C3820 divbuf_2/a_25862_n240# divbuf_2/a_26352_n240# 0.04fF
C3821 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_19200_n1600# 0.26fF
C3822 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/a_9150_n840# 0.03fF
C3823 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24480_n1600# 0.26fF
C3824 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_14910_n840# 0.02fF
C3825 divbuf_1/a_20160_n1600# divbuf_1/OUT4 0.00fF
C3826 pd_div_0/divbuf_0/a_11070_n1540# pd_div_0/divbuf_0/a_11550_n1540# 0.11fF
C3827 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/a_41790_n1540# 0.01fF
C3828 pll_full_0/divbuf_1/a_16350_n1540# pll_full_0/divbuf_1/a_16830_n1540# 0.11fF
C3829 pll_full_0/divbuf_1/a_47070_n840# pll_full_0/divbuf_1/a_47070_n1540# 0.01fF
C3830 divbuf_2/a_11040_n1600# divbuf_2/OUT4 0.00fF
C3831 divbuf_2/a_7230_n840# divbuf_2/a_7230_n1540# 0.01fF
C3832 divbuf_2/a_37470_n840# divbuf_2/a_37950_n840# 0.07fF
C3833 divbuf_2/a_37440_n1600# divbuf_2/a_37470_n1540# 0.19fF
C3834 divbuf_1/a_36532_170# divbuf_1/a_37022_170# 0.07fF
C3835 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/a_38472_170# 0.07fF
C3836 divbuf_0/a_57120_n1600# divbuf_0/a_57150_n840# 0.04fF
C3837 divbuf_0/a_31202_n240# divbuf_0/OUT4 0.04fF
C3838 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3839 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51390_n840# 0.04fF
C3840 divbuf_3/a_7302_170# divbuf_3/a_7302_n240# 0.01fF
C3841 divbuf_3/a_27322_170# divbuf_3/a_27802_170# 0.07fF
C3842 pd_div_0/pd_0/tspc_r_1/Qbar pd_div_0/pd_0/and_pd_0/Out1 0.05fF
C3843 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_10590_n1540# 0.19fF
C3844 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/OUT4 0.19fF
C3845 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/a_11070_n840# 0.07fF
C3846 ro_div_0/divider_0/nor_1/A gnd 1.05fF
C3847 divbuf_3/a_16642_170# divbuf_3/OUT4 0.19fF
C3848 divbuf_1/a_9150_n840# divbuf_1/a_9630_n840# 0.07fF
C3849 divbuf_1/a_9120_n1600# divbuf_1/a_9150_n1540# 0.19fF
C3850 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_8670_n840# 0.04fF
C3851 ro_div_0/divbuf_0/OUT3 ro_div_0/divbuf_0/OUT4 0.36fF
C3852 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_13950_n840# 0.04fF
C3853 divbuf_3/a_52830_n1540# divbuf_3/a_53310_n1540# 0.11fF
C3854 divbuf_1/a_510_n840# divbuf_1/OUT2 0.02fF
C3855 divbuf_1/a_31710_n840# divbuf_1/a_31710_n1540# 0.01fF
C3856 divbuf_0/a_35082_n240# divbuf_0/a_35562_n240# 0.05fF
C3857 pll_full_0/divbuf_0/a_29262_n240# pll_full_0/divbuf_0/a_29742_n240# 0.05fF
C3858 divbuf_0/a_46590_n840# divbuf_0/a_47070_n840# 0.07fF
C3859 divbuf_0/a_16350_n840# divbuf_0/a_16350_n1540# 0.01fF
C3860 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n1540# 0.19fF
C3861 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/a_10590_n1540# 0.01fF
C3862 pll_full_0/divbuf_0/a_40830_n840# pll_full_0/divbuf_0/a_41310_n840# 0.07fF
C3863 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_40830_n1540# 0.19fF
C3864 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/a_25862_170# 0.07fF
C3865 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C3866 divbuf_3/a_17612_n240# divbuf_3/OUT4 0.04fF
C3867 divbuf_3/a_50400_n1600# divbuf_3/a_50430_n840# 0.04fF
C3868 divbuf_1/a_59520_n1600# divbuf_1/a_59550_n840# 0.04fF
C3869 divbuf_1/a_53790_n1540# divbuf_1/a_54270_n1540# 0.11fF
C3870 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/a_11312_n240# 0.01fF
C3871 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/a_31202_170# 0.07fF
C3872 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/OUT3 0.19fF
C3873 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_59040_n1600# 0.26fF
C3874 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C3875 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z4 0.12fF
C3876 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C3877 pll_full_0/divbuf_1/a_3390_n840# pll_full_0/divbuf_1/a_3870_n840# 0.07fF
C3878 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/OUT4 0.19fF
C3879 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3390_n1540# 0.19fF
C3880 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C3881 divbuf_2/a_24000_n1600# divbuf_2/a_24480_n1600# 0.26fF
C3882 divbuf_2/a_14702_n240# divbuf_2/a_14910_n840# 0.02fF
C3883 pd_div_0/divbuf_0/a_50910_n1540# pd_div_0/divbuf_0/a_51390_n1540# 0.11fF
C3884 pll_full_0/divbuf_1/a_56190_n1540# pll_full_0/divbuf_1/a_56670_n1540# 0.11fF
C3885 divbuf_2/a_16350_n1540# divbuf_2/a_16830_n1540# 0.11fF
C3886 divbuf_2/a_47070_n840# divbuf_2/a_47070_n1540# 0.01fF
C3887 divbuf_1/a_37502_n240# divbuf_1/a_37992_n240# 0.04fF
C3888 ro_div_0/divbuf_0/a_38962_n240# ro_div_0/divbuf_0/a_39442_n240# 0.05fF
C3889 divbuf_3/a_28292_n240# divbuf_3/a_28772_n240# 0.05fF
C3890 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50430_n1540# 0.19fF
C3891 ro_div_0/divbuf_0/a_50430_n840# ro_div_0/divbuf_0/a_50910_n840# 0.07fF
C3892 ro_div_0/divbuf_0/a_20190_n840# ro_div_0/divbuf_0/a_20190_n1540# 0.01fF
C3893 divbuf_3/a_9630_n840# divbuf_3/a_9630_n1540# 0.01fF
C3894 divbuf_3/a_39870_n840# divbuf_3/a_40350_n840# 0.07fF
C3895 divbuf_3/a_39840_n1600# divbuf_3/a_39870_n1540# 0.19fF
C3896 divbuf_1/a_48990_n840# divbuf_1/a_49470_n840# 0.07fF
C3897 divbuf_1/a_9732_170# divbuf_1/OUT3 0.19fF
C3898 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C3899 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48510_n840# 0.04fF
C3900 pll_full_0/divbuf_1/a_24412_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C3901 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_53790_n840# 0.04fF
C3902 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C3903 divbuf_2/a_13920_n1600# divbuf_2/a_13950_n840# 0.04fF
C3904 divbuf_0/a_8762_170# divbuf_0/OUT3 0.19fF
C3905 divbuf_0/a_23922_n240# divbuf_0/a_24030_n840# 0.03fF
C3906 divbuf_0/a_33120_n1600# divbuf_0/a_33600_n1600# 0.26fF
C3907 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C3908 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27840_n1600# 0.26fF
C3909 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_18270_n840# 0.02fF
C3910 divbuf_0/a_56190_n840# divbuf_0/a_56190_n1540# 0.01fF
C3911 divbuf_0/a_25470_n1540# divbuf_0/a_25950_n1540# 0.11fF
C3912 pll_full_0/divbuf_0/a_19710_n1540# pll_full_0/divbuf_0/a_20190_n1540# 0.11fF
C3913 pll_full_0/divbuf_0/a_50430_n840# pll_full_0/divbuf_0/a_50430_n1540# 0.01fF
C3914 divbuf_2/a_11312_170# divbuf_2/a_11312_n240# 0.01fF
C3915 divbuf_2/a_30712_170# divbuf_2/a_31202_170# 0.07fF
C3916 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/a_26832_n240# 0.05fF
C3917 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/a_32172_n240# 0.04fF
C3918 divbuf_1/a_29262_170# divbuf_1/OUT4 0.19fF
C3919 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C3920 pd_div_0/divbuf_0/a_7710_n840# pd_div_0/divbuf_0/a_7710_n1540# 0.01fF
C3921 pd_div_0/divbuf_0/a_37950_n840# pd_div_0/divbuf_0/a_38430_n840# 0.07fF
C3922 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_37950_n1540# 0.19fF
C3923 pll_full_0/divbuf_1/a_12990_n840# pll_full_0/divbuf_1/a_12990_n1540# 0.01fF
C3924 pll_full_0/divbuf_1/a_43230_n840# pll_full_0/divbuf_1/a_43710_n840# 0.07fF
C3925 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43230_n1540# 0.19fF
C3926 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C3927 divbuf_2/a_3390_n840# divbuf_2/a_3870_n840# 0.07fF
C3928 divbuf_2/a_23442_170# divbuf_2/OUT4 0.19fF
C3929 divbuf_2/a_3360_n1600# divbuf_2/a_3390_n1540# 0.19fF
C3930 divbuf_1/a_8272_170# divbuf_1/a_8762_170# 0.07fF
C3931 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 gnd 0.27fF
C3932 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C3933 divbuf_0/a_23040_n1600# divbuf_0/a_23070_n840# 0.04fF
C3934 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C3935 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17310_n840# 0.04fF
C3936 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/OUT3 0.19fF
C3937 divbuf_2/a_56190_n1540# divbuf_2/a_56670_n1540# 0.11fF
C3938 divbuf_1/a_35520_n1600# divbuf_1/a_36000_n1600# 0.26fF
C3939 divbuf_1/a_26352_n240# divbuf_1/a_26430_n840# 0.04fF
C3940 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/a_27870_n840# 0.04fF
C3941 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_37440_n1600# 0.26fF
C3942 divbuf_3/a_26400_n1600# divbuf_3/a_26880_n1600# 0.26fF
C3943 divbuf_3/a_17122_n240# divbuf_3/a_17310_n840# 0.02fF
C3944 ro_div_0/divbuf_0/a_60030_n840# ro_div_0/divbuf_0/a_60030_n1540# 0.01fF
C3945 ro_div_0/divbuf_0/a_29310_n1540# ro_div_0/divbuf_0/a_29790_n1540# 0.11fF
C3946 divbuf_3/a_18750_n1540# divbuf_3/a_19230_n1540# 0.11fF
C3947 divbuf_3/a_49470_n840# divbuf_3/a_49470_n1540# 0.01fF
C3948 divbuf_1/a_33622_n240# divbuf_1/OUT4 0.04fF
C3949 divbuf_1/a_27840_n1600# divbuf_1/a_27870_n1540# 0.19fF
C3950 divbuf_0/a_39932_170# divbuf_0/a_40412_170# 0.07fF
C3951 divbuf_0/a_20532_170# divbuf_0/a_20532_n240# 0.01fF
C3952 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/a_34592_170# 0.07fF
C3953 divbuf_2/a_24412_n240# divbuf_2/OUT4 0.04fF
C3954 divbuf_2/a_53760_n1600# divbuf_2/a_53790_n840# 0.04fF
C3955 divbuf_0/a_12510_n840# divbuf_0/a_12990_n840# 0.07fF
C3956 divbuf_0/a_41382_170# divbuf_0/OUT5 0.07fF
C3957 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n1540# 0.19fF
C3958 divbuf_0/a_2322_n240# divbuf_0/OUT2 0.04fF
C3959 pll_full_0/divbuf_0/a_6750_n840# pll_full_0/divbuf_0/a_7230_n840# 0.07fF
C3960 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/OUT4 0.19fF
C3961 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_6750_n1540# 0.19fF
C3962 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_26910_n840# 0.04fF
C3963 pll_full_0/divbuf_0/a_59550_n1540# pll_full_0/divbuf_0/a_60030_n1540# 0.11fF
C3964 divbuf_3/a_16320_n1600# divbuf_3/a_16350_n840# 0.04fF
C3965 divbuf_1/a_25440_n1600# divbuf_1/a_25470_n840# 0.04fF
C3966 divbuf_1/a_19710_n1540# divbuf_1/a_20190_n1540# 0.11fF
C3967 divbuf_2/a_31682_n240# divbuf_2/a_32172_n240# 0.04fF
C3968 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24960_n1600# 0.26fF
C3969 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_15390_n840# 0.02fF
C3970 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_30240_n1600# 0.26fF
C3971 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/a_20670_n840# 0.03fF
C3972 divbuf_1/a_31680_n1600# divbuf_1/OUT4 0.00fF
C3973 pd_div_0/divbuf_0/a_16830_n1540# pd_div_0/divbuf_0/a_17310_n1540# 0.11fF
C3974 pd_div_0/divbuf_0/a_47550_n840# pd_div_0/divbuf_0/a_47550_n1540# 0.01fF
C3975 pll_full_0/divbuf_1/a_22110_n1540# pll_full_0/divbuf_1/a_22590_n1540# 0.11fF
C3976 pll_full_0/divbuf_1/a_52830_n840# pll_full_0/divbuf_1/a_52830_n1540# 0.01fF
C3977 divbuf_2/a_12990_n840# divbuf_2/a_12990_n1540# 0.01fF
C3978 divbuf_2/a_43230_n840# divbuf_2/a_43710_n840# 0.07fF
C3979 divbuf_2/a_43200_n1600# divbuf_2/a_43230_n1540# 0.19fF
C3980 divbuf_2/a_22560_n1600# divbuf_2/OUT4 0.01fF
C3981 divbuf_1/a_1842_n240# divbuf_1/a_2322_n240# 0.05fF
C3982 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/a_24412_n240# 0.01fF
C3983 ro_div_0/divbuf_0/a_3912_n240# ro_div_0/divbuf_0/a_4392_n240# 0.05fF
C3984 divbuf_0/a_1920_n1600# divbuf_0/OUT2 0.00fF
C3985 divbuf_0/a_0_n1600# divbuf_0/OUT 0.26fF
C3986 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C3987 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57150_n840# 0.04fF
C3988 divbuf_3/a_13742_170# divbuf_3/a_13742_n240# 0.01fF
C3989 divbuf_3/a_33142_170# divbuf_3/a_33622_170# 0.07fF
C3990 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/a_15182_170# 0.07fF
C3991 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16350_n1540# 0.19fF
C3992 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C3993 ro_div_0/divbuf_0/a_16350_n840# ro_div_0/divbuf_0/a_16830_n840# 0.07fF
C3994 divbuf_3/a_5790_n840# divbuf_3/a_6270_n840# 0.07fF
C3995 divbuf_3/a_28292_170# divbuf_3/OUT4 0.19fF
C3996 divbuf_3/a_5760_n1600# divbuf_3/a_5790_n1540# 0.19fF
C3997 divbuf_1/a_14910_n840# divbuf_1/a_15390_n840# 0.07fF
C3998 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14430_n840# 0.04fF
C3999 divbuf_0/a_18092_170# divbuf_0/a_18582_170# 0.07fF
C4000 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_19710_n840# 0.04fF
C4001 divbuf_3/a_58590_n1540# divbuf_3/a_59070_n1540# 0.11fF
C4002 divbuf_1/a_37470_n840# divbuf_1/a_37470_n1540# 0.01fF
C4003 divbuf_0/a_40902_n240# divbuf_0/a_41382_n240# 0.05fF
C4004 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/a_35562_n240# 0.05fF
C4005 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n1540# 0.19fF
C4006 divbuf_0/a_52350_n840# divbuf_0/a_52830_n840# 0.07fF
C4007 divbuf_0/a_22110_n840# divbuf_0/a_22110_n1540# 0.01fF
C4008 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_46590_n1540# 0.19fF
C4009 pll_full_0/divbuf_0/a_16350_n840# pll_full_0/divbuf_0/a_16350_n1540# 0.01fF
C4010 pll_full_0/divbuf_0/a_46590_n840# pll_full_0/divbuf_0/a_47070_n840# 0.07fF
C4011 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/a_31682_170# 0.07fF
C4012 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C4013 divbuf_3/a_56160_n1600# divbuf_3/a_56190_n840# 0.04fF
C4014 divbuf_3/a_29262_n240# divbuf_3/OUT4 0.04fF
C4015 divbuf_1/a_59550_n1540# divbuf_1/a_60030_n1540# 0.11fF
C4016 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/a_17122_n240# 0.01fF
C4017 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/a_37022_170# 0.07fF
C4018 pd_div_0/divbuf_0/a_3870_n840# pd_div_0/divbuf_0/a_4350_n840# 0.07fF
C4019 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4020 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_3870_n1540# 0.19fF
C4021 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C4022 pll_full_0/divbuf_1/a_9150_n840# pll_full_0/divbuf_1/a_9630_n840# 0.07fF
C4023 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4024 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9150_n1540# 0.19fF
C4025 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C4026 divbuf_2/a_29760_n1600# divbuf_2/a_30240_n1600# 0.26fF
C4027 divbuf_2/a_20532_n240# divbuf_2/a_20670_n840# 0.03fF
C4028 pd_div_0/divbuf_0/a_56670_n1540# pd_div_0/divbuf_0/a_57150_n1540# 0.11fF
C4029 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C4030 divbuf_2/a_22110_n1540# divbuf_2/a_22590_n1540# 0.11fF
C4031 divbuf_2/a_52830_n840# divbuf_2/a_52830_n1540# 0.01fF
C4032 divbuf_1/a_1440_n1600# divbuf_1/a_1920_n1600# 0.26fF
C4033 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_3360_n1600# 0.26fF
C4034 divbuf_3/a_34112_n240# divbuf_3/a_34592_n240# 0.05fF
C4035 ro_div_0/divbuf_0/a_56190_n840# ro_div_0/divbuf_0/a_56670_n840# 0.07fF
C4036 ro_div_0/divbuf_0/a_25950_n840# ro_div_0/divbuf_0/a_25950_n1540# 0.01fF
C4037 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56190_n1540# 0.19fF
C4038 divbuf_3/a_45600_n1600# divbuf_3/a_45630_n1540# 0.19fF
C4039 divbuf_3/a_15390_n840# divbuf_3/a_15390_n1540# 0.01fF
C4040 divbuf_3/a_45630_n840# divbuf_3/a_46110_n840# 0.07fF
C4041 divbuf_1/a_54750_n840# divbuf_1/a_55230_n840# 0.07fF
C4042 divbuf_1/a_15672_170# divbuf_1/OUT4 0.19fF
C4043 pd_div_0/divbuf_0/a_25382_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4044 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54270_n840# 0.04fF
C4045 pll_full_0/divbuf_1/a_36052_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4046 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_59550_n840# 0.04fF
C4047 divbuf_2/a_19680_n1600# divbuf_2/a_19710_n840# 0.04fF
C4048 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C4049 divbuf_0/a_29742_n240# divbuf_0/a_29790_n840# 0.04fF
C4050 divbuf_0/a_38880_n1600# divbuf_0/a_39360_n1600# 0.26fF
C4051 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C4052 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C4053 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C4054 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33600_n1600# 0.26fF
C4055 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/a_24030_n840# 0.03fF
C4056 divbuf_1/a_12282_n240# divbuf_1/a_12030_n840# 0.02fF
C4057 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_13470_n840# 0.01fF
C4058 divbuf_0/a_31230_n1540# divbuf_0/a_31710_n1540# 0.11fF
C4059 pll_full_0/divbuf_0/a_25470_n1540# pll_full_0/divbuf_0/a_25950_n1540# 0.11fF
C4060 pll_full_0/divbuf_0/a_56190_n840# pll_full_0/divbuf_0/a_56190_n1540# 0.01fF
C4061 divbuf_3/a_2322_n240# divbuf_3/a_2430_n840# 0.03fF
C4062 divbuf_2/a_17122_170# divbuf_2/a_17122_n240# 0.01fF
C4063 divbuf_2/a_36532_170# divbuf_2/a_37022_170# 0.07fF
C4064 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/a_32652_n240# 0.05fF
C4065 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/a_37992_n240# 0.04fF
C4066 divbuf_1/a_4882_n240# divbuf_1/OUT3 0.04fF
C4067 pd_div_0/divbuf_0/a_13470_n840# pd_div_0/divbuf_0/a_13470_n1540# 0.01fF
C4068 pd_div_0/divbuf_0/a_43710_n840# pd_div_0/divbuf_0/a_44190_n840# 0.07fF
C4069 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_43710_n1540# 0.19fF
C4070 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C4071 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C4072 pll_full_0/divbuf_1/a_18750_n840# pll_full_0/divbuf_1/a_18750_n1540# 0.01fF
C4073 pll_full_0/divbuf_1/a_48990_n840# pll_full_0/divbuf_1/a_49470_n840# 0.07fF
C4074 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_48990_n1540# 0.19fF
C4075 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/a_9732_n240# 0.01fF
C4076 divbuf_2/a_9150_n840# divbuf_2/a_9630_n840# 0.07fF
C4077 divbuf_2/a_35082_170# divbuf_2/OUT4 0.19fF
C4078 divbuf_2/a_9120_n1600# divbuf_2/a_9150_n1540# 0.19fF
C4079 divbuf_1/a_33622_170# divbuf_1/a_34112_170# 0.07fF
C4080 pd_div_0/divider_0/prescaler_0/nand_0/z1 gnd 0.16fF
C4081 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/Out 0.04fF
C4082 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C4083 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_2/v 0.08fF
C4084 divbuf_0/a_12772_170# divbuf_0/OUT4 0.19fF
C4085 divbuf_0/a_28800_n1600# divbuf_0/a_28830_n840# 0.04fF
C4086 gnd pll_full_0/divider_0/tspc_2/a_630_n680# 0.61fF
C4087 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C4088 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C4089 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z3 0.38fF
C4090 pll_full_0/divbuf_0/a_14222_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4091 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23070_n840# 0.04fF
C4092 divbuf_1/a_41280_n1600# divbuf_1/a_41760_n1600# 0.26fF
C4093 divbuf_1/a_32172_n240# divbuf_1/a_32190_n840# 0.06fF
C4094 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/a_33630_n840# 0.06fF
C4095 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/OUT3 0.19fF
C4096 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_43200_n1600# 0.26fF
C4097 divbuf_3/a_32160_n1600# divbuf_3/a_32640_n1600# 0.26fF
C4098 divbuf_3/a_22952_n240# divbuf_3/a_23070_n840# 0.03fF
C4099 ro_div_0/divbuf_0/a_35070_n1540# ro_div_0/divbuf_0/a_35550_n1540# 0.11fF
C4100 divbuf_3/a_24510_n1540# divbuf_3/a_24990_n1540# 0.11fF
C4101 divbuf_3/a_55230_n840# divbuf_3/a_55230_n1540# 0.01fF
C4102 divbuf_1/a_33600_n1600# divbuf_1/a_33630_n1540# 0.19fF
C4103 divbuf_0/a_5852_n240# divbuf_0/a_6332_n240# 0.05fF
C4104 divbuf_0/a_26352_170# divbuf_0/a_26352_n240# 0.01fF
C4105 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/a_20532_n240# 0.01fF
C4106 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/a_40412_170# 0.07fF
C4107 divbuf_2/a_36052_n240# divbuf_2/OUT4 0.04fF
C4108 divbuf_2/a_59520_n1600# divbuf_2/a_59550_n840# 0.04fF
C4109 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n1540# 0.19fF
C4110 divbuf_0/a_14222_n240# divbuf_0/OUT4 0.04fF
C4111 divbuf_0/a_18270_n840# divbuf_0/a_18750_n840# 0.07fF
C4112 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/OUT2 0.04fF
C4113 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12510_n1540# 0.19fF
C4114 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/OUT5 0.07fF
C4115 pll_full_0/divbuf_0/a_12510_n840# pll_full_0/divbuf_0/a_12990_n840# 0.07fF
C4116 divbuf_1/a_31200_n1600# divbuf_1/a_31230_n840# 0.04fF
C4117 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_32670_n840# 0.04fF
C4118 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4119 ro_div_0/divider_0/tspc_0/Z4 gnd 0.44fF
C4120 divbuf_3/a_22080_n1600# divbuf_3/a_22110_n840# 0.04fF
C4121 divbuf_1/a_25470_n1540# divbuf_1/a_25950_n1540# 0.11fF
C4122 divbuf_2/a_37502_n240# divbuf_2/a_37992_n240# 0.04fF
C4123 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30720_n1600# 0.26fF
C4124 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/a_21150_n840# 0.03fF
C4125 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_36000_n1600# 0.26fF
C4126 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/a_26430_n840# 0.04fF
C4127 pd_div_0/divbuf_0/a_22590_n1540# pd_div_0/divbuf_0/a_23070_n1540# 0.11fF
C4128 pd_div_0/divbuf_0/a_53310_n840# pd_div_0/divbuf_0/a_53310_n1540# 0.01fF
C4129 pll_full_0/divbuf_1/a_27870_n1540# pll_full_0/divbuf_1/a_28350_n1540# 0.11fF
C4130 pll_full_0/divbuf_1/a_58590_n840# pll_full_0/divbuf_1/a_58590_n1540# 0.01fF
C4131 divbuf_2/a_34080_n1600# divbuf_2/OUT4 0.01fF
C4132 divbuf_2/a_18750_n840# divbuf_2/a_18750_n1540# 0.01fF
C4133 divbuf_2/a_48990_n840# divbuf_2/a_49470_n840# 0.07fF
C4134 divbuf_2/a_48960_n1600# divbuf_2/a_48990_n1540# 0.19fF
C4135 divbuf_1/a_8272_n240# divbuf_1/a_8762_n240# 0.04fF
C4136 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/a_30232_n240# 0.01fF
C4137 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/a_10212_n240# 0.05fF
C4138 divbuf_0/a_12480_n1600# divbuf_0/OUT4 0.00fF
C4139 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C4140 divbuf_3/a_19562_170# divbuf_3/a_19562_n240# 0.01fF
C4141 divbuf_3/a_38962_170# divbuf_3/a_39442_170# 0.07fF
C4142 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/a_2322_n240# 0.01fF
C4143 ro_div_0/divbuf_0/a_22110_n840# ro_div_0/divbuf_0/a_22590_n840# 0.07fF
C4144 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22110_n1540# 0.19fF
C4145 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4146 divbuf_3/a_39932_170# divbuf_3/OUT4 0.19fF
C4147 divbuf_3/a_11520_n1600# divbuf_3/a_11550_n1540# 0.19fF
C4148 divbuf_3/a_11550_n840# divbuf_3/a_12030_n840# 0.07fF
C4149 divbuf_1/a_20670_n840# divbuf_1/a_21150_n840# 0.07fF
C4150 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20190_n840# 0.04fF
C4151 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/OUT2 0.42fF
C4152 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/OUT3 0.19fF
C4153 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25470_n840# 0.04fF
C4154 divbuf_1/a_43230_n840# divbuf_1/a_43230_n1540# 0.01fF
C4155 divbuf_0/a_4800_n1600# divbuf_0/a_5280_n1600# 0.26fF
C4156 pll_full_0/divbuf_0/a_40902_n240# pll_full_0/divbuf_0/a_41382_n240# 0.05fF
C4157 divbuf_0/a_58110_n840# divbuf_0/a_58590_n840# 0.07fF
C4158 divbuf_0/a_27870_n840# divbuf_0/a_27870_n1540# 0.01fF
C4159 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n1540# 0.19fF
C4160 pll_full_0/divbuf_0/a_22110_n840# pll_full_0/divbuf_0/a_22110_n1540# 0.01fF
C4161 pll_full_0/divbuf_0/a_52350_n840# pll_full_0/divbuf_0/a_52830_n840# 0.07fF
C4162 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52350_n1540# 0.19fF
C4163 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/a_17612_n240# 0.01fF
C4164 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/a_37502_170# 0.07fF
C4165 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C4166 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/a_2322_n240# 0.05fF
C4167 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/a_22952_n240# 0.01fF
C4168 divbuf_3/a_480_n1600# divbuf_3/IN 0.00fF
C4169 divbuf_3/a_40902_n240# divbuf_3/OUT4 0.04fF
C4170 pd_div_0/divbuf_0/a_9630_n840# pd_div_0/divbuf_0/a_10110_n840# 0.07fF
C4171 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4172 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_9630_n1540# 0.19fF
C4173 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/clk 0.45fF
C4174 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C4175 pll_full_0/divbuf_1/a_14910_n840# pll_full_0/divbuf_1/a_15390_n840# 0.07fF
C4176 pll_full_0/divbuf_1/a_7302_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C4177 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_14910_n1540# 0.19fF
C4178 divbuf_2/a_35520_n1600# divbuf_2/a_36000_n1600# 0.26fF
C4179 divbuf_2/a_26352_n240# divbuf_2/a_26430_n840# 0.04fF
C4180 divbuf_1/a_510_n1540# divbuf_1/OUT 0.11fF
C4181 pd_div_0/divbuf_0/a_60990_n1540# pd_div_0/divbuf_0/OUT5 0.19fF
C4182 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C4183 divbuf_0/a_15672_n240# divbuf_0/a_15390_n840# 0.01fF
C4184 divbuf_2/a_27870_n1540# divbuf_2/a_28350_n1540# 0.11fF
C4185 divbuf_2/a_58590_n840# divbuf_2/a_58590_n1540# 0.01fF
C4186 divbuf_1/a_7200_n1600# divbuf_1/a_7680_n1600# 0.26fF
C4187 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_9120_n1600# 0.26fF
C4188 divbuf_3/a_39932_n240# divbuf_3/a_40412_n240# 0.05fF
C4189 ro_div_0/divbuf_0/a_31710_n840# ro_div_0/divbuf_0/a_31710_n1540# 0.01fF
C4190 ro_div_0/divbuf_0/a_990_n1540# ro_div_0/divbuf_0/a_1470_n1540# 0.11fF
C4191 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/OUT2 0.02fF
C4192 divbuf_3/a_21150_n840# divbuf_3/a_21150_n1540# 0.01fF
C4193 divbuf_3/a_51390_n840# divbuf_3/a_51870_n840# 0.07fF
C4194 divbuf_3/a_51360_n1600# divbuf_3/a_51390_n1540# 0.19fF
C4195 divbuf_1/a_60510_n840# divbuf_1/a_60990_n840# 0.07fF
C4196 divbuf_1/a_13252_170# divbuf_1/OUT4 0.19fF
C4197 pd_div_0/divbuf_0/a_37022_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4198 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60030_n840# 0.04fF
C4199 divbuf_0/a_11312_170# divbuf_0/a_11802_170# 0.07fF
C4200 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C4201 divbuf_2/a_6332_170# divbuf_2/OUT3 0.19fF
C4202 divbuf_2/a_25440_n1600# divbuf_2/a_25470_n840# 0.04fF
C4203 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z3 0.06fF
C4204 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Q 0.51fF
C4205 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C4206 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/a_3912_170# 0.07fF
C4207 divbuf_0/a_35562_n240# divbuf_0/a_35550_n840# 0.05fF
C4208 divbuf_0/a_44640_n1600# divbuf_0/a_45120_n1600# 0.26fF
C4209 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_39360_n1600# 0.26fF
C4210 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/a_29790_n840# 0.04fF
C4211 divbuf_1/a_18092_n240# divbuf_1/a_17790_n840# 0.00fF
C4212 divbuf_0/a_36990_n1540# divbuf_0/a_37470_n1540# 0.11fF
C4213 pll_full_0/divbuf_0/a_31230_n1540# pll_full_0/divbuf_0/a_31710_n1540# 0.11fF
C4214 divbuf_2/a_1842_n240# divbuf_2/a_2322_n240# 0.05fF
C4215 divbuf_2/a_22952_170# divbuf_2/a_22952_n240# 0.01fF
C4216 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/a_38472_n240# 0.05fF
C4217 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1920_n1600# 0.26fF
C4218 divbuf_1/a_16642_n240# divbuf_1/OUT4 0.04fF
C4219 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C4220 pd_div_0/divbuf_0/a_19230_n840# pd_div_0/divbuf_0/a_19230_n1540# 0.01fF
C4221 pd_div_0/divbuf_0/a_49470_n840# pd_div_0/divbuf_0/a_49950_n840# 0.07fF
C4222 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49470_n1540# 0.19fF
C4223 pll_full_0/divbuf_1/a_24510_n840# pll_full_0/divbuf_1/a_24510_n1540# 0.01fF
C4224 pll_full_0/divbuf_1/a_54750_n840# pll_full_0/divbuf_1/a_55230_n840# 0.07fF
C4225 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_54750_n1540# 0.19fF
C4226 divbuf_2/a_14910_n840# divbuf_2/a_15390_n840# 0.07fF
C4227 divbuf_2/a_7302_n240# divbuf_2/OUT3 0.04fF
C4228 divbuf_2/a_14880_n1600# divbuf_2/a_14910_n1540# 0.19fF
C4229 pd_div_0/divider_0/tspc_2/Z2 pd_div_0/divider_0/tspc_2/Z3 0.16fF
C4230 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z4 0.22fF
C4231 gnd pd_div_0/divider_0/clk 0.07fF
C4232 ro_div_0/ro_complete_0/cbank_2/switch_4/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C4233 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/a_17122_170# 0.07fF
C4234 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/a_8762_n240# 0.01fF
C4235 divbuf_0/a_34560_n1600# divbuf_0/a_34590_n840# 0.04fF
C4236 divbuf_0/a_24892_170# divbuf_0/OUT4 0.19fF
C4237 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4238 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_28830_n840# 0.04fF
C4239 divbuf_3/a_3912_170# divbuf_3/a_4392_170# 0.07fF
C4240 divbuf_1/a_37992_n240# divbuf_1/a_37950_n840# 0.04fF
C4241 divbuf_1/a_47040_n1600# divbuf_1/a_47520_n1600# 0.26fF
C4242 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/OUT3 0.19fF
C4243 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48960_n1600# 0.26fF
C4244 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/a_39390_n840# 0.04fF
C4245 divbuf_3/a_37920_n1600# divbuf_3/a_38400_n1600# 0.26fF
C4246 divbuf_3/a_28772_n240# divbuf_3/a_28830_n840# 0.04fF
C4247 ro_div_0/divbuf_0/a_40830_n1540# ro_div_0/divbuf_0/a_41310_n1540# 0.11fF
C4248 divbuf_3/a_30270_n1540# divbuf_3/a_30750_n1540# 0.11fF
C4249 divbuf_3/a_60990_n840# divbuf_3/a_60990_n1540# 0.01fF
C4250 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12030_n840# 0.02fF
C4251 divbuf_1/a_39360_n1600# divbuf_1/a_39390_n1540# 0.19fF
C4252 divbuf_0/a_32172_170# divbuf_0/a_32172_n240# 0.01fF
C4253 divbuf_0/a_12282_n240# divbuf_0/a_12772_n240# 0.04fF
C4254 pll_full_0/divbuf_0/a_5852_n240# pll_full_0/divbuf_0/a_6332_n240# 0.05fF
C4255 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/a_26352_n240# 0.01fF
C4256 divbuf_1/a_13252_170# divbuf_1/a_13252_n240# 0.01fF
C4257 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/a_16642_n240# 0.01fF
C4258 divbuf_0/a_24030_n840# divbuf_0/a_24510_n840# 0.07fF
C4259 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n1540# 0.19fF
C4260 divbuf_0/a_25862_n240# divbuf_0/OUT4 0.04fF
C4261 pll_full_0/divbuf_0/a_18270_n840# pll_full_0/divbuf_0/a_18750_n840# 0.07fF
C4262 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4263 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18270_n1540# 0.19fF
C4264 divbuf_1/a_36960_n1600# divbuf_1/a_36990_n840# 0.04fF
C4265 pd_div_0/pd_0/R pd_div_0/pd_0/and_pd_0/Z1 0.02fF
C4266 pd_div_0/pd_0/tspc_r_1/Qbar1 pd_div_0/pd_0/tspc_r_1/z5 0.20fF
C4267 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38430_n840# 0.04fF
C4268 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4269 ro_div_0/divider_0/tspc_1/Z2 gnd 0.16fF
C4270 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/a_7792_170# 0.07fF
C4271 divbuf_3/a_11312_170# divbuf_3/OUT4 0.23fF
C4272 divbuf_3/a_27840_n1600# divbuf_3/a_27870_n840# 0.04fF
C4273 divbuf_1/a_31230_n1540# divbuf_1/a_31710_n1540# 0.11fF
C4274 divbuf_2/a_1440_n1600# divbuf_2/a_1920_n1600# 0.26fF
C4275 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/a_36480_n1600# 0.26fF
C4276 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/a_26910_n840# 0.04fF
C4277 pll_full_0/divbuf_1/a_41280_n1600# pll_full_0/divbuf_1/a_41760_n1600# 0.26fF
C4278 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/a_32190_n840# 0.06fF
C4279 pd_div_0/divbuf_0/a_28350_n1540# pd_div_0/divbuf_0/a_28830_n1540# 0.11fF
C4280 pd_div_0/divbuf_0/a_59070_n840# pd_div_0/divbuf_0/a_59070_n1540# 0.01fF
C4281 pll_full_0/divbuf_1/a_33630_n1540# pll_full_0/divbuf_1/a_34110_n1540# 0.11fF
C4282 divbuf_2/a_24510_n840# divbuf_2/a_24510_n1540# 0.01fF
C4283 divbuf_2/a_54750_n840# divbuf_2/a_55230_n840# 0.07fF
C4284 divbuf_2/a_54720_n1600# divbuf_2/a_54750_n1540# 0.19fF
C4285 divbuf_1/a_14702_n240# divbuf_1/a_15182_n240# 0.05fF
C4286 divbuf_1/a_34592_170# divbuf_1/a_34592_n240# 0.01fF
C4287 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/a_36052_n240# 0.01fF
C4288 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_16642_n240# 0.04fF
C4289 divbuf_0/a_24000_n1600# divbuf_0/OUT4 0.00fF
C4290 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C4291 divbuf_3/a_4882_n240# divbuf_3/a_5362_n240# 0.05fF
C4292 divbuf_3/a_25382_170# divbuf_3/a_25382_n240# 0.01fF
C4293 divbuf_1/a_26430_n840# divbuf_1/a_26910_n840# 0.07fF
C4294 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_27870_n1540# 0.19fF
C4295 ro_div_0/divbuf_0/a_27870_n840# ro_div_0/divbuf_0/a_28350_n840# 0.07fF
C4296 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4297 divbuf_3/a_17310_n840# divbuf_3/a_17790_n840# 0.07fF
C4298 divbuf_3/a_12282_n240# divbuf_3/OUT4 0.04fF
C4299 divbuf_3/a_17280_n1600# divbuf_3/a_17310_n1540# 0.19fF
C4300 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Q 0.04fF
C4301 divbuf_2/a_12282_n240# divbuf_2/a_12030_n840# 0.02fF
C4302 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4303 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_25950_n840# 0.04fF
C4304 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4305 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31230_n840# 0.04fF
C4306 divbuf_1/a_48990_n840# divbuf_1/a_48990_n1540# 0.01fF
C4307 divbuf_0/a_10560_n1600# divbuf_0/a_11040_n1600# 0.26fF
C4308 pll_full_0/divbuf_0/a_4800_n1600# pll_full_0/divbuf_0/a_5280_n1600# 0.26fF
C4309 divbuf_0/a_33630_n840# divbuf_0/a_33630_n1540# 0.01fF
C4310 divbuf_0/a_2910_n1540# divbuf_0/a_3390_n1540# 0.11fF
C4311 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58110_n1540# 0.19fF
C4312 pll_full_0/divbuf_0/a_27870_n840# pll_full_0/divbuf_0/a_27870_n1540# 0.01fF
C4313 pll_full_0/divbuf_0/a_58110_n840# pll_full_0/divbuf_0/a_58590_n840# 0.07fF
C4314 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/a_23442_n240# 0.01fF
C4315 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C4316 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/a_8762_n240# 0.04fF
C4317 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/a_28772_n240# 0.01fF
C4318 divbuf_3/a_11040_n1600# divbuf_3/OUT3 0.00fF
C4319 divbuf_2/a_7302_170# divbuf_2/a_7792_170# 0.07fF
C4320 divbuf_2/a_41280_n1600# divbuf_2/a_41760_n1600# 0.26fF
C4321 divbuf_2/a_32172_n240# divbuf_2/a_32190_n840# 0.06fF
C4322 pd_div_0/divbuf_0/a_15390_n840# pd_div_0/divbuf_0/a_15870_n840# 0.07fF
C4323 pd_div_0/divbuf_0/a_8272_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C4324 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15390_n1540# 0.19fF
C4325 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/nor_0/B 0.35fF
C4326 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C4327 pll_full_0/divbuf_1/a_20670_n840# pll_full_0/divbuf_1/a_21150_n840# 0.07fF
C4328 pll_full_0/divbuf_1/a_19072_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4329 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_20670_n1540# 0.19fF
C4330 divbuf_1/a_30712_170# divbuf_1/a_31202_170# 0.07fF
C4331 divbuf_0/a_480_n1600# divbuf_0/a_510_n840# 0.04fF
C4332 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_15390_n840# 0.01fF
C4333 divbuf_2/a_33630_n1540# divbuf_2/a_34110_n1540# 0.11fF
C4334 divbuf_1/a_12960_n1600# divbuf_1/a_13440_n1600# 0.26fF
C4335 divbuf_1/a_3422_n240# divbuf_1/a_3390_n840# 0.05fF
C4336 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/a_4830_n840# 0.04fF
C4337 ro_div_0/divbuf_0/a_14400_n1600# ro_div_0/divbuf_0/a_14880_n1600# 0.26fF
C4338 divbuf_3/a_3840_n1600# divbuf_3/a_4320_n1600# 0.26fF
C4339 ro_div_0/divbuf_0/a_37470_n840# ro_div_0/divbuf_0/a_37470_n1540# 0.01fF
C4340 ro_div_0/divbuf_0/a_6750_n1540# ro_div_0/divbuf_0/a_7230_n1540# 0.11fF
C4341 divbuf_3/a_57120_n1600# divbuf_3/a_57150_n1540# 0.19fF
C4342 divbuf_3/a_26910_n840# divbuf_3/a_26910_n1540# 0.01fF
C4343 divbuf_3/a_57150_n840# divbuf_3/a_57630_n840# 0.07fF
C4344 divbuf_1/a_5310_n1540# divbuf_1/a_5790_n1540# 0.11fF
C4345 divbuf_1/a_23922_170# divbuf_1/OUT4 0.19fF
C4346 divbuf_0/a_3912_170# divbuf_0/a_3912_n240# 0.01fF
C4347 divbuf_0/a_14702_170# divbuf_0/a_15182_170# 0.07fF
C4348 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C4349 divbuf_2/a_18092_170# divbuf_2/OUT4 0.19fF
C4350 divbuf_2/a_31200_n1600# divbuf_2/a_31230_n840# 0.04fF
C4351 pd_div_0/divider_0/tspc_1/Z3 pd_div_0/divider_0/tspc_1/Z4 0.65fF
C4352 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C4353 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.44fF
C4354 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/and_0/B 0.78fF
C4355 divbuf_0/a_50400_n1600# divbuf_0/a_50880_n1600# 0.26fF
C4356 divbuf_0/a_41382_n240# divbuf_0/a_41310_n840# 0.03fF
C4357 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.22fF
C4358 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C4359 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C4360 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.27fF
C4361 pll_full_0/divbuf_0/a_44640_n1600# pll_full_0/divbuf_0/a_45120_n1600# 0.26fF
C4362 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/a_35550_n840# 0.05fF
C4363 divbuf_1/a_2880_n1600# divbuf_1/a_2910_n840# 0.04fF
C4364 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4350_n840# 0.04fF
C4365 divbuf_0/a_42750_n1540# divbuf_0/a_43230_n1540# 0.11fF
C4366 pll_full_0/divbuf_0/a_36990_n1540# pll_full_0/divbuf_0/a_37470_n1540# 0.11fF
C4367 divbuf_3/a_14702_n240# divbuf_3/a_14430_n840# 0.01fF
C4368 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/a_2400_n1600# 0.26fF
C4369 divbuf_2/a_8272_n240# divbuf_2/a_8762_n240# 0.04fF
C4370 divbuf_2/a_28772_170# divbuf_2/a_28772_n240# 0.01fF
C4371 pll_full_0/divbuf_1/a_7200_n1600# pll_full_0/divbuf_1/a_7680_n1600# 0.26fF
C4372 divbuf_1/a_28292_n240# divbuf_1/OUT4 0.04fF
C4373 pd_div_0/divbuf_0/a_24990_n840# pd_div_0/divbuf_0/a_24990_n1540# 0.01fF
C4374 pd_div_0/divbuf_0/a_55230_n840# pd_div_0/divbuf_0/a_55710_n840# 0.07fF
C4375 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55230_n1540# 0.19fF
C4376 divbuf_0/a_16642_170# divbuf_0/a_16642_n240# 0.01fF
C4377 divbuf_0/a_492_n240# divbuf_0/a_960_n1600# 0.00fF
C4378 pll_full_0/divbuf_1/a_30270_n840# pll_full_0/divbuf_1/a_30270_n1540# 0.01fF
C4379 pll_full_0/divbuf_1/a_60510_n840# pll_full_0/divbuf_1/a_60990_n840# 0.07fF
C4380 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/a_60510_n1540# 0.19fF
C4381 divbuf_2/a_20670_n840# divbuf_2/a_21150_n840# 0.07fF
C4382 divbuf_2/a_19072_n240# divbuf_2/OUT4 0.04fF
C4383 divbuf_2/a_20640_n1600# divbuf_2/a_20670_n1540# 0.19fF
C4384 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/a_21502_170# 0.07fF
C4385 divbuf_0/a_40320_n1600# divbuf_0/a_40350_n840# 0.04fF
C4386 divbuf_0/a_36532_170# divbuf_0/OUT4 0.19fF
C4387 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4388 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_34590_n840# 0.04fF
C4389 divbuf_3/a_9732_170# divbuf_3/a_10212_170# 0.07fF
C4390 divbuf_1/a_52800_n1600# divbuf_1/a_53280_n1600# 0.26fF
C4391 ro_div_0/divbuf_0/a_54240_n1600# ro_div_0/divbuf_0/a_54720_n1600# 0.26fF
C4392 divbuf_3/a_43680_n1600# divbuf_3/a_44160_n1600# 0.26fF
C4393 divbuf_3/a_34592_n240# divbuf_3/a_34590_n840# 0.06fF
C4394 ro_div_0/divbuf_0/a_46590_n1540# ro_div_0/divbuf_0/a_47070_n1540# 0.11fF
C4395 divbuf_3/a_36030_n1540# divbuf_3/a_36510_n1540# 0.11fF
C4396 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_12510_n840# 0.01fF
C4397 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_17790_n840# 0.00fF
C4398 divbuf_1/a_45120_n1600# divbuf_1/a_45150_n1540# 0.19fF
C4399 divbuf_1/a_14910_n840# divbuf_1/a_14910_n1540# 0.01fF
C4400 divbuf_0/a_18092_n240# divbuf_0/a_18582_n240# 0.04fF
C4401 divbuf_0/a_37992_170# divbuf_0/a_37992_n240# 0.01fF
C4402 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12772_n240# 0.04fF
C4403 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/a_32172_n240# 0.01fF
C4404 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n1540# 0.19fF
C4405 divbuf_0/a_29790_n840# divbuf_0/a_30270_n840# 0.07fF
C4406 divbuf_0/a_37502_n240# divbuf_0/OUT4 0.04fF
C4407 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4408 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24030_n1540# 0.19fF
C4409 pll_full_0/divbuf_0/a_24030_n840# pll_full_0/divbuf_0/a_24510_n840# 0.07fF
C4410 divbuf_1/a_42720_n1600# divbuf_1/a_42750_n840# 0.04fF
C4411 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/a_3912_170# 0.07fF
C4412 pd_div_0/pd_0/and_pd_0/Out1 pd_div_0/pd_0/and_pd_0/Z1 0.18fF
C4413 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44190_n840# 0.04fF
C4414 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C4415 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/a_14222_170# 0.07fF
C4416 divbuf_3/a_33600_n1600# divbuf_3/a_33630_n840# 0.04fF
C4417 divbuf_3/a_22952_170# divbuf_3/OUT4 0.19fF
C4418 divbuf_1/a_36990_n1540# divbuf_1/a_37470_n1540# 0.11fF
C4419 divbuf_2/a_7200_n1600# divbuf_2/a_7680_n1600# 0.26fF
C4420 pd_div_0/divbuf_0/a_41760_n1600# pd_div_0/divbuf_0/a_42240_n1600# 0.26fF
C4421 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/a_32670_n840# 0.06fF
C4422 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/a_37950_n840# 0.04fF
C4423 pll_full_0/divbuf_1/a_47040_n1600# pll_full_0/divbuf_1/a_47520_n1600# 0.26fF
C4424 pd_div_0/divbuf_0/a_34110_n1540# pd_div_0/divbuf_0/a_34590_n1540# 0.11fF
C4425 pll_full_0/divbuf_1/a_39390_n1540# pll_full_0/divbuf_1/a_39870_n1540# 0.11fF
C4426 divbuf_2/a_30270_n840# divbuf_2/a_30270_n1540# 0.01fF
C4427 divbuf_2/a_60510_n840# divbuf_2/a_60990_n840# 0.07fF
C4428 divbuf_2/a_60480_n1600# divbuf_2/a_60510_n1540# 0.19fF
C4429 divbuf_1/a_40412_170# divbuf_1/a_40412_n240# 0.01fF
C4430 divbuf_1/a_20532_n240# divbuf_1/a_21012_n240# 0.05fF
C4431 ro_div_0/divbuf_0/a_21982_n240# ro_div_0/divbuf_0/a_22472_n240# 0.04fF
C4432 divbuf_0/a_35520_n1600# divbuf_0/OUT4 0.00fF
C4433 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C4434 divbuf_3/a_11312_n240# divbuf_3/a_11802_n240# 0.04fF
C4435 divbuf_3/a_31202_170# divbuf_3/a_31202_n240# 0.01fF
C4436 divbuf_1/a_1950_n840# divbuf_1/a_1950_n1540# 0.01fF
C4437 divbuf_1/a_32190_n840# divbuf_1/a_32670_n840# 0.07fF
C4438 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_12772_n240# 0.01fF
C4439 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/a_7302_n240# 0.01fF
C4440 ro_div_0/divbuf_0/a_33630_n840# ro_div_0/divbuf_0/a_34110_n840# 0.07fF
C4441 ro_div_0/divbuf_0/a_3390_n840# ro_div_0/divbuf_0/a_3390_n1540# 0.01fF
C4442 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_33630_n1540# 0.19fF
C4443 divbuf_3/a_23922_n240# divbuf_3/OUT4 0.04fF
C4444 divbuf_3/a_23040_n1600# divbuf_3/a_23070_n1540# 0.19fF
C4445 divbuf_3/a_23070_n840# divbuf_3/a_23550_n840# 0.07fF
C4446 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/and_0/OUT 0.14fF
C4447 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C4448 divbuf_0/a_3422_170# divbuf_0/a_3912_170# 0.07fF
C4449 divbuf_2/a_18092_n240# divbuf_2/a_17790_n840# 0.00fF
C4450 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4451 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_31710_n840# 0.04fF
C4452 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4453 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_36990_n840# 0.04fF
C4454 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C4455 divbuf_1/a_54750_n840# divbuf_1/a_54750_n1540# 0.01fF
C4456 divbuf_0/a_6822_n240# divbuf_0/a_6750_n840# 0.03fF
C4457 divbuf_0/a_16320_n1600# divbuf_0/a_16800_n1600# 0.26fF
C4458 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/a_11040_n1600# 0.26fF
C4459 divbuf_0/a_39390_n840# divbuf_0/a_39390_n1540# 0.01fF
C4460 divbuf_0/a_8670_n1540# divbuf_0/a_9150_n1540# 0.11fF
C4461 pll_full_0/divbuf_0/a_2910_n1540# pll_full_0/divbuf_0/a_3390_n1540# 0.11fF
C4462 pll_full_0/divbuf_0/a_33630_n840# pll_full_0/divbuf_0/a_33630_n1540# 0.01fF
C4463 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/a_9242_n240# 0.05fF
C4464 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/a_29262_n240# 0.01fF
C4465 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_15182_n240# 0.05fF
C4466 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/a_34592_n240# 0.01fF
C4467 divbuf_3/a_22080_n1600# divbuf_3/OUT4 0.01fF
C4468 divbuf_2/a_13742_170# divbuf_2/a_14222_170# 0.07fF
C4469 divbuf_2/a_37992_n240# divbuf_2/a_37950_n840# 0.04fF
C4470 divbuf_2/a_47040_n1600# divbuf_2/a_47520_n1600# 0.26fF
C4471 pd_div_0/divbuf_0/a_21150_n840# pd_div_0/divbuf_0/a_21630_n840# 0.07fF
C4472 pd_div_0/divbuf_0/a_20042_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4473 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21150_n1540# 0.19fF
C4474 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/tspc_0/Z2 0.11fF
C4475 divbuf_0/a_4392_170# divbuf_0/a_4882_170# 0.07fF
C4476 pll_full_0/divbuf_1/a_26430_n840# pll_full_0/divbuf_1/a_26910_n840# 0.07fF
C4477 pll_full_0/divbuf_1/a_30712_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4478 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26430_n1540# 0.19fF
C4479 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C4480 divbuf_0/a_1352_170# divbuf_0/OUT2 0.23fF
C4481 divbuf_0/a_6240_n1600# divbuf_0/a_6270_n840# 0.04fF
C4482 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C4483 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_510_n840# 0.04fF
C4484 divbuf_2/a_39390_n1540# divbuf_2/a_39870_n1540# 0.11fF
C4485 divbuf_1/a_18720_n1600# divbuf_1/a_19200_n1600# 0.26fF
C4486 divbuf_1/a_9242_n240# divbuf_1/a_9150_n840# 0.03fF
C4487 ro_div_0/divbuf_0/a_20160_n1600# ro_div_0/divbuf_0/a_20640_n1600# 0.26fF
C4488 divbuf_3/a_9600_n1600# divbuf_3/a_10080_n1600# 0.26fF
C4489 ro_div_0/divbuf_0/a_43230_n840# ro_div_0/divbuf_0/a_43230_n1540# 0.01fF
C4490 ro_div_0/divbuf_0/a_12510_n1540# ro_div_0/divbuf_0/a_12990_n1540# 0.11fF
C4491 divbuf_3/a_1950_n1540# divbuf_3/a_2430_n1540# 0.11fF
C4492 divbuf_3/a_32670_n840# divbuf_3/a_32670_n1540# 0.01fF
C4493 divbuf_3/a_510_n840# divbuf_3/OUT 0.07fF
C4494 divbuf_1/a_11070_n1540# divbuf_1/a_11550_n1540# 0.11fF
C4495 divbuf_2/a_29742_170# divbuf_2/OUT4 0.19fF
C4496 divbuf_2/a_36960_n1600# divbuf_2/a_36990_n840# 0.04fF
C4497 divbuf_1/a_38962_170# divbuf_1/OUT4 0.19fF
C4498 divbuf_0/a_22952_170# divbuf_0/a_23442_170# 0.07fF
C4499 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/a_19072_170# 0.07fF
C4500 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/and_0/B 0.31fF
C4501 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z2 0.14fF
C4502 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C4503 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 gnd 0.27fF
C4504 divbuf_0/a_56160_n1600# divbuf_0/a_56640_n1600# 0.26fF
C4505 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C4506 gnd pll_full_0/divider_0/prescaler_0/nand_0/z1 0.16fF
C4507 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/A 0.01fF
C4508 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/a_41310_n840# 0.03fF
C4509 pll_full_0/divbuf_0/a_50400_n1600# pll_full_0/divbuf_0/a_50880_n1600# 0.26fF
C4510 pll_full_0/divbuf_0/a_4392_170# pll_full_0/divbuf_0/OUT3 0.19fF
C4511 divbuf_1/a_8640_n1600# divbuf_1/a_8670_n840# 0.04fF
C4512 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10110_n840# 0.04fF
C4513 divbuf_0/a_48510_n1540# divbuf_0/a_48990_n1540# 0.11fF
C4514 pll_full_0/divbuf_0/a_42750_n1540# pll_full_0/divbuf_0/a_43230_n1540# 0.11fF
C4515 pd_div_0/divbuf_0/a_7680_n1600# pd_div_0/divbuf_0/a_8160_n1600# 0.26fF
C4516 ro_div_0/divbuf_0/a_510_n1540# ro_div_0/divbuf_0/OUT 0.11fF
C4517 divbuf_2/a_14702_n240# divbuf_2/a_15182_n240# 0.05fF
C4518 divbuf_2/a_34592_170# divbuf_2/a_34592_n240# 0.01fF
C4519 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/a_13440_n1600# 0.26fF
C4520 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/a_3390_n840# 0.05fF
C4521 divbuf_1/a_39932_n240# divbuf_1/OUT4 0.04fF
C4522 pd_div_0/divbuf_0/a_30750_n840# pd_div_0/divbuf_0/a_30750_n1540# 0.01fF
C4523 pll_full_0/divbuf_1/a_5310_n1540# pll_full_0/divbuf_1/a_5790_n1540# 0.11fF
C4524 pll_full_0/divbuf_1/a_36030_n840# pll_full_0/divbuf_1/a_36030_n1540# 0.01fF
C4525 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/a_18582_n240# 0.01fF
C4526 divbuf_2/a_26430_n840# divbuf_2/a_26910_n840# 0.07fF
C4527 divbuf_2/a_30712_n240# divbuf_2/OUT4 0.04fF
C4528 divbuf_2/a_26400_n1600# divbuf_2/a_26430_n1540# 0.19fF
C4529 divbuf_1/a_21982_170# divbuf_1/a_22472_170# 0.07fF
C4530 divbuf_1/a_31682_170# divbuf_1/a_31682_n240# 0.01fF
C4531 ro_div_0/divbuf_0/a_6332_170# ro_div_0/divbuf_0/a_6332_n240# 0.01fF
C4532 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/a_27322_170# 0.07fF
C4533 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/a_13742_n240# 0.01fF
C4534 divbuf_0/a_46080_n1600# divbuf_0/a_46110_n840# 0.04fF
C4535 divbuf_0/a_8762_n240# divbuf_0/OUT3 0.04fF
C4536 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4537 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40350_n840# 0.04fF
C4538 divbuf_3/a_16152_170# divbuf_3/a_16642_170# 0.07fF
C4539 divbuf_1/a_58560_n1600# divbuf_1/a_59040_n1600# 0.26fF
C4540 pd_div_0/div pd_div_0/pd_0/R 0.51fF
C4541 ro_div_0/divbuf_0/a_60000_n1600# ro_div_0/divbuf_0/a_60480_n1600# 0.26fF
C4542 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4543 divbuf_3/a_40412_n240# divbuf_3/a_40350_n840# 0.04fF
C4544 divbuf_3/a_49440_n1600# divbuf_3/a_49920_n1600# 0.26fF
C4545 ro_div_0/divbuf_0/a_52350_n1540# ro_div_0/divbuf_0/a_52830_n1540# 0.11fF
C4546 divbuf_3/a_41790_n1540# divbuf_3/a_42270_n1540# 0.11fF
C4547 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_2910_n840# 0.04fF
C4548 divbuf_1/a_20670_n840# divbuf_1/a_20670_n1540# 0.01fF
C4549 divbuf_1/a_50880_n1600# divbuf_1/a_50910_n1540# 0.19fF
C4550 divbuf_0/a_23922_n240# divbuf_0/a_24412_n240# 0.04fF
C4551 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_18582_n240# 0.04fF
C4552 pll_full_0/divbuf_0/a_37992_170# pll_full_0/divbuf_0/a_37992_n240# 0.01fF
C4553 divbuf_1/a_24412_170# divbuf_1/a_24412_n240# 0.01fF
C4554 divbuf_0/a_35550_n840# divbuf_0/a_36030_n840# 0.07fF
C4555 divbuf_0/a_5310_n840# divbuf_0/a_5310_n1540# 0.01fF
C4556 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n1540# 0.19fF
C4557 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4558 pll_full_0/divbuf_0/a_29790_n840# pll_full_0/divbuf_0/a_30270_n840# 0.07fF
C4559 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_29790_n1540# 0.19fF
C4560 divbuf_1/a_48480_n1600# divbuf_1/a_48510_n840# 0.04fF
C4561 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/a_12282_170# 0.07fF
C4562 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_49950_n840# 0.04fF
C4563 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4564 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/a_20042_170# 0.07fF
C4565 divbuf_3/a_34592_170# divbuf_3/OUT4 0.19fF
C4566 divbuf_3/a_39360_n1600# divbuf_3/a_39390_n840# 0.04fF
C4567 divbuf_1/a_42750_n1540# divbuf_1/a_43230_n1540# 0.11fF
C4568 divbuf_2/a_12960_n1600# divbuf_2/a_13440_n1600# 0.26fF
C4569 divbuf_2/a_3422_n240# divbuf_2/a_3390_n840# 0.05fF
C4570 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/a_38430_n840# 0.04fF
C4571 pd_div_0/divbuf_0/a_47520_n1600# pd_div_0/divbuf_0/a_48000_n1600# 0.26fF
C4572 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/OUT2 0.19fF
C4573 pll_full_0/divbuf_1/a_52800_n1600# pll_full_0/divbuf_1/a_53280_n1600# 0.26fF
C4574 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C4575 pd_div_0/divbuf_0/a_39870_n1540# pd_div_0/divbuf_0/a_40350_n1540# 0.11fF
C4576 pll_full_0/divbuf_1/a_45150_n1540# pll_full_0/divbuf_1/a_45630_n1540# 0.11fF
C4577 divbuf_2/a_5310_n1540# divbuf_2/a_5790_n1540# 0.11fF
C4578 divbuf_2/a_36030_n840# divbuf_2/a_36030_n1540# 0.01fF
C4579 divbuf_1/a_26352_n240# divbuf_1/a_26832_n240# 0.05fF
C4580 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/a_28292_n240# 0.04fF
C4581 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C4582 divbuf_3/a_17122_n240# divbuf_3/a_17612_n240# 0.04fF
C4583 divbuf_3/a_37022_170# divbuf_3/a_37022_n240# 0.01fF
C4584 divbuf_1/a_7710_n840# divbuf_1/a_7710_n1540# 0.01fF
C4585 divbuf_1/a_37950_n840# divbuf_1/a_38430_n840# 0.07fF
C4586 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39390_n1540# 0.19fF
C4587 ro_div_0/divbuf_0/a_39390_n840# ro_div_0/divbuf_0/a_39870_n840# 0.07fF
C4588 ro_div_0/divbuf_0/a_9150_n840# ro_div_0/divbuf_0/a_9150_n1540# 0.01fF
C4589 divbuf_3/a_35562_n240# divbuf_3/OUT4 0.04fF
C4590 divbuf_3/a_28830_n840# divbuf_3/a_29310_n840# 0.07fF
C4591 divbuf_3/a_28800_n1600# divbuf_3/a_28830_n1540# 0.19fF
C4592 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 ro_div_0/divider_0/clk 0.12fF
C4593 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/tspc_0/Z2 1.07fF
C4594 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C4595 divbuf_2/a_2880_n1600# divbuf_2/a_2910_n840# 0.04fF
C4596 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/OUT4 0.19fF
C4597 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37470_n840# 0.04fF
C4598 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/OUT2 0.04fF
C4599 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4600 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_42750_n840# 0.04fF
C4601 divbuf_1/a_60510_n840# divbuf_1/a_60510_n1540# 0.01fF
C4602 divbuf_0/a_12772_n240# divbuf_0/a_12990_n840# 0.02fF
C4603 divbuf_0/a_22080_n1600# divbuf_0/a_22560_n1600# 0.26fF
C4604 pll_full_0/divbuf_0/a_16320_n1600# pll_full_0/divbuf_0/a_16800_n1600# 0.26fF
C4605 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/a_6750_n840# 0.03fF
C4606 divbuf_0/a_45150_n840# divbuf_0/a_45150_n1540# 0.01fF
C4607 divbuf_0/a_14430_n1540# divbuf_0/a_14910_n1540# 0.11fF
C4608 pll_full_0/divbuf_0/a_8670_n1540# pll_full_0/divbuf_0/a_9150_n1540# 0.11fF
C4609 pll_full_0/divbuf_0/a_39390_n840# pll_full_0/divbuf_0/a_39390_n1540# 0.01fF
C4610 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_15672_n240# 0.04fF
C4611 pd_div_0/divbuf_0/a_35082_170# pd_div_0/divbuf_0/a_35082_n240# 0.01fF
C4612 pll_full_0/divbuf_1/a_40412_170# pll_full_0/divbuf_1/a_40412_n240# 0.01fF
C4613 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/a_21012_n240# 0.05fF
C4614 divbuf_3/a_33600_n1600# divbuf_3/OUT4 0.01fF
C4615 divbuf_2/a_19562_170# divbuf_2/a_20042_170# 0.07fF
C4616 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C4617 divbuf_2/a_52800_n1600# divbuf_2/a_53280_n1600# 0.26fF
C4618 divbuf_2/a_492_n240# divbuf_2/OUT2 0.42fF
C4619 pd_div_0/divbuf_0/a_26910_n840# pd_div_0/divbuf_0/a_27390_n840# 0.07fF
C4620 pd_div_0/divbuf_0/a_31682_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4621 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_26910_n1540# 0.19fF
C4622 pll_full_0/divbuf_1/a_1950_n840# pll_full_0/divbuf_1/a_1950_n1540# 0.01fF
C4623 pll_full_0/divbuf_1/a_32190_n840# pll_full_0/divbuf_1/a_32670_n840# 0.07fF
C4624 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32190_n1540# 0.19fF
C4625 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/OUT2 0.01fF
C4626 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_0/a_630_n680# 0.04fF
C4627 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_5852_170# 0.07fF
C4628 divbuf_0/a_12000_n1600# divbuf_0/a_12030_n840# 0.04fF
C4629 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_1/A 0.01fF
C4630 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C4631 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C4632 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.15fF
C4633 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6270_n840# 0.04fF
C4634 divbuf_2/a_45150_n1540# divbuf_2/a_45630_n1540# 0.11fF
C4635 divbuf_1/a_24480_n1600# divbuf_1/a_24960_n1600# 0.26fF
C4636 divbuf_1/a_15182_n240# divbuf_1/a_15390_n840# 0.02fF
C4637 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_16830_n840# 0.02fF
C4638 ro_div_0/divbuf_0/a_25920_n1600# ro_div_0/divbuf_0/a_26400_n1600# 0.26fF
C4639 divbuf_3/a_15360_n1600# divbuf_3/a_15840_n1600# 0.26fF
C4640 divbuf_3/a_5852_n240# divbuf_3/a_5790_n840# 0.04fF
C4641 ro_div_0/divbuf_0/a_48990_n840# ro_div_0/divbuf_0/a_48990_n1540# 0.01fF
C4642 ro_div_0/divbuf_0/a_18270_n1540# ro_div_0/divbuf_0/a_18750_n1540# 0.11fF
C4643 divbuf_3/a_7710_n1540# divbuf_3/a_8190_n1540# 0.11fF
C4644 divbuf_3/a_38430_n840# divbuf_3/a_38430_n1540# 0.01fF
C4645 divbuf_2/a_1842_n240# divbuf_2/OUT2 0.04fF
C4646 divbuf_2/a_41382_170# divbuf_2/OUT4 0.19fF
C4647 divbuf_2/a_42720_n1600# divbuf_2/a_42750_n840# 0.04fF
C4648 divbuf_1/a_11312_n240# divbuf_1/OUT4 0.07fF
C4649 divbuf_1/a_16800_n1600# divbuf_1/a_16830_n1540# 0.19fF
C4650 divbuf_0/a_28772_170# divbuf_0/a_29262_170# 0.07fF
C4651 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/a_23442_170# 0.07fF
C4652 gnd pll_full_0/divider_0/clk 0.08fF
C4653 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/clk 0.04fF
C4654 gnd pd_div_0/divider_0/nor_0/B 1.23fF
C4655 ro_div_0/ro_complete_0/cbank_0/v ro_div_0/ro_complete_0/cbank_2/v 0.04fF
C4656 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/a_1842_170# 0.07fF
C4657 divbuf_0/a_1470_n840# divbuf_0/a_1950_n840# 0.07fF
C4658 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n1540# 0.19fF
C4659 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.29fF
C4660 pll_full_0/divbuf_0/a_56160_n1600# pll_full_0/divbuf_0/a_56640_n1600# 0.26fF
C4661 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/OUT3 0.19fF
C4662 divbuf_1/a_14400_n1600# divbuf_1/a_14430_n840# 0.04fF
C4663 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_15870_n840# 0.04fF
C4664 divbuf_0/a_54270_n1540# divbuf_0/a_54750_n1540# 0.11fF
C4665 pll_full_0/divbuf_0/a_48510_n1540# pll_full_0/divbuf_0/a_48990_n1540# 0.11fF
C4666 divbuf_3/a_5280_n1600# divbuf_3/a_5310_n840# 0.04fF
C4667 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/a_13920_n1600# 0.26fF
C4668 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/a_3870_n840# 0.04fF
C4669 pll_full_0/divbuf_1/a_18720_n1600# pll_full_0/divbuf_1/a_19200_n1600# 0.26fF
C4670 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/a_9150_n840# 0.03fF
C4671 divbuf_2/a_40412_170# divbuf_2/a_40412_n240# 0.01fF
C4672 divbuf_2/a_20532_n240# divbuf_2/a_21012_n240# 0.05fF
C4673 divbuf_2/a_1950_n840# divbuf_2/a_1950_n1540# 0.01fF
C4674 divbuf_2/a_32190_n840# divbuf_2/a_32670_n840# 0.07fF
C4675 divbuf_2/a_32160_n1600# divbuf_2/a_32190_n1540# 0.19fF
C4676 divbuf_2/a_1440_n1600# divbuf_2/OUT2 0.01fF
C4677 divbuf_1/a_10080_n1600# divbuf_1/OUT3 0.00fF
C4678 pd_div_0/divbuf_0/a_5790_n1540# pd_div_0/divbuf_0/a_6270_n1540# 0.11fF
C4679 pd_div_0/divbuf_0/a_36510_n840# pd_div_0/divbuf_0/a_36510_n1540# 0.01fF
C4680 pll_full_0/divbuf_1/a_11070_n1540# pll_full_0/divbuf_1/a_11550_n1540# 0.11fF
C4681 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/a_41790_n1540# 0.01fF
C4682 divbuf_1/a_3422_170# divbuf_1/a_3422_n240# 0.01fF
C4683 divbuf_1/a_27802_170# divbuf_1/a_28292_170# 0.07fF
C4684 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/a_33142_170# 0.07fF
C4685 divbuf_0/a_51840_n1600# divbuf_0/a_51870_n840# 0.04fF
C4686 divbuf_0/a_20532_n240# divbuf_0/OUT4 0.04fF
C4687 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C4688 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46110_n840# 0.04fF
C4689 divbuf_3/a_1352_170# divbuf_3/a_1352_n240# 0.01fF
C4690 divbuf_3/a_21982_170# divbuf_3/a_22472_170# 0.07fF
C4691 divbuf_1/a_3870_n840# divbuf_1/a_4350_n840# 0.07fF
C4692 divbuf_1/a_3840_n1600# divbuf_1/a_3870_n1540# 0.19fF
C4693 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Qbar1 0.12fF
C4694 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5310_n1540# 0.19fF
C4695 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4696 ro_div_0/divbuf_0/a_5310_n840# ro_div_0/divbuf_0/a_5790_n840# 0.07fF
C4697 divbuf_3/a_55200_n1600# divbuf_3/a_55680_n1600# 0.26fF
C4698 divbuf_3/a_5852_170# divbuf_3/OUT3 0.19fF
C4699 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3390_n840# 0.04fF
C4700 ro_div_0/divbuf_0/a_58110_n1540# ro_div_0/divbuf_0/a_58590_n1540# 0.11fF
C4701 divbuf_3/a_47550_n1540# divbuf_3/a_48030_n1540# 0.11fF
C4702 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_8670_n840# 0.04fF
C4703 divbuf_1/a_56640_n1600# divbuf_1/a_56670_n1540# 0.19fF
C4704 divbuf_1/a_26430_n840# divbuf_1/a_26430_n1540# 0.01fF
C4705 divbuf_0/a_29742_n240# divbuf_0/a_30232_n240# 0.04fF
C4706 pll_full_0/divbuf_0/a_23922_n240# pll_full_0/divbuf_0/a_24412_n240# 0.04fF
C4707 divbuf_1/a_30232_170# divbuf_1/a_30232_n240# 0.01fF
C4708 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n1540# 0.19fF
C4709 divbuf_0/a_41310_n840# divbuf_0/a_41790_n840# 0.07fF
C4710 divbuf_0/a_11070_n840# divbuf_0/a_11070_n1540# 0.01fF
C4711 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_35550_n1540# 0.19fF
C4712 pll_full_0/divbuf_0/a_5310_n840# pll_full_0/divbuf_0/a_5310_n1540# 0.01fF
C4713 pll_full_0/divbuf_0/a_35550_n840# pll_full_0/divbuf_0/a_36030_n840# 0.07fF
C4714 divbuf_1/a_54240_n1600# divbuf_1/a_54270_n840# 0.04fF
C4715 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/a_20532_170# 0.07fF
C4716 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_55710_n840# 0.04fF
C4717 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4718 pll_full_0/divbuf_1/a_5362_170# pll_full_0/divbuf_1/a_5362_n240# 0.01fF
C4719 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/a_25862_170# 0.07fF
C4720 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.01fF
C4721 divbuf_3/a_6822_n240# divbuf_3/OUT3 0.04fF
C4722 divbuf_3/a_45120_n1600# divbuf_3/a_45150_n840# 0.04fF
C4723 divbuf_1/a_48510_n1540# divbuf_1/a_48990_n1540# 0.11fF
C4724 pd_div_0/divbuf_0/a_53280_n1600# pd_div_0/divbuf_0/a_53760_n1600# 0.26fF
C4725 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C4726 divbuf_2/a_18720_n1600# divbuf_2/a_19200_n1600# 0.26fF
C4727 divbuf_2/a_9242_n240# divbuf_2/a_9150_n840# 0.03fF
C4728 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4729 pll_full_0/divbuf_1/a_58560_n1600# pll_full_0/divbuf_1/a_59040_n1600# 0.26fF
C4730 pd_div_0/divbuf_0/a_45630_n1540# pd_div_0/divbuf_0/a_46110_n1540# 0.11fF
C4731 pll_full_0/divbuf_1/a_50910_n1540# pll_full_0/divbuf_1/a_51390_n1540# 0.11fF
C4732 divbuf_2/a_11070_n1540# divbuf_2/a_11550_n1540# 0.11fF
C4733 divbuf_2/a_41790_n840# divbuf_2/a_41790_n1540# 0.01fF
C4734 divbuf_1/a_32172_n240# divbuf_1/a_32652_n240# 0.05fF
C4735 ro_div_0/divbuf_0/a_33622_n240# ro_div_0/divbuf_0/a_34112_n240# 0.04fF
C4736 divbuf_3/a_22952_n240# divbuf_3/a_23442_n240# 0.04fF
C4737 divbuf_1/a_13470_n840# divbuf_1/a_13470_n1540# 0.01fF
C4738 divbuf_1/a_43710_n840# divbuf_1/a_44190_n840# 0.07fF
C4739 ro_div_0/divbuf_0/a_45150_n840# ro_div_0/divbuf_0/a_45630_n840# 0.07fF
C4740 ro_div_0/divbuf_0/a_14910_n840# ro_div_0/divbuf_0/a_14910_n1540# 0.01fF
C4741 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45150_n1540# 0.19fF
C4742 divbuf_3/a_34560_n1600# divbuf_3/a_34590_n1540# 0.19fF
C4743 divbuf_3/a_4350_n840# divbuf_3/a_4350_n1540# 0.01fF
C4744 divbuf_3/a_34590_n840# divbuf_3/a_35070_n840# 0.07fF
C4745 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/clk 0.64fF
C4746 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/prescaler_0/Out 0.15fF
C4747 divbuf_2/a_8640_n1600# divbuf_2/a_8670_n840# 0.04fF
C4748 divbuf_1/a_33142_170# divbuf_1/OUT4 0.19fF
C4749 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C4750 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43230_n840# 0.04fF
C4751 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4752 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48510_n840# 0.04fF
C4753 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C4754 divbuf_0/a_18582_n240# divbuf_0/a_18750_n840# 0.02fF
C4755 divbuf_0/a_27840_n1600# divbuf_0/a_28320_n1600# 0.26fF
C4756 pll_full_0/divbuf_0/a_22080_n1600# pll_full_0/divbuf_0/a_22560_n1600# 0.26fF
C4757 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_12990_n840# 0.02fF
C4758 ro_div_0/divbuf_0/a_1842_n240# ro_div_0/divbuf_0/a_1950_n840# 0.03fF
C4759 divbuf_0/a_50910_n840# divbuf_0/a_50910_n1540# 0.01fF
C4760 divbuf_0/a_20190_n1540# divbuf_0/a_20670_n1540# 0.11fF
C4761 pll_full_0/divbuf_0/a_14430_n1540# pll_full_0/divbuf_0/a_14910_n1540# 0.11fF
C4762 pll_full_0/divbuf_0/a_45150_n840# pll_full_0/divbuf_0/a_45150_n1540# 0.01fF
C4763 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/a_40902_n240# 0.01fF
C4764 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/a_21502_n240# 0.04fF
C4765 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/a_26832_n240# 0.05fF
C4766 divbuf_2/a_5362_170# divbuf_2/a_5362_n240# 0.01fF
C4767 divbuf_2/a_25382_170# divbuf_2/a_25862_170# 0.07fF
C4768 divbuf_2/a_12772_170# divbuf_2/OUT4 0.19fF
C4769 divbuf_2/a_58560_n1600# divbuf_2/a_59040_n1600# 0.26fF
C4770 pd_div_0/divbuf_0/a_2430_n840# pd_div_0/divbuf_0/a_2430_n1540# 0.01fF
C4771 pd_div_0/divbuf_0/a_32670_n840# pd_div_0/divbuf_0/a_33150_n840# 0.07fF
C4772 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_32670_n1540# 0.19fF
C4773 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C4774 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C4775 pll_full_0/divbuf_1/a_7710_n840# pll_full_0/divbuf_1/a_7710_n1540# 0.01fF
C4776 pll_full_0/divbuf_1/a_37950_n840# pll_full_0/divbuf_1/a_38430_n840# 0.07fF
C4777 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_37950_n1540# 0.19fF
C4778 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/a_1842_170# 0.07fF
C4779 gnd pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.44fF
C4780 pd_div_0/divider_0/tspc_1/Z3 pd_div_0/divider_0/tspc_1/Q 0.05fF
C4781 pd_div_0/divider_0/tspc_0/Q gnd 0.33fF
C4782 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C4783 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C4784 divbuf_0/a_17760_n1600# divbuf_0/a_17790_n840# 0.04fF
C4785 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12030_n840# 0.04fF
C4786 divbuf_2/a_50910_n1540# divbuf_2/a_51390_n1540# 0.11fF
C4787 divbuf_1/a_30240_n1600# divbuf_1/a_30720_n1600# 0.26fF
C4788 divbuf_1/a_21012_n240# divbuf_1/a_21150_n840# 0.03fF
C4789 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/a_22590_n840# 0.03fF
C4790 ro_div_0/divbuf_0/a_31680_n1600# ro_div_0/divbuf_0/a_32160_n1600# 0.26fF
C4791 divbuf_3/a_21120_n1600# divbuf_3/a_21600_n1600# 0.26fF
C4792 divbuf_3/a_11802_n240# divbuf_3/a_12030_n840# 0.02fF
C4793 ro_div_0/divbuf_0/a_54750_n840# ro_div_0/divbuf_0/a_54750_n1540# 0.01fF
C4794 ro_div_0/divbuf_0/a_24030_n1540# ro_div_0/divbuf_0/a_24510_n1540# 0.11fF
C4795 divbuf_3/a_13470_n1540# divbuf_3/a_13950_n1540# 0.11fF
C4796 divbuf_3/a_44190_n840# divbuf_3/a_44190_n1540# 0.01fF
C4797 divbuf_0/a_34592_170# divbuf_0/a_35082_170# 0.07fF
C4798 divbuf_2/a_13742_n240# divbuf_2/OUT4 0.04fF
C4799 divbuf_2/a_48480_n1600# divbuf_2/a_48510_n840# 0.04fF
C4800 divbuf_1/a_22952_n240# divbuf_1/OUT4 0.04fF
C4801 divbuf_1/a_22560_n1600# divbuf_1/a_22590_n1540# 0.19fF
C4802 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/a_29262_170# 0.07fF
C4803 divbuf_1/a_17612_170# divbuf_1/a_17612_n240# 0.01fF
C4804 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n1540# 0.19fF
C4805 divbuf_0/a_31202_170# divbuf_0/OUT4 0.19fF
C4806 divbuf_0/a_7230_n840# divbuf_0/a_7710_n840# 0.07fF
C4807 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1470_n1540# 0.19fF
C4808 pll_full_0/divbuf_0/a_1470_n840# pll_full_0/divbuf_0/a_1950_n840# 0.07fF
C4809 divbuf_1/a_20160_n1600# divbuf_1/a_20190_n840# 0.04fF
C4810 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_21630_n840# 0.04fF
C4811 divbuf_0/a_60030_n1540# divbuf_0/a_60510_n1540# 0.11fF
C4812 pll_full_0/divbuf_0/a_54270_n1540# pll_full_0/divbuf_0/a_54750_n1540# 0.11fF
C4813 divbuf_3/a_11040_n1600# divbuf_3/a_11070_n840# 0.04fF
C4814 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/a_19680_n1600# 0.26fF
C4815 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/a_9630_n840# 0.03fF
C4816 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/a_24960_n1600# 0.26fF
C4817 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_15390_n840# 0.02fF
C4818 divbuf_2/a_26352_n240# divbuf_2/a_26832_n240# 0.05fF
C4819 divbuf_2/a_12000_n1600# divbuf_2/OUT4 0.00fF
C4820 divbuf_2/a_7710_n840# divbuf_2/a_7710_n1540# 0.01fF
C4821 divbuf_2/a_37950_n840# divbuf_2/a_38430_n840# 0.07fF
C4822 divbuf_2/a_37920_n1600# divbuf_2/a_37950_n1540# 0.19fF
C4823 divbuf_1/a_21120_n1600# divbuf_1/OUT4 0.00fF
C4824 pd_div_0/divbuf_0/a_11550_n1540# pd_div_0/divbuf_0/a_12030_n1540# 0.11fF
C4825 pd_div_0/divbuf_0/a_42270_n840# pd_div_0/divbuf_0/a_42270_n1540# 0.01fF
C4826 pll_full_0/divbuf_1/a_16830_n1540# pll_full_0/divbuf_1/a_17310_n1540# 0.11fF
C4827 pll_full_0/divbuf_1/a_47550_n840# pll_full_0/divbuf_1/a_47550_n1540# 0.01fF
C4828 divbuf_1/a_37022_170# divbuf_1/a_37502_170# 0.07fF
C4829 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/a_38962_170# 0.07fF
C4830 divbuf_0/a_57600_n1600# divbuf_0/a_57630_n840# 0.04fF
C4831 divbuf_0/a_32172_n240# divbuf_0/OUT4 0.04fF
C4832 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4833 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_51870_n840# 0.04fF
C4834 divbuf_3/a_7792_170# divbuf_3/a_7792_n240# 0.01fF
C4835 divbuf_3/a_27802_170# divbuf_3/a_28292_170# 0.07fF
C4836 divbuf_1/a_9630_n840# divbuf_1/a_10110_n840# 0.07fF
C4837 divbuf_1/a_9600_n1600# divbuf_1/a_9630_n1540# 0.19fF
C4838 ro_div_0/divbuf_0/a_11070_n840# ro_div_0/divbuf_0/a_11550_n840# 0.07fF
C4839 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11070_n1540# 0.19fF
C4840 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4841 ro_div_0/divider_0/tspc_1/Z4 gnd 0.44fF
C4842 divbuf_3/a_510_n840# divbuf_3/a_990_n840# 0.07fF
C4843 divbuf_3/a_17612_170# divbuf_3/OUT4 0.19fF
C4844 divbuf_3/a_480_n1600# divbuf_3/a_510_n1540# 0.19fF
C4845 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9150_n840# 0.04fF
C4846 ro_div_0/divbuf_0/OUT4 ro_div_0/divbuf_0/OUT5 0.26fF
C4847 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14430_n840# 0.04fF
C4848 divbuf_3/a_53310_n1540# divbuf_3/a_53790_n1540# 0.11fF
C4849 divbuf_1/a_32190_n840# divbuf_1/a_32190_n1540# 0.01fF
C4850 divbuf_1/a_60480_n1600# divbuf_1/OUT5 0.26fF
C4851 divbuf_0/a_35562_n240# divbuf_0/a_36052_n240# 0.04fF
C4852 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/a_30232_n240# 0.04fF
C4853 divbuf_0/a_47070_n840# divbuf_0/a_47550_n840# 0.07fF
C4854 divbuf_0/a_16830_n840# divbuf_0/a_16830_n1540# 0.01fF
C4855 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n1540# 0.19fF
C4856 pll_full_0/divbuf_0/a_11070_n840# pll_full_0/divbuf_0/a_11070_n1540# 0.01fF
C4857 pll_full_0/divbuf_0/a_41310_n840# pll_full_0/divbuf_0/a_41790_n840# 0.07fF
C4858 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41310_n1540# 0.19fF
C4859 divbuf_1/a_60000_n1600# divbuf_1/a_60030_n840# 0.04fF
C4860 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/a_26352_170# 0.07fF
C4861 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C4862 pll_full_0/divbuf_1/a_11802_170# pll_full_0/divbuf_1/a_11802_n240# 0.01fF
C4863 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/a_31682_170# 0.07fF
C4864 divbuf_3/a_18582_n240# divbuf_3/OUT4 0.04fF
C4865 divbuf_3/a_50880_n1600# divbuf_3/a_50910_n840# 0.04fF
C4866 divbuf_1/a_54270_n1540# divbuf_1/a_54750_n1540# 0.11fF
C4867 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/OUT4 0.23fF
C4868 pd_div_0/divbuf_0/a_59040_n1600# pd_div_0/divbuf_0/a_59520_n1600# 0.26fF
C4869 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C4870 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/nor_1/A 0.03fF
C4871 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C4872 divbuf_2/a_24480_n1600# divbuf_2/a_24960_n1600# 0.26fF
C4873 divbuf_2/a_15182_n240# divbuf_2/a_15390_n840# 0.02fF
C4874 pll_full_0/divbuf_1/a_3870_n840# pll_full_0/divbuf_1/a_4350_n840# 0.07fF
C4875 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/OUT4 0.19fF
C4876 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_3870_n1540# 0.19fF
C4877 ashish_0/a_150_0# ashish_0/a_150_n710# 6.31fF
C4878 pd_div_0/divbuf_0/a_51390_n1540# pd_div_0/divbuf_0/a_51870_n1540# 0.11fF
C4879 pll_full_0/divbuf_1/a_56670_n1540# pll_full_0/divbuf_1/a_57150_n1540# 0.11fF
C4880 divbuf_2/a_16830_n1540# divbuf_2/a_17310_n1540# 0.11fF
C4881 divbuf_2/a_47550_n840# divbuf_2/a_47550_n1540# 0.01fF
C4882 divbuf_1/a_37992_n240# divbuf_1/a_38472_n240# 0.05fF
C4883 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/a_39932_n240# 0.04fF
C4884 divbuf_3/a_28772_n240# divbuf_3/a_29262_n240# 0.04fF
C4885 divbuf_1/a_49470_n840# divbuf_1/a_49950_n840# 0.07fF
C4886 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_50910_n1540# 0.19fF
C4887 ro_div_0/divbuf_0/a_50910_n840# ro_div_0/divbuf_0/a_51390_n840# 0.07fF
C4888 ro_div_0/divbuf_0/a_20670_n840# ro_div_0/divbuf_0/a_20670_n1540# 0.01fF
C4889 divbuf_3/a_10110_n840# divbuf_3/a_10110_n1540# 0.01fF
C4890 divbuf_3/a_40350_n840# divbuf_3/a_40830_n840# 0.07fF
C4891 divbuf_3/a_40320_n1600# divbuf_3/a_40350_n1540# 0.19fF
C4892 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C4893 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_48990_n840# 0.04fF
C4894 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C4895 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C4896 divbuf_2/a_14400_n1600# divbuf_2/a_14430_n840# 0.04fF
C4897 divbuf_1/a_10212_170# divbuf_1/OUT4 0.07fF
C4898 pll_full_0/divbuf_1/a_25382_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C4899 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54270_n840# 0.04fF
C4900 divbuf_0/a_33600_n1600# divbuf_0/a_34080_n1600# 0.26fF
C4901 divbuf_0/a_24412_n240# divbuf_0/a_24510_n840# 0.03fF
C4902 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C4903 pll_full_0/divbuf_0/a_27840_n1600# pll_full_0/divbuf_0/a_28320_n1600# 0.26fF
C4904 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/a_18750_n840# 0.02fF
C4905 divbuf_0/a_56670_n840# divbuf_0/a_56670_n1540# 0.01fF
C4906 divbuf_0/a_25950_n1540# divbuf_0/a_26430_n1540# 0.11fF
C4907 pll_full_0/divbuf_0/a_20190_n1540# pll_full_0/divbuf_0/a_20670_n1540# 0.11fF
C4908 pll_full_0/divbuf_0/a_50910_n840# pll_full_0/divbuf_0/a_50910_n1540# 0.01fF
C4909 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/a_27322_n240# 0.04fF
C4910 pll_full_0/divbuf_1/a_32172_n240# pll_full_0/divbuf_1/a_32652_n240# 0.05fF
C4911 divbuf_2/a_11802_170# divbuf_2/a_11802_n240# 0.01fF
C4912 divbuf_2/a_31202_170# divbuf_2/a_31682_170# 0.07fF
C4913 divbuf_2/a_3870_n840# divbuf_2/a_4350_n840# 0.07fF
C4914 divbuf_2/a_24412_170# divbuf_2/OUT4 0.19fF
C4915 divbuf_2/a_3840_n1600# divbuf_2/a_3870_n1540# 0.19fF
C4916 divbuf_1/a_30232_170# divbuf_1/OUT4 0.19fF
C4917 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C4918 pd_div_0/divbuf_0/a_8190_n840# pd_div_0/divbuf_0/a_8190_n1540# 0.01fF
C4919 pd_div_0/divbuf_0/a_38430_n840# pd_div_0/divbuf_0/a_38910_n840# 0.07fF
C4920 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38430_n1540# 0.19fF
C4921 pll_full_0/divbuf_1/a_13470_n840# pll_full_0/divbuf_1/a_13470_n1540# 0.01fF
C4922 pll_full_0/divbuf_1/a_43710_n840# pll_full_0/divbuf_1/a_44190_n840# 0.07fF
C4923 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_43710_n1540# 0.19fF
C4924 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C4925 gnd pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.27fF
C4926 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_2/Z4 0.02fF
C4927 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.44fF
C4928 divbuf_0/a_23520_n1600# divbuf_0/a_23550_n840# 0.04fF
C4929 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C4930 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_17790_n840# 0.04fF
C4931 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/OUT4 0.07fF
C4932 divbuf_2/a_56670_n1540# divbuf_2/a_57150_n1540# 0.11fF
C4933 divbuf_1/a_36000_n1600# divbuf_1/a_36480_n1600# 0.26fF
C4934 divbuf_1/a_26832_n240# divbuf_1/a_26910_n840# 0.04fF
C4935 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/a_28350_n840# 0.04fF
C4936 ro_div_0/divbuf_0/a_37440_n1600# ro_div_0/divbuf_0/a_37920_n1600# 0.26fF
C4937 divbuf_3/a_26880_n1600# divbuf_3/a_27360_n1600# 0.26fF
C4938 divbuf_3/a_17612_n240# divbuf_3/a_17790_n840# 0.02fF
C4939 ro_div_0/divbuf_0/a_60510_n840# ro_div_0/divbuf_0/a_60510_n1540# 0.01fF
C4940 ro_div_0/divbuf_0/a_29790_n1540# ro_div_0/divbuf_0/a_30270_n1540# 0.11fF
C4941 divbuf_3/a_19230_n1540# divbuf_3/a_19710_n1540# 0.11fF
C4942 divbuf_3/a_49950_n840# divbuf_3/a_49950_n1540# 0.01fF
C4943 divbuf_0/a_40412_170# divbuf_0/a_40902_170# 0.07fF
C4944 divbuf_0/a_21012_170# divbuf_0/a_21012_n240# 0.01fF
C4945 divbuf_2/a_25382_n240# divbuf_2/OUT4 0.04fF
C4946 divbuf_2/a_54240_n1600# divbuf_2/a_54270_n840# 0.04fF
C4947 divbuf_1/a_34592_n240# divbuf_1/OUT4 0.04fF
C4948 divbuf_1/a_28320_n1600# divbuf_1/a_28350_n1540# 0.19fF
C4949 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/a_35082_170# 0.07fF
C4950 divbuf_0/a_12990_n840# divbuf_0/a_13470_n840# 0.07fF
C4951 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n1540# 0.19fF
C4952 divbuf_0/a_3422_n240# divbuf_0/OUT3 0.07fF
C4953 pll_full_0/divbuf_0/a_7230_n840# pll_full_0/divbuf_0/a_7710_n840# 0.07fF
C4954 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/OUT4 0.19fF
C4955 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7230_n1540# 0.19fF
C4956 divbuf_1/a_25920_n1600# divbuf_1/a_25950_n840# 0.04fF
C4957 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27390_n840# 0.04fF
C4958 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/OUT4 0.19fF
C4959 pll_full_0/divbuf_0/a_60030_n1540# pll_full_0/divbuf_0/a_60510_n1540# 0.11fF
C4960 divbuf_3/a_16800_n1600# divbuf_3/a_16830_n840# 0.04fF
C4961 divbuf_1/a_20190_n1540# divbuf_1/a_20670_n1540# 0.11fF
C4962 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/a_25440_n1600# 0.26fF
C4963 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_15870_n840# 0.02fF
C4964 pll_full_0/divbuf_1/a_30240_n1600# pll_full_0/divbuf_1/a_30720_n1600# 0.26fF
C4965 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/a_21150_n840# 0.03fF
C4966 divbuf_2/a_32172_n240# divbuf_2/a_32652_n240# 0.05fF
C4967 divbuf_2/a_13470_n840# divbuf_2/a_13470_n1540# 0.01fF
C4968 divbuf_2/a_43710_n840# divbuf_2/a_44190_n840# 0.07fF
C4969 divbuf_2/a_43680_n1600# divbuf_2/a_43710_n1540# 0.19fF
C4970 divbuf_2/a_23520_n1600# divbuf_2/OUT4 0.00fF
C4971 divbuf_1/a_32640_n1600# divbuf_1/OUT4 0.00fF
C4972 pd_div_0/divbuf_0/a_17310_n1540# pd_div_0/divbuf_0/a_17790_n1540# 0.11fF
C4973 pd_div_0/divbuf_0/a_48030_n840# pd_div_0/divbuf_0/a_48030_n1540# 0.01fF
C4974 pll_full_0/divbuf_1/a_22590_n1540# pll_full_0/divbuf_1/a_23070_n1540# 0.11fF
C4975 pll_full_0/divbuf_1/a_53310_n840# pll_full_0/divbuf_1/a_53310_n1540# 0.01fF
C4976 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/a_24892_n240# 0.01fF
C4977 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/a_4882_n240# 0.04fF
C4978 divbuf_0/a_2880_n1600# divbuf_0/OUT2 0.00fF
C4979 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C4980 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_57630_n840# 0.04fF
C4981 divbuf_3/a_14222_170# divbuf_3/a_14222_n240# 0.01fF
C4982 divbuf_3/a_33622_170# divbuf_3/a_34112_170# 0.07fF
C4983 divbuf_1/a_15390_n840# divbuf_1/a_15870_n840# 0.07fF
C4984 ro_div_0/ro_complete_0/a0 ro_div_0/divider_0/clk 0.05fF
C4985 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_16830_n1540# 0.19fF
C4986 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/OUT4 0.07fF
C4987 ro_div_0/divbuf_0/a_16830_n840# ro_div_0/divbuf_0/a_17310_n840# 0.07fF
C4988 ro_div_0/divider_0/tspc_2/Z3 gnd 0.27fF
C4989 divbuf_3/a_6270_n840# divbuf_3/a_6750_n840# 0.07fF
C4990 divbuf_3/a_29262_170# divbuf_3/OUT4 0.19fF
C4991 divbuf_3/a_6240_n1600# divbuf_3/a_6270_n1540# 0.19fF
C4992 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_14910_n840# 0.04fF
C4993 divbuf_0/a_18582_170# divbuf_0/a_19072_170# 0.07fF
C4994 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20190_n840# 0.04fF
C4995 divbuf_3/a_59070_n1540# divbuf_3/a_59550_n1540# 0.11fF
C4996 divbuf_1/a_37950_n840# divbuf_1/a_37950_n1540# 0.01fF
C4997 pll_full_0/divbuf_0/a_35562_n240# pll_full_0/divbuf_0/a_36052_n240# 0.04fF
C4998 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n1540# 0.19fF
C4999 divbuf_0/a_52830_n840# divbuf_0/a_53310_n840# 0.07fF
C5000 divbuf_0/a_22590_n840# divbuf_0/a_22590_n1540# 0.01fF
C5001 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47070_n1540# 0.19fF
C5002 pll_full_0/divbuf_0/a_16830_n840# pll_full_0/divbuf_0/a_16830_n1540# 0.01fF
C5003 pll_full_0/divbuf_0/a_47070_n840# pll_full_0/divbuf_0/a_47550_n840# 0.07fF
C5004 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/a_32172_170# 0.07fF
C5005 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C5006 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/a_17612_n240# 0.01fF
C5007 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/a_37502_170# 0.07fF
C5008 divbuf_3/a_30232_n240# divbuf_3/OUT4 0.04fF
C5009 divbuf_3/a_56640_n1600# divbuf_3/a_56670_n840# 0.04fF
C5010 divbuf_1/a_60030_n1540# divbuf_1/a_60510_n1540# 0.11fF
C5011 pd_div_0/divbuf_0/a_4350_n840# pd_div_0/divbuf_0/a_4830_n840# 0.07fF
C5012 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5013 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4350_n1540# 0.19fF
C5014 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C5015 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C5016 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/prescaler_0/Out 0.12fF
C5017 divbuf_0/a_9242_170# divbuf_0/a_9732_170# 0.07fF
C5018 pll_full_0/divbuf_1/a_9630_n840# pll_full_0/divbuf_1/a_10110_n840# 0.07fF
C5019 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5020 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_9630_n1540# 0.19fF
C5021 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C5022 divbuf_2/a_30240_n1600# divbuf_2/a_30720_n1600# 0.26fF
C5023 divbuf_2/a_21012_n240# divbuf_2/a_21150_n840# 0.03fF
C5024 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C5025 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C5026 pd_div_0/divbuf_0/a_57150_n1540# pd_div_0/divbuf_0/a_57630_n1540# 0.11fF
C5027 pll_full_0/divbuf_1/a_60990_n1540# pll_full_0/divbuf_1/OUT5 0.19fF
C5028 divbuf_2/a_22590_n1540# divbuf_2/a_23070_n1540# 0.11fF
C5029 divbuf_2/a_53310_n840# divbuf_2/a_53310_n1540# 0.01fF
C5030 divbuf_1/a_1920_n1600# divbuf_1/a_2400_n1600# 0.26fF
C5031 ro_div_0/divbuf_0/a_3360_n1600# ro_div_0/divbuf_0/a_3840_n1600# 0.26fF
C5032 divbuf_3/a_34592_n240# divbuf_3/a_35082_n240# 0.04fF
C5033 divbuf_1/a_55230_n840# divbuf_1/a_55710_n840# 0.07fF
C5034 ro_div_0/divbuf_0/a_56670_n840# ro_div_0/divbuf_0/a_57150_n840# 0.07fF
C5035 ro_div_0/divbuf_0/a_26430_n840# ro_div_0/divbuf_0/a_26430_n1540# 0.01fF
C5036 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_56670_n1540# 0.19fF
C5037 divbuf_3/a_46080_n1600# divbuf_3/a_46110_n1540# 0.19fF
C5038 divbuf_3/a_15870_n840# divbuf_3/a_15870_n1540# 0.01fF
C5039 divbuf_3/a_46110_n840# divbuf_3/a_46590_n840# 0.07fF
C5040 pd_div_0/divbuf_0/a_26352_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5041 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_54750_n840# 0.04fF
C5042 ro_div_0/divider_0/and_0/B ro_div_0/divider_0/and_0/Z1 0.07fF
C5043 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/a_6332_170# 0.07fF
C5044 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_13252_170# 0.07fF
C5045 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C5046 divbuf_2/a_20160_n1600# divbuf_2/a_20190_n840# 0.04fF
C5047 pll_full_0/divbuf_1/a_37022_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5048 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60030_n840# 0.04fF
C5049 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C5050 divbuf_0/a_30232_n240# divbuf_0/a_30270_n840# 0.05fF
C5051 divbuf_0/a_39360_n1600# divbuf_0/a_39840_n1600# 0.26fF
C5052 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C5053 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C5054 pll_full_0/divbuf_0/a_33600_n1600# pll_full_0/divbuf_0/a_34080_n1600# 0.26fF
C5055 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/a_24510_n840# 0.03fF
C5056 divbuf_1/a_12772_n240# divbuf_1/a_12510_n840# 0.01fF
C5057 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_13950_n840# 0.01fF
C5058 divbuf_0/a_31710_n1540# divbuf_0/a_32190_n1540# 0.11fF
C5059 pll_full_0/divbuf_0/a_25950_n1540# pll_full_0/divbuf_0/a_26430_n1540# 0.11fF
C5060 pll_full_0/divbuf_0/a_56670_n840# pll_full_0/divbuf_0/a_56670_n1540# 0.01fF
C5061 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/a_33142_n240# 0.04fF
C5062 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/a_38472_n240# 0.05fF
C5063 divbuf_2/a_17612_170# divbuf_2/a_17612_n240# 0.01fF
C5064 divbuf_2/a_37022_170# divbuf_2/a_37502_170# 0.07fF
C5065 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/a_10212_n240# 0.01fF
C5066 pll_full_0/divbuf_0/a_4392_170# pll_full_0/divbuf_0/a_4392_n240# 0.01fF
C5067 divbuf_2/a_9630_n840# divbuf_2/a_10110_n840# 0.07fF
C5068 divbuf_2/a_36052_170# divbuf_2/OUT4 0.19fF
C5069 divbuf_2/a_9600_n1600# divbuf_2/a_9630_n1540# 0.19fF
C5070 divbuf_1/a_5852_n240# divbuf_1/OUT3 0.04fF
C5071 pd_div_0/divbuf_0/a_13950_n840# pd_div_0/divbuf_0/a_13950_n1540# 0.01fF
C5072 pd_div_0/divbuf_0/a_44190_n840# pd_div_0/divbuf_0/a_44670_n840# 0.07fF
C5073 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44190_n1540# 0.19fF
C5074 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5075 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5076 pll_full_0/divbuf_1/a_19230_n840# pll_full_0/divbuf_1/a_19230_n1540# 0.01fF
C5077 pll_full_0/divbuf_1/a_49470_n840# pll_full_0/divbuf_1/a_49950_n840# 0.07fF
C5078 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49470_n1540# 0.19fF
C5079 gnd pll_full_0/divider_0/nor_0/B 1.23fF
C5080 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/tspc_0/Z3 0.05fF
C5081 pd_div_0/divider_0/prescaler_0/tspc_1/Q gnd 0.83fF
C5082 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/a_11802_170# 0.07fF
C5083 divbuf_0/a_13742_170# divbuf_0/OUT4 0.19fF
C5084 divbuf_0/a_29280_n1600# divbuf_0/a_29310_n840# 0.04fF
C5085 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C5086 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z4 0.22fF
C5087 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_23550_n840# 0.04fF
C5088 divbuf_2/a_60990_n1540# divbuf_2/OUT5 0.19fF
C5089 divbuf_1/a_41760_n1600# divbuf_1/a_42240_n1600# 0.26fF
C5090 divbuf_1/a_32652_n240# divbuf_1/a_32670_n840# 0.06fF
C5091 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/a_34110_n840# 0.06fF
C5092 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/OUT3 0.19fF
C5093 ro_div_0/divbuf_0/a_43200_n1600# ro_div_0/divbuf_0/a_43680_n1600# 0.26fF
C5094 divbuf_3/a_32640_n1600# divbuf_3/a_33120_n1600# 0.26fF
C5095 divbuf_3/a_23442_n240# divbuf_3/a_23550_n840# 0.03fF
C5096 ro_div_0/divbuf_0/a_35550_n1540# ro_div_0/divbuf_0/a_36030_n1540# 0.11fF
C5097 io_clamp_low[2] io_clamp_high[2] 0.53fF
C5098 divbuf_3/a_24990_n1540# divbuf_3/a_25470_n1540# 0.11fF
C5099 divbuf_3/a_55710_n840# divbuf_3/a_55710_n1540# 0.01fF
C5100 divbuf_0/a_26832_170# divbuf_0/a_26832_n240# 0.01fF
C5101 divbuf_0/a_6332_n240# divbuf_0/a_6822_n240# 0.04fF
C5102 pll_full_0/divbuf_0/a_21012_170# pll_full_0/divbuf_0/a_21012_n240# 0.01fF
C5103 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/a_40902_170# 0.07fF
C5104 divbuf_2/a_37022_n240# divbuf_2/OUT4 0.04fF
C5105 divbuf_2/a_60000_n1600# divbuf_2/a_60030_n840# 0.04fF
C5106 divbuf_1/a_34080_n1600# divbuf_1/a_34110_n1540# 0.19fF
C5107 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/a_11312_n240# 0.01fF
C5108 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n1540# 0.19fF
C5109 divbuf_0/a_15182_n240# divbuf_0/OUT4 0.04fF
C5110 divbuf_0/a_18750_n840# divbuf_0/a_19230_n840# 0.07fF
C5111 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/OUT3 0.07fF
C5112 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_12990_n1540# 0.19fF
C5113 pll_full_0/divbuf_0/a_12990_n840# pll_full_0/divbuf_0/a_13470_n840# 0.07fF
C5114 divbuf_1/a_31680_n1600# divbuf_1/a_31710_n840# 0.04fF
C5115 pd_div_0/pd_0/DOWN pd_div_0/pd_0/UP 0.49fF
C5116 pd_div_0/pd_0/tspc_r_0/Z4 pd_div_0/pd_0/tspc_r_0/z5 0.04fF
C5117 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33150_n840# 0.04fF
C5118 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5119 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/a_1842_170# 0.07fF
C5120 divbuf_3/a_492_n240# divbuf_3/IN 0.13fF
C5121 divbuf_3/a_22560_n1600# divbuf_3/a_22590_n840# 0.04fF
C5122 divbuf_1/a_25950_n1540# divbuf_1/a_26430_n1540# 0.11fF
C5123 pd_div_0/divbuf_0/a_30720_n1600# pd_div_0/divbuf_0/a_31200_n1600# 0.26fF
C5124 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/a_21630_n840# 0.03fF
C5125 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/a_36480_n1600# 0.26fF
C5126 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/a_26910_n840# 0.04fF
C5127 divbuf_2/a_37992_n240# divbuf_2/a_38472_n240# 0.05fF
C5128 divbuf_2/a_35040_n1600# divbuf_2/OUT4 0.00fF
C5129 divbuf_2/a_19230_n840# divbuf_2/a_19230_n1540# 0.01fF
C5130 divbuf_2/a_49470_n840# divbuf_2/a_49950_n840# 0.07fF
C5131 divbuf_2/a_49440_n1600# divbuf_2/a_49470_n1540# 0.19fF
C5132 pd_div_0/divbuf_0/a_23070_n1540# pd_div_0/divbuf_0/a_23550_n1540# 0.11fF
C5133 pd_div_0/divbuf_0/a_53790_n840# pd_div_0/divbuf_0/a_53790_n1540# 0.01fF
C5134 pll_full_0/divbuf_1/a_28350_n1540# pll_full_0/divbuf_1/a_28830_n1540# 0.11fF
C5135 pll_full_0/divbuf_1/a_59070_n840# pll_full_0/divbuf_1/a_59070_n1540# 0.01fF
C5136 divbuf_1/a_8762_n240# divbuf_1/a_9242_n240# 0.05fF
C5137 ro_div_0/divbuf_0/a_30712_170# ro_div_0/divbuf_0/a_30712_n240# 0.01fF
C5138 divbuf_0/a_13440_n1600# divbuf_0/OUT4 0.00fF
C5139 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C5140 divbuf_3/a_20042_170# divbuf_3/a_20042_n240# 0.01fF
C5141 divbuf_3/a_39442_170# divbuf_3/a_39932_170# 0.07fF
C5142 divbuf_1/a_21150_n840# divbuf_1/a_21630_n840# 0.07fF
C5143 ro_div_0/divbuf_0/a_22590_n840# ro_div_0/divbuf_0/a_23070_n840# 0.07fF
C5144 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_22590_n1540# 0.19fF
C5145 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5146 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C5147 divbuf_3/a_1352_n240# divbuf_3/OUT2 0.07fF
C5148 divbuf_3/a_40902_170# divbuf_3/OUT4 0.19fF
C5149 divbuf_3/a_12000_n1600# divbuf_3/a_12030_n1540# 0.19fF
C5150 divbuf_3/a_12030_n840# divbuf_3/a_12510_n840# 0.07fF
C5151 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_20670_n840# 0.04fF
C5152 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C5153 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z1 0.00fF
C5154 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/OUT3 0.19fF
C5155 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_25950_n840# 0.04fF
C5156 io_clamp_high[1] io_analog[5] 0.53fF
C5157 divbuf_0/a_5280_n1600# divbuf_0/a_5760_n1600# 0.26fF
C5158 divbuf_1/a_43710_n840# divbuf_1/a_43710_n1540# 0.01fF
C5159 divbuf_0/a_58590_n840# divbuf_0/a_59070_n840# 0.07fF
C5160 divbuf_0/a_28350_n840# divbuf_0/a_28350_n1540# 0.01fF
C5161 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n1540# 0.19fF
C5162 pll_full_0/divbuf_0/a_22590_n840# pll_full_0/divbuf_0/a_22590_n1540# 0.01fF
C5163 pll_full_0/divbuf_0/a_52830_n840# pll_full_0/divbuf_0/a_53310_n840# 0.07fF
C5164 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_52830_n1540# 0.19fF
C5165 pd_div_0/divbuf_0/a_18092_170# pd_div_0/divbuf_0/a_18092_n240# 0.01fF
C5166 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/a_37992_170# 0.07fF
C5167 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C5168 pll_full_0/divbuf_1/a_23442_170# pll_full_0/divbuf_1/a_23442_n240# 0.01fF
C5169 divbuf_3/a_41382_n240# divbuf_3/OUT5 0.04fF
C5170 divbuf_3/a_960_n1600# divbuf_3/OUT2 0.00fF
C5171 divbuf_2/a_1352_170# divbuf_2/a_1842_170# 0.07fF
C5172 pd_div_0/divbuf_0/a_10110_n840# pd_div_0/divbuf_0/a_10590_n840# 0.07fF
C5173 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5174 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10110_n1540# 0.19fF
C5175 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/clk 0.12fF
C5176 pll_full_0/divbuf_1/a_15390_n840# pll_full_0/divbuf_1/a_15870_n840# 0.07fF
C5177 pll_full_0/divbuf_1/a_8272_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C5178 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15390_n1540# 0.19fF
C5179 pll_full_0/divbuf_0/a_8762_170# pll_full_0/divbuf_0/a_9242_170# 0.07fF
C5180 divbuf_2/a_36000_n1600# divbuf_2/a_36480_n1600# 0.26fF
C5181 divbuf_2/a_26832_n240# divbuf_2/a_26910_n840# 0.04fF
C5182 divbuf_1/a_16642_170# divbuf_1/OUT4 0.19fF
C5183 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C5184 divbuf_2/a_28350_n1540# divbuf_2/a_28830_n1540# 0.11fF
C5185 divbuf_2/a_59070_n840# divbuf_2/a_59070_n1540# 0.01fF
C5186 pd_div_0/divbuf_0/OUT2 pd_div_0/divbuf_0/OUT3 0.36fF
C5187 divbuf_0/a_16152_n240# divbuf_0/a_15870_n840# 0.01fF
C5188 divbuf_1/a_7680_n1600# divbuf_1/a_8160_n1600# 0.26fF
C5189 ro_div_0/divbuf_0/a_9120_n1600# ro_div_0/divbuf_0/a_9600_n1600# 0.26fF
C5190 divbuf_3/a_40412_n240# divbuf_3/a_40902_n240# 0.04fF
C5191 ro_div_0/divbuf_0/a_60480_n1600# ro_div_0/divbuf_0/OUT5 0.26fF
C5192 ro_div_0/divbuf_0/a_32190_n840# ro_div_0/divbuf_0/a_32190_n1540# 0.01fF
C5193 ro_div_0/divbuf_0/a_1470_n1540# ro_div_0/divbuf_0/a_1950_n1540# 0.11fF
C5194 divbuf_3/a_21630_n840# divbuf_3/a_21630_n1540# 0.01fF
C5195 divbuf_3/a_51870_n840# divbuf_3/a_52350_n840# 0.07fF
C5196 divbuf_3/a_51840_n1600# divbuf_3/a_51870_n1540# 0.19fF
C5197 pd_div_0/divbuf_0/a_37992_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5198 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/a_60510_n840# 0.04fF
C5199 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C5200 divbuf_0/a_11802_170# divbuf_0/a_12282_170# 0.07fF
C5201 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C5202 divbuf_2/a_7302_170# divbuf_2/OUT3 0.19fF
C5203 divbuf_2/a_25920_n1600# divbuf_2/a_25950_n840# 0.04fF
C5204 divbuf_1/a_14222_170# divbuf_1/OUT4 0.19fF
C5205 gnd pll_full_0/divider_0/tspc_0/Q 0.33fF
C5206 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_0/a_630_n680# 0.01fF
C5207 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C5208 pd_div_0/divider_0/nor_0/Z1 gnd 0.01fF
C5209 divbuf_0/a_45120_n1600# divbuf_0/a_45600_n1600# 0.26fF
C5210 divbuf_0/a_36052_n240# divbuf_0/a_36030_n840# 0.05fF
C5211 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C5212 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C5213 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C5214 pll_full_0/divbuf_0/a_39360_n1600# pll_full_0/divbuf_0/a_39840_n1600# 0.26fF
C5215 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/a_30270_n840# 0.05fF
C5216 divbuf_0/a_37470_n1540# divbuf_0/a_37950_n1540# 0.11fF
C5217 pll_full_0/divbuf_0/a_31710_n1540# pll_full_0/divbuf_0/a_32190_n1540# 0.11fF
C5218 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/a_38962_n240# 0.04fF
C5219 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/a_2400_n1600# 0.26fF
C5220 divbuf_2/a_23442_170# divbuf_2/a_23442_n240# 0.01fF
C5221 pd_div_0/divbuf_0/a_36000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5222 pd_div_0/divbuf_0/a_19710_n840# pd_div_0/divbuf_0/a_19710_n1540# 0.01fF
C5223 pd_div_0/divbuf_0/a_49950_n840# pd_div_0/divbuf_0/a_50430_n840# 0.07fF
C5224 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_49950_n1540# 0.19fF
C5225 divbuf_2/a_15390_n840# divbuf_2/a_15870_n840# 0.07fF
C5226 divbuf_2/a_8272_n240# divbuf_2/OUT3 0.04fF
C5227 divbuf_2/a_15360_n1600# divbuf_2/a_15390_n1540# 0.19fF
C5228 divbuf_1/a_17612_n240# divbuf_1/OUT4 0.04fF
C5229 pll_full_0/divbuf_1/a_24990_n840# pll_full_0/divbuf_1/a_24990_n1540# 0.01fF
C5230 pll_full_0/divbuf_1/a_55230_n840# pll_full_0/divbuf_1/a_55710_n840# 0.07fF
C5231 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55230_n1540# 0.19fF
C5232 ro_div_0/ro_complete_0/cbank_2/switch_0/vin ro_div_0/ro_complete_0/cbank_2/v 1.44fF
C5233 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/a_17612_170# 0.07fF
C5234 pd_div_0/divider_0/tspc_2/Z2 pd_div_0/divider_0/tspc_2/Z4 0.36fF
C5235 pd_div_0/divider_0/tspc_2/Z3 pd_div_0/bufin 0.05fF
C5236 gnd pd_div_0/divider_0/tspc_0/Z3 0.27fF
C5237 divbuf_0/a_35040_n1600# divbuf_0/a_35070_n840# 0.04fF
C5238 divbuf_0/a_25862_170# divbuf_0/OUT4 0.19fF
C5239 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5240 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29310_n840# 0.04fF
C5241 divbuf_3/a_4392_170# divbuf_3/a_4882_170# 0.07fF
C5242 divbuf_1/a_38472_n240# divbuf_1/a_38430_n840# 0.04fF
C5243 divbuf_1/a_47520_n1600# divbuf_1/a_48000_n1600# 0.26fF
C5244 ro_div_0/divbuf_0/a_48960_n1600# ro_div_0/divbuf_0/a_49440_n1600# 0.26fF
C5245 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/a_39870_n840# 0.04fF
C5246 divbuf_3/a_38400_n1600# divbuf_3/a_38880_n1600# 0.26fF
C5247 divbuf_3/a_29262_n240# divbuf_3/a_29310_n840# 0.04fF
C5248 ro_div_0/divbuf_0/a_41310_n1540# ro_div_0/divbuf_0/a_41790_n1540# 0.11fF
C5249 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_12510_n840# 0.01fF
C5250 divbuf_3/a_30750_n1540# divbuf_3/a_31230_n1540# 0.11fF
C5251 divbuf_0/a_32652_170# divbuf_0/a_32652_n240# 0.01fF
C5252 divbuf_0/a_12772_n240# divbuf_0/a_13252_n240# 0.05fF
C5253 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/a_26832_n240# 0.01fF
C5254 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/a_6822_n240# 0.04fF
C5255 divbuf_1/a_39840_n1600# divbuf_1/a_39870_n1540# 0.19fF
C5256 divbuf_1/a_13742_170# divbuf_1/a_13742_n240# 0.01fF
C5257 ro_div_0/divbuf_0/a_17122_170# ro_div_0/divbuf_0/a_17122_n240# 0.01fF
C5258 divbuf_0/a_24510_n840# divbuf_0/a_24990_n840# 0.07fF
C5259 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n1540# 0.19fF
C5260 divbuf_0/a_26832_n240# divbuf_0/OUT4 0.04fF
C5261 pll_full_0/divbuf_0/a_18750_n840# pll_full_0/divbuf_0/a_19230_n840# 0.07fF
C5262 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5263 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_18750_n1540# 0.19fF
C5264 divbuf_1/a_37440_n1600# divbuf_1/a_37470_n840# 0.04fF
C5265 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_38910_n840# 0.04fF
C5266 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5267 ro_div_0/divider_0/tspc_1/Q gnd 0.33fF
C5268 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/a_8272_170# 0.07fF
C5269 divbuf_3/a_12282_170# divbuf_3/OUT4 0.19fF
C5270 divbuf_3/a_28320_n1600# divbuf_3/a_28350_n840# 0.04fF
C5271 divbuf_1/a_31710_n1540# divbuf_1/a_32190_n1540# 0.11fF
C5272 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/a_36960_n1600# 0.26fF
C5273 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/a_27390_n840# 0.04fF
C5274 pll_full_0/divbuf_1/a_41760_n1600# pll_full_0/divbuf_1/a_42240_n1600# 0.26fF
C5275 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/a_32670_n840# 0.06fF
C5276 divbuf_2/a_1920_n1600# divbuf_2/a_2400_n1600# 0.26fF
C5277 divbuf_2/a_24990_n840# divbuf_2/a_24990_n1540# 0.01fF
C5278 divbuf_2/a_55230_n840# divbuf_2/a_55710_n840# 0.07fF
C5279 divbuf_2/a_55200_n1600# divbuf_2/a_55230_n1540# 0.19fF
C5280 pd_div_0/divbuf_0/a_28830_n1540# pd_div_0/divbuf_0/a_29310_n1540# 0.11fF
C5281 pd_div_0/divbuf_0/a_59550_n840# pd_div_0/divbuf_0/a_59550_n1540# 0.01fF
C5282 pll_full_0/divbuf_1/a_34110_n1540# pll_full_0/divbuf_1/a_34590_n1540# 0.11fF
C5283 divbuf_1/a_15182_n240# divbuf_1/a_15672_n240# 0.04fF
C5284 divbuf_1/a_35082_170# divbuf_1/a_35082_n240# 0.01fF
C5285 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/a_36532_n240# 0.01fF
C5286 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_17122_n240# 0.05fF
C5287 divbuf_0/a_24960_n1600# divbuf_0/OUT4 0.00fF
C5288 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C5289 divbuf_3/a_5362_n240# divbuf_3/a_5852_n240# 0.04fF
C5290 divbuf_3/a_25862_170# divbuf_3/a_25862_n240# 0.01fF
C5291 divbuf_1/a_26910_n840# divbuf_1/a_27390_n840# 0.07fF
C5292 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28350_n1540# 0.19fF
C5293 ro_div_0/divbuf_0/a_28350_n840# ro_div_0/divbuf_0/a_28830_n840# 0.07fF
C5294 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5295 divbuf_3/a_17790_n840# divbuf_3/a_18270_n840# 0.07fF
C5296 divbuf_3/a_13252_n240# divbuf_3/OUT4 0.04fF
C5297 divbuf_3/a_17760_n1600# divbuf_3/a_17790_n1540# 0.19fF
C5298 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26430_n840# 0.04fF
C5299 pd_div_0/divbuf_0/a_3912_170# pd_div_0/divbuf_0/OUT3 0.19fF
C5300 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5301 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_31710_n840# 0.04fF
C5302 divbuf_2/a_12772_n240# divbuf_2/a_12510_n840# 0.01fF
C5303 divbuf_0/a_11040_n1600# divbuf_0/a_11520_n1600# 0.26fF
C5304 divbuf_1/a_49470_n840# divbuf_1/a_49470_n1540# 0.01fF
C5305 pll_full_0/divbuf_0/a_5280_n1600# pll_full_0/divbuf_0/a_5760_n1600# 0.26fF
C5306 divbuf_0/a_34110_n840# divbuf_0/a_34110_n1540# 0.01fF
C5307 divbuf_0/a_3390_n1540# divbuf_0/a_3870_n1540# 0.11fF
C5308 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_58590_n1540# 0.19fF
C5309 pll_full_0/divbuf_0/a_28350_n840# pll_full_0/divbuf_0/a_28350_n1540# 0.01fF
C5310 pll_full_0/divbuf_0/a_58590_n840# pll_full_0/divbuf_0/a_59070_n840# 0.07fF
C5311 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/a_3912_n240# 0.04fF
C5312 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/a_23922_n240# 0.01fF
C5313 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C5314 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/a_9242_n240# 0.05fF
C5315 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/a_29262_n240# 0.01fF
C5316 divbuf_3/a_11520_n1600# divbuf_3/OUT4 0.01fF
C5317 divbuf_2/a_7792_170# divbuf_2/a_8272_170# 0.07fF
C5318 pd_div_0/divbuf_0/a_15870_n840# pd_div_0/divbuf_0/a_16350_n840# 0.07fF
C5319 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C5320 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_15870_n1540# 0.19fF
C5321 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/clk 0.60fF
C5322 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z2 0.01fF
C5323 pll_full_0/divbuf_1/a_21150_n840# pll_full_0/divbuf_1/a_21630_n840# 0.07fF
C5324 pll_full_0/divbuf_1/a_20042_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5325 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21150_n1540# 0.19fF
C5326 divbuf_2/a_41760_n1600# divbuf_2/a_42240_n1600# 0.26fF
C5327 divbuf_2/a_32652_n240# divbuf_2/a_32670_n840# 0.06fF
C5328 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C5329 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_8272_170# 0.07fF
C5330 divbuf_2/a_34110_n1540# divbuf_2/a_34590_n1540# 0.11fF
C5331 divbuf_1/a_31202_170# divbuf_1/a_31682_170# 0.07fF
C5332 divbuf_0/a_960_n1600# divbuf_0/a_990_n840# 0.04fF
C5333 divbuf_0/a_6332_170# divbuf_0/OUT3 0.19fF
C5334 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_15870_n840# 0.01fF
C5335 divbuf_1/a_13440_n1600# divbuf_1/a_13920_n1600# 0.26fF
C5336 divbuf_1/a_3912_n240# divbuf_1/a_3870_n840# 0.04fF
C5337 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/a_5310_n840# 0.04fF
C5338 ro_div_0/divbuf_0/a_14880_n1600# ro_div_0/divbuf_0/a_15360_n1600# 0.26fF
C5339 divbuf_3/a_4320_n1600# divbuf_3/a_4800_n1600# 0.26fF
C5340 divbuf_1/a_5790_n1540# divbuf_1/a_6270_n1540# 0.11fF
C5341 ro_div_0/divbuf_0/a_37950_n840# ro_div_0/divbuf_0/a_37950_n1540# 0.01fF
C5342 ro_div_0/divbuf_0/a_7230_n1540# ro_div_0/divbuf_0/a_7710_n1540# 0.11fF
C5343 divbuf_3/a_57600_n1600# divbuf_3/a_57630_n1540# 0.19fF
C5344 divbuf_3/a_27390_n840# divbuf_3/a_27390_n1540# 0.01fF
C5345 divbuf_3/a_57630_n840# divbuf_3/a_58110_n840# 0.07fF
C5346 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C5347 divbuf_0/a_15182_170# divbuf_0/a_15672_170# 0.07fF
C5348 divbuf_2/a_19072_170# divbuf_2/OUT4 0.19fF
C5349 divbuf_2/a_31680_n1600# divbuf_2/a_31710_n840# 0.04fF
C5350 divbuf_1/a_24892_170# divbuf_1/OUT4 0.19fF
C5351 ro_div_0/ro_complete_0/cbank_0/switch_2/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C5352 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C5353 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.44fF
C5354 pd_div_0/divider_0/nor_1/B gnd 1.17fF
C5355 divbuf_0/a_50880_n1600# divbuf_0/a_51360_n1600# 0.26fF
C5356 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.31fF
C5357 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z2 0.14fF
C5358 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C5359 pll_full_0/divbuf_0/a_45120_n1600# pll_full_0/divbuf_0/a_45600_n1600# 0.26fF
C5360 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/a_36030_n840# 0.05fF
C5361 divbuf_1/a_3360_n1600# divbuf_1/a_3390_n840# 0.04fF
C5362 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_4830_n840# 0.04fF
C5363 divbuf_0/a_43230_n1540# divbuf_0/a_43710_n1540# 0.11fF
C5364 pll_full_0/divbuf_0/a_37470_n1540# pll_full_0/divbuf_0/a_37950_n1540# 0.11fF
C5365 divbuf_3/a_15182_n240# divbuf_3/a_14910_n840# 0.01fF
C5366 pd_div_0/divbuf_0/a_2400_n1600# pd_div_0/divbuf_0/a_2880_n1600# 0.26fF
C5367 pll_full_0/divbuf_1/a_7680_n1600# pll_full_0/divbuf_1/a_8160_n1600# 0.26fF
C5368 divbuf_2/a_8762_n240# divbuf_2/a_9242_n240# 0.05fF
C5369 divbuf_2/a_29262_170# divbuf_2/a_29262_n240# 0.01fF
C5370 pd_div_0/divbuf_0/a_25470_n840# pd_div_0/divbuf_0/a_25470_n1540# 0.01fF
C5371 pd_div_0/divbuf_0/a_55710_n840# pd_div_0/divbuf_0/a_56190_n840# 0.07fF
C5372 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_55710_n1540# 0.19fF
C5373 divbuf_2/a_21150_n840# divbuf_2/a_21630_n840# 0.07fF
C5374 divbuf_2/a_20042_n240# divbuf_2/OUT4 0.04fF
C5375 divbuf_2/a_21120_n1600# divbuf_2/a_21150_n1540# 0.19fF
C5376 divbuf_1/a_29262_n240# divbuf_1/OUT4 0.04fF
C5377 pll_full_0/divbuf_1/a_30750_n840# pll_full_0/divbuf_1/a_30750_n1540# 0.01fF
C5378 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/a_21982_170# 0.07fF
C5379 divbuf_1/a_5362_170# divbuf_1/a_5362_n240# 0.01fF
C5380 pd_div_0/divider_0/and_0/A pd_div_0/divider_0/and_0/B 0.18fF
C5381 divbuf_0/a_40800_n1600# divbuf_0/a_40830_n840# 0.04fF
C5382 divbuf_0/a_37502_170# divbuf_0/OUT4 0.19fF
C5383 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5384 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35070_n840# 0.04fF
C5385 divbuf_1/a_53280_n1600# divbuf_1/a_53760_n1600# 0.26fF
C5386 ro_div_0/divbuf_0/a_54720_n1600# ro_div_0/divbuf_0/a_55200_n1600# 0.26fF
C5387 divbuf_3/a_44160_n1600# divbuf_3/a_44640_n1600# 0.26fF
C5388 divbuf_3/a_35082_n240# divbuf_3/a_35070_n840# 0.05fF
C5389 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/a_12990_n840# 0.01fF
C5390 ro_div_0/divbuf_0/a_47070_n1540# ro_div_0/divbuf_0/a_47550_n1540# 0.11fF
C5391 divbuf_3/a_36510_n1540# divbuf_3/a_36990_n1540# 0.11fF
C5392 divbuf_0/a_18582_n240# divbuf_0/a_19072_n240# 0.04fF
C5393 divbuf_0/a_38472_170# divbuf_0/a_38472_n240# 0.01fF
C5394 pll_full_0/divbuf_0/a_32652_170# pll_full_0/divbuf_0/a_32652_n240# 0.01fF
C5395 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_13252_n240# 0.05fF
C5396 divbuf_1/a_45600_n1600# divbuf_1/a_45630_n1540# 0.19fF
C5397 divbuf_1/a_15390_n840# divbuf_1/a_15390_n1540# 0.01fF
C5398 divbuf_1/a_19072_170# divbuf_1/a_19072_n240# 0.01fF
C5399 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n1540# 0.19fF
C5400 divbuf_0/a_30270_n840# divbuf_0/a_30750_n840# 0.07fF
C5401 divbuf_0/a_38472_n240# divbuf_0/OUT4 0.04fF
C5402 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5403 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24510_n1540# 0.19fF
C5404 pll_full_0/divbuf_0/a_24510_n840# pll_full_0/divbuf_0/a_24990_n840# 0.07fF
C5405 divbuf_1/a_43200_n1600# divbuf_1/a_43230_n840# 0.04fF
C5406 ro_div_0/ro_complete_0/a3 ro_div_0/divider_0/clk 0.05fF
C5407 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_44670_n840# 0.04fF
C5408 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C5409 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/a_14702_170# 0.07fF
C5410 divbuf_3/a_23922_170# divbuf_3/OUT4 0.19fF
C5411 divbuf_3/a_34080_n1600# divbuf_3/a_34110_n840# 0.04fF
C5412 divbuf_1/a_37470_n1540# divbuf_1/a_37950_n1540# 0.11fF
C5413 pd_div_0/divbuf_0/a_42240_n1600# pd_div_0/divbuf_0/a_42720_n1600# 0.26fF
C5414 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/a_33150_n840# 0.06fF
C5415 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/a_38430_n840# 0.04fF
C5416 pll_full_0/divbuf_1/a_47520_n1600# pll_full_0/divbuf_1/a_48000_n1600# 0.26fF
C5417 divbuf_2/a_7680_n1600# divbuf_2/a_8160_n1600# 0.26fF
C5418 divbuf_2/a_30750_n840# divbuf_2/a_30750_n1540# 0.01fF
C5419 pd_div_0/divbuf_0/a_34590_n1540# pd_div_0/divbuf_0/a_35070_n1540# 0.11fF
C5420 pll_full_0/divbuf_1/a_39870_n1540# pll_full_0/divbuf_1/a_40350_n1540# 0.11fF
C5421 divbuf_1/a_40902_170# divbuf_1/a_40902_n240# 0.01fF
C5422 divbuf_1/a_21012_n240# divbuf_1/a_21502_n240# 0.04fF
C5423 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/a_22952_n240# 0.05fF
C5424 divbuf_0/a_36480_n1600# divbuf_0/OUT4 0.00fF
C5425 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C5426 divbuf_3/a_11802_n240# divbuf_3/a_12282_n240# 0.05fF
C5427 divbuf_3/a_31682_170# divbuf_3/a_31682_n240# 0.01fF
C5428 divbuf_1/a_2430_n840# divbuf_1/a_2430_n1540# 0.01fF
C5429 divbuf_1/a_32670_n840# divbuf_1/a_33150_n840# 0.07fF
C5430 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/a_13252_n240# 0.01fF
C5431 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/a_7792_n240# 0.01fF
C5432 ro_div_0/divbuf_0/a_34110_n840# ro_div_0/divbuf_0/a_34590_n840# 0.07fF
C5433 ro_div_0/divbuf_0/a_3870_n840# ro_div_0/divbuf_0/a_3870_n1540# 0.01fF
C5434 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34110_n1540# 0.19fF
C5435 divbuf_3/a_24892_n240# divbuf_3/OUT4 0.04fF
C5436 divbuf_3/a_23520_n1600# divbuf_3/a_23550_n1540# 0.19fF
C5437 divbuf_3/a_23550_n840# divbuf_3/a_24030_n840# 0.07fF
C5438 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5439 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32190_n840# 0.04fF
C5440 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C5441 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C5442 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/a4 0.09fF
C5443 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5444 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37470_n840# 0.04fF
C5445 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C5446 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C5447 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C5448 divbuf_0/a_7302_n240# divbuf_0/a_7230_n840# 0.03fF
C5449 divbuf_0/a_16800_n1600# divbuf_0/a_17280_n1600# 0.26fF
C5450 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/a_11520_n1600# 0.26fF
C5451 divbuf_1/a_55230_n840# divbuf_1/a_55230_n1540# 0.01fF
C5452 divbuf_0/a_39870_n840# divbuf_0/a_39870_n1540# 0.01fF
C5453 divbuf_0/a_9150_n1540# divbuf_0/a_9630_n1540# 0.11fF
C5454 pll_full_0/divbuf_0/a_3390_n1540# pll_full_0/divbuf_0/a_3870_n1540# 0.11fF
C5455 pll_full_0/divbuf_0/a_34110_n840# pll_full_0/divbuf_0/a_34110_n1540# 0.01fF
C5456 pd_div_0/divbuf_0/a_9242_n240# pd_div_0/divbuf_0/a_9732_n240# 0.04fF
C5457 pd_div_0/divbuf_0/a_29742_170# pd_div_0/divbuf_0/a_29742_n240# 0.01fF
C5458 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_15672_n240# 0.04fF
C5459 pll_full_0/divbuf_1/a_35082_170# pll_full_0/divbuf_1/a_35082_n240# 0.01fF
C5460 divbuf_3/a_23040_n1600# divbuf_3/OUT4 0.01fF
C5461 divbuf_2/a_14222_170# divbuf_2/a_14702_170# 0.07fF
C5462 pd_div_0/divbuf_0/a_21630_n840# pd_div_0/divbuf_0/a_22110_n840# 0.07fF
C5463 pd_div_0/divbuf_0/a_21012_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5464 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_21630_n1540# 0.19fF
C5465 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/A 0.01fF
C5466 pll_full_0/divbuf_1/a_26910_n840# pll_full_0/divbuf_1/a_27390_n840# 0.07fF
C5467 pll_full_0/divbuf_1/a_31682_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5468 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_26910_n1540# 0.19fF
C5469 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C5470 divbuf_2/a_38472_n240# divbuf_2/a_38430_n840# 0.04fF
C5471 divbuf_2/a_47520_n1600# divbuf_2/a_48000_n1600# 0.26fF
C5472 divbuf_1/a_11802_170# divbuf_1/OUT4 0.19fF
C5473 divbuf_0/a_6720_n1600# divbuf_0/a_6750_n840# 0.04fF
C5474 divbuf_2/a_39870_n1540# divbuf_2/a_40350_n1540# 0.11fF
C5475 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C5476 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_990_n840# 0.04fF
C5477 divbuf_1/a_19200_n1600# divbuf_1/a_19680_n1600# 0.26fF
C5478 divbuf_1/a_9732_n240# divbuf_1/a_9630_n840# 0.03fF
C5479 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11550_n840# 0.02fF
C5480 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/a_21120_n1600# 0.26fF
C5481 divbuf_3/a_10080_n1600# divbuf_3/a_10560_n1600# 0.26fF
C5482 divbuf_1/a_11550_n1540# divbuf_1/a_12030_n1540# 0.11fF
C5483 ro_div_0/divbuf_0/a_43710_n840# ro_div_0/divbuf_0/a_43710_n1540# 0.01fF
C5484 ro_div_0/divbuf_0/a_12990_n1540# ro_div_0/divbuf_0/a_13470_n1540# 0.11fF
C5485 divbuf_3/a_2430_n1540# divbuf_3/a_2910_n1540# 0.11fF
C5486 divbuf_3/a_33150_n840# divbuf_3/a_33150_n1540# 0.01fF
C5487 divbuf_3/a_2910_n840# divbuf_3/OUT3 0.03fF
C5488 pd_div_0/divbuf_0/a_19200_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C5489 divbuf_0/a_23442_170# divbuf_0/a_23922_170# 0.07fF
C5490 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/a_19562_170# 0.07fF
C5491 divbuf_2/a_30712_170# divbuf_2/OUT4 0.19fF
C5492 divbuf_2/a_37440_n1600# divbuf_2/a_37470_n840# 0.04fF
C5493 divbuf_1/a_39932_170# divbuf_1/OUT4 0.19fF
C5494 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/a_14702_170# 0.07fF
C5495 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.83fF
C5496 pd_div_0/divider_0/prescaler_0/tspc_0/D pd_div_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C5497 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.44fF
C5498 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/Out 0.19fF
C5499 divbuf_0/a_56640_n1600# divbuf_0/a_57120_n1600# 0.26fF
C5500 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.05fF
C5501 pll_full_0/divbuf_0/a_50880_n1600# pll_full_0/divbuf_0/a_51360_n1600# 0.26fF
C5502 divbuf_1/a_9120_n1600# divbuf_1/a_9150_n840# 0.04fF
C5503 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_10590_n840# 0.04fF
C5504 divbuf_0/a_48990_n1540# divbuf_0/a_49470_n1540# 0.11fF
C5505 pll_full_0/divbuf_0/a_43230_n1540# pll_full_0/divbuf_0/a_43710_n1540# 0.11fF
C5506 pd_div_0/divbuf_0/a_8160_n1600# pd_div_0/divbuf_0/a_8640_n1600# 0.26fF
C5507 pll_full_0/divbuf_1/a_13440_n1600# pll_full_0/divbuf_1/a_13920_n1600# 0.26fF
C5508 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/a_3870_n840# 0.04fF
C5509 divbuf_3/a_41790_n840# divbuf_3/OUT5 0.03fF
C5510 divbuf_2/a_15182_n240# divbuf_2/a_15672_n240# 0.04fF
C5511 divbuf_2/a_35082_170# divbuf_2/a_35082_n240# 0.01fF
C5512 pd_div_0/divbuf_0/a_510_n1540# pd_div_0/divbuf_0/a_990_n1540# 0.11fF
C5513 pd_div_0/divbuf_0/a_31230_n840# pd_div_0/divbuf_0/a_31230_n1540# 0.01fF
C5514 pll_full_0/divbuf_1/a_5790_n1540# pll_full_0/divbuf_1/a_6270_n1540# 0.11fF
C5515 pll_full_0/divbuf_1/a_36510_n840# pll_full_0/divbuf_1/a_36510_n1540# 0.01fF
C5516 pll_full_0/divbuf_0/a_19072_170# pll_full_0/divbuf_0/a_19072_n240# 0.01fF
C5517 divbuf_2/a_26910_n840# divbuf_2/a_27390_n840# 0.07fF
C5518 divbuf_2/a_31682_n240# divbuf_2/OUT4 0.04fF
C5519 divbuf_2/a_26880_n1600# divbuf_2/a_26910_n1540# 0.19fF
C5520 divbuf_1/a_480_n1600# divbuf_1/IN 0.00fF
C5521 divbuf_1/a_40902_n240# divbuf_1/OUT4 0.04fF
C5522 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/a_6822_n240# 0.01fF
C5523 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/a_27802_170# 0.07fF
C5524 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/a_14222_n240# 0.01fF
C5525 divbuf_3/a_16642_170# divbuf_3/a_17122_170# 0.07fF
C5526 divbuf_1/a_22472_170# divbuf_1/a_22952_170# 0.07fF
C5527 divbuf_1/a_32172_170# divbuf_1/a_32172_n240# 0.01fF
C5528 divbuf_0/a_46560_n1600# divbuf_0/a_46590_n840# 0.04fF
C5529 divbuf_0/a_9732_n240# divbuf_0/OUT3 0.04fF
C5530 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5531 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_40830_n840# 0.04fF
C5532 divbuf_1/a_59040_n1600# divbuf_1/a_59520_n1600# 0.26fF
C5533 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/R 0.01fF
C5534 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z4 0.02fF
C5535 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_0/Qbar 0.21fF
C5536 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5537 divbuf_3/a_40902_n240# divbuf_3/a_40830_n840# 0.03fF
C5538 divbuf_3/a_49920_n1600# divbuf_3/a_50400_n1600# 0.26fF
C5539 ro_div_0/divbuf_0/a_52830_n1540# ro_div_0/divbuf_0/a_53310_n1540# 0.11fF
C5540 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3390_n840# 0.04fF
C5541 divbuf_3/a_42270_n1540# divbuf_3/a_42750_n1540# 0.11fF
C5542 divbuf_0/a_24412_n240# divbuf_0/a_24892_n240# 0.05fF
C5543 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/a_38472_n240# 0.01fF
C5544 pll_full_0/divbuf_0/a_18582_n240# pll_full_0/divbuf_0/a_19072_n240# 0.04fF
C5545 divbuf_1/a_21150_n840# divbuf_1/a_21150_n1540# 0.01fF
C5546 divbuf_1/a_51360_n1600# divbuf_1/a_51390_n1540# 0.19fF
C5547 divbuf_1/a_24892_170# divbuf_1/a_24892_n240# 0.01fF
C5548 divbuf_0/a_36030_n840# divbuf_0/a_36510_n840# 0.07fF
C5549 divbuf_0/a_5790_n840# divbuf_0/a_5790_n1540# 0.01fF
C5550 divbuf_0/a_8640_n1600# divbuf_0/OUT3 0.00fF
C5551 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n1540# 0.19fF
C5552 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5553 pll_full_0/divbuf_0/a_30270_n840# pll_full_0/divbuf_0/a_30750_n840# 0.07fF
C5554 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30270_n1540# 0.19fF
C5555 divbuf_1/a_48960_n1600# divbuf_1/a_48990_n840# 0.04fF
C5556 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50430_n840# 0.04fF
C5557 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5558 ro_div_0/divider_0/and_0/B gnd 0.66fF
C5559 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/a_20532_170# 0.07fF
C5560 divbuf_3/a_35562_170# divbuf_3/OUT4 0.19fF
C5561 divbuf_3/a_39840_n1600# divbuf_3/a_39870_n840# 0.04fF
C5562 divbuf_1/a_43230_n1540# divbuf_1/a_43710_n1540# 0.11fF
C5563 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/a_38910_n840# 0.04fF
C5564 pd_div_0/divbuf_0/a_48000_n1600# pd_div_0/divbuf_0/a_48480_n1600# 0.26fF
C5565 pll_full_0/divbuf_1/a_53280_n1600# pll_full_0/divbuf_1/a_53760_n1600# 0.26fF
C5566 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/OUT2 0.19fF
C5567 divbuf_2/a_13440_n1600# divbuf_2/a_13920_n1600# 0.26fF
C5568 divbuf_2/a_3912_n240# divbuf_2/a_3870_n840# 0.04fF
C5569 pd_div_0/divbuf_0/a_40350_n1540# pd_div_0/divbuf_0/a_40830_n1540# 0.11fF
C5570 divbuf_2/a_5790_n1540# divbuf_2/a_6270_n1540# 0.11fF
C5571 divbuf_2/a_36510_n840# divbuf_2/a_36510_n1540# 0.01fF
C5572 pll_full_0/divbuf_1/a_45630_n1540# pll_full_0/divbuf_1/a_46110_n1540# 0.11fF
C5573 ro_div_0/divbuf_0/a_28292_n240# ro_div_0/divbuf_0/a_28772_n240# 0.05fF
C5574 divbuf_1/a_26832_n240# divbuf_1/a_27322_n240# 0.04fF
C5575 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C5576 divbuf_3/a_17612_n240# divbuf_3/a_18092_n240# 0.05fF
C5577 divbuf_3/a_37502_170# divbuf_3/a_37502_n240# 0.01fF
C5578 divbuf_1/a_8190_n840# divbuf_1/a_8190_n1540# 0.01fF
C5579 divbuf_1/a_38430_n840# divbuf_1/a_38910_n840# 0.07fF
C5580 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_39870_n1540# 0.19fF
C5581 ro_div_0/divbuf_0/a_39870_n840# ro_div_0/divbuf_0/a_40350_n840# 0.07fF
C5582 ro_div_0/divbuf_0/a_9630_n840# ro_div_0/divbuf_0/a_9630_n1540# 0.01fF
C5583 divbuf_3/a_36532_n240# divbuf_3/OUT4 0.04fF
C5584 divbuf_3/a_29310_n840# divbuf_3/a_29790_n840# 0.07fF
C5585 divbuf_3/a_29280_n1600# divbuf_3/a_29310_n1540# 0.19fF
C5586 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5587 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_37950_n840# 0.04fF
C5588 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C5589 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C5590 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C5591 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43230_n840# 0.04fF
C5592 divbuf_2/a_3360_n1600# divbuf_2/a_3390_n840# 0.04fF
C5593 divbuf_1/a_492_n240# divbuf_1/IN 0.13fF
C5594 divbuf_0/a_22560_n1600# divbuf_0/a_23040_n1600# 0.26fF
C5595 divbuf_0/a_13252_n240# divbuf_0/a_13470_n840# 0.02fF
C5596 pll_full_0/divbuf_0/a_16800_n1600# pll_full_0/divbuf_0/a_17280_n1600# 0.26fF
C5597 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/a_7230_n840# 0.03fF
C5598 divbuf_1/a_60990_n840# divbuf_1/a_60990_n1540# 0.01fF
C5599 divbuf_0/a_45630_n840# divbuf_0/a_45630_n1540# 0.01fF
C5600 divbuf_0/a_14910_n1540# divbuf_0/a_15390_n1540# 0.11fF
C5601 pll_full_0/divbuf_0/a_9150_n1540# pll_full_0/divbuf_0/a_9630_n1540# 0.11fF
C5602 pll_full_0/divbuf_0/a_39870_n840# pll_full_0/divbuf_0/a_39870_n1540# 0.01fF
C5603 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_16152_n240# 0.05fF
C5604 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/a_35562_n240# 0.01fF
C5605 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/a_40902_n240# 0.01fF
C5606 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/a_21502_n240# 0.04fF
C5607 divbuf_3/a_34560_n1600# divbuf_3/OUT4 0.01fF
C5608 divbuf_2/a_20042_170# divbuf_2/a_20532_170# 0.07fF
C5609 pd_div_0/divbuf_0/a_32652_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5610 pd_div_0/divbuf_0/a_27390_n840# pd_div_0/divbuf_0/a_27870_n840# 0.07fF
C5611 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27390_n1540# 0.19fF
C5612 pll_full_0/divbuf_1/a_2430_n840# pll_full_0/divbuf_1/a_2430_n1540# 0.01fF
C5613 pll_full_0/divbuf_1/a_32670_n840# pll_full_0/divbuf_1/a_33150_n840# 0.07fF
C5614 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_32670_n1540# 0.19fF
C5615 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C5616 divbuf_2/a_53280_n1600# divbuf_2/a_53760_n1600# 0.26fF
C5617 divbuf_2/a_1842_170# divbuf_2/OUT2 0.19fF
C5618 divbuf_1/a_12772_170# divbuf_1/OUT4 0.19fF
C5619 divbuf_1/a_1842_170# divbuf_1/OUT2 0.19fF
C5620 divbuf_0/a_12480_n1600# divbuf_0/a_12510_n840# 0.04fF
C5621 gnd pll_full_0/divider_0/nor_0/Z1 0.01fF
C5622 divbuf_2/a_45630_n1540# divbuf_2/a_46110_n1540# 0.11fF
C5623 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z2 0.01fF
C5624 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C5625 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C5626 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_6750_n840# 0.04fF
C5627 divbuf_1/a_24960_n1600# divbuf_1/a_25440_n1600# 0.26fF
C5628 divbuf_1/a_15672_n240# divbuf_1/a_15870_n840# 0.02fF
C5629 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_17310_n840# 0.02fF
C5630 ro_div_0/divbuf_0/a_26400_n1600# ro_div_0/divbuf_0/a_26880_n1600# 0.26fF
C5631 divbuf_3/a_15840_n1600# divbuf_3/a_16320_n1600# 0.26fF
C5632 divbuf_3/a_6332_n240# divbuf_3/a_6270_n840# 0.04fF
C5633 ro_div_0/divbuf_0/a_49470_n840# ro_div_0/divbuf_0/a_49470_n1540# 0.01fF
C5634 ro_div_0/divbuf_0/a_18750_n1540# ro_div_0/divbuf_0/a_19230_n1540# 0.11fF
C5635 divbuf_3/a_8190_n1540# divbuf_3/a_8670_n1540# 0.11fF
C5636 divbuf_3/a_38910_n840# divbuf_3/a_38910_n1540# 0.01fF
C5637 divbuf_0/a_29262_170# divbuf_0/a_29742_170# 0.07fF
C5638 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/a_23922_170# 0.07fF
C5639 divbuf_2/a_2322_n240# divbuf_2/OUT3 0.04fF
C5640 divbuf_2/a_43200_n1600# divbuf_2/a_43230_n840# 0.04fF
C5641 divbuf_1/a_12282_n240# divbuf_1/OUT4 0.04fF
C5642 divbuf_1/a_17280_n1600# divbuf_1/a_17310_n1540# 0.19fF
C5643 divbuf_0/a_1950_n840# divbuf_0/a_2430_n840# 0.07fF
C5644 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n1540# 0.19fF
C5645 divbuf_0/a_20532_170# divbuf_0/OUT4 0.19fF
C5646 gnd pll_full_0/divider_0/tspc_0/Z3 0.27fF
C5647 gnd pd_div_0/divider_0/tspc_2/Z2 0.16fF
C5648 pd_div_0/divider_0/prescaler_0/tspc_0/D pd_div_0/divider_0/clk 0.26fF
C5649 pll_full_0/divbuf_0/a_56640_n1600# pll_full_0/divbuf_0/a_57120_n1600# 0.26fF
C5650 divbuf_1/a_14880_n1600# divbuf_1/a_14910_n840# 0.04fF
C5651 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16350_n840# 0.04fF
C5652 divbuf_0/a_54750_n1540# divbuf_0/a_55230_n1540# 0.11fF
C5653 pll_full_0/divbuf_0/a_48990_n1540# pll_full_0/divbuf_0/a_49470_n1540# 0.11fF
C5654 divbuf_3/a_5760_n1600# divbuf_3/a_5790_n840# 0.04fF
C5655 pd_div_0/divbuf_0/a_13920_n1600# pd_div_0/divbuf_0/a_14400_n1600# 0.26fF
C5656 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/a_4350_n840# 0.04fF
C5657 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/a_19680_n1600# 0.26fF
C5658 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/a_9630_n840# 0.03fF
C5659 divbuf_2/a_40902_170# divbuf_2/a_40902_n240# 0.01fF
C5660 divbuf_2/a_21012_n240# divbuf_2/a_21502_n240# 0.04fF
C5661 pd_div_0/divbuf_0/a_6270_n1540# pd_div_0/divbuf_0/a_6750_n1540# 0.11fF
C5662 pd_div_0/divbuf_0/a_36990_n840# pd_div_0/divbuf_0/a_36990_n1540# 0.01fF
C5663 pll_full_0/divbuf_1/a_11550_n1540# pll_full_0/divbuf_1/a_12030_n1540# 0.11fF
C5664 pll_full_0/divbuf_1/a_42270_n840# pll_full_0/divbuf_1/a_42270_n1540# 0.01fF
C5665 divbuf_2/a_2430_n840# divbuf_2/a_2430_n1540# 0.01fF
C5666 divbuf_2/a_32670_n840# divbuf_2/a_33150_n840# 0.07fF
C5667 divbuf_2/a_32640_n1600# divbuf_2/a_32670_n1540# 0.19fF
C5668 divbuf_2/a_2400_n1600# divbuf_2/OUT2 0.00fF
C5669 divbuf_1/a_11040_n1600# divbuf_1/OUT3 0.00fF
C5670 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/a_33622_170# 0.07fF
C5671 divbuf_3/a_1842_170# divbuf_3/a_1842_n240# 0.01fF
C5672 divbuf_3/a_22472_170# divbuf_3/a_22952_170# 0.07fF
C5673 divbuf_1/a_28292_170# divbuf_1/a_28772_170# 0.07fF
C5674 divbuf_0/a_52320_n1600# divbuf_0/a_52350_n840# 0.04fF
C5675 divbuf_0/a_21502_n240# divbuf_0/OUT4 0.04fF
C5676 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C5677 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_46590_n840# 0.04fF
C5678 divbuf_1/a_4350_n840# divbuf_1/a_4830_n840# 0.07fF
C5679 divbuf_1/a_4320_n1600# divbuf_1/a_4350_n1540# 0.19fF
C5680 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/UP 0.03fF
C5681 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_5790_n1540# 0.19fF
C5682 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5683 ro_div_0/divbuf_0/a_5790_n840# ro_div_0/divbuf_0/a_6270_n840# 0.07fF
C5684 divbuf_3/a_55680_n1600# divbuf_3/a_56160_n1600# 0.26fF
C5685 divbuf_3/a_6822_170# divbuf_3/OUT3 0.19fF
C5686 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_3870_n840# 0.04fF
C5687 ro_div_0/divbuf_0/a_58590_n1540# ro_div_0/divbuf_0/a_59070_n1540# 0.11fF
C5688 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9150_n840# 0.04fF
C5689 divbuf_3/a_48030_n1540# divbuf_3/a_48510_n1540# 0.11fF
C5690 divbuf_0/a_30232_n240# divbuf_0/a_30712_n240# 0.05fF
C5691 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/a_24892_n240# 0.05fF
C5692 divbuf_1/a_57120_n1600# divbuf_1/a_57150_n1540# 0.19fF
C5693 divbuf_1/a_26910_n840# divbuf_1/a_26910_n1540# 0.01fF
C5694 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n1540# 0.19fF
C5695 divbuf_0/a_41790_n840# divbuf_0/a_42270_n840# 0.07fF
C5696 divbuf_0/a_11550_n840# divbuf_0/a_11550_n1540# 0.01fF
C5697 divbuf_0/a_19680_n1600# divbuf_0/OUT4 0.00fF
C5698 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36030_n1540# 0.19fF
C5699 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C5700 pll_full_0/divbuf_0/a_5790_n840# pll_full_0/divbuf_0/a_5790_n1540# 0.01fF
C5701 pll_full_0/divbuf_0/a_36030_n840# pll_full_0/divbuf_0/a_36510_n840# 0.07fF
C5702 divbuf_1/a_54720_n1600# divbuf_1/a_54750_n840# 0.04fF
C5703 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/a_21012_170# 0.07fF
C5704 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5705 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56190_n840# 0.04fF
C5706 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/a_5852_n240# 0.01fF
C5707 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/a_26352_170# 0.07fF
C5708 divbuf_3/a_7792_n240# divbuf_3/OUT3 0.04fF
C5709 divbuf_3/a_45600_n1600# divbuf_3/a_45630_n840# 0.04fF
C5710 divbuf_1/a_48990_n1540# divbuf_1/a_49470_n1540# 0.11fF
C5711 pd_div_0/divbuf_0/a_53760_n1600# pd_div_0/divbuf_0/a_54240_n1600# 0.26fF
C5712 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/OUT3 0.19fF
C5713 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5714 pll_full_0/divbuf_1/a_59040_n1600# pll_full_0/divbuf_1/a_59520_n1600# 0.26fF
C5715 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C5716 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C5717 divbuf_2/a_19200_n1600# divbuf_2/a_19680_n1600# 0.26fF
C5718 divbuf_2/a_9732_n240# divbuf_2/a_9630_n840# 0.03fF
C5719 pd_div_0/divbuf_0/a_46110_n1540# pd_div_0/divbuf_0/a_46590_n1540# 0.11fF
C5720 divbuf_2/a_11550_n1540# divbuf_2/a_12030_n1540# 0.11fF
C5721 divbuf_2/a_42270_n840# divbuf_2/a_42270_n1540# 0.01fF
C5722 pll_full_0/divbuf_1/a_51390_n1540# pll_full_0/divbuf_1/a_51870_n1540# 0.11fF
C5723 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/a_34592_n240# 0.05fF
C5724 divbuf_1/a_32652_n240# divbuf_1/a_33142_n240# 0.04fF
C5725 divbuf_3/a_23442_n240# divbuf_3/a_23922_n240# 0.05fF
C5726 divbuf_1/a_13950_n840# divbuf_1/a_13950_n1540# 0.01fF
C5727 divbuf_1/a_44190_n840# divbuf_1/a_44670_n840# 0.07fF
C5728 ro_div_0/divbuf_0/a_45630_n840# ro_div_0/divbuf_0/a_46110_n840# 0.07fF
C5729 ro_div_0/divbuf_0/a_15390_n840# ro_div_0/divbuf_0/a_15390_n1540# 0.01fF
C5730 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_45630_n1540# 0.19fF
C5731 divbuf_3/a_35040_n1600# divbuf_3/a_35070_n1540# 0.19fF
C5732 divbuf_3/a_4830_n840# divbuf_3/a_4830_n1540# 0.01fF
C5733 divbuf_3/a_35070_n840# divbuf_3/a_35550_n840# 0.07fF
C5734 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C5735 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_43710_n840# 0.04fF
C5736 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/clk 0.12fF
C5737 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_0/Z2 0.23fF
C5738 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5739 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_48990_n840# 0.04fF
C5740 divbuf_2/a_9120_n1600# divbuf_2/a_9150_n840# 0.04fF
C5741 divbuf_1/a_7792_170# divbuf_1/OUT3 0.19fF
C5742 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C5743 divbuf_0/a_19072_n240# divbuf_0/a_19230_n840# 0.02fF
C5744 divbuf_0/a_28320_n1600# divbuf_0/a_28800_n1600# 0.26fF
C5745 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/a_23040_n1600# 0.26fF
C5746 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_13470_n840# 0.02fF
C5747 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/a_2430_n840# 0.03fF
C5748 divbuf_0/a_51390_n840# divbuf_0/a_51390_n1540# 0.01fF
C5749 divbuf_0/a_20670_n1540# divbuf_0/a_21150_n1540# 0.11fF
C5750 pll_full_0/divbuf_0/a_14910_n1540# pll_full_0/divbuf_0/a_15390_n1540# 0.11fF
C5751 pll_full_0/divbuf_0/a_45630_n840# pll_full_0/divbuf_0/a_45630_n1540# 0.01fF
C5752 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/a_41382_n240# 0.01fF
C5753 pd_div_0/divbuf_0/a_21502_n240# pd_div_0/divbuf_0/a_21982_n240# 0.05fF
C5754 pll_full_0/divbuf_1/a_26832_n240# pll_full_0/divbuf_1/a_27322_n240# 0.04fF
C5755 divbuf_2/a_5852_170# divbuf_2/a_5852_n240# 0.01fF
C5756 divbuf_2/a_25862_170# divbuf_2/a_26352_170# 0.07fF
C5757 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/a_2910_n1540# 0.01fF
C5758 pd_div_0/divbuf_0/a_33150_n840# pd_div_0/divbuf_0/a_33630_n840# 0.07fF
C5759 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33150_n1540# 0.19fF
C5760 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C5761 pll_full_0/divbuf_1/a_12960_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5762 pll_full_0/divbuf_1/a_8190_n840# pll_full_0/divbuf_1/a_8190_n1540# 0.01fF
C5763 pll_full_0/divbuf_1/a_38430_n840# pll_full_0/divbuf_1/a_38910_n840# 0.07fF
C5764 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38430_n1540# 0.19fF
C5765 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C5766 divbuf_2/a_13742_170# divbuf_2/OUT4 0.19fF
C5767 divbuf_2/a_59040_n1600# divbuf_2/a_59520_n1600# 0.26fF
C5768 divbuf_1/a_19562_170# divbuf_1/OUT4 0.19fF
C5769 divbuf_0/a_492_n240# divbuf_0/OUT2 0.42fF
C5770 divbuf_0/a_18240_n1600# divbuf_0/a_18270_n840# 0.04fF
C5771 gnd pll_full_0/divider_0/nor_1/B 1.17fF
C5772 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12510_n840# 0.04fF
C5773 divbuf_2/a_51390_n1540# divbuf_2/a_51870_n1540# 0.11fF
C5774 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C5775 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 0.22fF
C5776 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z4 0.02fF
C5777 divbuf_1/a_30720_n1600# divbuf_1/a_31200_n1600# 0.26fF
C5778 divbuf_1/a_21502_n240# divbuf_1/a_21630_n840# 0.03fF
C5779 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/a_23070_n840# 0.03fF
C5780 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/a_32640_n1600# 0.26fF
C5781 divbuf_3/a_21600_n1600# divbuf_3/a_22080_n1600# 0.26fF
C5782 divbuf_3/a_12282_n240# divbuf_3/a_12510_n840# 0.02fF
C5783 ro_div_0/divbuf_0/a_55230_n840# ro_div_0/divbuf_0/a_55230_n1540# 0.01fF
C5784 ro_div_0/divbuf_0/a_24510_n1540# ro_div_0/divbuf_0/a_24990_n1540# 0.11fF
C5785 divbuf_3/a_13950_n1540# divbuf_3/a_14430_n1540# 0.11fF
C5786 divbuf_3/a_44670_n840# divbuf_3/a_44670_n1540# 0.01fF
C5787 divbuf_0/a_35082_170# divbuf_0/a_35562_170# 0.07fF
C5788 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/a_29742_170# 0.07fF
C5789 divbuf_2/a_14702_n240# divbuf_2/OUT4 0.04fF
C5790 divbuf_2/a_48960_n1600# divbuf_2/a_48990_n840# 0.04fF
C5791 divbuf_1/a_23922_n240# divbuf_1/OUT4 0.04fF
C5792 divbuf_1/a_23040_n1600# divbuf_1/a_23070_n1540# 0.19fF
C5793 ro_div_0/ro_complete_0/cbank_2/switch_5/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C5794 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/a_20042_170# 0.07fF
C5795 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/a_3422_n240# 0.01fF
C5796 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n1540# 0.19fF
C5797 divbuf_0/a_32172_170# divbuf_0/OUT4 0.19fF
C5798 divbuf_0/a_7710_n840# divbuf_0/a_8190_n840# 0.07fF
C5799 divbuf_1/a_18092_170# divbuf_1/a_18092_n240# 0.01fF
C5800 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5801 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_1950_n1540# 0.19fF
C5802 pll_full_0/divbuf_0/a_1950_n840# pll_full_0/divbuf_0/a_2430_n840# 0.07fF
C5803 divbuf_1/a_20640_n1600# divbuf_1/a_20670_n840# 0.04fF
C5804 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22110_n840# 0.04fF
C5805 divbuf_0/a_60510_n1540# divbuf_0/a_60990_n1540# 0.11fF
C5806 pll_full_0/divbuf_0/a_54750_n1540# pll_full_0/divbuf_0/a_55230_n1540# 0.11fF
C5807 divbuf_3/a_11520_n1600# divbuf_3/a_11550_n840# 0.04fF
C5808 divbuf_1/a_14910_n1540# divbuf_1/a_15390_n1540# 0.11fF
C5809 pd_div_0/divbuf_0/a_19680_n1600# pd_div_0/divbuf_0/a_20160_n1600# 0.26fF
C5810 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/a_10110_n840# 0.03fF
C5811 pll_full_0/divbuf_1/a_24960_n1600# pll_full_0/divbuf_1/a_25440_n1600# 0.26fF
C5812 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_15870_n840# 0.02fF
C5813 divbuf_2/a_26832_n240# divbuf_2/a_27322_n240# 0.04fF
C5814 pd_div_0/divbuf_0/a_12030_n1540# pd_div_0/divbuf_0/a_12510_n1540# 0.11fF
C5815 pd_div_0/divbuf_0/a_42750_n840# pd_div_0/divbuf_0/a_42750_n1540# 0.01fF
C5816 pll_full_0/divbuf_1/a_17310_n1540# pll_full_0/divbuf_1/a_17790_n1540# 0.11fF
C5817 pll_full_0/divbuf_1/a_48030_n840# pll_full_0/divbuf_1/a_48030_n1540# 0.01fF
C5818 divbuf_2/a_12960_n1600# divbuf_2/OUT4 0.00fF
C5819 divbuf_2/a_8190_n840# divbuf_2/a_8190_n1540# 0.01fF
C5820 divbuf_2/a_38430_n840# divbuf_2/a_38910_n840# 0.07fF
C5821 divbuf_2/a_38400_n1600# divbuf_2/a_38430_n1540# 0.19fF
C5822 divbuf_1/a_22080_n1600# divbuf_1/OUT4 0.01fF
C5823 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/a_39442_170# 0.07fF
C5824 divbuf_0/a_58080_n1600# divbuf_0/a_58110_n840# 0.04fF
C5825 divbuf_0/a_33142_n240# divbuf_0/OUT4 0.04fF
C5826 divbuf_3/a_8272_170# divbuf_3/a_8272_n240# 0.01fF
C5827 divbuf_3/a_28292_170# divbuf_3/a_28772_170# 0.07fF
C5828 divbuf_1/a_37502_170# divbuf_1/a_37992_170# 0.07fF
C5829 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5830 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52350_n840# 0.04fF
C5831 divbuf_1/a_10110_n840# divbuf_1/a_10590_n840# 0.07fF
C5832 divbuf_1/a_10080_n1600# divbuf_1/a_10110_n1540# 0.19fF
C5833 ro_div_0/divbuf_0/a_11550_n840# ro_div_0/divbuf_0/a_12030_n840# 0.07fF
C5834 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_11550_n1540# 0.19fF
C5835 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/OUT4 0.19fF
C5836 divbuf_3/a_18582_170# divbuf_3/OUT4 0.19fF
C5837 divbuf_3/a_960_n1600# divbuf_3/a_990_n1540# 0.19fF
C5838 divbuf_3/a_990_n840# divbuf_3/a_1470_n840# 0.07fF
C5839 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_9630_n840# 0.04fF
C5840 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_14910_n840# 0.04fF
C5841 divbuf_3/a_53790_n1540# divbuf_3/a_54270_n1540# 0.11fF
C5842 pd_div_0/divbuf_0/a_60990_n840# pd_div_0/divbuf_0/OUT5 0.04fF
C5843 divbuf_0/a_36052_n240# divbuf_0/a_36532_n240# 0.05fF
C5844 pll_full_0/divbuf_0/a_30232_n240# pll_full_0/divbuf_0/a_30712_n240# 0.05fF
C5845 divbuf_1/a_32670_n840# divbuf_1/a_32670_n1540# 0.01fF
C5846 divbuf_1/a_510_n840# divbuf_1/OUT 0.07fF
C5847 divbuf_0/a_47550_n840# divbuf_0/a_48030_n840# 0.07fF
C5848 divbuf_0/a_17310_n840# divbuf_0/a_17310_n1540# 0.01fF
C5849 divbuf_0/a_31200_n1600# divbuf_0/OUT4 0.00fF
C5850 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n1540# 0.19fF
C5851 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C5852 pll_full_0/divbuf_0/a_11550_n840# pll_full_0/divbuf_0/a_11550_n1540# 0.01fF
C5853 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/a_42270_n840# 0.07fF
C5854 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_41790_n1540# 0.19fF
C5855 divbuf_1/a_60480_n1600# divbuf_1/a_60510_n840# 0.04fF
C5856 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/a_26832_170# 0.07fF
C5857 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5858 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/a_12282_n240# 0.01fF
C5859 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/a_32172_170# 0.07fF
C5860 divbuf_3/a_19562_n240# divbuf_3/OUT4 0.04fF
C5861 divbuf_3/a_51360_n1600# divbuf_3/a_51390_n840# 0.04fF
C5862 divbuf_1/a_54750_n1540# divbuf_1/a_55230_n1540# 0.11fF
C5863 pd_div_0/divbuf_0/a_12282_170# pd_div_0/divbuf_0/OUT4 0.19fF
C5864 pd_div_0/divbuf_0/a_59520_n1600# pd_div_0/divbuf_0/a_60000_n1600# 0.26fF
C5865 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/nor_0/B 0.06fF
C5866 pll_full_0/divbuf_1/a_4350_n840# pll_full_0/divbuf_1/a_4830_n840# 0.07fF
C5867 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/OUT4 0.19fF
C5868 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4350_n1540# 0.19fF
C5869 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C5870 divbuf_2/a_24960_n1600# divbuf_2/a_25440_n1600# 0.26fF
C5871 divbuf_2/a_15672_n240# divbuf_2/a_15870_n840# 0.02fF
C5872 pd_div_0/divbuf_0/a_51870_n1540# pd_div_0/divbuf_0/a_52350_n1540# 0.11fF
C5873 ashish_0/a_150_0# ashish_0/vop 4.44fF
C5874 ashish_0/a_150_n710# ashish_0/von 4.33fF
C5875 pll_full_0/divbuf_1/a_57150_n1540# pll_full_0/divbuf_1/a_57630_n1540# 0.11fF
C5876 divbuf_2/a_17310_n1540# divbuf_2/a_17790_n1540# 0.11fF
C5877 divbuf_2/a_48030_n840# divbuf_2/a_48030_n1540# 0.01fF
C5878 ro_div_0/divbuf_0/a_39932_n240# ro_div_0/divbuf_0/a_40412_n240# 0.05fF
C5879 divbuf_1/a_38472_n240# divbuf_1/a_38962_n240# 0.04fF
C5880 divbuf_0/a_10590_n840# divbuf_0/OUT4 0.03fF
C5881 divbuf_3/a_29262_n240# divbuf_3/a_29742_n240# 0.05fF
C5882 divbuf_1/a_49950_n840# divbuf_1/a_50430_n840# 0.07fF
C5883 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51390_n1540# 0.19fF
C5884 ro_div_0/divbuf_0/a_51390_n840# ro_div_0/divbuf_0/a_51870_n840# 0.07fF
C5885 ro_div_0/divbuf_0/a_21150_n840# ro_div_0/divbuf_0/a_21150_n1540# 0.01fF
C5886 divbuf_3/a_10590_n840# divbuf_3/a_10590_n1540# 0.01fF
C5887 divbuf_3/a_40830_n840# divbuf_3/a_41310_n840# 0.07fF
C5888 divbuf_3/a_40800_n1600# divbuf_3/a_40830_n1540# 0.19fF
C5889 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C5890 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49470_n840# 0.04fF
C5891 pll_full_0/divbuf_1/a_26352_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C5892 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_54750_n840# 0.04fF
C5893 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_7302_170# 0.07fF
C5894 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C5895 divbuf_2/a_14880_n1600# divbuf_2/a_14910_n840# 0.04fF
C5896 divbuf_0/a_34080_n1600# divbuf_0/a_34560_n1600# 0.26fF
C5897 divbuf_0/a_24892_n240# divbuf_0/a_24990_n840# 0.03fF
C5898 pll_full_0/divbuf_0/a_28320_n1600# pll_full_0/divbuf_0/a_28800_n1600# 0.26fF
C5899 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/a_19230_n840# 0.02fF
C5900 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C5901 divbuf_0/a_57150_n840# divbuf_0/a_57150_n1540# 0.01fF
C5902 divbuf_0/a_26430_n1540# divbuf_0/a_26910_n1540# 0.11fF
C5903 pll_full_0/divbuf_0/a_20670_n1540# pll_full_0/divbuf_0/a_21150_n1540# 0.11fF
C5904 pll_full_0/divbuf_0/a_51390_n840# pll_full_0/divbuf_0/a_51390_n1540# 0.01fF
C5905 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/a_27802_n240# 0.05fF
C5906 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/a_33142_n240# 0.04fF
C5907 divbuf_2/a_12282_170# divbuf_2/a_12282_n240# 0.01fF
C5908 divbuf_2/a_31682_170# divbuf_2/a_32172_170# 0.07fF
C5909 pd_div_0/divbuf_0/a_8670_n840# pd_div_0/divbuf_0/a_8670_n1540# 0.01fF
C5910 pd_div_0/divbuf_0/a_38910_n840# pd_div_0/divbuf_0/a_39390_n840# 0.07fF
C5911 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_38910_n1540# 0.19fF
C5912 pll_full_0/divbuf_1/a_13950_n840# pll_full_0/divbuf_1/a_13950_n1540# 0.01fF
C5913 pll_full_0/divbuf_1/a_44190_n840# pll_full_0/divbuf_1/a_44670_n840# 0.07fF
C5914 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44190_n1540# 0.19fF
C5915 pll_full_0/divbuf_1/a_24480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C5916 divbuf_2/a_4350_n840# divbuf_2/a_4830_n840# 0.07fF
C5917 divbuf_2/a_25382_170# divbuf_2/OUT4 0.19fF
C5918 divbuf_2/a_4320_n1600# divbuf_2/a_4350_n1540# 0.19fF
C5919 divbuf_1/a_34592_170# divbuf_1/OUT4 0.19fF
C5920 divbuf_1/a_14702_170# divbuf_1/a_15182_170# 0.07fF
C5921 pd_div_0/divider_0/tspc_1/Z3 gnd 0.27fF
C5922 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/clk 0.45fF
C5923 divbuf_0/a_24000_n1600# divbuf_0/a_24030_n840# 0.04fF
C5924 gnd pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.44fF
C5925 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18270_n840# 0.04fF
C5926 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/OUT3 0.19fF
C5927 divbuf_2/a_57150_n1540# divbuf_2/a_57630_n1540# 0.11fF
C5928 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C5929 divbuf_1/a_36480_n1600# divbuf_1/a_36960_n1600# 0.26fF
C5930 divbuf_1/a_27322_n240# divbuf_1/a_27390_n840# 0.04fF
C5931 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/a_28830_n840# 0.04fF
C5932 ro_div_0/divbuf_0/a_37920_n1600# ro_div_0/divbuf_0/a_38400_n1600# 0.26fF
C5933 divbuf_3/a_27360_n1600# divbuf_3/a_27840_n1600# 0.26fF
C5934 divbuf_3/a_18092_n240# divbuf_3/a_18270_n840# 0.02fF
C5935 ro_div_0/divbuf_0/a_60990_n840# ro_div_0/divbuf_0/a_60990_n1540# 0.01fF
C5936 ro_div_0/divbuf_0/a_30270_n1540# ro_div_0/divbuf_0/a_30750_n1540# 0.11fF
C5937 divbuf_3/a_19710_n1540# divbuf_3/a_20190_n1540# 0.11fF
C5938 divbuf_3/a_50430_n840# divbuf_3/a_50430_n1540# 0.01fF
C5939 divbuf_0/a_40902_170# divbuf_0/a_41382_170# 0.07fF
C5940 divbuf_0/a_21502_170# divbuf_0/a_21502_n240# 0.01fF
C5941 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/a_35562_170# 0.07fF
C5942 divbuf_2/a_26352_n240# divbuf_2/OUT4 0.04fF
C5943 divbuf_2/a_54720_n1600# divbuf_2/a_54750_n840# 0.04fF
C5944 divbuf_1/a_35562_n240# divbuf_1/OUT4 0.04fF
C5945 divbuf_1/a_28800_n1600# divbuf_1/a_28830_n1540# 0.19fF
C5946 divbuf_0/a_13470_n840# divbuf_0/a_13950_n840# 0.07fF
C5947 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n1540# 0.19fF
C5948 divbuf_0/a_4392_n240# divbuf_0/OUT3 0.04fF
C5949 pll_full_0/divbuf_0/a_7710_n840# pll_full_0/divbuf_0/a_8190_n840# 0.07fF
C5950 pll_full_0/divbuf_0/a_32172_170# pll_full_0/divbuf_0/OUT4 0.19fF
C5951 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_7710_n1540# 0.19fF
C5952 divbuf_1/a_26400_n1600# divbuf_1/a_26430_n840# 0.04fF
C5953 divbuf_1/a_20670_n1540# divbuf_1/a_21150_n1540# 0.11fF
C5954 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_27870_n840# 0.04fF
C5955 pll_full_0/divbuf_0/a_60510_n1540# pll_full_0/divbuf_0/a_60990_n1540# 0.11fF
C5956 divbuf_3/a_17280_n1600# divbuf_3/a_17310_n840# 0.04fF
C5957 pd_div_0/divbuf_0/a_25440_n1600# pd_div_0/divbuf_0/a_25920_n1600# 0.26fF
C5958 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_16350_n840# 0.02fF
C5959 pll_full_0/divbuf_1/a_30720_n1600# pll_full_0/divbuf_1/a_31200_n1600# 0.26fF
C5960 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/a_21630_n840# 0.03fF
C5961 divbuf_2/a_32652_n240# divbuf_2/a_33142_n240# 0.04fF
C5962 pd_div_0/divbuf_0/a_17790_n1540# pd_div_0/divbuf_0/a_18270_n1540# 0.11fF
C5963 pd_div_0/divbuf_0/a_48510_n840# pd_div_0/divbuf_0/a_48510_n1540# 0.01fF
C5964 pll_full_0/divbuf_1/a_23070_n1540# pll_full_0/divbuf_1/a_23550_n1540# 0.11fF
C5965 pll_full_0/divbuf_1/a_53790_n840# pll_full_0/divbuf_1/a_53790_n1540# 0.01fF
C5966 divbuf_2/a_13950_n840# divbuf_2/a_13950_n1540# 0.01fF
C5967 divbuf_2/a_44190_n840# divbuf_2/a_44670_n840# 0.07fF
C5968 divbuf_2/a_44160_n1600# divbuf_2/a_44190_n1540# 0.19fF
C5969 divbuf_2/a_24480_n1600# divbuf_2/OUT4 0.00fF
C5970 divbuf_1/a_33600_n1600# divbuf_1/OUT4 0.01fF
C5971 ro_div_0/divbuf_0/a_25382_170# ro_div_0/divbuf_0/a_25382_n240# 0.01fF
C5972 ro_div_0/divbuf_0/a_4882_n240# ro_div_0/divbuf_0/a_5362_n240# 0.05fF
C5973 divbuf_3/a_14702_170# divbuf_3/a_14702_n240# 0.01fF
C5974 divbuf_3/a_34112_170# divbuf_3/a_34592_170# 0.07fF
C5975 divbuf_1/a_3422_n240# divbuf_1/a_3912_n240# 0.04fF
C5976 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C5977 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58110_n840# 0.04fF
C5978 divbuf_1/a_15870_n840# divbuf_1/a_16350_n840# 0.07fF
C5979 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17310_n1540# 0.19fF
C5980 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C5981 ro_div_0/divbuf_0/a_17310_n840# ro_div_0/divbuf_0/a_17790_n840# 0.07fF
C5982 ro_div_0/divider_0/tspc_2/Z4 gnd 0.44fF
C5983 divbuf_3/a_6750_n840# divbuf_3/a_7230_n840# 0.07fF
C5984 divbuf_3/a_30232_170# divbuf_3/OUT4 0.19fF
C5985 divbuf_3/a_6720_n1600# divbuf_3/a_6750_n1540# 0.19fF
C5986 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15390_n840# 0.04fF
C5987 divbuf_0/a_19072_170# divbuf_0/a_19562_170# 0.07fF
C5988 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_20670_n840# 0.04fF
C5989 divbuf_3/a_59550_n1540# divbuf_3/a_60030_n1540# 0.11fF
C5990 divbuf_0/a_0_n1600# divbuf_0/a_480_n1600# 0.26fF
C5991 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/a_36532_n240# 0.05fF
C5992 divbuf_1/a_38430_n840# divbuf_1/a_38430_n1540# 0.01fF
C5993 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n1540# 0.19fF
C5994 divbuf_0/a_53310_n840# divbuf_0/a_53790_n840# 0.07fF
C5995 divbuf_0/a_23070_n840# divbuf_0/a_23070_n1540# 0.01fF
C5996 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_47550_n1540# 0.19fF
C5997 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C5998 pll_full_0/divbuf_0/a_17310_n840# pll_full_0/divbuf_0/a_17310_n1540# 0.01fF
C5999 pll_full_0/divbuf_0/a_47550_n840# pll_full_0/divbuf_0/a_48030_n840# 0.07fF
C6000 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/a_32652_170# 0.07fF
C6001 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C6002 pll_full_0/divbuf_1/a_18092_170# pll_full_0/divbuf_1/a_18092_n240# 0.01fF
C6003 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/a_37992_170# 0.07fF
C6004 divbuf_3/a_31202_n240# divbuf_3/OUT4 0.04fF
C6005 divbuf_3/a_57120_n1600# divbuf_3/a_57150_n840# 0.04fF
C6006 divbuf_1/a_60510_n1540# divbuf_1/a_60990_n1540# 0.11fF
C6007 pd_div_0/divbuf_0/a_4830_n840# pd_div_0/divbuf_0/a_5310_n840# 0.07fF
C6008 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6009 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_4830_n1540# 0.19fF
C6010 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/clk 0.01fF
C6011 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C6012 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_0/Z3 0.05fF
C6013 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/Z2 0.36fF
C6014 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/nor_0/B 0.47fF
C6015 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/and_0/B 0.18fF
C6016 pll_full_0/divbuf_1/a_10110_n840# pll_full_0/divbuf_1/a_10590_n840# 0.07fF
C6017 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6018 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10110_n1540# 0.19fF
C6019 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C6020 divbuf_2/a_30720_n1600# divbuf_2/a_31200_n1600# 0.26fF
C6021 divbuf_2/a_21502_n240# divbuf_2/a_21630_n840# 0.03fF
C6022 pd_div_0/divbuf_0/a_57630_n1540# pd_div_0/divbuf_0/a_58110_n1540# 0.11fF
C6023 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C6024 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C6025 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C6026 pd_0/DOWN pd_0/R 0.36fF
C6027 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 0.36fF
C6028 divbuf_2/a_23070_n1540# divbuf_2/a_23550_n1540# 0.11fF
C6029 divbuf_2/a_53790_n840# divbuf_2/a_53790_n1540# 0.01fF
C6030 ro_div_0/divbuf_0/a_3840_n1600# ro_div_0/divbuf_0/a_4320_n1600# 0.26fF
C6031 divbuf_3/a_35082_n240# divbuf_3/a_35562_n240# 0.05fF
C6032 divbuf_1/a_2400_n1600# divbuf_1/a_2880_n1600# 0.26fF
C6033 pll_full_0/divbuf_0/a_10590_n840# pll_full_0/divbuf_0/OUT4 0.03fF
C6034 divbuf_1/a_55710_n840# divbuf_1/a_56190_n840# 0.07fF
C6035 ro_div_0/divbuf_0/a_57150_n840# ro_div_0/divbuf_0/a_57630_n840# 0.07fF
C6036 ro_div_0/divbuf_0/a_26910_n840# ro_div_0/divbuf_0/a_26910_n1540# 0.01fF
C6037 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57150_n1540# 0.19fF
C6038 divbuf_3/a_46560_n1600# divbuf_3/a_46590_n1540# 0.19fF
C6039 divbuf_3/a_16350_n840# divbuf_3/a_16350_n1540# 0.01fF
C6040 divbuf_3/a_46590_n840# divbuf_3/a_47070_n840# 0.07fF
C6041 pd_div_0/divbuf_0/a_27322_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6042 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55230_n840# 0.04fF
C6043 divbuf_0/a_5362_170# divbuf_0/a_4882_170# 0.07fF
C6044 pll_full_0/divbuf_1/a_37992_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6045 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/a_60510_n840# 0.04fF
C6046 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/a_13742_170# 0.07fF
C6047 divbuf_2/a_20640_n1600# divbuf_2/a_20670_n840# 0.04fF
C6048 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C6049 divbuf_0/a_30712_n240# divbuf_0/a_30750_n840# 0.05fF
C6050 divbuf_0/a_39840_n1600# divbuf_0/a_40320_n1600# 0.26fF
C6051 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C6052 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C6053 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/a_24990_n840# 0.03fF
C6054 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/a_34560_n1600# 0.26fF
C6055 ro_div_0/divbuf_0/a_14702_n240# ro_div_0/divbuf_0/a_14430_n840# 0.01fF
C6056 divbuf_1/a_13252_n240# divbuf_1/a_12990_n840# 0.01fF
C6057 divbuf_0/a_32190_n1540# divbuf_0/a_32670_n1540# 0.11fF
C6058 pll_full_0/divbuf_0/a_26430_n1540# pll_full_0/divbuf_0/a_26910_n1540# 0.11fF
C6059 pll_full_0/divbuf_0/a_57150_n840# pll_full_0/divbuf_0/a_57150_n1540# 0.01fF
C6060 pd_div_0/divbuf_0/a_33142_n240# pd_div_0/divbuf_0/a_33622_n240# 0.05fF
C6061 pll_full_0/divbuf_1/a_38472_n240# pll_full_0/divbuf_1/a_38962_n240# 0.04fF
C6062 divbuf_2/a_18092_170# divbuf_2/a_18092_n240# 0.01fF
C6063 divbuf_2/a_37502_170# divbuf_2/a_37992_170# 0.07fF
C6064 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_44670_n1540# 0.19fF
C6065 pd_div_0/divbuf_0/a_14430_n840# pd_div_0/divbuf_0/a_14430_n1540# 0.01fF
C6066 pd_div_0/divbuf_0/a_44670_n840# pd_div_0/divbuf_0/a_45150_n840# 0.07fF
C6067 divbuf_0/a_4882_170# divbuf_0/a_4882_n240# 0.01fF
C6068 pll_full_0/divbuf_1/a_36000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6069 pll_full_0/divbuf_1/a_19710_n840# pll_full_0/divbuf_1/a_19710_n1540# 0.01fF
C6070 pll_full_0/divbuf_1/a_49950_n840# pll_full_0/divbuf_1/a_50430_n840# 0.07fF
C6071 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_49950_n1540# 0.19fF
C6072 divbuf_2/a_10110_n840# divbuf_2/a_10590_n840# 0.07fF
C6073 divbuf_2/a_37022_170# divbuf_2/OUT4 0.19fF
C6074 divbuf_2/a_10080_n1600# divbuf_2/a_10110_n1540# 0.19fF
C6075 divbuf_1/a_6822_n240# divbuf_1/OUT3 0.04fF
C6076 pd_div_0/divider_0/prescaler_0/tspc_0/Q gnd 0.35fF
C6077 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/a_12282_170# 0.07fF
C6078 divbuf_0/a_7302_170# divbuf_0/OUT3 0.19fF
C6079 divbuf_0/a_29760_n1600# divbuf_0/a_29790_n840# 0.04fF
C6080 gnd pll_full_0/divider_0/tspc_2/Z2 0.16fF
C6081 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24030_n840# 0.04fF
C6082 divbuf_2/OUT2 divbuf_2/OUT3 0.36fF
C6083 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C6084 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divbuf_0/IN 0.05fF
C6085 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/a_34590_n840# 0.06fF
C6086 ro_div_0/divbuf_0/a_43680_n1600# ro_div_0/divbuf_0/a_44160_n1600# 0.26fF
C6087 divbuf_1/a_42240_n1600# divbuf_1/a_42720_n1600# 0.26fF
C6088 divbuf_1/a_33142_n240# divbuf_1/a_33150_n840# 0.06fF
C6089 divbuf_3/a_33120_n1600# divbuf_3/a_33600_n1600# 0.26fF
C6090 divbuf_3/a_23922_n240# divbuf_3/a_24030_n840# 0.03fF
C6091 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/a_1470_n840# 0.03fF
C6092 ro_div_0/divbuf_0/a_36030_n1540# ro_div_0/divbuf_0/a_36510_n1540# 0.11fF
C6093 divbuf_3/a_25470_n1540# divbuf_3/a_25950_n1540# 0.11fF
C6094 divbuf_3/a_56190_n840# divbuf_3/a_56190_n1540# 0.01fF
C6095 divbuf_0/a_27322_170# divbuf_0/a_27322_n240# 0.01fF
C6096 divbuf_0/a_6822_n240# divbuf_0/a_7302_n240# 0.05fF
C6097 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/a_21502_n240# 0.01fF
C6098 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/a_41382_170# 0.07fF
C6099 divbuf_2/a_37992_n240# divbuf_2/OUT4 0.04fF
C6100 divbuf_2/a_60480_n1600# divbuf_2/a_60510_n840# 0.04fF
C6101 divbuf_1/a_34560_n1600# divbuf_1/a_34590_n1540# 0.19fF
C6102 ro_div_0/divbuf_0/a_11802_170# ro_div_0/divbuf_0/a_11802_n240# 0.01fF
C6103 ro_div_0/divbuf_0/a_1842_170# ro_div_0/divbuf_0/a_1842_n240# 0.01fF
C6104 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n1540# 0.19fF
C6105 divbuf_0/a_16152_n240# divbuf_0/OUT4 0.04fF
C6106 divbuf_0/a_19230_n840# divbuf_0/a_19710_n840# 0.07fF
C6107 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C6108 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13470_n1540# 0.19fF
C6109 pll_full_0/divbuf_0/a_13470_n840# pll_full_0/divbuf_0/a_13950_n840# 0.07fF
C6110 divbuf_1/a_32160_n1600# divbuf_1/a_32190_n840# 0.04fF
C6111 divbuf_1/a_26430_n1540# divbuf_1/a_26910_n1540# 0.11fF
C6112 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/a_1352_170# 0.07fF
C6113 pd_div_0/pd_0/R pd_div_0/pd_0/REF 0.61fF
C6114 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6115 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_33630_n840# 0.04fF
C6116 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/a_2322_170# 0.07fF
C6117 divbuf_3/a_1352_170# divbuf_3/OUT2 0.23fF
C6118 divbuf_3/a_23040_n1600# divbuf_3/a_23070_n840# 0.04fF
C6119 pd_div_0/divbuf_0/a_31200_n1600# pd_div_0/divbuf_0/a_31680_n1600# 0.26fF
C6120 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/a_22110_n840# 0.03fF
C6121 pll_full_0/divbuf_1/a_36480_n1600# pll_full_0/divbuf_1/a_36960_n1600# 0.26fF
C6122 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/a_27390_n840# 0.04fF
C6123 divbuf_2/a_38472_n240# divbuf_2/a_38962_n240# 0.04fF
C6124 pd_div_0/divbuf_0/a_23550_n1540# pd_div_0/divbuf_0/a_24030_n1540# 0.11fF
C6125 pd_div_0/divbuf_0/a_54270_n840# pd_div_0/divbuf_0/a_54270_n1540# 0.01fF
C6126 pll_full_0/divbuf_1/a_28830_n1540# pll_full_0/divbuf_1/a_29310_n1540# 0.11fF
C6127 pll_full_0/divbuf_1/a_59550_n840# pll_full_0/divbuf_1/a_59550_n1540# 0.01fF
C6128 divbuf_2/a_36000_n1600# divbuf_2/OUT4 0.00fF
C6129 divbuf_2/a_19710_n840# divbuf_2/a_19710_n1540# 0.01fF
C6130 divbuf_2/a_49950_n840# divbuf_2/a_50430_n840# 0.07fF
C6131 divbuf_2/a_49920_n1600# divbuf_2/a_49950_n1540# 0.19fF
C6132 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/a_31202_n240# 0.01fF
C6133 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11802_n240# 0.04fF
C6134 divbuf_3/a_20532_170# divbuf_3/a_20532_n240# 0.01fF
C6135 divbuf_3/a_39932_170# divbuf_3/a_40412_170# 0.07fF
C6136 divbuf_1/a_9242_n240# divbuf_1/a_9732_n240# 0.04fF
C6137 divbuf_1/a_21630_n840# divbuf_1/a_22110_n840# 0.07fF
C6138 ro_div_0/divbuf_0/a_23070_n840# ro_div_0/divbuf_0/a_23550_n840# 0.07fF
C6139 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23070_n1540# 0.19fF
C6140 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6141 divbuf_3/a_2322_n240# divbuf_3/OUT2 0.04fF
C6142 divbuf_3/a_12480_n1600# divbuf_3/a_12510_n1540# 0.19fF
C6143 divbuf_3/a_41382_170# divbuf_3/OUT5 0.07fF
C6144 divbuf_3/a_12510_n840# divbuf_3/a_12990_n840# 0.07fF
C6145 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21150_n840# 0.04fF
C6146 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/OUT3 0.19fF
C6147 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C6148 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C6149 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/nor_1/B 0.22fF
C6150 io_clamp_low[0] io_analog[4] 0.53fF
C6151 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/OUT3 0.19fF
C6152 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26430_n840# 0.04fF
C6153 divbuf_0/a_5760_n1600# divbuf_0/a_6240_n1600# 0.26fF
C6154 pll_full_0/divbuf_0/a_0_n1600# pll_full_0/divbuf_0/a_480_n1600# 0.26fF
C6155 divbuf_1/a_44190_n840# divbuf_1/a_44190_n1540# 0.01fF
C6156 divbuf_0/a_59070_n840# divbuf_0/a_59550_n840# 0.07fF
C6157 divbuf_0/a_28830_n840# divbuf_0/a_28830_n1540# 0.01fF
C6158 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n1540# 0.19fF
C6159 pll_full_0/divbuf_0/a_23070_n840# pll_full_0/divbuf_0/a_23070_n1540# 0.01fF
C6160 pll_full_0/divbuf_0/a_53310_n840# pll_full_0/divbuf_0/a_53790_n840# 0.07fF
C6161 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53310_n1540# 0.19fF
C6162 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/a_18582_n240# 0.01fF
C6163 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/a_38472_170# 0.07fF
C6164 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C6165 pll_full_0/divbuf_1/a_3422_n240# pll_full_0/divbuf_1/a_3912_n240# 0.04fF
C6166 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/a_23922_n240# 0.01fF
C6167 divbuf_3/a_0_n1600# divbuf_3/OUT 0.26fF
C6168 divbuf_3/a_1920_n1600# divbuf_3/OUT2 0.00fF
C6169 divbuf_2/a_1842_170# divbuf_2/a_2322_170# 0.07fF
C6170 divbuf_1/a_17612_170# divbuf_1/OUT4 0.19fF
C6171 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/a_11070_n840# 0.07fF
C6172 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6173 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_10590_n1540# 0.19fF
C6174 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C6175 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C6176 pll_full_0/divbuf_1/a_15870_n840# pll_full_0/divbuf_1/a_16350_n840# 0.07fF
C6177 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C6178 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_15870_n1540# 0.19fF
C6179 divbuf_2/a_36480_n1600# divbuf_2/a_36960_n1600# 0.26fF
C6180 divbuf_2/a_27322_n240# divbuf_2/a_27390_n840# 0.04fF
C6181 pd_div_0/divbuf_0/OUT3 pd_div_0/divbuf_0/OUT4 0.36fF
C6182 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C6183 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C6184 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C6185 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C6186 divbuf_0/a_16642_n240# divbuf_0/a_16350_n840# 0.00fF
C6187 divbuf_2/a_28830_n1540# divbuf_2/a_29310_n1540# 0.11fF
C6188 divbuf_2/a_59550_n840# divbuf_2/a_59550_n1540# 0.01fF
C6189 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/a_10080_n1600# 0.26fF
C6190 divbuf_3/a_40902_n240# divbuf_3/a_41382_n240# 0.05fF
C6191 divbuf_1/a_8160_n1600# divbuf_1/a_8640_n1600# 0.26fF
C6192 divbuf_1/a_510_n1540# divbuf_1/a_990_n1540# 0.11fF
C6193 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/OUT 0.07fF
C6194 ro_div_0/divbuf_0/a_32670_n840# ro_div_0/divbuf_0/a_32670_n1540# 0.01fF
C6195 ro_div_0/divbuf_0/a_1950_n1540# ro_div_0/divbuf_0/a_2430_n1540# 0.11fF
C6196 divbuf_3/a_22110_n840# divbuf_3/a_22110_n1540# 0.01fF
C6197 divbuf_3/a_52350_n840# divbuf_3/a_52830_n840# 0.07fF
C6198 divbuf_3/a_52320_n1600# divbuf_3/a_52350_n1540# 0.19fF
C6199 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6200 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C6201 divbuf_2/a_8272_170# divbuf_2/OUT3 0.19fF
C6202 divbuf_2/a_26400_n1600# divbuf_2/a_26430_n840# 0.04fF
C6203 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Z4 0.12fF
C6204 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C6205 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C6206 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/a_4392_170# 0.07fF
C6207 divbuf_0/a_45600_n1600# divbuf_0/a_46080_n1600# 0.26fF
C6208 divbuf_0/a_36532_n240# divbuf_0/a_36510_n840# 0.05fF
C6209 gnd pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# 0.22fF
C6210 pll_full_0/divbuf_0/a_39840_n1600# pll_full_0/divbuf_0/a_40320_n1600# 0.26fF
C6211 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/a_30750_n840# 0.05fF
C6212 divbuf_0/a_37950_n1540# divbuf_0/a_38430_n1540# 0.11fF
C6213 pll_full_0/divbuf_0/a_32190_n1540# pll_full_0/divbuf_0/a_32670_n1540# 0.11fF
C6214 pd_div_0/divbuf_0/a_38962_n240# pd_div_0/divbuf_0/a_39442_n240# 0.05fF
C6215 pll_full_0/divbuf_1/a_2400_n1600# pll_full_0/divbuf_1/a_2880_n1600# 0.26fF
C6216 divbuf_2/a_3422_n240# divbuf_2/a_3912_n240# 0.04fF
C6217 divbuf_2/a_23922_170# divbuf_2/a_23922_n240# 0.01fF
C6218 pd_div_0/divbuf_0/a_20190_n840# pd_div_0/divbuf_0/a_20190_n1540# 0.01fF
C6219 pd_div_0/divbuf_0/a_50430_n840# pd_div_0/divbuf_0/a_50910_n840# 0.07fF
C6220 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50430_n1540# 0.19fF
C6221 divbuf_0/a_12772_170# divbuf_0/a_12772_n240# 0.01fF
C6222 pll_full_0/divbuf_1/a_25470_n840# pll_full_0/divbuf_1/a_25470_n1540# 0.01fF
C6223 pll_full_0/divbuf_1/a_55710_n840# pll_full_0/divbuf_1/a_56190_n840# 0.07fF
C6224 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_55710_n1540# 0.19fF
C6225 divbuf_2/a_15870_n840# divbuf_2/a_16350_n840# 0.07fF
C6226 divbuf_2/a_9242_n240# divbuf_2/OUT3 0.04fF
C6227 divbuf_2/a_15840_n1600# divbuf_2/a_15870_n1540# 0.19fF
C6228 divbuf_1/a_18582_n240# divbuf_1/OUT4 0.04fF
C6229 gnd pd_div_0/divider_0/and_0/A 0.69fF
C6230 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/a_18092_170# 0.07fF
C6231 divbuf_0/a_35520_n1600# divbuf_0/a_35550_n840# 0.04fF
C6232 divbuf_0/a_26832_170# divbuf_0/OUT4 0.19fF
C6233 pll_full_0/divbuf_0/a_16642_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6234 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_29790_n840# 0.04fF
C6235 divbuf_3/a_4882_170# divbuf_3/a_5362_170# 0.07fF
C6236 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C6237 ro_div_0/divbuf_0/a_3422_170# ro_div_0/divbuf_0/OUT3 0.23fF
C6238 ro_div_0/divbuf_0/a_49440_n1600# ro_div_0/divbuf_0/a_49920_n1600# 0.26fF
C6239 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/a_40350_n840# 0.04fF
C6240 divbuf_1/a_38962_n240# divbuf_1/a_38910_n840# 0.04fF
C6241 divbuf_1/a_48000_n1600# divbuf_1/a_48480_n1600# 0.26fF
C6242 divbuf_3/a_38880_n1600# divbuf_3/a_39360_n1600# 0.26fF
C6243 divbuf_3/a_29742_n240# divbuf_3/a_29790_n840# 0.04fF
C6244 ro_div_0/divbuf_0/a_41790_n1540# ro_div_0/divbuf_0/a_42270_n1540# 0.11fF
C6245 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/a_12990_n840# 0.01fF
C6246 divbuf_3/a_31230_n1540# divbuf_3/a_31710_n1540# 0.11fF
C6247 divbuf_0/a_33142_170# divbuf_0/a_33142_n240# 0.01fF
C6248 divbuf_0/a_13252_n240# divbuf_0/a_13742_n240# 0.04fF
C6249 pll_full_0/divbuf_0/a_6822_n240# pll_full_0/divbuf_0/a_7302_n240# 0.05fF
C6250 pll_full_0/divbuf_0/a_27322_170# pll_full_0/divbuf_0/a_27322_n240# 0.01fF
C6251 divbuf_1/a_40320_n1600# divbuf_1/a_40350_n1540# 0.19fF
C6252 divbuf_1/a_14222_170# divbuf_1/a_14222_n240# 0.01fF
C6253 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/a_17612_n240# 0.01fF
C6254 divbuf_0/a_24990_n840# divbuf_0/a_25470_n840# 0.07fF
C6255 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n1540# 0.19fF
C6256 divbuf_0/a_27802_n240# divbuf_0/OUT4 0.04fF
C6257 pll_full_0/divbuf_0/a_19230_n840# pll_full_0/divbuf_0/a_19710_n840# 0.07fF
C6258 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6259 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19230_n1540# 0.19fF
C6260 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39390_n840# 0.04fF
C6261 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6262 divbuf_1/a_37920_n1600# divbuf_1/a_37950_n840# 0.04fF
C6263 divbuf_1/a_32190_n1540# divbuf_1/a_32670_n1540# 0.11fF
C6264 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_4882_170# 0.07fF
C6265 ro_div_0/divider_0/tspc_0/a_630_n680# gnd 0.62fF
C6266 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/a_8762_170# 0.07fF
C6267 divbuf_3/a_13252_170# divbuf_3/OUT4 0.19fF
C6268 divbuf_3/a_28800_n1600# divbuf_3/a_28830_n840# 0.04fF
C6269 pd_div_0/divbuf_0/a_36960_n1600# pd_div_0/divbuf_0/a_37440_n1600# 0.26fF
C6270 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/a_27870_n840# 0.04fF
C6271 pll_full_0/divbuf_1/a_42240_n1600# pll_full_0/divbuf_1/a_42720_n1600# 0.26fF
C6272 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/a_33150_n840# 0.06fF
C6273 divbuf_2/a_2400_n1600# divbuf_2/a_2880_n1600# 0.26fF
C6274 pd_div_0/divbuf_0/a_29310_n1540# pd_div_0/divbuf_0/a_29790_n1540# 0.11fF
C6275 pd_div_0/divbuf_0/a_60030_n840# pd_div_0/divbuf_0/a_60030_n1540# 0.01fF
C6276 pll_full_0/divbuf_1/a_34590_n1540# pll_full_0/divbuf_1/a_35070_n1540# 0.11fF
C6277 divbuf_2/a_25470_n840# divbuf_2/a_25470_n1540# 0.01fF
C6278 divbuf_2/a_55710_n840# divbuf_2/a_56190_n840# 0.07fF
C6279 divbuf_2/a_55680_n1600# divbuf_2/a_55710_n1540# 0.19fF
C6280 ro_div_0/divbuf_0/a_37022_170# ro_div_0/divbuf_0/a_37022_n240# 0.01fF
C6281 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_17612_n240# 0.04fF
C6282 divbuf_3/a_5852_n240# divbuf_3/a_6332_n240# 0.05fF
C6283 divbuf_3/a_26352_170# divbuf_3/a_26352_n240# 0.01fF
C6284 divbuf_1/a_15672_n240# divbuf_1/a_16152_n240# 0.05fF
C6285 divbuf_1/a_35562_170# divbuf_1/a_35562_n240# 0.01fF
C6286 divbuf_1/a_27390_n840# divbuf_1/a_27870_n840# 0.07fF
C6287 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_4392_n240# 0.01fF
C6288 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_28830_n1540# 0.19fF
C6289 ro_div_0/divbuf_0/a_28830_n840# ro_div_0/divbuf_0/a_29310_n840# 0.07fF
C6290 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6291 divbuf_3/a_18270_n840# divbuf_3/a_18750_n840# 0.07fF
C6292 divbuf_3/a_14222_n240# divbuf_3/OUT4 0.04fF
C6293 divbuf_3/a_18240_n1600# divbuf_3/a_18270_n1540# 0.19fF
C6294 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_26910_n840# 0.04fF
C6295 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/OUT3 0.19fF
C6296 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C6297 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/nor_1/A 0.21fF
C6298 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C6299 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6300 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32190_n840# 0.04fF
C6301 divbuf_2/a_13252_n240# divbuf_2/a_12990_n840# 0.01fF
C6302 divbuf_0/a_11520_n1600# divbuf_0/a_12000_n1600# 0.26fF
C6303 pll_full_0/divbuf_0/a_5760_n1600# pll_full_0/divbuf_0/a_6240_n1600# 0.26fF
C6304 divbuf_1/a_49950_n840# divbuf_1/a_49950_n1540# 0.01fF
C6305 divbuf_0/a_34590_n840# divbuf_0/a_34590_n1540# 0.01fF
C6306 divbuf_0/a_3870_n1540# divbuf_0/a_4350_n1540# 0.11fF
C6307 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59070_n1540# 0.19fF
C6308 pll_full_0/divbuf_0/a_28830_n840# pll_full_0/divbuf_0/a_28830_n1540# 0.01fF
C6309 pll_full_0/divbuf_0/a_59070_n840# pll_full_0/divbuf_0/a_59550_n840# 0.07fF
C6310 pd_div_0/divbuf_0/a_3912_n240# pd_div_0/divbuf_0/a_4392_n240# 0.05fF
C6311 pd_div_0/divbuf_0/a_24412_170# pd_div_0/divbuf_0/a_24412_n240# 0.01fF
C6312 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C6313 pll_full_0/divbuf_1/a_9242_n240# pll_full_0/divbuf_1/a_9732_n240# 0.04fF
C6314 pll_full_0/divbuf_1/a_29742_170# pll_full_0/divbuf_1/a_29742_n240# 0.01fF
C6315 divbuf_3/a_12480_n1600# divbuf_3/OUT4 0.00fF
C6316 divbuf_2/a_8272_170# divbuf_2/a_8762_170# 0.07fF
C6317 pd_div_0/divbuf_0/a_16350_n840# pd_div_0/divbuf_0/a_16830_n840# 0.07fF
C6318 pd_div_0/divbuf_0/a_10212_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C6319 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16350_n1540# 0.19fF
C6320 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/clk 0.05fF
C6321 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z2 0.40fF
C6322 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divbuf_0/IN 0.04fF
C6323 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/Z1 0.04fF
C6324 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C6325 pll_full_0/divbuf_1/a_21630_n840# pll_full_0/divbuf_1/a_22110_n840# 0.07fF
C6326 pll_full_0/divbuf_1/a_21012_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6327 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_21630_n1540# 0.19fF
C6328 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C6329 divbuf_2/a_42240_n1600# divbuf_2/a_42720_n1600# 0.26fF
C6330 divbuf_2/a_33142_n240# divbuf_2/a_33150_n840# 0.06fF
C6331 divbuf_1/a_31682_170# divbuf_1/a_32172_170# 0.07fF
C6332 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/a_8762_170# 0.07fF
C6333 divbuf_0/a_1440_n1600# divbuf_0/a_1470_n840# 0.04fF
C6334 pll_full_0/divbuf_0/a_16642_n240# pll_full_0/divbuf_0/a_16350_n840# 0.00fF
C6335 divbuf_2/a_34590_n1540# divbuf_2/a_35070_n1540# 0.11fF
C6336 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/a_5790_n840# 0.04fF
C6337 ro_div_0/divbuf_0/a_15360_n1600# ro_div_0/divbuf_0/a_15840_n1600# 0.26fF
C6338 divbuf_3/a_4800_n1600# divbuf_3/a_5280_n1600# 0.26fF
C6339 divbuf_1/a_13920_n1600# divbuf_1/a_14400_n1600# 0.26fF
C6340 divbuf_1/a_4392_n240# divbuf_1/a_4350_n840# 0.04fF
C6341 divbuf_1/a_6270_n1540# divbuf_1/a_6750_n1540# 0.11fF
C6342 ro_div_0/divbuf_0/a_38430_n840# ro_div_0/divbuf_0/a_38430_n1540# 0.01fF
C6343 ro_div_0/divbuf_0/a_7710_n1540# ro_div_0/divbuf_0/a_8190_n1540# 0.11fF
C6344 divbuf_3/a_58080_n1600# divbuf_3/a_58110_n1540# 0.19fF
C6345 divbuf_3/a_27870_n840# divbuf_3/a_27870_n1540# 0.01fF
C6346 divbuf_3/a_58110_n840# divbuf_3/a_58590_n840# 0.07fF
C6347 divbuf_1/a_25862_170# divbuf_1/OUT4 0.19fF
C6348 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C6349 divbuf_0/a_15672_170# divbuf_0/a_16152_170# 0.07fF
C6350 pll_full_0/divbuf_1/a_19200_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C6351 divbuf_2/a_20042_170# divbuf_2/OUT4 0.19fF
C6352 divbuf_2/a_32160_n1600# divbuf_2/a_32190_n840# 0.04fF
C6353 divbuf_1/a_5362_170# divbuf_1/a_4882_170# 0.07fF
C6354 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C6355 pd_div_0/divider_0/prescaler_0/m1_2700_2190# gnd 0.22fF
C6356 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C6357 divbuf_0/a_51360_n1600# divbuf_0/a_51840_n1600# 0.26fF
C6358 gnd pll_full_0/divider_0/tspc_1/Z3 0.27fF
C6359 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C6360 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/Out 0.19fF
C6361 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/a_36510_n840# 0.05fF
C6362 pll_full_0/divbuf_0/a_45600_n1600# pll_full_0/divbuf_0/a_46080_n1600# 0.26fF
C6363 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5310_n840# 0.04fF
C6364 divbuf_3/a_15672_n240# divbuf_3/a_15390_n840# 0.01fF
C6365 divbuf_1/a_3840_n1600# divbuf_1/a_3870_n840# 0.04fF
C6366 divbuf_0/a_43710_n1540# divbuf_0/a_44190_n1540# 0.11fF
C6367 pll_full_0/divbuf_0/a_37950_n1540# pll_full_0/divbuf_0/a_38430_n1540# 0.11fF
C6368 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/a_3360_n1600# 0.26fF
C6369 pll_full_0/divbuf_1/a_8160_n1600# pll_full_0/divbuf_1/a_8640_n1600# 0.26fF
C6370 divbuf_2/a_9242_n240# divbuf_2/a_9732_n240# 0.04fF
C6371 divbuf_2/a_29742_170# divbuf_2/a_29742_n240# 0.01fF
C6372 divbuf_1/a_30232_n240# divbuf_1/OUT4 0.04fF
C6373 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56190_n1540# 0.19fF
C6374 pd_div_0/divbuf_0/a_25950_n840# pd_div_0/divbuf_0/a_25950_n1540# 0.01fF
C6375 pd_div_0/divbuf_0/a_56190_n840# pd_div_0/divbuf_0/a_56670_n840# 0.07fF
C6376 pll_full_0/divbuf_1/a_510_n1540# pll_full_0/divbuf_1/a_990_n1540# 0.11fF
C6377 pll_full_0/divbuf_1/a_31230_n840# pll_full_0/divbuf_1/a_31230_n1540# 0.01fF
C6378 divbuf_2/a_21630_n840# divbuf_2/a_22110_n840# 0.07fF
C6379 divbuf_2/a_21012_n240# divbuf_2/OUT4 0.04fF
C6380 divbuf_2/a_21600_n1600# divbuf_2/a_21630_n1540# 0.19fF
C6381 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/a_22472_170# 0.07fF
C6382 divbuf_0/a_41280_n1600# divbuf_0/a_41310_n840# 0.04fF
C6383 divbuf_0/a_38472_170# divbuf_0/OUT4 0.19fF
C6384 pll_full_0/divbuf_0/a_26832_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6385 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_35550_n840# 0.04fF
C6386 divbuf_3/a_11312_170# divbuf_3/a_11802_170# 0.07fF
C6387 ro_div_0/divbuf_0/a_55200_n1600# ro_div_0/divbuf_0/a_55680_n1600# 0.26fF
C6388 divbuf_3/a_44640_n1600# divbuf_3/a_45120_n1600# 0.26fF
C6389 divbuf_3/a_35562_n240# divbuf_3/a_35550_n840# 0.05fF
C6390 divbuf_1/a_53760_n1600# divbuf_1/a_54240_n1600# 0.26fF
C6391 pd_div_0/divbuf_0/a_13742_n240# pd_div_0/divbuf_0/a_13470_n840# 0.01fF
C6392 ro_div_0/divbuf_0/a_47550_n1540# ro_div_0/divbuf_0/a_48030_n1540# 0.11fF
C6393 divbuf_3/a_36990_n1540# divbuf_3/a_37470_n1540# 0.11fF
C6394 divbuf_0/a_19072_n240# divbuf_0/a_19562_n240# 0.04fF
C6395 divbuf_0/a_38962_170# divbuf_0/a_38962_n240# 0.01fF
C6396 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_13742_n240# 0.04fF
C6397 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/a_33142_n240# 0.01fF
C6398 divbuf_2/a_19200_n1600# divbuf_2/OUT4 0.00fF
C6399 divbuf_1/a_46080_n1600# divbuf_1/a_46110_n1540# 0.19fF
C6400 divbuf_1/a_15870_n840# divbuf_1/a_15870_n1540# 0.01fF
C6401 divbuf_1/a_19562_170# divbuf_1/a_19562_n240# 0.01fF
C6402 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_480_n1600# 0.00fF
C6403 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n1540# 0.19fF
C6404 divbuf_0/a_510_n840# divbuf_0/a_510_n1540# 0.01fF
C6405 divbuf_0/a_30750_n840# divbuf_0/a_31230_n840# 0.07fF
C6406 divbuf_0/a_39442_n240# divbuf_0/OUT4 0.04fF
C6407 pll_full_0/divbuf_0/a_27802_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6408 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_24990_n1540# 0.19fF
C6409 pll_full_0/divbuf_0/a_24990_n840# pll_full_0/divbuf_0/a_25470_n840# 0.07fF
C6410 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45150_n840# 0.04fF
C6411 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C6412 divbuf_1/a_43680_n1600# divbuf_1/a_43710_n840# 0.04fF
C6413 divbuf_1/a_37950_n1540# divbuf_1/a_38430_n1540# 0.11fF
C6414 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/a_15182_170# 0.07fF
C6415 divbuf_3/a_24892_170# divbuf_3/OUT4 0.19fF
C6416 divbuf_3/a_34560_n1600# divbuf_3/a_34590_n840# 0.04fF
C6417 pd_div_0/divbuf_0/a_42720_n1600# pd_div_0/divbuf_0/a_43200_n1600# 0.26fF
C6418 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/a_33630_n840# 0.06fF
C6419 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/a_38910_n840# 0.04fF
C6420 pll_full_0/divbuf_1/a_48000_n1600# pll_full_0/divbuf_1/a_48480_n1600# 0.26fF
C6421 divbuf_2/a_8160_n1600# divbuf_2/a_8640_n1600# 0.26fF
C6422 pd_div_0/divbuf_0/a_35070_n1540# pd_div_0/divbuf_0/a_35550_n1540# 0.11fF
C6423 pll_full_0/divbuf_1/a_40350_n1540# pll_full_0/divbuf_1/a_40830_n1540# 0.11fF
C6424 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_510_n840# 0.00fF
C6425 divbuf_2/a_510_n1540# divbuf_2/a_990_n1540# 0.11fF
C6426 divbuf_2/a_31230_n840# divbuf_2/a_31230_n1540# 0.01fF
C6427 divbuf_1/a_41382_170# divbuf_1/a_41382_n240# 0.01fF
C6428 divbuf_1/a_21502_n240# divbuf_1/a_21982_n240# 0.05fF
C6429 ro_div_0/divbuf_0/a_22952_n240# ro_div_0/divbuf_0/a_23442_n240# 0.04fF
C6430 divbuf_3/a_12282_n240# divbuf_3/a_12772_n240# 0.04fF
C6431 divbuf_3/a_32172_170# divbuf_3/a_32172_n240# 0.01fF
C6432 ro_div_0/divbuf_0/a_34590_n840# ro_div_0/divbuf_0/a_35070_n840# 0.07fF
C6433 ro_div_0/divbuf_0/a_4350_n840# ro_div_0/divbuf_0/a_4350_n1540# 0.01fF
C6434 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_34590_n1540# 0.19fF
C6435 divbuf_1/a_2910_n840# divbuf_1/a_2910_n1540# 0.01fF
C6436 divbuf_1/a_33150_n840# divbuf_1/a_33630_n840# 0.07fF
C6437 pd_div_0/divbuf_0/a_13742_170# pd_div_0/divbuf_0/a_13742_n240# 0.01fF
C6438 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/a_8272_n240# 0.01fF
C6439 divbuf_3/a_25862_n240# divbuf_3/OUT4 0.04fF
C6440 divbuf_3/a_24000_n1600# divbuf_3/a_24030_n1540# 0.19fF
C6441 divbuf_3/a_24030_n840# divbuf_3/a_24510_n840# 0.07fF
C6442 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6443 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_32670_n840# 0.04fF
C6444 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C6445 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/nor_1/A 0.15fF
C6446 divbuf_0/a_8762_170# divbuf_0/a_8272_170# 0.07fF
C6447 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6448 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_37950_n840# 0.04fF
C6449 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C6450 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C6451 divbuf_0/a_7792_n240# divbuf_0/a_7710_n840# 0.03fF
C6452 divbuf_0/a_17280_n1600# divbuf_0/a_17760_n1600# 0.26fF
C6453 pll_full_0/divbuf_0/a_11520_n1600# pll_full_0/divbuf_0/a_12000_n1600# 0.26fF
C6454 divbuf_1/a_55710_n840# divbuf_1/a_55710_n1540# 0.01fF
C6455 divbuf_0/a_40350_n840# divbuf_0/a_40350_n1540# 0.01fF
C6456 divbuf_0/a_9630_n1540# divbuf_0/a_10110_n1540# 0.11fF
C6457 pll_full_0/divbuf_0/a_3870_n1540# pll_full_0/divbuf_0/a_4350_n1540# 0.11fF
C6458 pll_full_0/divbuf_0/a_34590_n840# pll_full_0/divbuf_0/a_34590_n1540# 0.01fF
C6459 divbuf_2/a_14702_170# divbuf_2/a_15182_170# 0.07fF
C6460 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/a_10212_n240# 0.05fF
C6461 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/a_30232_n240# 0.01fF
C6462 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_16152_n240# 0.05fF
C6463 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/a_35562_n240# 0.01fF
C6464 divbuf_3/a_24000_n1600# divbuf_3/OUT4 0.00fF
C6465 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6466 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22110_n1540# 0.19fF
C6467 pd_div_0/divbuf_0/a_22110_n840# pd_div_0/divbuf_0/a_22590_n840# 0.07fF
C6468 pll_full_0/divbuf_1/a_32652_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6469 pll_full_0/divbuf_1/a_27390_n840# pll_full_0/divbuf_1/a_27870_n840# 0.07fF
C6470 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27390_n1540# 0.19fF
C6471 divbuf_2/a_38962_n240# divbuf_2/a_38910_n840# 0.04fF
C6472 divbuf_2/a_48000_n1600# divbuf_2/a_48480_n1600# 0.26fF
C6473 filter_0/a_4216_n2998# filter_0/v 0.31fF
C6474 divbuf_0/a_7200_n1600# divbuf_0/a_7230_n840# 0.04fF
C6475 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C6476 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1470_n840# 0.04fF
C6477 divbuf_2/a_40350_n1540# divbuf_2/a_40830_n1540# 0.11fF
C6478 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_12030_n840# 0.02fF
C6479 ro_div_0/divbuf_0/a_21120_n1600# ro_div_0/divbuf_0/a_21600_n1600# 0.26fF
C6480 divbuf_3/a_10560_n1600# divbuf_3/a_11040_n1600# 0.26fF
C6481 divbuf_1/a_19680_n1600# divbuf_1/a_20160_n1600# 0.26fF
C6482 divbuf_1/a_10212_n240# divbuf_1/a_10110_n840# 0.03fF
C6483 divbuf_1/a_12030_n1540# divbuf_1/a_12510_n1540# 0.11fF
C6484 ro_div_0/divbuf_0/a_44190_n840# ro_div_0/divbuf_0/a_44190_n1540# 0.01fF
C6485 ro_div_0/divbuf_0/a_13470_n1540# ro_div_0/divbuf_0/a_13950_n1540# 0.11fF
C6486 divbuf_3/a_2910_n1540# divbuf_3/a_3390_n1540# 0.11fF
C6487 divbuf_3/a_33630_n840# divbuf_3/a_33630_n1540# 0.01fF
C6488 divbuf_1/a_1352_n240# divbuf_1/OUT2 0.07fF
C6489 divbuf_1/a_40902_170# divbuf_1/OUT4 0.19fF
C6490 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6491 divbuf_0/a_23922_170# divbuf_0/a_24412_170# 0.07fF
C6492 divbuf_0/a_7792_170# divbuf_0/a_7792_n240# 0.01fF
C6493 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_4882_n240# 0.01fF
C6494 divbuf_2/a_31682_170# divbuf_2/OUT4 0.19fF
C6495 divbuf_2/a_37920_n1600# divbuf_2/a_37950_n840# 0.04fF
C6496 divbuf_1/a_30712_170# divbuf_1/a_30232_170# 0.07fF
C6497 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C6498 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/clk 0.45fF
C6499 ro_div_0/ro_complete_0/cbank_2/switch_3/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C6500 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C6501 divbuf_0/a_57120_n1600# divbuf_0/a_57600_n1600# 0.26fF
C6502 gnd pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.35fF
C6503 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.26fF
C6504 pll_full_0/divbuf_0/a_51360_n1600# pll_full_0/divbuf_0/a_51840_n1600# 0.26fF
C6505 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/OUT3 0.07fF
C6506 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11070_n840# 0.04fF
C6507 divbuf_0/a_49470_n1540# divbuf_0/a_49950_n1540# 0.11fF
C6508 divbuf_3/a_480_n1600# divbuf_3/a_510_n840# 0.04fF
C6509 divbuf_1/a_9600_n1600# divbuf_1/a_9630_n840# 0.04fF
C6510 pll_full_0/divbuf_0/a_43710_n1540# pll_full_0/divbuf_0/a_44190_n1540# 0.11fF
C6511 pd_div_0/divbuf_0/a_8640_n1600# pd_div_0/divbuf_0/a_9120_n1600# 0.26fF
C6512 pll_full_0/divbuf_1/a_13920_n1600# pll_full_0/divbuf_1/a_14400_n1600# 0.26fF
C6513 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/a_4350_n840# 0.04fF
C6514 divbuf_2/a_15672_n240# divbuf_2/a_16152_n240# 0.05fF
C6515 divbuf_2/a_35562_170# divbuf_2/a_35562_n240# 0.01fF
C6516 divbuf_1/a_41382_n240# divbuf_1/OUT5 0.04fF
C6517 divbuf_1/a_960_n1600# divbuf_1/OUT2 0.00fF
C6518 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/OUT2 0.02fF
C6519 pd_div_0/divbuf_0/a_990_n1540# pd_div_0/divbuf_0/a_1470_n1540# 0.11fF
C6520 pd_div_0/divbuf_0/a_31710_n840# pd_div_0/divbuf_0/a_31710_n1540# 0.01fF
C6521 pll_full_0/divbuf_1/a_6270_n1540# pll_full_0/divbuf_1/a_6750_n1540# 0.11fF
C6522 pll_full_0/divbuf_1/a_36990_n840# pll_full_0/divbuf_1/a_36990_n1540# 0.01fF
C6523 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/a_19562_n240# 0.01fF
C6524 divbuf_2/a_32652_n240# divbuf_2/OUT4 0.04fF
C6525 divbuf_2/a_27390_n840# divbuf_2/a_27870_n840# 0.07fF
C6526 divbuf_2/a_27360_n1600# divbuf_2/a_27390_n1540# 0.19fF
C6527 divbuf_1/a_32652_170# divbuf_1/a_32652_n240# 0.01fF
C6528 divbuf_1/a_22952_170# divbuf_1/a_23442_170# 0.07fF
C6529 ro_div_0/divbuf_0/a_7302_170# ro_div_0/divbuf_0/a_7302_n240# 0.01fF
C6530 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/a_28292_170# 0.07fF
C6531 divbuf_0/a_47040_n1600# divbuf_0/a_47070_n840# 0.04fF
C6532 divbuf_0/a_10212_n240# divbuf_0/OUT4 0.04fF
C6533 pll_full_0/divbuf_0/a_38472_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6534 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41310_n840# 0.04fF
C6535 divbuf_3/a_17122_170# divbuf_3/a_17612_170# 0.07fF
C6536 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_510_n1540# 0.19fF
C6537 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/a_990_n840# 0.07fF
C6538 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6539 divbuf_3/a_41382_n240# divbuf_3/a_41310_n840# 0.03fF
C6540 divbuf_3/a_50400_n1600# divbuf_3/a_50880_n1600# 0.26fF
C6541 divbuf_1/a_59520_n1600# divbuf_1/a_60000_n1600# 0.26fF
C6542 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/z5 0.11fF
C6543 ro_div_0/divbuf_0/a_53310_n1540# ro_div_0/divbuf_0/a_53790_n1540# 0.11fF
C6544 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_3870_n840# 0.04fF
C6545 divbuf_3/a_42750_n1540# divbuf_3/a_43230_n1540# 0.11fF
C6546 divbuf_1/a_21630_n840# divbuf_1/a_21630_n1540# 0.01fF
C6547 divbuf_1/a_51840_n1600# divbuf_1/a_51870_n1540# 0.19fF
C6548 divbuf_0/a_24892_n240# divbuf_0/a_25382_n240# 0.04fF
C6549 pll_full_0/divbuf_0/a_38962_170# pll_full_0/divbuf_0/a_38962_n240# 0.01fF
C6550 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/a_19562_n240# 0.04fF
C6551 divbuf_1/a_25382_170# divbuf_1/a_25382_n240# 0.01fF
C6552 divbuf_0/a_36510_n840# divbuf_0/a_36990_n840# 0.07fF
C6553 divbuf_0/a_6270_n840# divbuf_0/a_6270_n1540# 0.01fF
C6554 divbuf_0/a_9600_n1600# divbuf_0/OUT3 0.00fF
C6555 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n1540# 0.19fF
C6556 pll_full_0/divbuf_0/a_39442_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6557 pll_full_0/divbuf_0/a_30750_n840# pll_full_0/divbuf_0/a_31230_n840# 0.07fF
C6558 pll_full_0/divbuf_0/a_510_n840# pll_full_0/divbuf_0/a_510_n1540# 0.01fF
C6559 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_30750_n1540# 0.19fF
C6560 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_50910_n840# 0.04fF
C6561 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6562 divbuf_3/a_36532_170# divbuf_3/OUT4 0.19fF
C6563 divbuf_3/a_40320_n1600# divbuf_3/a_40350_n840# 0.04fF
C6564 divbuf_1/a_49440_n1600# divbuf_1/a_49470_n840# 0.04fF
C6565 divbuf_1/a_43710_n1540# divbuf_1/a_44190_n1540# 0.11fF
C6566 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/a_15672_170# 0.07fF
C6567 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/a_21012_170# 0.07fF
C6568 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.11fF
C6569 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/a_39390_n840# 0.04fF
C6570 pd_div_0/divbuf_0/a_48480_n1600# pd_div_0/divbuf_0/a_48960_n1600# 0.26fF
C6571 ro_div_0/divider_0/nor_0/Z1 ro_div_0/divider_0/nor_1/B 0.18fF
C6572 pll_full_0/divbuf_1/a_53760_n1600# pll_full_0/divbuf_1/a_54240_n1600# 0.26fF
C6573 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/OUT3 0.07fF
C6574 divbuf_2/a_13920_n1600# divbuf_2/a_14400_n1600# 0.26fF
C6575 divbuf_2/a_4392_n240# divbuf_2/a_4350_n840# 0.04fF
C6576 pd_div_0/divbuf_0/a_40830_n1540# pd_div_0/divbuf_0/a_41310_n1540# 0.11fF
C6577 pll_full_0/divbuf_1/a_46110_n1540# pll_full_0/divbuf_1/a_46590_n1540# 0.11fF
C6578 divbuf_2/a_6270_n1540# divbuf_2/a_6750_n1540# 0.11fF
C6579 divbuf_2/a_36990_n840# divbuf_2/a_36990_n1540# 0.01fF
C6580 divbuf_1/a_27322_n240# divbuf_1/a_27802_n240# 0.05fF
C6581 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/a_29262_n240# 0.04fF
C6582 divbuf_3/a_18092_n240# divbuf_3/a_18582_n240# 0.04fF
C6583 divbuf_3/a_37992_170# divbuf_3/a_37992_n240# 0.01fF
C6584 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40350_n1540# 0.19fF
C6585 ro_div_0/divbuf_0/a_40350_n840# ro_div_0/divbuf_0/a_40830_n840# 0.07fF
C6586 ro_div_0/divbuf_0/a_10110_n840# ro_div_0/divbuf_0/a_10110_n1540# 0.01fF
C6587 divbuf_1/a_8670_n840# divbuf_1/a_8670_n1540# 0.01fF
C6588 divbuf_1/a_38910_n840# divbuf_1/a_39390_n840# 0.07fF
C6589 divbuf_3/a_37502_n240# divbuf_3/OUT4 0.04fF
C6590 divbuf_3/a_29790_n840# divbuf_3/a_30270_n840# 0.07fF
C6591 divbuf_3/a_29760_n1600# divbuf_3/a_29790_n1540# 0.19fF
C6592 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6593 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38430_n840# 0.04fF
C6594 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/clk 0.01fF
C6595 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C6596 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C6597 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C6598 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C6599 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C6600 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_43710_n840# 0.04fF
C6601 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C6602 divbuf_2/a_3840_n1600# divbuf_2/a_3870_n840# 0.04fF
C6603 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C6604 divbuf_0/a_23040_n1600# divbuf_0/a_23520_n1600# 0.26fF
C6605 divbuf_0/a_13742_n240# divbuf_0/a_13950_n840# 0.02fF
C6606 pll_full_0/divbuf_0/a_17280_n1600# pll_full_0/divbuf_0/a_17760_n1600# 0.26fF
C6607 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/a_7710_n840# 0.03fF
C6608 divbuf_0/a_46110_n840# divbuf_0/a_46110_n1540# 0.01fF
C6609 divbuf_0/a_15390_n1540# divbuf_0/a_15870_n1540# 0.11fF
C6610 pll_full_0/divbuf_0/a_9630_n1540# pll_full_0/divbuf_0/a_10110_n1540# 0.11fF
C6611 pll_full_0/divbuf_0/a_40350_n840# pll_full_0/divbuf_0/a_40350_n1540# 0.01fF
C6612 divbuf_2/a_20532_170# divbuf_2/a_21012_170# 0.07fF
C6613 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_16642_n240# 0.04fF
C6614 pd_div_0/divbuf_0/a_36052_170# pd_div_0/divbuf_0/a_36052_n240# 0.01fF
C6615 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/a_41382_n240# 0.01fF
C6616 pll_full_0/divbuf_1/a_21502_n240# pll_full_0/divbuf_1/a_21982_n240# 0.05fF
C6617 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/IN 0.00fF
C6618 divbuf_3/a_35520_n1600# divbuf_3/OUT4 0.00fF
C6619 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6620 pd_div_0/divbuf_0/a_27870_n840# pd_div_0/divbuf_0/a_28350_n840# 0.07fF
C6621 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_27870_n1540# 0.19fF
C6622 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/a_2910_n1540# 0.01fF
C6623 pll_full_0/divbuf_1/a_33150_n840# pll_full_0/divbuf_1/a_33630_n840# 0.07fF
C6624 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33150_n1540# 0.19fF
C6625 divbuf_2/a_53760_n1600# divbuf_2/a_54240_n1600# 0.26fF
C6626 divbuf_2/a_2322_170# divbuf_2/OUT3 0.07fF
C6627 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/tspc_1/Q 0.04fF
C6628 divbuf_0/a_12960_n1600# divbuf_0/a_12990_n840# 0.04fF
C6629 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C6630 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7230_n840# 0.04fF
C6631 divbuf_2/a_46110_n1540# divbuf_2/a_46590_n1540# 0.11fF
C6632 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_17790_n840# 0.02fF
C6633 ro_div_0/divbuf_0/a_26880_n1600# ro_div_0/divbuf_0/a_27360_n1600# 0.26fF
C6634 divbuf_3/a_16320_n1600# divbuf_3/a_16800_n1600# 0.26fF
C6635 divbuf_3/a_6822_n240# divbuf_3/a_6750_n840# 0.03fF
C6636 divbuf_1/a_25440_n1600# divbuf_1/a_25920_n1600# 0.26fF
C6637 divbuf_1/a_16152_n240# divbuf_1/a_16350_n840# 0.02fF
C6638 ro_div_0/divbuf_0/a_49950_n840# ro_div_0/divbuf_0/a_49950_n1540# 0.01fF
C6639 ro_div_0/divbuf_0/a_19230_n1540# ro_div_0/divbuf_0/a_19710_n1540# 0.11fF
C6640 divbuf_3/a_8670_n1540# divbuf_3/a_9150_n1540# 0.11fF
C6641 divbuf_3/a_39390_n840# divbuf_3/a_39390_n1540# 0.01fF
C6642 divbuf_1/a_13252_n240# divbuf_1/OUT4 0.04fF
C6643 divbuf_1/a_17760_n1600# divbuf_1/a_17790_n1540# 0.19fF
C6644 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C6645 divbuf_0/a_29742_170# divbuf_0/a_30232_170# 0.07fF
C6646 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/a_1352_n240# 0.01fF
C6647 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/a_24412_170# 0.07fF
C6648 divbuf_2/a_3912_n240# divbuf_2/OUT3 0.04fF
C6649 divbuf_2/a_43680_n1600# divbuf_2/a_43710_n840# 0.04fF
C6650 divbuf_1/a_3912_170# divbuf_1/a_3422_170# 0.07fF
C6651 gnd pd_div_0/bufin 0.29fF
C6652 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/nor_0/B 0.35fF
C6653 divbuf_0/a_2430_n840# divbuf_0/a_2910_n840# 0.07fF
C6654 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n1540# 0.19fF
C6655 divbuf_0/a_21502_170# divbuf_0/OUT4 0.19fF
C6656 gnd pll_full_0/divider_0/and_0/A 0.69fF
C6657 pll_full_0/divbuf_0/a_11312_170# pll_full_0/divbuf_0/OUT4 0.23fF
C6658 pll_full_0/divbuf_0/a_57120_n1600# pll_full_0/divbuf_0/a_57600_n1600# 0.26fF
C6659 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_16830_n840# 0.04fF
C6660 divbuf_0/a_55230_n1540# divbuf_0/a_55710_n1540# 0.11fF
C6661 divbuf_3/a_6240_n1600# divbuf_3/a_6270_n840# 0.04fF
C6662 divbuf_1/a_15360_n1600# divbuf_1/a_15390_n840# 0.04fF
C6663 pll_full_0/divbuf_0/a_49470_n1540# pll_full_0/divbuf_0/a_49950_n1540# 0.11fF
C6664 pd_div_0/divbuf_0/a_14400_n1600# pd_div_0/divbuf_0/a_14880_n1600# 0.26fF
C6665 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/a_4830_n840# 0.04fF
C6666 pll_full_0/divbuf_1/a_19680_n1600# pll_full_0/divbuf_1/a_20160_n1600# 0.26fF
C6667 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/a_10110_n840# 0.03fF
C6668 divbuf_2/a_41382_170# divbuf_2/a_41382_n240# 0.01fF
C6669 divbuf_2/a_21502_n240# divbuf_2/a_21982_n240# 0.05fF
C6670 divbuf_1/a_11520_n1600# divbuf_1/OUT4 0.01fF
C6671 pd_div_0/divbuf_0/a_6750_n1540# pd_div_0/divbuf_0/a_7230_n1540# 0.11fF
C6672 pd_div_0/divbuf_0/a_37470_n840# pd_div_0/divbuf_0/a_37470_n1540# 0.01fF
C6673 pll_full_0/divbuf_1/a_12030_n1540# pll_full_0/divbuf_1/a_12510_n1540# 0.11fF
C6674 pll_full_0/divbuf_1/a_42750_n840# pll_full_0/divbuf_1/a_42750_n1540# 0.01fF
C6675 divbuf_2/a_2910_n840# divbuf_2/a_2910_n1540# 0.01fF
C6676 divbuf_2/a_33150_n840# divbuf_2/a_33630_n840# 0.07fF
C6677 divbuf_2/a_33120_n1600# divbuf_2/a_33150_n1540# 0.19fF
C6678 divbuf_1/a_28772_170# divbuf_1/a_29262_170# 0.07fF
C6679 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/a_34112_170# 0.07fF
C6680 divbuf_0/a_52800_n1600# divbuf_0/a_52830_n840# 0.04fF
C6681 divbuf_0/a_22472_n240# divbuf_0/OUT4 0.04fF
C6682 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6683 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47070_n840# 0.04fF
C6684 divbuf_3/a_2322_170# divbuf_3/a_2322_n240# 0.01fF
C6685 divbuf_3/a_22952_170# divbuf_3/a_23442_170# 0.07fF
C6686 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_4882_170# 0.07fF
C6687 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Z1 0.09fF
C6688 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z2 0.19fF
C6689 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6270_n1540# 0.19fF
C6690 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6691 ro_div_0/divbuf_0/a_6270_n840# ro_div_0/divbuf_0/a_6750_n840# 0.07fF
C6692 divbuf_3/a_56160_n1600# divbuf_3/a_56640_n1600# 0.26fF
C6693 divbuf_3/a_7792_170# divbuf_3/OUT3 0.19fF
C6694 divbuf_1/a_4830_n840# divbuf_1/a_5310_n840# 0.07fF
C6695 divbuf_1/a_4800_n1600# divbuf_1/a_4830_n1540# 0.19fF
C6696 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4350_n840# 0.04fF
C6697 ro_div_0/divbuf_0/a_59070_n1540# ro_div_0/divbuf_0/a_59550_n1540# 0.11fF
C6698 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_9630_n840# 0.04fF
C6699 divbuf_3/a_48510_n1540# divbuf_3/a_48990_n1540# 0.11fF
C6700 divbuf_1/a_57600_n1600# divbuf_1/a_57630_n1540# 0.19fF
C6701 divbuf_1/a_27390_n840# divbuf_1/a_27390_n1540# 0.01fF
C6702 divbuf_0/a_30712_n240# divbuf_0/a_31202_n240# 0.04fF
C6703 pll_full_0/divbuf_1/a_60990_n840# pll_full_0/divbuf_1/OUT5 0.04fF
C6704 pll_full_0/divbuf_0/a_24892_n240# pll_full_0/divbuf_0/a_25382_n240# 0.04fF
C6705 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n1540# 0.19fF
C6706 divbuf_0/a_42270_n840# divbuf_0/a_42750_n840# 0.07fF
C6707 divbuf_0/a_12030_n840# divbuf_0/a_12030_n1540# 0.01fF
C6708 divbuf_0/a_20640_n1600# divbuf_0/OUT4 0.00fF
C6709 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36510_n1540# 0.19fF
C6710 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/OUT3 0.00fF
C6711 pll_full_0/divbuf_0/a_6270_n840# pll_full_0/divbuf_0/a_6270_n1540# 0.01fF
C6712 pll_full_0/divbuf_0/a_36510_n840# pll_full_0/divbuf_0/a_36990_n840# 0.07fF
C6713 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_56670_n840# 0.04fF
C6714 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6715 divbuf_3/a_8762_n240# divbuf_3/OUT3 0.04fF
C6716 divbuf_3/a_46080_n1600# divbuf_3/a_46110_n840# 0.04fF
C6717 divbuf_1/a_55200_n1600# divbuf_1/a_55230_n840# 0.04fF
C6718 divbuf_1/a_49470_n1540# divbuf_1/a_49950_n1540# 0.11fF
C6719 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/a_21502_170# 0.07fF
C6720 pll_full_0/divbuf_1/a_6332_170# pll_full_0/divbuf_1/a_6332_n240# 0.01fF
C6721 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/a_26832_170# 0.07fF
C6722 pd_div_0/divbuf_0/a_54240_n1600# pd_div_0/divbuf_0/a_54720_n1600# 0.26fF
C6723 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/Z3 0.45fF
C6724 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6725 pll_full_0/divbuf_1/a_59520_n1600# pll_full_0/divbuf_1/a_60000_n1600# 0.26fF
C6726 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C6727 divbuf_2/a_19680_n1600# divbuf_2/a_20160_n1600# 0.26fF
C6728 divbuf_2/a_10212_n240# divbuf_2/a_10110_n840# 0.03fF
C6729 pd_div_0/divbuf_0/a_46590_n1540# pd_div_0/divbuf_0/a_47070_n1540# 0.11fF
C6730 pll_full_0/divbuf_1/a_51870_n1540# pll_full_0/divbuf_1/a_52350_n1540# 0.11fF
C6731 divbuf_2/a_12030_n1540# divbuf_2/a_12510_n1540# 0.11fF
C6732 divbuf_2/a_42750_n840# divbuf_2/a_42750_n1540# 0.01fF
C6733 divbuf_1/a_33142_n240# divbuf_1/a_33622_n240# 0.05fF
C6734 ro_div_0/divbuf_0/a_34592_n240# ro_div_0/divbuf_0/a_35082_n240# 0.04fF
C6735 divbuf_0/a_990_n840# divbuf_0/OUT2 0.02fF
C6736 divbuf_3/a_23922_n240# divbuf_3/a_24412_n240# 0.04fF
C6737 ro_div_0/divbuf_0/a_46110_n840# ro_div_0/divbuf_0/a_46590_n840# 0.07fF
C6738 ro_div_0/divbuf_0/a_15870_n840# ro_div_0/divbuf_0/a_15870_n1540# 0.01fF
C6739 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46110_n1540# 0.19fF
C6740 divbuf_3/a_35520_n1600# divbuf_3/a_35550_n1540# 0.19fF
C6741 divbuf_3/a_5310_n840# divbuf_3/a_5310_n1540# 0.01fF
C6742 divbuf_3/a_35550_n840# divbuf_3/a_36030_n840# 0.07fF
C6743 divbuf_1/a_14430_n840# divbuf_1/a_14430_n1540# 0.01fF
C6744 divbuf_1/a_44670_n840# divbuf_1/a_45150_n840# 0.07fF
C6745 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C6746 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44190_n840# 0.04fF
C6747 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/switch_3/vin 0.20fF
C6748 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C6749 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6750 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49470_n840# 0.04fF
C6751 divbuf_2/a_9600_n1600# divbuf_2/a_9630_n840# 0.04fF
C6752 divbuf_0/a_19562_n240# divbuf_0/a_19710_n840# 0.03fF
C6753 divbuf_0/a_28800_n1600# divbuf_0/a_29280_n1600# 0.26fF
C6754 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_13950_n840# 0.02fF
C6755 pll_full_0/divbuf_0/a_23040_n1600# pll_full_0/divbuf_0/a_23520_n1600# 0.26fF
C6756 divbuf_2/a_60990_n840# divbuf_2/OUT5 0.04fF
C6757 divbuf_1/a_1352_n240# divbuf_1/a_1470_n840# 0.03fF
C6758 divbuf_0/a_51870_n840# divbuf_0/a_51870_n1540# 0.01fF
C6759 divbuf_0/a_21150_n1540# divbuf_0/a_21630_n1540# 0.11fF
C6760 pll_full_0/divbuf_0/a_15390_n1540# pll_full_0/divbuf_0/a_15870_n1540# 0.11fF
C6761 pll_full_0/divbuf_0/a_46110_n840# pll_full_0/divbuf_0/a_46110_n1540# 0.01fF
C6762 divbuf_2/a_6332_170# divbuf_2/a_6332_n240# 0.01fF
C6763 divbuf_2/a_26352_170# divbuf_2/a_26832_170# 0.07fF
C6764 pd_div_0/divbuf_0/a_21982_n240# pd_div_0/divbuf_0/a_22472_n240# 0.04fF
C6765 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/a_27802_n240# 0.05fF
C6766 divbuf_1/a_20532_170# divbuf_1/OUT4 0.19fF
C6767 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_33630_n1540# 0.19fF
C6768 pd_div_0/divbuf_0/a_3390_n840# pd_div_0/divbuf_0/a_3390_n1540# 0.01fF
C6769 pd_div_0/divbuf_0/a_33630_n840# pd_div_0/divbuf_0/a_34110_n840# 0.07fF
C6770 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C6771 pll_full_0/divbuf_1/a_8670_n840# pll_full_0/divbuf_1/a_8670_n1540# 0.01fF
C6772 pll_full_0/divbuf_1/a_38910_n840# pll_full_0/divbuf_1/a_39390_n840# 0.07fF
C6773 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_38910_n1540# 0.19fF
C6774 divbuf_2/a_14702_170# divbuf_2/OUT4 0.19fF
C6775 divbuf_2/a_59520_n1600# divbuf_2/a_60000_n1600# 0.26fF
C6776 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/and_0/OUT 0.14fF
C6777 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 0.94fF
C6778 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C6779 divbuf_0/a_18720_n1600# divbuf_0/a_18750_n840# 0.04fF
C6780 gnd pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.22fF
C6781 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.45fF
C6782 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/OUT3 0.19fF
C6783 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_12990_n840# 0.04fF
C6784 divbuf_2/a_51870_n1540# divbuf_2/a_52350_n1540# 0.11fF
C6785 divbuf_1/a_31200_n1600# divbuf_1/a_31680_n1600# 0.26fF
C6786 divbuf_1/a_21982_n240# divbuf_1/a_22110_n840# 0.03fF
C6787 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/a_23550_n840# 0.03fF
C6788 ro_div_0/divbuf_0/a_32640_n1600# ro_div_0/divbuf_0/a_33120_n1600# 0.26fF
C6789 divbuf_3/a_22080_n1600# divbuf_3/a_22560_n1600# 0.26fF
C6790 divbuf_3/a_12772_n240# divbuf_3/a_12990_n840# 0.02fF
C6791 ro_div_0/divbuf_0/a_55710_n840# ro_div_0/divbuf_0/a_55710_n1540# 0.01fF
C6792 ro_div_0/divbuf_0/a_24990_n1540# ro_div_0/divbuf_0/a_25470_n1540# 0.11fF
C6793 divbuf_3/a_14430_n1540# divbuf_3/a_14910_n1540# 0.11fF
C6794 divbuf_3/a_45150_n840# divbuf_3/a_45150_n1540# 0.01fF
C6795 divbuf_1/a_24892_n240# divbuf_1/OUT4 0.04fF
C6796 divbuf_1/a_23520_n1600# divbuf_1/a_23550_n1540# 0.19fF
C6797 divbuf_0/a_35562_170# divbuf_0/a_36052_170# 0.07fF
C6798 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/a_30232_170# 0.07fF
C6799 divbuf_2/a_15672_n240# divbuf_2/OUT4 0.04fF
C6800 divbuf_2/a_49440_n1600# divbuf_2/a_49470_n840# 0.04fF
C6801 divbuf_1/a_18582_170# divbuf_1/a_18582_n240# 0.01fF
C6802 divbuf_1/a_6332_170# divbuf_1/a_6332_n240# 0.01fF
C6803 pd_div_0/divider_0/prescaler_0/Out pd_div_0/divider_0/tspc_0/Z2 0.11fF
C6804 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/a_9242_n240# 0.01fF
C6805 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n1540# 0.19fF
C6806 divbuf_0/a_33142_170# divbuf_0/OUT4 0.19fF
C6807 divbuf_0/a_8190_n840# divbuf_0/a_8670_n840# 0.07fF
C6808 pll_full_0/divbuf_0/a_21502_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6809 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2430_n1540# 0.19fF
C6810 pll_full_0/divbuf_0/a_2430_n840# pll_full_0/divbuf_0/a_2910_n840# 0.07fF
C6811 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_22590_n840# 0.04fF
C6812 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6813 pll_full_0/divbuf_0/a_55230_n1540# pll_full_0/divbuf_0/a_55710_n1540# 0.11fF
C6814 divbuf_3/a_12000_n1600# divbuf_3/a_12030_n840# 0.04fF
C6815 divbuf_1/a_21120_n1600# divbuf_1/a_21150_n840# 0.04fF
C6816 divbuf_1/a_15390_n1540# divbuf_1/a_15870_n1540# 0.11fF
C6817 divbuf_2/a_27322_n240# divbuf_2/a_27802_n240# 0.05fF
C6818 pd_div_0/divbuf_0/a_20160_n1600# pd_div_0/divbuf_0/a_20640_n1600# 0.26fF
C6819 pll_full_0/divbuf_1/a_25440_n1600# pll_full_0/divbuf_1/a_25920_n1600# 0.26fF
C6820 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_16350_n840# 0.02fF
C6821 divbuf_1/a_23040_n1600# divbuf_1/OUT4 0.01fF
C6822 pd_div_0/divbuf_0/a_12510_n1540# pd_div_0/divbuf_0/a_12990_n1540# 0.11fF
C6823 pd_div_0/divbuf_0/a_43230_n840# pd_div_0/divbuf_0/a_43230_n1540# 0.01fF
C6824 pll_full_0/divbuf_1/a_17790_n1540# pll_full_0/divbuf_1/a_18270_n1540# 0.11fF
C6825 pll_full_0/divbuf_1/a_48510_n840# pll_full_0/divbuf_1/a_48510_n1540# 0.01fF
C6826 divbuf_2/a_8670_n840# divbuf_2/a_8670_n1540# 0.01fF
C6827 divbuf_2/a_38910_n840# divbuf_2/a_39390_n840# 0.07fF
C6828 divbuf_2/a_38880_n1600# divbuf_2/a_38910_n1540# 0.19fF
C6829 divbuf_1/a_37992_170# divbuf_1/a_38472_170# 0.07fF
C6830 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/a_39932_170# 0.07fF
C6831 ro_div_0/divbuf_0/a_20042_170# ro_div_0/divbuf_0/a_20042_n240# 0.01fF
C6832 divbuf_0/a_58560_n1600# divbuf_0/a_58590_n840# 0.04fF
C6833 divbuf_0/a_34112_n240# divbuf_0/OUT4 0.04fF
C6834 pll_full_0/divbuf_0/a_22472_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6835 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_52830_n840# 0.04fF
C6836 divbuf_3/a_8762_170# divbuf_3/a_8762_n240# 0.01fF
C6837 divbuf_3/a_28772_170# divbuf_3/a_29262_170# 0.07fF
C6838 ro_div_0/ro_complete_0/a4 ro_div_0/divider_0/clk 0.05fF
C6839 ro_div_0/divbuf_0/a_12030_n840# ro_div_0/divbuf_0/a_12510_n840# 0.07fF
C6840 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12030_n1540# 0.19fF
C6841 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/OUT4 0.19fF
C6842 ro_div_0/divbuf_0/a_1352_n240# ro_div_0/divbuf_0/OUT2 0.07fF
C6843 ro_div_0/divider_0/and_0/OUT gnd 0.32fF
C6844 divbuf_3/a_19562_170# divbuf_3/OUT4 0.19fF
C6845 divbuf_3/a_1440_n1600# divbuf_3/a_1470_n1540# 0.19fF
C6846 divbuf_3/a_1470_n840# divbuf_3/a_1950_n840# 0.07fF
C6847 divbuf_1/a_10590_n840# divbuf_1/a_11070_n840# 0.07fF
C6848 divbuf_1/a_10560_n1600# divbuf_1/a_10590_n1540# 0.19fF
C6849 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10110_n840# 0.04fF
C6850 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15390_n840# 0.04fF
C6851 divbuf_3/a_54270_n1540# divbuf_3/a_54750_n1540# 0.11fF
C6852 divbuf_1/a_33150_n840# divbuf_1/a_33150_n1540# 0.01fF
C6853 divbuf_1/a_2910_n840# divbuf_1/OUT3 0.03fF
C6854 divbuf_0/a_36532_n240# divbuf_0/a_37022_n240# 0.04fF
C6855 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/a_31202_n240# 0.04fF
C6856 divbuf_0/a_48030_n840# divbuf_0/a_48510_n840# 0.07fF
C6857 divbuf_0/a_17790_n840# divbuf_0/a_17790_n1540# 0.01fF
C6858 divbuf_0/a_32160_n1600# divbuf_0/OUT4 0.00fF
C6859 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n1540# 0.19fF
C6860 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C6861 pll_full_0/divbuf_0/a_12030_n840# pll_full_0/divbuf_0/a_12030_n1540# 0.01fF
C6862 pll_full_0/divbuf_0/a_42270_n840# pll_full_0/divbuf_0/a_42750_n840# 0.07fF
C6863 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42270_n1540# 0.19fF
C6864 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/a_27322_170# 0.07fF
C6865 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C6866 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/OUT5 0.04fF
C6867 divbuf_3/a_20532_n240# divbuf_3/OUT4 0.04fF
C6868 divbuf_3/a_51840_n1600# divbuf_3/a_51870_n840# 0.04fF
C6869 divbuf_1/a_55230_n1540# divbuf_1/a_55710_n1540# 0.11fF
C6870 pll_full_0/divbuf_1/a_12772_170# pll_full_0/divbuf_1/a_12772_n240# 0.01fF
C6871 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/a_32652_170# 0.07fF
C6872 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/OUT4 0.19fF
C6873 pd_div_0/divbuf_0/a_60000_n1600# pd_div_0/divbuf_0/a_60480_n1600# 0.26fF
C6874 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/and_0/OUT 0.05fF
C6875 pll_full_0/divbuf_1/a_4830_n840# pll_full_0/divbuf_1/a_5310_n840# 0.07fF
C6876 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/OUT4 0.19fF
C6877 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_4830_n1540# 0.19fF
C6878 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C6879 divbuf_2/a_25440_n1600# divbuf_2/a_25920_n1600# 0.26fF
C6880 divbuf_2/a_16152_n240# divbuf_2/a_16350_n840# 0.02fF
C6881 divbuf_1/a_41790_n840# divbuf_1/OUT5 0.03fF
C6882 pd_div_0/divbuf_0/a_52350_n1540# pd_div_0/divbuf_0/a_52830_n1540# 0.11fF
C6883 ashish_0/von ashish_0/vop 12.87fF
C6884 ashish_0/a_150_n710# ashish_0/Gnd 1.71fF
C6885 pll_full_0/divbuf_1/a_57630_n1540# pll_full_0/divbuf_1/a_58110_n1540# 0.11fF
C6886 divbuf_2/a_17790_n1540# divbuf_2/a_18270_n1540# 0.11fF
C6887 divbuf_2/a_48510_n840# divbuf_2/a_48510_n1540# 0.01fF
C6888 divbuf_1/a_38962_n240# divbuf_1/a_39442_n240# 0.05fF
C6889 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/a_40902_n240# 0.04fF
C6890 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/OUT2 0.02fF
C6891 divbuf_3/a_29742_n240# divbuf_3/a_30232_n240# 0.04fF
C6892 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_51870_n1540# 0.19fF
C6893 ro_div_0/divbuf_0/a_51870_n840# ro_div_0/divbuf_0/a_52350_n840# 0.07fF
C6894 ro_div_0/divbuf_0/a_21630_n840# ro_div_0/divbuf_0/a_21630_n1540# 0.01fF
C6895 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/IN 0.00fF
C6896 divbuf_3/a_11070_n840# divbuf_3/a_11070_n1540# 0.01fF
C6897 divbuf_3/a_41310_n840# divbuf_3/a_41790_n840# 0.07fF
C6898 divbuf_3/a_41280_n1600# divbuf_3/a_41310_n1540# 0.19fF
C6899 divbuf_1/a_50430_n840# divbuf_1/a_50910_n840# 0.07fF
C6900 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C6901 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_49950_n840# 0.04fF
C6902 pll_full_0/divbuf_1/a_27322_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C6903 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55230_n840# 0.04fF
C6904 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C6905 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C6906 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C6907 divbuf_2/a_15360_n1600# divbuf_2/a_15390_n840# 0.04fF
C6908 divbuf_0/a_34560_n1600# divbuf_0/a_35040_n1600# 0.26fF
C6909 divbuf_0/a_17122_170# divbuf_0/OUT4 0.19fF
C6910 divbuf_0/a_25382_n240# divbuf_0/a_25470_n840# 0.03fF
C6911 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C6912 pll_full_0/divbuf_0/a_28800_n1600# pll_full_0/divbuf_0/a_29280_n1600# 0.26fF
C6913 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/a_19710_n840# 0.03fF
C6914 divbuf_0/a_57630_n840# divbuf_0/a_57630_n1540# 0.01fF
C6915 divbuf_0/a_26910_n1540# divbuf_0/a_27390_n1540# 0.11fF
C6916 pll_full_0/divbuf_0/a_21150_n1540# pll_full_0/divbuf_0/a_21630_n1540# 0.11fF
C6917 pll_full_0/divbuf_0/a_51870_n840# pll_full_0/divbuf_0/a_51870_n1540# 0.01fF
C6918 divbuf_2/a_12772_170# divbuf_2/a_12772_n240# 0.01fF
C6919 divbuf_2/a_32172_170# divbuf_2/a_32652_170# 0.07fF
C6920 pd_div_0/divbuf_0/a_27802_n240# pd_div_0/divbuf_0/a_28292_n240# 0.04fF
C6921 pll_full_0/divbuf_1/a_33142_n240# pll_full_0/divbuf_1/a_33622_n240# 0.05fF
C6922 divbuf_1/a_35562_170# divbuf_1/OUT4 0.19fF
C6923 pd_div_0/divbuf_0/a_9150_n840# pd_div_0/divbuf_0/a_9150_n1540# 0.01fF
C6924 pd_div_0/divbuf_0/a_39390_n840# pd_div_0/divbuf_0/a_39870_n840# 0.07fF
C6925 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39390_n1540# 0.19fF
C6926 divbuf_0/a_6822_170# divbuf_0/a_6822_n240# 0.01fF
C6927 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_44670_n1540# 0.19fF
C6928 pll_full_0/divbuf_1/a_14430_n840# pll_full_0/divbuf_1/a_14430_n1540# 0.01fF
C6929 pll_full_0/divbuf_1/a_44670_n840# pll_full_0/divbuf_1/a_45150_n840# 0.07fF
C6930 divbuf_2/a_4830_n840# divbuf_2/a_5310_n840# 0.07fF
C6931 divbuf_2/a_26352_170# divbuf_2/OUT4 0.19fF
C6932 divbuf_2/a_4800_n1600# divbuf_2/a_4830_n1540# 0.19fF
C6933 divbuf_1/a_15182_170# divbuf_1/a_15672_170# 0.07fF
C6934 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/tspc_0/Z2 1.07fF
C6935 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 0.22fF
C6936 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 pd_div_0/divider_0/clk 0.12fF
C6937 divbuf_0/a_24480_n1600# divbuf_0/a_24510_n840# 0.04fF
C6938 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_18750_n840# 0.04fF
C6939 divbuf_2/a_57630_n1540# divbuf_2/a_58110_n1540# 0.11fF
C6940 divbuf_1/a_36960_n1600# divbuf_1/a_37440_n1600# 0.26fF
C6941 divbuf_1/a_27802_n240# divbuf_1/a_27870_n840# 0.04fF
C6942 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/a_29310_n840# 0.04fF
C6943 ro_div_0/divbuf_0/a_38400_n1600# ro_div_0/divbuf_0/a_38880_n1600# 0.26fF
C6944 divbuf_3/a_27840_n1600# divbuf_3/a_28320_n1600# 0.26fF
C6945 divbuf_3/a_18582_n240# divbuf_3/a_18750_n840# 0.02fF
C6946 ro_div_0/divbuf_0/a_30750_n1540# ro_div_0/divbuf_0/a_31230_n1540# 0.11fF
C6947 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/a_1470_n840# 0.03fF
C6948 divbuf_3/a_20190_n1540# divbuf_3/a_20670_n1540# 0.11fF
C6949 divbuf_3/a_50910_n840# divbuf_3/a_50910_n1540# 0.01fF
C6950 divbuf_1/a_36532_n240# divbuf_1/OUT4 0.04fF
C6951 divbuf_1/a_29280_n1600# divbuf_1/a_29310_n1540# 0.19fF
C6952 divbuf_0/a_21982_170# divbuf_0/a_21982_n240# 0.01fF
C6953 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/a_36052_170# 0.07fF
C6954 divbuf_2/a_27322_n240# divbuf_2/OUT4 0.04fF
C6955 divbuf_2/a_55200_n1600# divbuf_2/a_55230_n840# 0.04fF
C6956 divbuf_0/a_5362_n240# divbuf_0/OUT3 0.04fF
C6957 divbuf_0/a_13950_n840# divbuf_0/a_14430_n840# 0.07fF
C6958 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n1540# 0.19fF
C6959 pll_full_0/divbuf_0/a_8190_n840# pll_full_0/divbuf_0/a_8670_n840# 0.07fF
C6960 pll_full_0/divbuf_0/a_33142_170# pll_full_0/divbuf_0/OUT4 0.19fF
C6961 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8190_n1540# 0.19fF
C6962 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z3 0.65fF
C6963 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28350_n840# 0.04fF
C6964 divbuf_3/a_17760_n1600# divbuf_3/a_17790_n840# 0.04fF
C6965 divbuf_1/a_26880_n1600# divbuf_1/a_26910_n840# 0.04fF
C6966 divbuf_1/a_21150_n1540# divbuf_1/a_21630_n1540# 0.11fF
C6967 divbuf_2/a_33142_n240# divbuf_2/a_33622_n240# 0.05fF
C6968 pd_div_0/divbuf_0/a_25920_n1600# pd_div_0/divbuf_0/a_26400_n1600# 0.26fF
C6969 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_16830_n840# 0.02fF
C6970 pll_full_0/divbuf_1/a_31200_n1600# pll_full_0/divbuf_1/a_31680_n1600# 0.26fF
C6971 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/a_22110_n840# 0.03fF
C6972 divbuf_1/a_34560_n1600# divbuf_1/OUT4 0.01fF
C6973 pd_div_0/divbuf_0/a_18270_n1540# pd_div_0/divbuf_0/a_18750_n1540# 0.11fF
C6974 pd_div_0/divbuf_0/a_48990_n840# pd_div_0/divbuf_0/a_48990_n1540# 0.01fF
C6975 pll_full_0/divbuf_1/a_23550_n1540# pll_full_0/divbuf_1/a_24030_n1540# 0.11fF
C6976 pll_full_0/divbuf_1/a_54270_n840# pll_full_0/divbuf_1/a_54270_n1540# 0.01fF
C6977 divbuf_2/a_44640_n1600# divbuf_2/a_44670_n1540# 0.19fF
C6978 divbuf_2/a_14430_n840# divbuf_2/a_14430_n1540# 0.01fF
C6979 divbuf_2/a_44670_n840# divbuf_2/a_45150_n840# 0.07fF
C6980 divbuf_1/a_3912_n240# divbuf_1/a_4392_n240# 0.05fF
C6981 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/a_25862_n240# 0.01fF
C6982 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/a_5852_n240# 0.04fF
C6983 pll_full_0/divbuf_0/a_34112_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C6984 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_58590_n840# 0.04fF
C6985 divbuf_3/a_15182_170# divbuf_3/a_15182_n240# 0.01fF
C6986 divbuf_3/a_34592_170# divbuf_3/a_35082_170# 0.07fF
C6987 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_17790_n1540# 0.19fF
C6988 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C6989 ro_div_0/divbuf_0/a_17790_n840# ro_div_0/divbuf_0/a_18270_n840# 0.07fF
C6990 divbuf_3/a_7230_n840# divbuf_3/a_7710_n840# 0.07fF
C6991 divbuf_3/a_31202_170# divbuf_3/OUT4 0.19fF
C6992 divbuf_3/a_7200_n1600# divbuf_3/a_7230_n1540# 0.19fF
C6993 divbuf_1/a_16350_n840# divbuf_1/a_16830_n840# 0.07fF
C6994 divbuf_1/a_1352_170# divbuf_1/OUT2 0.23fF
C6995 divbuf_2/a_1352_n240# divbuf_2/a_1470_n840# 0.03fF
C6996 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_15870_n840# 0.04fF
C6997 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21150_n840# 0.04fF
C6998 divbuf_3/a_60030_n1540# divbuf_3/a_60510_n1540# 0.11fF
C6999 divbuf_1/a_38910_n840# divbuf_1/a_38910_n1540# 0.01fF
C7000 divbuf_0/a_480_n1600# divbuf_0/a_960_n1600# 0.26fF
C7001 pll_full_0/divbuf_0/a_36532_n240# pll_full_0/divbuf_0/a_37022_n240# 0.04fF
C7002 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n1540# 0.19fF
C7003 divbuf_0/a_53790_n840# divbuf_0/a_54270_n840# 0.07fF
C7004 divbuf_0/a_23550_n840# divbuf_0/a_23550_n1540# 0.01fF
C7005 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48030_n1540# 0.19fF
C7006 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C7007 pll_full_0/divbuf_0/a_17790_n840# pll_full_0/divbuf_0/a_17790_n1540# 0.01fF
C7008 pll_full_0/divbuf_0/a_48030_n840# pll_full_0/divbuf_0/a_48510_n840# 0.07fF
C7009 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/a_33142_170# 0.07fF
C7010 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C7011 divbuf_3/a_32172_n240# divbuf_3/OUT4 0.04fF
C7012 divbuf_3/a_57600_n1600# divbuf_3/a_57630_n840# 0.04fF
C7013 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/a_18582_n240# 0.01fF
C7014 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/a_38472_170# 0.07fF
C7015 pd_div_0/divbuf_0/a_5310_n840# pd_div_0/divbuf_0/a_5790_n840# 0.07fF
C7016 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7017 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5310_n1540# 0.19fF
C7018 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C7019 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_2/Z2 0.20fF
C7020 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/tspc_1/Z4 0.02fF
C7021 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/a_11070_n840# 0.07fF
C7022 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7023 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_10590_n1540# 0.19fF
C7024 divbuf_2/a_31200_n1600# divbuf_2/a_31680_n1600# 0.26fF
C7025 divbuf_2/a_21982_n240# divbuf_2/a_22110_n840# 0.03fF
C7026 pd_div_0/divbuf_0/a_58110_n1540# pd_div_0/divbuf_0/a_58590_n1540# 0.11fF
C7027 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C7028 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C7029 divbuf_0/a_11312_n240# divbuf_0/a_11070_n840# 0.02fF
C7030 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 0.36fF
C7031 divbuf_2/a_23550_n1540# divbuf_2/a_24030_n1540# 0.11fF
C7032 divbuf_2/a_54270_n840# divbuf_2/a_54270_n1540# 0.01fF
C7033 divbuf_1/a_2880_n1600# divbuf_1/a_3360_n1600# 0.26fF
C7034 ro_div_0/divbuf_0/a_4320_n1600# ro_div_0/divbuf_0/a_4800_n1600# 0.26fF
C7035 divbuf_3/a_35562_n240# divbuf_3/a_36052_n240# 0.04fF
C7036 ro_div_0/divbuf_0/a_57630_n840# ro_div_0/divbuf_0/a_58110_n840# 0.07fF
C7037 ro_div_0/divbuf_0/a_27390_n840# ro_div_0/divbuf_0/a_27390_n1540# 0.01fF
C7038 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_57630_n1540# 0.19fF
C7039 divbuf_3/a_47040_n1600# divbuf_3/a_47070_n1540# 0.19fF
C7040 divbuf_3/a_16830_n840# divbuf_3/a_16830_n1540# 0.01fF
C7041 divbuf_3/a_47070_n840# divbuf_3/a_47550_n840# 0.07fF
C7042 divbuf_1/a_56190_n840# divbuf_1/a_56670_n840# 0.07fF
C7043 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7044 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_55710_n840# 0.04fF
C7045 divbuf_0/a_5362_170# divbuf_0/a_5852_170# 0.07fF
C7046 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7047 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/a_14222_170# 0.07fF
C7048 divbuf_2/a_21120_n1600# divbuf_2/a_21150_n840# 0.04fF
C7049 divbuf_0/a_31202_n240# divbuf_0/a_31230_n840# 0.05fF
C7050 divbuf_0/a_40320_n1600# divbuf_0/a_40800_n1600# 0.26fF
C7051 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C7052 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C7053 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/a_25470_n840# 0.03fF
C7054 pll_full_0/divbuf_0/a_34560_n1600# pll_full_0/divbuf_0/a_35040_n1600# 0.26fF
C7055 divbuf_1/a_13742_n240# divbuf_1/a_13470_n840# 0.01fF
C7056 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/a_14910_n840# 0.01fF
C7057 divbuf_0/a_32670_n1540# divbuf_0/a_33150_n1540# 0.11fF
C7058 pll_full_0/divbuf_0/a_26910_n1540# pll_full_0/divbuf_0/a_27390_n1540# 0.11fF
C7059 pll_full_0/divbuf_0/a_57630_n840# pll_full_0/divbuf_0/a_57630_n1540# 0.01fF
C7060 divbuf_2/a_18582_170# divbuf_2/a_18582_n240# 0.01fF
C7061 divbuf_2/a_37992_170# divbuf_2/a_38472_170# 0.07fF
C7062 pd_div_0/divbuf_0/a_33622_n240# pd_div_0/divbuf_0/a_34112_n240# 0.04fF
C7063 pll_full_0/divbuf_1/a_38962_n240# pll_full_0/divbuf_1/a_39442_n240# 0.05fF
C7064 divbuf_1/a_7792_n240# divbuf_1/OUT3 0.04fF
C7065 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45150_n1540# 0.19fF
C7066 pd_div_0/divbuf_0/a_14910_n840# pd_div_0/divbuf_0/a_14910_n1540# 0.01fF
C7067 pd_div_0/divbuf_0/a_45150_n840# pd_div_0/divbuf_0/a_45630_n840# 0.07fF
C7068 pll_full_0/divbuf_1/a_20190_n840# pll_full_0/divbuf_1/a_20190_n1540# 0.01fF
C7069 pll_full_0/divbuf_1/a_50430_n840# pll_full_0/divbuf_1/a_50910_n840# 0.07fF
C7070 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50430_n1540# 0.19fF
C7071 divbuf_2/a_10590_n840# divbuf_2/a_11070_n840# 0.07fF
C7072 divbuf_2/a_37992_170# divbuf_2/OUT4 0.19fF
C7073 divbuf_2/a_10560_n1600# divbuf_2/a_10590_n1540# 0.19fF
C7074 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/prescaler_0/Out 0.15fF
C7075 pd_div_0/divider_0/prescaler_0/tspc_2/D gnd 0.05fF
C7076 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/clk 0.64fF
C7077 divbuf_0/a_30240_n1600# divbuf_0/a_30270_n840# 0.04fF
C7078 gnd pll_full_0/divbuf_0/IN 3.72fF
C7079 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24510_n840# 0.04fF
C7080 divbuf_2/OUT3 divbuf_2/OUT4 0.36fF
C7081 divbuf_1/a_42720_n1600# divbuf_1/a_43200_n1600# 0.26fF
C7082 divbuf_1/a_33622_n240# divbuf_1/a_33630_n840# 0.06fF
C7083 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/a_35070_n840# 0.05fF
C7084 ro_div_0/divbuf_0/a_44160_n1600# ro_div_0/divbuf_0/a_44640_n1600# 0.26fF
C7085 divbuf_3/a_33600_n1600# divbuf_3/a_34080_n1600# 0.26fF
C7086 divbuf_3/a_24412_n240# divbuf_3/a_24510_n840# 0.03fF
C7087 ro_div_0/divbuf_0/a_36510_n1540# ro_div_0/divbuf_0/a_36990_n1540# 0.11fF
C7088 pd_div_0/divbuf_0/a_1842_n240# pd_div_0/divbuf_0/a_1950_n840# 0.03fF
C7089 io_clamp_low[1] io_clamp_high[1] 0.53fF
C7090 divbuf_3/a_25950_n1540# divbuf_3/a_26430_n1540# 0.11fF
C7091 divbuf_3/a_56670_n840# divbuf_3/a_56670_n1540# 0.01fF
C7092 divbuf_1/a_35040_n1600# divbuf_1/a_35070_n1540# 0.19fF
C7093 divbuf_0/a_27802_170# divbuf_0/a_27802_n240# 0.01fF
C7094 divbuf_0/a_7302_n240# divbuf_0/a_7792_n240# 0.04fF
C7095 pll_full_0/divbuf_0/a_21982_170# pll_full_0/divbuf_0/a_21982_n240# 0.01fF
C7096 divbuf_2/a_38962_n240# divbuf_2/OUT4 0.04fF
C7097 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/a_12282_n240# 0.01fF
C7098 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n1540# 0.19fF
C7099 divbuf_0/a_17122_n240# divbuf_0/OUT4 0.04fF
C7100 divbuf_0/a_19710_n840# divbuf_0/a_20190_n840# 0.07fF
C7101 pll_full_0/divbuf_0/a_5362_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C7102 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_13950_n1540# 0.19fF
C7103 pll_full_0/divbuf_0/a_13950_n840# pll_full_0/divbuf_0/a_14430_n840# 0.07fF
C7104 divbuf_1/a_32640_n1600# divbuf_1/a_32670_n840# 0.04fF
C7105 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_5852_170# 0.07fF
C7106 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_1/Qbar 0.02fF
C7107 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Qbar1 0.30fF
C7108 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34110_n840# 0.04fF
C7109 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7110 divbuf_3/a_2322_170# divbuf_3/OUT2 0.19fF
C7111 divbuf_3/a_23520_n1600# divbuf_3/a_23550_n840# 0.04fF
C7112 divbuf_1/a_26910_n1540# divbuf_1/a_27390_n1540# 0.11fF
C7113 divbuf_2/a_38962_n240# divbuf_2/a_39442_n240# 0.05fF
C7114 pd_div_0/divbuf_0/a_31680_n1600# pd_div_0/divbuf_0/a_32160_n1600# 0.26fF
C7115 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/a_22590_n840# 0.03fF
C7116 pll_full_0/divbuf_1/a_36960_n1600# pll_full_0/divbuf_1/a_37440_n1600# 0.26fF
C7117 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/a_27870_n840# 0.04fF
C7118 pd_div_0/divbuf_0/a_24030_n1540# pd_div_0/divbuf_0/a_24510_n1540# 0.11fF
C7119 pd_div_0/divbuf_0/a_54750_n840# pd_div_0/divbuf_0/a_54750_n1540# 0.01fF
C7120 pll_full_0/divbuf_1/a_29310_n1540# pll_full_0/divbuf_1/a_29790_n1540# 0.11fF
C7121 pll_full_0/divbuf_1/a_60030_n840# pll_full_0/divbuf_1/a_60030_n1540# 0.01fF
C7122 divbuf_2/a_20190_n840# divbuf_2/a_20190_n1540# 0.01fF
C7123 divbuf_2/a_50430_n840# divbuf_2/a_50910_n840# 0.07fF
C7124 divbuf_2/a_50400_n1600# divbuf_2/a_50430_n1540# 0.19fF
C7125 divbuf_1/a_9732_n240# divbuf_1/a_10212_n240# 0.05fF
C7126 ro_div_0/divbuf_0/a_31682_170# ro_div_0/divbuf_0/a_31682_n240# 0.01fF
C7127 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/a_12282_n240# 0.05fF
C7128 divbuf_3/a_21012_170# divbuf_3/a_21012_n240# 0.01fF
C7129 divbuf_3/a_40412_170# divbuf_3/a_40902_170# 0.07fF
C7130 ro_div_0/divbuf_0/a_23550_n840# ro_div_0/divbuf_0/a_24030_n840# 0.07fF
C7131 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_23550_n1540# 0.19fF
C7132 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7133 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C7134 divbuf_3/a_3422_n240# divbuf_3/OUT3 0.07fF
C7135 divbuf_3/a_12960_n1600# divbuf_3/a_12990_n1540# 0.19fF
C7136 divbuf_3/a_12990_n840# divbuf_3/a_13470_n840# 0.07fF
C7137 divbuf_1/a_22110_n840# divbuf_1/a_22590_n840# 0.07fF
C7138 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_21630_n840# 0.04fF
C7139 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/OUT3 0.19fF
C7140 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C7141 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C7142 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/OUT3 0.19fF
C7143 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_26910_n840# 0.04fF
C7144 divbuf_1/a_44670_n840# divbuf_1/a_44670_n1540# 0.01fF
C7145 divbuf_0/a_6240_n1600# divbuf_0/a_6720_n1600# 0.26fF
C7146 pll_full_0/divbuf_0/a_480_n1600# pll_full_0/divbuf_0/a_960_n1600# 0.26fF
C7147 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n1540# 0.19fF
C7148 divbuf_0/a_59550_n840# divbuf_0/a_60030_n840# 0.07fF
C7149 divbuf_0/a_29310_n840# divbuf_0/a_29310_n1540# 0.01fF
C7150 pll_full_0/divbuf_0/a_23550_n840# pll_full_0/divbuf_0/a_23550_n1540# 0.01fF
C7151 pll_full_0/divbuf_0/a_53790_n840# pll_full_0/divbuf_0/a_54270_n840# 0.07fF
C7152 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_53790_n1540# 0.19fF
C7153 pd_div_0/divbuf_0/a_19072_170# pd_div_0/divbuf_0/a_19072_n240# 0.01fF
C7154 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/a_38962_170# 0.07fF
C7155 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C7156 pll_full_0/divbuf_1/a_3912_n240# pll_full_0/divbuf_1/a_4392_n240# 0.05fF
C7157 pll_full_0/divbuf_1/a_24412_170# pll_full_0/divbuf_1/a_24412_n240# 0.01fF
C7158 divbuf_3/a_2880_n1600# divbuf_3/OUT2 0.00fF
C7159 divbuf_1/a_18582_170# divbuf_1/OUT4 0.19fF
C7160 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7161 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11070_n1540# 0.19fF
C7162 pd_div_0/divbuf_0/a_11070_n840# pd_div_0/divbuf_0/a_11550_n840# 0.07fF
C7163 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/clk 0.14fF
C7164 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C7165 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/Out 0.01fF
C7166 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/a3 0.13fF
C7167 pll_full_0/divbuf_1/a_16350_n840# pll_full_0/divbuf_1/a_16830_n840# 0.07fF
C7168 pll_full_0/divbuf_1/a_10212_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C7169 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16350_n1540# 0.19fF
C7170 divbuf_2/a_36960_n1600# divbuf_2/a_37440_n1600# 0.26fF
C7171 divbuf_2/a_27802_n240# divbuf_2/a_27870_n840# 0.04fF
C7172 pd_div_0/divbuf_0/OUT4 pd_div_0/divbuf_0/OUT5 0.26fF
C7173 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C7174 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C7175 divbuf_0/a_17122_n240# divbuf_0/a_16830_n840# 0.00fF
C7176 pll_full_0/divbuf_0/a_11312_n240# pll_full_0/divbuf_0/a_11070_n840# 0.02fF
C7177 divbuf_2/a_29310_n1540# divbuf_2/a_29790_n1540# 0.11fF
C7178 divbuf_2/a_60030_n840# divbuf_2/a_60030_n1540# 0.01fF
C7179 divbuf_1/a_8640_n1600# divbuf_1/a_9120_n1600# 0.26fF
C7180 ro_div_0/divbuf_0/a_10080_n1600# ro_div_0/divbuf_0/a_10560_n1600# 0.26fF
C7181 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/OUT3 0.03fF
C7182 ro_div_0/divbuf_0/a_33150_n840# ro_div_0/divbuf_0/a_33150_n1540# 0.01fF
C7183 ro_div_0/divbuf_0/a_2430_n1540# ro_div_0/divbuf_0/a_2910_n1540# 0.11fF
C7184 divbuf_3/a_22590_n840# divbuf_3/a_22590_n1540# 0.01fF
C7185 divbuf_3/a_52830_n840# divbuf_3/a_53310_n840# 0.07fF
C7186 divbuf_3/a_52800_n1600# divbuf_3/a_52830_n1540# 0.19fF
C7187 divbuf_1/a_990_n1540# divbuf_1/a_1470_n1540# 0.11fF
C7188 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7189 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C7190 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C7191 divbuf_2/a_9242_170# divbuf_2/OUT3 0.19fF
C7192 divbuf_2/a_26880_n1600# divbuf_2/a_26910_n840# 0.04fF
C7193 pd_div_0/divider_0/tspc_0/Z1 pd_div_0/divider_0/nor_1/A 0.03fF
C7194 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C7195 divbuf_0/a_46080_n1600# divbuf_0/a_46560_n1600# 0.26fF
C7196 divbuf_0/a_9732_170# divbuf_0/OUT3 0.19fF
C7197 divbuf_0/a_37022_n240# divbuf_0/a_36990_n840# 0.05fF
C7198 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C7199 gnd pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.94fF
C7200 pll_full_0/divbuf_0/a_40320_n1600# pll_full_0/divbuf_0/a_40800_n1600# 0.26fF
C7201 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/a_31230_n840# 0.05fF
C7202 divbuf_0/a_38430_n1540# divbuf_0/a_38910_n1540# 0.11fF
C7203 pll_full_0/divbuf_0/a_32670_n1540# pll_full_0/divbuf_0/a_33150_n1540# 0.11fF
C7204 pd_div_0/divbuf_0/a_39442_n240# pd_div_0/divbuf_0/a_39932_n240# 0.04fF
C7205 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/OUT5 0.03fF
C7206 divbuf_2/a_3912_n240# divbuf_2/a_4392_n240# 0.05fF
C7207 divbuf_2/a_24412_170# divbuf_2/a_24412_n240# 0.01fF
C7208 pll_full_0/divbuf_1/a_2880_n1600# pll_full_0/divbuf_1/a_3360_n1600# 0.26fF
C7209 divbuf_1/a_19562_n240# divbuf_1/OUT4 0.04fF
C7210 pd_div_0/divbuf_0/a_20670_n840# pd_div_0/divbuf_0/a_20670_n1540# 0.01fF
C7211 pd_div_0/divbuf_0/a_50910_n840# pd_div_0/divbuf_0/a_51390_n840# 0.07fF
C7212 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_50910_n1540# 0.19fF
C7213 divbuf_0/a_13252_170# divbuf_0/a_13252_n240# 0.01fF
C7214 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56190_n1540# 0.19fF
C7215 pll_full_0/divbuf_1/a_25950_n840# pll_full_0/divbuf_1/a_25950_n1540# 0.01fF
C7216 pll_full_0/divbuf_1/a_56190_n840# pll_full_0/divbuf_1/a_56670_n840# 0.07fF
C7217 divbuf_2/a_16350_n840# divbuf_2/a_16830_n840# 0.07fF
C7218 divbuf_2/a_10212_n240# divbuf_2/OUT3 0.04fF
C7219 divbuf_2/a_16320_n1600# divbuf_2/a_16350_n1540# 0.19fF
C7220 divbuf_1/a_7792_170# divbuf_1/a_7792_n240# 0.01fF
C7221 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/a_18582_170# 0.07fF
C7222 divbuf_0/a_36000_n1600# divbuf_0/a_36030_n840# 0.04fF
C7223 divbuf_0/a_27802_170# divbuf_0/OUT4 0.19fF
C7224 pll_full_0/divbuf_0/a_17612_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7225 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30270_n840# 0.04fF
C7226 divbuf_3/a_5362_170# divbuf_3/a_5852_170# 0.07fF
C7227 divbuf_1/a_39442_n240# divbuf_1/a_39390_n840# 0.04fF
C7228 divbuf_1/a_48480_n1600# divbuf_1/a_48960_n1600# 0.26fF
C7229 ro_div_0/divbuf_0/a_3912_170# ro_div_0/divbuf_0/OUT3 0.19fF
C7230 ro_div_0/divbuf_0/a_49920_n1600# ro_div_0/divbuf_0/a_50400_n1600# 0.26fF
C7231 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/a_40830_n840# 0.03fF
C7232 divbuf_3/a_39360_n1600# divbuf_3/a_39840_n1600# 0.26fF
C7233 divbuf_3/a_30232_n240# divbuf_3/a_30270_n840# 0.05fF
C7234 ro_div_0/divbuf_0/a_42270_n1540# ro_div_0/divbuf_0/a_42750_n1540# 0.11fF
C7235 divbuf_3/a_31710_n1540# divbuf_3/a_32190_n1540# 0.11fF
C7236 pll_full_0/divbuf_1/a_13742_n240# pll_full_0/divbuf_1/a_13470_n840# 0.01fF
C7237 divbuf_1/a_40800_n1600# divbuf_1/a_40830_n1540# 0.19fF
C7238 divbuf_0/a_33622_170# divbuf_0/a_33622_n240# 0.01fF
C7239 divbuf_0/a_13742_n240# divbuf_0/a_14222_n240# 0.05fF
C7240 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/a_7792_n240# 0.04fF
C7241 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/a_27802_n240# 0.01fF
C7242 divbuf_2/a_9120_n1600# divbuf_2/OUT3 0.00fF
C7243 divbuf_0/a_28772_n240# divbuf_0/OUT4 0.04fF
C7244 ro_div_0/divbuf_0/a_18092_170# ro_div_0/divbuf_0/a_18092_n240# 0.01fF
C7245 divbuf_0/a_25470_n840# divbuf_0/a_25950_n840# 0.07fF
C7246 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n1540# 0.19fF
C7247 pll_full_0/divbuf_0/a_19710_n840# pll_full_0/divbuf_0/a_20190_n840# 0.07fF
C7248 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7249 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_19710_n1540# 0.19fF
C7250 divbuf_1/a_38400_n1600# divbuf_1/a_38430_n840# 0.04fF
C7251 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_39870_n840# 0.04fF
C7252 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7253 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/a_9242_170# 0.07fF
C7254 divbuf_3/a_14222_170# divbuf_3/OUT4 0.19fF
C7255 divbuf_3/a_29280_n1600# divbuf_3/a_29310_n840# 0.04fF
C7256 divbuf_1/a_32670_n1540# divbuf_1/a_33150_n1540# 0.11fF
C7257 divbuf_2/a_2880_n1600# divbuf_2/a_3360_n1600# 0.26fF
C7258 pd_div_0/divbuf_0/a_37440_n1600# pd_div_0/divbuf_0/a_37920_n1600# 0.26fF
C7259 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/a_28350_n840# 0.04fF
C7260 pll_full_0/divbuf_1/a_42720_n1600# pll_full_0/divbuf_1/a_43200_n1600# 0.26fF
C7261 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/a_33630_n840# 0.06fF
C7262 pd_div_0/divbuf_0/a_29790_n1540# pd_div_0/divbuf_0/a_30270_n1540# 0.11fF
C7263 pd_div_0/divbuf_0/a_60510_n840# pd_div_0/divbuf_0/a_60510_n1540# 0.01fF
C7264 pll_full_0/divbuf_1/a_35070_n1540# pll_full_0/divbuf_1/a_35550_n1540# 0.11fF
C7265 divbuf_2/a_56160_n1600# divbuf_2/a_56190_n1540# 0.19fF
C7266 divbuf_2/a_25950_n840# divbuf_2/a_25950_n1540# 0.01fF
C7267 divbuf_2/a_56190_n840# divbuf_2/a_56670_n840# 0.07fF
C7268 divbuf_1/a_16152_n240# divbuf_1/a_16642_n240# 0.04fF
C7269 divbuf_1/a_36052_170# divbuf_1/a_36052_n240# 0.01fF
C7270 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/a_37502_n240# 0.01fF
C7271 ro_div_0/divbuf_0/a_17612_n240# ro_div_0/divbuf_0/a_18092_n240# 0.05fF
C7272 divbuf_3/a_26832_170# divbuf_3/a_26832_n240# 0.01fF
C7273 divbuf_3/a_6332_n240# divbuf_3/a_6822_n240# 0.04fF
C7274 divbuf_1/a_27870_n840# divbuf_1/a_28350_n840# 0.07fF
C7275 pd_div_0/divbuf_0/a_4882_170# pd_div_0/divbuf_0/a_4882_n240# 0.01fF
C7276 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29310_n1540# 0.19fF
C7277 ro_div_0/divbuf_0/a_29310_n840# ro_div_0/divbuf_0/a_29790_n840# 0.07fF
C7278 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7279 divbuf_3/a_18750_n840# divbuf_3/a_19230_n840# 0.07fF
C7280 divbuf_3/a_15182_n240# divbuf_3/OUT4 0.04fF
C7281 divbuf_3/a_18720_n1600# divbuf_3/a_18750_n1540# 0.19fF
C7282 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C7283 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C7284 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/tspc_1/Z3 0.38fF
C7285 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z2 1.07fF
C7286 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/switch_1/vin 0.20fF
C7287 divbuf_2/a_13742_n240# divbuf_2/a_13470_n840# 0.01fF
C7288 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27390_n840# 0.04fF
C7289 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/OUT3 0.19fF
C7290 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7291 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_32670_n840# 0.04fF
C7292 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C7293 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C7294 divbuf_1/a_50430_n840# divbuf_1/a_50430_n1540# 0.01fF
C7295 divbuf_0/a_12000_n1600# divbuf_0/a_12480_n1600# 0.26fF
C7296 pll_full_0/divbuf_0/a_6240_n1600# pll_full_0/divbuf_0/a_6720_n1600# 0.26fF
C7297 divbuf_0/a_35070_n840# divbuf_0/a_35070_n1540# 0.01fF
C7298 divbuf_0/a_4350_n1540# divbuf_0/a_4830_n1540# 0.11fF
C7299 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_59550_n1540# 0.19fF
C7300 pll_full_0/divbuf_0/a_29310_n840# pll_full_0/divbuf_0/a_29310_n1540# 0.01fF
C7301 pll_full_0/divbuf_0/a_59550_n840# pll_full_0/divbuf_0/a_60030_n840# 0.07fF
C7302 pd_div_0/divbuf_0/a_4392_n240# pd_div_0/divbuf_0/a_4882_n240# 0.04fF
C7303 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/a_24892_n240# 0.01fF
C7304 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C7305 pll_full_0/divbuf_1/a_9732_n240# pll_full_0/divbuf_1/a_10212_n240# 0.05fF
C7306 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/a_30232_n240# 0.01fF
C7307 divbuf_3/a_13440_n1600# divbuf_3/OUT4 0.00fF
C7308 divbuf_2/a_8762_170# divbuf_2/a_9242_170# 0.07fF
C7309 divbuf_2/a_42720_n1600# divbuf_2/a_43200_n1600# 0.26fF
C7310 divbuf_2/a_33622_n240# divbuf_2/a_33630_n840# 0.06fF
C7311 pd_div_0/divbuf_0/a_16830_n840# pd_div_0/divbuf_0/a_17310_n840# 0.07fF
C7312 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/OUT4 0.07fF
C7313 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_16830_n1540# 0.19fF
C7314 ro_div_0/divider_0/prescaler_0/tspc_2/D ro_div_0/divider_0/clk 0.29fF
C7315 ro_div_0/divider_0/nor_0/B ro_div_0/divbuf_0/IN 0.30fF
C7316 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z3 0.06fF
C7317 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C7318 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7319 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22110_n1540# 0.19fF
C7320 pll_full_0/divbuf_1/a_22110_n840# pll_full_0/divbuf_1/a_22590_n840# 0.07fF
C7321 divbuf_1/a_32172_170# divbuf_1/a_32652_170# 0.07fF
C7322 divbuf_0/a_1920_n1600# divbuf_0/a_1950_n840# 0.04fF
C7323 pll_full_0/divbuf_0/a_17122_n240# pll_full_0/divbuf_0/a_16830_n840# 0.00fF
C7324 divbuf_2/a_35070_n1540# divbuf_2/a_35550_n1540# 0.11fF
C7325 divbuf_1/a_14400_n1600# divbuf_1/a_14880_n1600# 0.26fF
C7326 divbuf_1/a_4882_n240# divbuf_1/a_4830_n840# 0.04fF
C7327 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/a_6270_n840# 0.04fF
C7328 ro_div_0/divbuf_0/a_15840_n1600# ro_div_0/divbuf_0/a_16320_n1600# 0.26fF
C7329 divbuf_3/a_5280_n1600# divbuf_3/a_5760_n1600# 0.26fF
C7330 ro_div_0/divbuf_0/a_38910_n840# ro_div_0/divbuf_0/a_38910_n1540# 0.01fF
C7331 ro_div_0/divbuf_0/a_8190_n1540# ro_div_0/divbuf_0/a_8670_n1540# 0.11fF
C7332 divbuf_3/a_58560_n1600# divbuf_3/a_58590_n1540# 0.19fF
C7333 divbuf_3/a_28350_n840# divbuf_3/a_28350_n1540# 0.01fF
C7334 divbuf_3/a_58590_n840# divbuf_3/a_59070_n840# 0.07fF
C7335 divbuf_1/a_6750_n1540# divbuf_1/a_7230_n1540# 0.11fF
C7336 divbuf_1/a_26832_170# divbuf_1/OUT4 0.19fF
C7337 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C7338 divbuf_0/a_16152_170# divbuf_0/a_16642_170# 0.07fF
C7339 divbuf_0/a_9732_170# divbuf_0/a_9732_n240# 0.01fF
C7340 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C7341 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C7342 divbuf_2/a_21012_170# divbuf_2/OUT4 0.19fF
C7343 divbuf_2/a_32640_n1600# divbuf_2/a_32670_n840# 0.04fF
C7344 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/prescaler_0/Out 0.12fF
C7345 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C7346 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 0.61fF
C7347 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C7348 ro_div_0/ro_complete_0/cbank_0/switch_4/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C7349 ro_div_0/ro_complete_0/a5 ro_div_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C7350 divbuf_0/a_51840_n1600# divbuf_0/a_52320_n1600# 0.26fF
C7351 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C7352 gnd pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.22fF
C7353 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C7354 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/a_36990_n840# 0.05fF
C7355 pll_full_0/divbuf_0/a_46080_n1600# pll_full_0/divbuf_0/a_46560_n1600# 0.26fF
C7356 divbuf_1/a_4320_n1600# divbuf_1/a_4350_n840# 0.04fF
C7357 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_5790_n840# 0.04fF
C7358 divbuf_0/a_44190_n1540# divbuf_0/a_44670_n1540# 0.11fF
C7359 pll_full_0/divbuf_0/a_38430_n1540# pll_full_0/divbuf_0/a_38910_n1540# 0.11fF
C7360 divbuf_3/a_16152_n240# divbuf_3/a_15870_n840# 0.01fF
C7361 pd_div_0/divbuf_0/a_3360_n1600# pd_div_0/divbuf_0/a_3840_n1600# 0.26fF
C7362 divbuf_2/a_9732_n240# divbuf_2/a_10212_n240# 0.05fF
C7363 divbuf_2/a_30232_170# divbuf_2/a_30232_n240# 0.01fF
C7364 pll_full_0/divbuf_1/a_8640_n1600# pll_full_0/divbuf_1/a_9120_n1600# 0.26fF
C7365 divbuf_1/a_31202_n240# divbuf_1/OUT4 0.04fF
C7366 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_56670_n1540# 0.19fF
C7367 pd_div_0/divbuf_0/a_26430_n840# pd_div_0/divbuf_0/a_26430_n1540# 0.01fF
C7368 pd_div_0/divbuf_0/a_56670_n840# pd_div_0/divbuf_0/a_57150_n840# 0.07fF
C7369 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/OUT2 0.02fF
C7370 pll_full_0/divbuf_1/a_990_n1540# pll_full_0/divbuf_1/a_1470_n1540# 0.11fF
C7371 pll_full_0/divbuf_1/a_31710_n840# pll_full_0/divbuf_1/a_31710_n1540# 0.01fF
C7372 divbuf_2/a_21982_n240# divbuf_2/OUT4 0.04fF
C7373 divbuf_2/a_22080_n1600# divbuf_2/a_22110_n1540# 0.19fF
C7374 divbuf_2/a_22110_n840# divbuf_2/a_22590_n840# 0.07fF
C7375 divbuf_1/a_8762_170# divbuf_1/a_9242_170# 0.07fF
C7376 divbuf_1/a_9732_170# divbuf_1/a_9732_n240# 0.01fF
C7377 pd_div_0/divider_0/and_0/B pd_div_0/divider_0/and_0/Z1 0.07fF
C7378 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/a_22952_170# 0.07fF
C7379 divbuf_0/a_41760_n1600# divbuf_0/a_41790_n840# 0.04fF
C7380 divbuf_0/a_39442_170# divbuf_0/OUT4 0.19fF
C7381 pll_full_0/divbuf_0/a_27802_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7382 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36030_n840# 0.04fF
C7383 divbuf_3/a_11802_170# divbuf_3/a_12282_170# 0.07fF
C7384 divbuf_1/a_54240_n1600# divbuf_1/a_54720_n1600# 0.26fF
C7385 ro_div_0/divbuf_0/a_55680_n1600# ro_div_0/divbuf_0/a_56160_n1600# 0.26fF
C7386 divbuf_3/a_45120_n1600# divbuf_3/a_45600_n1600# 0.26fF
C7387 divbuf_3/a_36052_n240# divbuf_3/a_36030_n840# 0.05fF
C7388 ro_div_0/divbuf_0/a_48030_n1540# ro_div_0/divbuf_0/a_48510_n1540# 0.11fF
C7389 divbuf_3/a_37470_n1540# divbuf_3/a_37950_n1540# 0.11fF
C7390 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/a_13950_n840# 0.01fF
C7391 divbuf_1/a_46560_n1600# divbuf_1/a_46590_n1540# 0.19fF
C7392 divbuf_1/a_16350_n840# divbuf_1/a_16350_n1540# 0.01fF
C7393 divbuf_0/a_19562_n240# divbuf_0/a_20042_n240# 0.05fF
C7394 divbuf_0/a_39442_170# divbuf_0/a_39442_n240# 0.01fF
C7395 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/a_14222_n240# 0.05fF
C7396 pll_full_0/divbuf_0/a_33622_170# pll_full_0/divbuf_0/a_33622_n240# 0.01fF
C7397 divbuf_2/a_20160_n1600# divbuf_2/OUT4 0.00fF
C7398 divbuf_1/a_20042_170# divbuf_1/a_20042_n240# 0.01fF
C7399 divbuf_0/a_40412_n240# divbuf_0/OUT4 0.04fF
C7400 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n1540# 0.19fF
C7401 divbuf_0/a_31230_n840# divbuf_0/a_31710_n840# 0.07fF
C7402 divbuf_0/a_990_n840# divbuf_0/a_990_n1540# 0.01fF
C7403 pll_full_0/divbuf_0/a_28772_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7404 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25470_n1540# 0.19fF
C7405 pll_full_0/divbuf_0/a_25470_n840# pll_full_0/divbuf_0/a_25950_n840# 0.07fF
C7406 divbuf_1/a_44160_n1600# divbuf_1/a_44190_n840# 0.04fF
C7407 pd_div_0/divbuf_0/a_6822_170# pd_div_0/divbuf_0/a_7302_170# 0.07fF
C7408 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_12282_170# 0.07fF
C7409 ro_div_0/ro_complete_0/a1 ro_div_0/divider_0/clk 0.05fF
C7410 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_45630_n840# 0.04fF
C7411 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C7412 pll_full_0/divbuf_1/a_15182_170# pll_full_0/divbuf_1/a_15672_170# 0.07fF
C7413 divbuf_3/a_25862_170# divbuf_3/OUT4 0.19fF
C7414 divbuf_3/a_35040_n1600# divbuf_3/a_35070_n840# 0.04fF
C7415 divbuf_1/a_38430_n1540# divbuf_1/a_38910_n1540# 0.11fF
C7416 divbuf_2/a_8640_n1600# divbuf_2/a_9120_n1600# 0.26fF
C7417 pd_div_0/divbuf_0/a_43200_n1600# pd_div_0/divbuf_0/a_43680_n1600# 0.26fF
C7418 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/a_34110_n840# 0.06fF
C7419 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/a_39390_n840# 0.04fF
C7420 pll_full_0/divbuf_1/a_48480_n1600# pll_full_0/divbuf_1/a_48960_n1600# 0.26fF
C7421 pd_div_0/divbuf_0/a_35550_n1540# pd_div_0/divbuf_0/a_36030_n1540# 0.11fF
C7422 pll_full_0/divbuf_1/a_40830_n1540# pll_full_0/divbuf_1/a_41310_n1540# 0.11fF
C7423 divbuf_2/a_510_n840# divbuf_2/OUT2 0.02fF
C7424 divbuf_2/a_990_n1540# divbuf_2/a_1470_n1540# 0.11fF
C7425 divbuf_2/a_31710_n840# divbuf_2/a_31710_n1540# 0.01fF
C7426 divbuf_1/a_21982_n240# divbuf_1/a_22472_n240# 0.04fF
C7427 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/a_23922_n240# 0.05fF
C7428 divbuf_3/a_32652_170# divbuf_3/a_32652_n240# 0.01fF
C7429 divbuf_3/a_12772_n240# divbuf_3/a_13252_n240# 0.05fF
C7430 divbuf_1/a_3390_n840# divbuf_1/a_3390_n1540# 0.01fF
C7431 divbuf_1/a_33630_n840# divbuf_1/a_34110_n840# 0.07fF
C7432 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/a_14222_n240# 0.01fF
C7433 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/a_8762_n240# 0.01fF
C7434 ro_div_0/divbuf_0/a_35070_n840# ro_div_0/divbuf_0/a_35550_n840# 0.07fF
C7435 ro_div_0/divbuf_0/a_4830_n840# ro_div_0/divbuf_0/a_4830_n1540# 0.01fF
C7436 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35070_n1540# 0.19fF
C7437 divbuf_3/a_26832_n240# divbuf_3/OUT4 0.04fF
C7438 divbuf_3/a_24480_n1600# divbuf_3/a_24510_n1540# 0.19fF
C7439 divbuf_3/a_24510_n840# divbuf_3/a_24990_n840# 0.07fF
C7440 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C7441 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C7442 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/and_0/OUT 0.06fF
C7443 ro_div_0/divider_0/tspc_1/Z2 ro_div_0/divider_0/tspc_1/Z4 0.36fF
C7444 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7445 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33150_n840# 0.04fF
C7446 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7447 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38430_n840# 0.04fF
C7448 divbuf_1/a_56190_n840# divbuf_1/a_56190_n1540# 0.01fF
C7449 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C7450 divbuf_0/a_8272_n240# divbuf_0/a_8190_n840# 0.03fF
C7451 divbuf_0/a_17760_n1600# divbuf_0/a_18240_n1600# 0.26fF
C7452 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/a_12480_n1600# 0.26fF
C7453 divbuf_0/a_40830_n840# divbuf_0/a_40830_n1540# 0.01fF
C7454 divbuf_0/a_10110_n1540# divbuf_0/a_10590_n1540# 0.11fF
C7455 pll_full_0/divbuf_0/a_4350_n1540# pll_full_0/divbuf_0/a_4830_n1540# 0.11fF
C7456 pll_full_0/divbuf_0/a_35070_n840# pll_full_0/divbuf_0/a_35070_n1540# 0.01fF
C7457 divbuf_3/a_492_n240# divbuf_3/a_510_n840# 0.00fF
C7458 pd_div_0/divbuf_0/a_30712_170# pd_div_0/divbuf_0/a_30712_n240# 0.01fF
C7459 pll_full_0/divbuf_1/a_16152_n240# pll_full_0/divbuf_1/a_16642_n240# 0.04fF
C7460 pll_full_0/divbuf_1/a_36052_170# pll_full_0/divbuf_1/a_36052_n240# 0.01fF
C7461 divbuf_3/a_24960_n1600# divbuf_3/OUT4 0.00fF
C7462 divbuf_2/a_15182_170# divbuf_2/a_15672_170# 0.07fF
C7463 ro_div_0/divider_0/and_0/out1 ro_div_0/divider_0/and_0/Z1 0.36fF
C7464 divbuf_2/a_39442_n240# divbuf_2/a_39390_n840# 0.04fF
C7465 divbuf_2/a_48480_n1600# divbuf_2/a_48960_n1600# 0.26fF
C7466 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7467 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_22590_n1540# 0.19fF
C7468 pd_div_0/divbuf_0/a_22590_n840# pd_div_0/divbuf_0/a_23070_n840# 0.07fF
C7469 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7470 pll_full_0/divbuf_1/a_27870_n840# pll_full_0/divbuf_1/a_28350_n840# 0.07fF
C7471 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_27870_n1540# 0.19fF
C7472 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C7473 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z1 0.00fF
C7474 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C7475 filter_0/a_4216_n5230# filter_0/v 0.19fF
C7476 divbuf_0/a_7680_n1600# divbuf_0/a_7710_n840# 0.04fF
C7477 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.04fF
C7478 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_1950_n840# 0.04fF
C7479 divbuf_2/a_40830_n1540# divbuf_2/a_41310_n1540# 0.11fF
C7480 divbuf_1/a_20160_n1600# divbuf_1/a_20640_n1600# 0.26fF
C7481 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12510_n840# 0.02fF
C7482 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/a_22080_n1600# 0.26fF
C7483 divbuf_3/a_11040_n1600# divbuf_3/a_11520_n1600# 0.26fF
C7484 ro_div_0/divbuf_0/a_44670_n840# ro_div_0/divbuf_0/a_44670_n1540# 0.01fF
C7485 ro_div_0/divbuf_0/a_13950_n1540# ro_div_0/divbuf_0/a_14430_n1540# 0.11fF
C7486 divbuf_3/a_3390_n1540# divbuf_3/a_3870_n1540# 0.11fF
C7487 divbuf_3/a_34110_n840# divbuf_3/a_34110_n1540# 0.01fF
C7488 divbuf_1/a_12510_n1540# divbuf_1/a_12990_n1540# 0.11fF
C7489 divbuf_2/a_32652_170# divbuf_2/OUT4 0.19fF
C7490 divbuf_2/a_38400_n1600# divbuf_2/a_38430_n840# 0.04fF
C7491 divbuf_1/a_2322_n240# divbuf_1/OUT2 0.04fF
C7492 divbuf_1/a_41382_170# divbuf_1/OUT5 0.07fF
C7493 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7494 divbuf_0/a_24412_170# divbuf_0/a_24892_170# 0.07fF
C7495 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C7496 pll_full_0/divbuf_0/a_5362_170# pll_full_0/divbuf_0/a_5362_n240# 0.01fF
C7497 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/clk 0.12fF
C7498 divbuf_0/a_57600_n1600# divbuf_0/a_58080_n1600# 0.26fF
C7499 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C7500 gnd pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C7501 pll_full_0/divbuf_0/a_51840_n1600# pll_full_0/divbuf_0/a_52320_n1600# 0.26fF
C7502 divbuf_1/a_10080_n1600# divbuf_1/a_10110_n840# 0.04fF
C7503 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_11550_n840# 0.04fF
C7504 divbuf_0/a_49950_n1540# divbuf_0/a_50430_n1540# 0.11fF
C7505 pll_full_0/divbuf_0/a_44190_n1540# pll_full_0/divbuf_0/a_44670_n1540# 0.11fF
C7506 divbuf_3/a_960_n1600# divbuf_3/a_990_n840# 0.04fF
C7507 pd_div_0/divbuf_0/a_9120_n1600# pd_div_0/divbuf_0/a_9600_n1600# 0.26fF
C7508 divbuf_2/a_16152_n240# divbuf_2/a_16642_n240# 0.04fF
C7509 divbuf_2/a_36052_170# divbuf_2/a_36052_n240# 0.01fF
C7510 pll_full_0/divbuf_1/a_14400_n1600# pll_full_0/divbuf_1/a_14880_n1600# 0.26fF
C7511 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/a_4830_n840# 0.04fF
C7512 divbuf_1/a_0_n1600# divbuf_1/OUT 0.26fF
C7513 divbuf_1/a_1920_n1600# divbuf_1/OUT2 0.00fF
C7514 pd_div_0/divbuf_0/a_1470_n1540# pd_div_0/divbuf_0/a_1950_n1540# 0.11fF
C7515 pd_div_0/divbuf_0/a_32190_n840# pd_div_0/divbuf_0/a_32190_n1540# 0.01fF
C7516 pd_div_0/divbuf_0/a_60480_n1600# pd_div_0/divbuf_0/OUT5 0.26fF
C7517 pll_full_0/divbuf_1/a_6750_n1540# pll_full_0/divbuf_1/a_7230_n1540# 0.11fF
C7518 pll_full_0/divbuf_1/a_37470_n840# pll_full_0/divbuf_1/a_37470_n1540# 0.01fF
C7519 divbuf_2/a_33622_n240# divbuf_2/OUT4 0.04fF
C7520 divbuf_2/a_27870_n840# divbuf_2/a_28350_n840# 0.07fF
C7521 divbuf_2/a_27840_n1600# divbuf_2/a_27870_n1540# 0.19fF
C7522 divbuf_1/a_23442_170# divbuf_1/a_23922_170# 0.07fF
C7523 divbuf_1/a_492_n240# divbuf_1/a_480_n1600# 0.00fF
C7524 divbuf_1/a_33142_170# divbuf_1/a_33142_n240# 0.01fF
C7525 ro_div_0/divbuf_0/a_28292_170# ro_div_0/divbuf_0/a_28772_170# 0.07fF
C7526 divbuf_0/a_47520_n1600# divbuf_0/a_47550_n840# 0.04fF
C7527 divbuf_0/a_11802_n240# divbuf_0/OUT4 0.04fF
C7528 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7529 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_41790_n840# 0.04fF
C7530 divbuf_3/a_17612_170# divbuf_3/a_18092_170# 0.07fF
C7531 divbuf_1/a_60000_n1600# divbuf_1/a_60480_n1600# 0.26fF
C7532 pd_div_0/pd_0/DOWN pd_div_0/pd_0/tspc_r_0/z5 0.03fF
C7533 pd_div_0/pd_0/tspc_r_0/Z2 pd_div_0/pd_0/R 0.21fF
C7534 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/a_1470_n840# 0.07fF
C7535 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_990_n1540# 0.19fF
C7536 divbuf_3/a_50880_n1600# divbuf_3/a_51360_n1600# 0.26fF
C7537 ro_div_0/divbuf_0/a_53790_n1540# ro_div_0/divbuf_0/a_54270_n1540# 0.11fF
C7538 divbuf_3/a_43230_n1540# divbuf_3/a_43710_n1540# 0.11fF
C7539 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4350_n840# 0.04fF
C7540 divbuf_1/a_22110_n840# divbuf_1/a_22110_n1540# 0.01fF
C7541 divbuf_1/a_52320_n1600# divbuf_1/a_52350_n1540# 0.19fF
C7542 divbuf_0/a_25382_n240# divbuf_0/a_25862_n240# 0.05fF
C7543 pll_full_0/divbuf_0/a_39442_170# pll_full_0/divbuf_0/a_39442_n240# 0.01fF
C7544 pll_full_0/divbuf_0/a_19562_n240# pll_full_0/divbuf_0/a_20042_n240# 0.05fF
C7545 divbuf_2/a_31680_n1600# divbuf_2/OUT4 0.00fF
C7546 divbuf_1/a_25862_170# divbuf_1/a_25862_n240# 0.01fF
C7547 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n1540# 0.19fF
C7548 divbuf_0/a_36990_n840# divbuf_0/a_37470_n840# 0.07fF
C7549 divbuf_0/a_6750_n840# divbuf_0/a_6750_n1540# 0.01fF
C7550 divbuf_0/a_10560_n1600# divbuf_0/OUT3 0.01fF
C7551 pll_full_0/divbuf_0/a_40412_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7552 pll_full_0/divbuf_0/a_990_n840# pll_full_0/divbuf_0/a_990_n1540# 0.01fF
C7553 pll_full_0/divbuf_0/a_31230_n840# pll_full_0/divbuf_0/a_31710_n840# 0.07fF
C7554 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31230_n1540# 0.19fF
C7555 divbuf_1/a_49920_n1600# divbuf_1/a_49950_n840# 0.04fF
C7556 pd_div_0/divbuf_0/a_15672_170# pd_div_0/divbuf_0/a_16152_170# 0.07fF
C7557 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51390_n840# 0.04fF
C7558 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7559 pll_full_0/divbuf_1/a_21012_170# pll_full_0/divbuf_1/a_21502_170# 0.07fF
C7560 divbuf_3/a_37502_170# divbuf_3/OUT4 0.19fF
C7561 divbuf_3/a_40800_n1600# divbuf_3/a_40830_n840# 0.04fF
C7562 divbuf_1/a_44190_n1540# divbuf_1/a_44670_n1540# 0.11fF
C7563 divbuf_2/a_14400_n1600# divbuf_2/a_14880_n1600# 0.26fF
C7564 divbuf_2/a_4882_n240# divbuf_2/a_4830_n840# 0.04fF
C7565 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/a_39870_n840# 0.04fF
C7566 pd_div_0/divbuf_0/a_48960_n1600# pd_div_0/divbuf_0/a_49440_n1600# 0.26fF
C7567 pd_div_0/divbuf_0/a_1842_170# pd_div_0/divbuf_0/OUT2 0.19fF
C7568 pll_full_0/divbuf_1/a_54240_n1600# pll_full_0/divbuf_1/a_54720_n1600# 0.26fF
C7569 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/OUT3 0.19fF
C7570 pd_div_0/divbuf_0/a_41310_n1540# pd_div_0/divbuf_0/a_41790_n1540# 0.11fF
C7571 pll_full_0/divbuf_1/a_46590_n1540# pll_full_0/divbuf_1/a_47070_n1540# 0.11fF
C7572 divbuf_2/a_6750_n1540# divbuf_2/a_7230_n1540# 0.11fF
C7573 divbuf_2/a_37470_n840# divbuf_2/a_37470_n1540# 0.01fF
C7574 divbuf_1/a_27802_n240# divbuf_1/a_28292_n240# 0.04fF
C7575 ro_div_0/divbuf_0/a_29262_n240# ro_div_0/divbuf_0/a_29742_n240# 0.05fF
C7576 divbuf_3/a_38472_170# divbuf_3/a_38472_n240# 0.01fF
C7577 divbuf_3/a_18582_n240# divbuf_3/a_19072_n240# 0.04fF
C7578 divbuf_1/a_9150_n840# divbuf_1/a_9150_n1540# 0.01fF
C7579 divbuf_1/a_39390_n840# divbuf_1/a_39870_n840# 0.07fF
C7580 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_40830_n1540# 0.19fF
C7581 ro_div_0/divbuf_0/a_40830_n840# ro_div_0/divbuf_0/a_41310_n840# 0.07fF
C7582 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/a_10590_n1540# 0.01fF
C7583 divbuf_3/a_38472_n240# divbuf_3/OUT4 0.04fF
C7584 divbuf_3/a_30270_n840# divbuf_3/a_30750_n840# 0.07fF
C7585 divbuf_3/a_30240_n1600# divbuf_3/a_30270_n1540# 0.19fF
C7586 ro_div_0/divider_0/nor_1/B ro_div_0/divider_0/and_0/A 0.26fF
C7587 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C7588 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C7589 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z1 0.01fF
C7590 divbuf_2/a_4320_n1600# divbuf_2/a_4350_n840# 0.04fF
C7591 divbuf_1/a_4392_170# divbuf_1/OUT3 0.19fF
C7592 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7593 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_38910_n840# 0.04fF
C7594 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C7595 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44190_n840# 0.04fF
C7596 divbuf_0/a_14222_n240# divbuf_0/a_14430_n840# 0.02fF
C7597 pd_0/R pd_0/UP 0.45fF
C7598 divbuf_0/a_23520_n1600# divbuf_0/a_24000_n1600# 0.26fF
C7599 pll_full_0/divbuf_0/a_17760_n1600# pll_full_0/divbuf_0/a_18240_n1600# 0.26fF
C7600 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/a_8190_n840# 0.03fF
C7601 divbuf_0/a_46590_n840# divbuf_0/a_46590_n1540# 0.01fF
C7602 divbuf_0/a_15870_n1540# divbuf_0/a_16350_n1540# 0.11fF
C7603 pll_full_0/divbuf_0/a_10110_n1540# pll_full_0/divbuf_0/a_10590_n1540# 0.11fF
C7604 pll_full_0/divbuf_0/a_40830_n840# pll_full_0/divbuf_0/a_40830_n1540# 0.01fF
C7605 pd_div_0/divbuf_0/a_16642_n240# pd_div_0/divbuf_0/a_17122_n240# 0.05fF
C7606 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/a_36532_n240# 0.01fF
C7607 pll_full_0/divbuf_1/a_21982_n240# pll_full_0/divbuf_1/a_22472_n240# 0.04fF
C7608 divbuf_3/a_36480_n1600# divbuf_3/OUT4 0.00fF
C7609 divbuf_2/a_21012_170# divbuf_2/a_21502_170# 0.07fF
C7610 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C7611 divbuf_0/a_17122_170# divbuf_0/a_17122_n240# 0.01fF
C7612 divbuf_2/a_54240_n1600# divbuf_2/a_54720_n1600# 0.26fF
C7613 divbuf_2/a_3912_170# divbuf_2/OUT3 0.19fF
C7614 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7615 pd_div_0/divbuf_0/a_28350_n840# pd_div_0/divbuf_0/a_28830_n840# 0.07fF
C7616 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28350_n1540# 0.19fF
C7617 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_33630_n1540# 0.19fF
C7618 pll_full_0/divbuf_1/a_3390_n840# pll_full_0/divbuf_1/a_3390_n1540# 0.01fF
C7619 pll_full_0/divbuf_1/a_33630_n840# pll_full_0/divbuf_1/a_34110_n840# 0.07fF
C7620 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C7621 divbuf_0/a_13440_n1600# divbuf_0/a_13470_n840# 0.04fF
C7622 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C7623 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_7710_n840# 0.04fF
C7624 divbuf_2/a_46590_n1540# divbuf_2/a_47070_n1540# 0.11fF
C7625 divbuf_1/a_25920_n1600# divbuf_1/a_26400_n1600# 0.26fF
C7626 divbuf_1/a_16642_n240# divbuf_1/a_16830_n840# 0.02fF
C7627 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_18270_n840# 0.02fF
C7628 ro_div_0/divbuf_0/a_27360_n1600# ro_div_0/divbuf_0/a_27840_n1600# 0.26fF
C7629 divbuf_3/a_16800_n1600# divbuf_3/a_17280_n1600# 0.26fF
C7630 divbuf_3/a_7302_n240# divbuf_3/a_7230_n840# 0.03fF
C7631 ro_div_0/divbuf_0/a_50430_n840# ro_div_0/divbuf_0/a_50430_n1540# 0.01fF
C7632 ro_div_0/divbuf_0/a_19710_n1540# ro_div_0/divbuf_0/a_20190_n1540# 0.11fF
C7633 divbuf_3/a_9150_n1540# divbuf_3/a_9630_n1540# 0.11fF
C7634 divbuf_3/a_39870_n840# divbuf_3/a_39870_n1540# 0.01fF
C7635 divbuf_2/a_4882_n240# divbuf_2/OUT3 0.04fF
C7636 divbuf_2/a_44160_n1600# divbuf_2/a_44190_n840# 0.04fF
C7637 divbuf_1/a_14222_n240# divbuf_1/OUT4 0.04fF
C7638 divbuf_1/a_18240_n1600# divbuf_1/a_18270_n1540# 0.19fF
C7639 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C7640 divbuf_0/a_30232_170# divbuf_0/a_30712_170# 0.07fF
C7641 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/a_24892_170# 0.07fF
C7642 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/divider_0/tspc_2/Z2 0.01fF
C7643 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/clk 0.60fF
C7644 divbuf_0/a_22472_170# divbuf_0/OUT4 0.19fF
C7645 divbuf_0/a_2910_n840# divbuf_0/a_3390_n840# 0.07fF
C7646 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n1540# 0.19fF
C7647 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_0/Z2 0.11fF
C7648 pll_full_0/divbuf_0/a_12282_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7649 pll_full_0/divbuf_0/a_57600_n1600# pll_full_0/divbuf_0/a_58080_n1600# 0.26fF
C7650 divbuf_1/a_15840_n1600# divbuf_1/a_15870_n840# 0.04fF
C7651 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/OUT3 0.19fF
C7652 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17310_n840# 0.04fF
C7653 divbuf_0/a_55710_n1540# divbuf_0/a_56190_n1540# 0.11fF
C7654 pll_full_0/divbuf_0/a_49950_n1540# pll_full_0/divbuf_0/a_50430_n1540# 0.11fF
C7655 divbuf_3/a_6720_n1600# divbuf_3/a_6750_n840# 0.04fF
C7656 pd_div_0/divbuf_0/a_14880_n1600# pd_div_0/divbuf_0/a_15360_n1600# 0.26fF
C7657 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/a_5310_n840# 0.04fF
C7658 pll_full_0/divbuf_1/a_20160_n1600# pll_full_0/divbuf_1/a_20640_n1600# 0.26fF
C7659 divbuf_2/a_21982_n240# divbuf_2/a_22472_n240# 0.04fF
C7660 divbuf_2/a_33600_n1600# divbuf_2/a_33630_n1540# 0.19fF
C7661 divbuf_2/a_3390_n840# divbuf_2/a_3390_n1540# 0.01fF
C7662 divbuf_2/a_33630_n840# divbuf_2/a_34110_n840# 0.07fF
C7663 divbuf_1/a_12480_n1600# divbuf_1/OUT4 0.00fF
C7664 pd_div_0/divbuf_0/a_7230_n1540# pd_div_0/divbuf_0/a_7710_n1540# 0.11fF
C7665 pd_div_0/divbuf_0/a_37950_n840# pd_div_0/divbuf_0/a_37950_n1540# 0.01fF
C7666 pll_full_0/divbuf_1/a_12510_n1540# pll_full_0/divbuf_1/a_12990_n1540# 0.11fF
C7667 pll_full_0/divbuf_1/a_43230_n840# pll_full_0/divbuf_1/a_43230_n1540# 0.01fF
C7668 divbuf_1/a_29262_170# divbuf_1/a_29742_170# 0.07fF
C7669 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/a_34592_170# 0.07fF
C7670 divbuf_0/a_53280_n1600# divbuf_0/a_53310_n840# 0.04fF
C7671 divbuf_0/a_23442_n240# divbuf_0/OUT4 0.04fF
C7672 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7673 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_47550_n840# 0.04fF
C7674 divbuf_3/a_3422_170# divbuf_3/a_3422_n240# 0.01fF
C7675 divbuf_3/a_23442_170# divbuf_3/a_23922_170# 0.07fF
C7676 divbuf_1/a_5310_n840# divbuf_1/a_5790_n840# 0.07fF
C7677 divbuf_1/a_5280_n1600# divbuf_1/a_5310_n1540# 0.19fF
C7678 pd_div_0/pd_0/DOWN pd_div_0/pd_0/and_pd_0/Z1 0.07fF
C7679 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_6750_n1540# 0.19fF
C7680 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7681 ro_div_0/divbuf_0/a_6750_n840# ro_div_0/divbuf_0/a_7230_n840# 0.07fF
C7682 divbuf_3/a_8762_170# divbuf_3/OUT3 0.19fF
C7683 divbuf_3/a_56640_n1600# divbuf_3/a_57120_n1600# 0.26fF
C7684 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_4830_n840# 0.04fF
C7685 ro_div_0/divbuf_0/a_59550_n1540# ro_div_0/divbuf_0/a_60030_n1540# 0.11fF
C7686 divbuf_3/a_48990_n1540# divbuf_3/a_49470_n1540# 0.11fF
C7687 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10110_n840# 0.04fF
C7688 divbuf_1/a_58080_n1600# divbuf_1/a_58110_n1540# 0.19fF
C7689 divbuf_1/a_27870_n840# divbuf_1/a_27870_n1540# 0.01fF
C7690 divbuf_0/a_31202_n240# divbuf_0/a_31682_n240# 0.05fF
C7691 pll_full_0/divbuf_1/a_510_n1540# pll_full_0/divbuf_1/OUT 0.11fF
C7692 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/a_25862_n240# 0.05fF
C7693 divbuf_0/a_21600_n1600# divbuf_0/OUT4 0.01fF
C7694 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n1540# 0.19fF
C7695 divbuf_0/a_42750_n840# divbuf_0/a_43230_n840# 0.07fF
C7696 divbuf_0/a_12510_n840# divbuf_0/a_12510_n1540# 0.01fF
C7697 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_36990_n1540# 0.19fF
C7698 pll_full_0/divbuf_0/a_10560_n1600# pll_full_0/divbuf_0/OUT3 0.01fF
C7699 pll_full_0/divbuf_0/a_6750_n840# pll_full_0/divbuf_0/a_6750_n1540# 0.01fF
C7700 pll_full_0/divbuf_0/a_36990_n840# pll_full_0/divbuf_0/a_37470_n840# 0.07fF
C7701 divbuf_1/a_55680_n1600# divbuf_1/a_55710_n840# 0.04fF
C7702 pd_div_0/divbuf_0/a_1352_170# pd_div_0/divbuf_0/a_1352_n240# 0.01fF
C7703 pd_div_0/divbuf_0/a_21502_170# pd_div_0/divbuf_0/a_21982_170# 0.07fF
C7704 pd_div_0/divbuf_0/a_5362_170# pd_div_0/divbuf_0/a_5362_n240# 0.01fF
C7705 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57150_n840# 0.04fF
C7706 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7707 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/a_6822_n240# 0.01fF
C7708 pll_full_0/divbuf_1/a_26832_170# pll_full_0/divbuf_1/a_27322_170# 0.07fF
C7709 divbuf_3/a_9732_n240# divbuf_3/OUT3 0.04fF
C7710 divbuf_3/a_46560_n1600# divbuf_3/a_46590_n840# 0.04fF
C7711 divbuf_1/a_49950_n1540# divbuf_1/a_50430_n1540# 0.11fF
C7712 pd_div_0/divbuf_0/a_54720_n1600# pd_div_0/divbuf_0/a_55200_n1600# 0.26fF
C7713 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C7714 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C7715 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar 0.21fF
C7716 divbuf_2/a_20160_n1600# divbuf_2/a_20640_n1600# 0.26fF
C7717 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7718 pll_full_0/divbuf_1/a_60000_n1600# pll_full_0/divbuf_1/a_60480_n1600# 0.26fF
C7719 pd_div_0/divbuf_0/a_47070_n1540# pd_div_0/divbuf_0/a_47550_n1540# 0.11fF
C7720 pll_full_0/divbuf_1/a_52350_n1540# pll_full_0/divbuf_1/a_52830_n1540# 0.11fF
C7721 divbuf_2/a_12510_n1540# divbuf_2/a_12990_n1540# 0.11fF
C7722 divbuf_2/a_43230_n840# divbuf_2/a_43230_n1540# 0.01fF
C7723 divbuf_1/a_33622_n240# divbuf_1/a_34112_n240# 0.04fF
C7724 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/a_35562_n240# 0.05fF
C7725 divbuf_3/a_24412_n240# divbuf_3/a_24892_n240# 0.05fF
C7726 divbuf_1/a_45150_n840# divbuf_1/a_45630_n840# 0.07fF
C7727 ro_div_0/divbuf_0/a_46590_n840# ro_div_0/divbuf_0/a_47070_n840# 0.07fF
C7728 ro_div_0/divbuf_0/a_16350_n840# ro_div_0/divbuf_0/a_16350_n1540# 0.01fF
C7729 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_46590_n1540# 0.19fF
C7730 divbuf_3/a_36000_n1600# divbuf_3/a_36030_n1540# 0.19fF
C7731 divbuf_3/a_8640_n1600# divbuf_3/OUT3 0.00fF
C7732 divbuf_3/a_5790_n840# divbuf_3/a_5790_n1540# 0.01fF
C7733 divbuf_3/a_36030_n840# divbuf_3/a_36510_n840# 0.07fF
C7734 ro_div_0/divider_0/nor_1/A ro_div_0/divider_0/and_0/B 0.08fF
C7735 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/a_9732_170# 0.07fF
C7736 divbuf_2/a_10080_n1600# divbuf_2/a_10110_n840# 0.04fF
C7737 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C7738 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_44670_n840# 0.04fF
C7739 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7740 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_49950_n840# 0.04fF
C7741 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C7742 divbuf_0/a_20042_n240# divbuf_0/a_20190_n840# 0.03fF
C7743 divbuf_0/a_29280_n1600# divbuf_0/a_29760_n1600# 0.26fF
C7744 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_14430_n840# 0.02fF
C7745 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/a_24000_n1600# 0.26fF
C7746 divbuf_2/a_510_n1540# divbuf_2/OUT 0.11fF
C7747 divbuf_1/a_1842_n240# divbuf_1/a_1950_n840# 0.03fF
C7748 divbuf_0/a_52350_n840# divbuf_0/a_52350_n1540# 0.01fF
C7749 divbuf_0/a_21630_n1540# divbuf_0/a_22110_n1540# 0.11fF
C7750 pll_full_0/divbuf_0/a_15870_n1540# pll_full_0/divbuf_0/a_16350_n1540# 0.11fF
C7751 pll_full_0/divbuf_0/a_46590_n840# pll_full_0/divbuf_0/a_46590_n1540# 0.01fF
C7752 pd_div_0/divbuf_0/a_22472_n240# pd_div_0/divbuf_0/a_22952_n240# 0.05fF
C7753 pll_full_0/divbuf_1/a_27802_n240# pll_full_0/divbuf_1/a_28292_n240# 0.04fF
C7754 divbuf_2/a_6822_170# divbuf_2/a_6822_n240# 0.01fF
C7755 divbuf_2/a_26832_170# divbuf_2/a_27322_170# 0.07fF
C7756 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C7757 divbuf_2/a_15672_170# divbuf_2/OUT4 0.19fF
C7758 divbuf_2/a_60000_n1600# divbuf_2/a_60480_n1600# 0.26fF
C7759 divbuf_1/a_21502_170# divbuf_1/OUT4 0.19fF
C7760 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34110_n1540# 0.19fF
C7761 pd_div_0/divbuf_0/a_3870_n840# pd_div_0/divbuf_0/a_3870_n1540# 0.01fF
C7762 pd_div_0/divbuf_0/a_34110_n840# pd_div_0/divbuf_0/a_34590_n840# 0.07fF
C7763 pll_full_0/divbuf_1/a_9150_n840# pll_full_0/divbuf_1/a_9150_n1540# 0.01fF
C7764 pll_full_0/divbuf_1/a_39390_n840# pll_full_0/divbuf_1/a_39870_n840# 0.07fF
C7765 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39390_n1540# 0.19fF
C7766 gnd pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.61fF
C7767 pd_div_0/divider_0/tspc_1/a_630_n680# gnd 0.62fF
C7768 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C7769 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C7770 divbuf_0/a_19200_n1600# divbuf_0/a_19230_n840# 0.04fF
C7771 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C7772 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C7773 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13470_n840# 0.04fF
C7774 divbuf_2/a_52350_n1540# divbuf_2/a_52830_n1540# 0.11fF
C7775 divbuf_1/a_31680_n1600# divbuf_1/a_32160_n1600# 0.26fF
C7776 divbuf_1/a_22472_n240# divbuf_1/a_22590_n840# 0.03fF
C7777 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/a_24030_n840# 0.03fF
C7778 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/a_33600_n1600# 0.26fF
C7779 divbuf_3/a_22560_n1600# divbuf_3/a_23040_n1600# 0.26fF
C7780 divbuf_3/a_13252_n240# divbuf_3/a_13470_n840# 0.02fF
C7781 ro_div_0/divbuf_0/a_56190_n840# ro_div_0/divbuf_0/a_56190_n1540# 0.01fF
C7782 ro_div_0/divbuf_0/a_25470_n1540# ro_div_0/divbuf_0/a_25950_n1540# 0.11fF
C7783 divbuf_3/a_14910_n1540# divbuf_3/a_15390_n1540# 0.11fF
C7784 divbuf_3/a_45630_n840# divbuf_3/a_45630_n1540# 0.01fF
C7785 divbuf_0/a_36052_170# divbuf_0/a_36532_170# 0.07fF
C7786 divbuf_2/a_16642_n240# divbuf_2/OUT4 0.04fF
C7787 divbuf_2/a_49920_n1600# divbuf_2/a_49950_n840# 0.04fF
C7788 divbuf_1/a_25862_n240# divbuf_1/OUT4 0.04fF
C7789 divbuf_1/a_24000_n1600# divbuf_1/a_24030_n1540# 0.19fF
C7790 pll_full_0/divbuf_0/a_30232_170# pll_full_0/divbuf_0/a_30712_170# 0.07fF
C7791 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/A 0.01fF
C7792 ro_div_0/divbuf_0/a_9732_170# ro_div_0/divbuf_0/a_9732_n240# 0.01fF
C7793 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n1540# 0.19fF
C7794 divbuf_0/a_34112_170# divbuf_0/OUT4 0.19fF
C7795 divbuf_0/a_8670_n840# divbuf_0/a_9150_n840# 0.07fF
C7796 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7797 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_2910_n1540# 0.19fF
C7798 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/a_3390_n840# 0.07fF
C7799 divbuf_1/a_21600_n1600# divbuf_1/a_21630_n840# 0.04fF
C7800 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23070_n840# 0.04fF
C7801 ro_div_0/divbuf_0/a_14222_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7802 pll_full_0/divbuf_0/a_55710_n1540# pll_full_0/divbuf_0/a_56190_n1540# 0.11fF
C7803 divbuf_3/a_12480_n1600# divbuf_3/a_12510_n840# 0.04fF
C7804 divbuf_1/a_15870_n1540# divbuf_1/a_16350_n1540# 0.11fF
C7805 pd_div_0/divbuf_0/a_20640_n1600# pd_div_0/divbuf_0/a_21120_n1600# 0.26fF
C7806 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11550_n840# 0.02fF
C7807 pll_full_0/divbuf_1/a_25920_n1600# pll_full_0/divbuf_1/a_26400_n1600# 0.26fF
C7808 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_16830_n840# 0.02fF
C7809 divbuf_2/a_27802_n240# divbuf_2/a_28292_n240# 0.04fF
C7810 divbuf_2/a_9150_n840# divbuf_2/a_9150_n1540# 0.01fF
C7811 divbuf_2/a_39390_n840# divbuf_2/a_39870_n840# 0.07fF
C7812 divbuf_2/a_39360_n1600# divbuf_2/a_39390_n1540# 0.19fF
C7813 divbuf_1/a_24000_n1600# divbuf_1/OUT4 0.00fF
C7814 pd_div_0/divbuf_0/a_12990_n1540# pd_div_0/divbuf_0/a_13470_n1540# 0.11fF
C7815 pd_div_0/divbuf_0/a_43710_n840# pd_div_0/divbuf_0/a_43710_n1540# 0.01fF
C7816 pll_full_0/divbuf_1/a_18270_n1540# pll_full_0/divbuf_1/a_18750_n1540# 0.11fF
C7817 pll_full_0/divbuf_1/a_48990_n840# pll_full_0/divbuf_1/a_48990_n1540# 0.01fF
C7818 divbuf_1/a_38472_170# divbuf_1/a_38962_170# 0.07fF
C7819 ro_div_0/divbuf_0/a_39932_170# ro_div_0/divbuf_0/a_40412_170# 0.07fF
C7820 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/a_20532_n240# 0.01fF
C7821 divbuf_0/a_59040_n1600# divbuf_0/a_59070_n840# 0.04fF
C7822 divbuf_0/a_35082_n240# divbuf_0/OUT4 0.04fF
C7823 pll_full_0/divbuf_0/a_23442_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7824 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53310_n840# 0.04fF
C7825 divbuf_3/a_9242_170# divbuf_3/a_9242_n240# 0.01fF
C7826 divbuf_3/a_29262_170# divbuf_3/a_29742_170# 0.07fF
C7827 divbuf_1/a_11040_n1600# divbuf_1/a_11070_n1540# 0.19fF
C7828 divbuf_1/a_11070_n840# divbuf_1/a_11550_n840# 0.07fF
C7829 ro_div_0/divbuf_0/a_12510_n840# ro_div_0/divbuf_0/a_12990_n840# 0.07fF
C7830 ro_div_0/divbuf_0/a_41382_170# ro_div_0/divbuf_0/OUT5 0.07fF
C7831 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12510_n1540# 0.19fF
C7832 ro_div_0/divbuf_0/a_2322_n240# ro_div_0/divbuf_0/OUT2 0.04fF
C7833 ro_div_0/divider_0/prescaler_0/tspc_0/D gnd 0.05fF
C7834 divbuf_3/a_20532_170# divbuf_3/OUT4 0.19fF
C7835 divbuf_3/a_1920_n1600# divbuf_3/a_1950_n1540# 0.19fF
C7836 divbuf_3/a_1950_n840# divbuf_3/a_2430_n840# 0.07fF
C7837 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_10590_n840# 0.04fF
C7838 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_15870_n840# 0.04fF
C7839 divbuf_3/a_54750_n1540# divbuf_3/a_55230_n1540# 0.11fF
C7840 divbuf_1/a_33630_n840# divbuf_1/a_33630_n1540# 0.01fF
C7841 divbuf_0/a_37022_n240# divbuf_0/a_37502_n240# 0.05fF
C7842 pll_full_0/divbuf_0/a_31202_n240# pll_full_0/divbuf_0/a_31682_n240# 0.05fF
C7843 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n1540# 0.19fF
C7844 divbuf_0/a_48510_n840# divbuf_0/a_48990_n840# 0.07fF
C7845 divbuf_0/a_18270_n840# divbuf_0/a_18270_n1540# 0.01fF
C7846 divbuf_0/a_33120_n1600# divbuf_0/OUT4 0.01fF
C7847 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C7848 pll_full_0/divbuf_0/a_12510_n840# pll_full_0/divbuf_0/a_12510_n1540# 0.01fF
C7849 pll_full_0/divbuf_0/a_42750_n840# pll_full_0/divbuf_0/a_43230_n840# 0.07fF
C7850 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_42750_n1540# 0.19fF
C7851 pd_div_0/divbuf_0/a_27322_170# pd_div_0/divbuf_0/a_27802_170# 0.07fF
C7852 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C7853 ro_div_0/divbuf_0/a_0_n1600# ro_div_0/divbuf_0/OUT 0.26fF
C7854 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/a_13252_n240# 0.01fF
C7855 pll_full_0/divbuf_1/a_32652_170# pll_full_0/divbuf_1/a_33142_170# 0.07fF
C7856 divbuf_3/a_21502_n240# divbuf_3/OUT4 0.04fF
C7857 divbuf_3/a_52320_n1600# divbuf_3/a_52350_n840# 0.04fF
C7858 divbuf_1/a_55710_n1540# divbuf_1/a_56190_n1540# 0.11fF
C7859 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/OUT4 0.19fF
C7860 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C7861 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C7862 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C7863 ro_div_0/divider_0/tspc_1/Z1 ro_div_0/divider_0/tspc_1/Z4 0.00fF
C7864 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C7865 divbuf_2/a_25920_n1600# divbuf_2/a_26400_n1600# 0.26fF
C7866 divbuf_2/a_16642_n240# divbuf_2/a_16830_n840# 0.02fF
C7867 pll_full_0/divbuf_1/a_5310_n840# pll_full_0/divbuf_1/a_5790_n840# 0.07fF
C7868 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/OUT4 0.19fF
C7869 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5310_n1540# 0.19fF
C7870 ashish_0/vop ashish_0/Gnd 0.33fF
C7871 pd_div_0/divbuf_0/a_52830_n1540# pd_div_0/divbuf_0/a_53310_n1540# 0.11fF
C7872 pll_full_0/divbuf_1/a_58110_n1540# pll_full_0/divbuf_1/a_58590_n1540# 0.11fF
C7873 divbuf_2/a_18270_n1540# divbuf_2/a_18750_n1540# 0.11fF
C7874 divbuf_2/a_48990_n840# divbuf_2/a_48990_n1540# 0.01fF
C7875 divbuf_1/a_39442_n240# divbuf_1/a_39932_n240# 0.04fF
C7876 ro_div_0/divbuf_0/a_40902_n240# ro_div_0/divbuf_0/a_41382_n240# 0.05fF
C7877 divbuf_3/a_30232_n240# divbuf_3/a_30712_n240# 0.05fF
C7878 divbuf_1/a_50910_n840# divbuf_1/a_51390_n840# 0.07fF
C7879 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52350_n1540# 0.19fF
C7880 ro_div_0/divbuf_0/a_52350_n840# ro_div_0/divbuf_0/a_52830_n840# 0.07fF
C7881 ro_div_0/divbuf_0/a_22110_n840# ro_div_0/divbuf_0/a_22110_n1540# 0.01fF
C7882 divbuf_3/a_19680_n1600# divbuf_3/OUT4 0.00fF
C7883 divbuf_3/a_11550_n840# divbuf_3/a_11550_n1540# 0.01fF
C7884 divbuf_3/a_41790_n840# divbuf_3/a_42270_n840# 0.07fF
C7885 divbuf_3/a_41760_n1600# divbuf_3/a_41790_n1540# 0.19fF
C7886 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C7887 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50430_n840# 0.04fF
C7888 divbuf_0/a_6332_170# divbuf_0/a_6332_n240# 0.01fF
C7889 divbuf_2/a_15840_n1600# divbuf_2/a_15870_n840# 0.04fF
C7890 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C7891 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_55710_n840# 0.04fF
C7892 divbuf_0/a_25862_n240# divbuf_0/a_25950_n840# 0.03fF
C7893 divbuf_0/a_35040_n1600# divbuf_0/a_35520_n1600# 0.26fF
C7894 divbuf_0/a_18092_170# divbuf_0/OUT4 0.19fF
C7895 pll_full_0/divbuf_0/a_29280_n1600# pll_full_0/divbuf_0/a_29760_n1600# 0.26fF
C7896 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/a_20190_n840# 0.03fF
C7897 divbuf_0/a_58110_n840# divbuf_0/a_58110_n1540# 0.01fF
C7898 divbuf_0/a_27390_n1540# divbuf_0/a_27870_n1540# 0.11fF
C7899 pll_full_0/divbuf_0/a_21630_n1540# pll_full_0/divbuf_0/a_22110_n1540# 0.11fF
C7900 pll_full_0/divbuf_0/a_52350_n840# pll_full_0/divbuf_0/a_52350_n1540# 0.01fF
C7901 pd_div_0/divbuf_0/a_28292_n240# pd_div_0/divbuf_0/a_28772_n240# 0.05fF
C7902 pll_full_0/divbuf_1/a_33622_n240# pll_full_0/divbuf_1/a_34112_n240# 0.04fF
C7903 divbuf_2/a_13252_170# divbuf_2/a_13252_n240# 0.01fF
C7904 divbuf_2/a_32652_170# divbuf_2/a_33142_170# 0.07fF
C7905 divbuf_2/a_5310_n840# divbuf_2/a_5790_n840# 0.07fF
C7906 divbuf_2/a_27322_170# divbuf_2/OUT4 0.19fF
C7907 divbuf_2/a_5280_n1600# divbuf_2/a_5310_n1540# 0.19fF
C7908 divbuf_1/a_36532_170# divbuf_1/OUT4 0.19fF
C7909 pd_div_0/divbuf_0/a_9630_n840# pd_div_0/divbuf_0/a_9630_n1540# 0.01fF
C7910 pd_div_0/divbuf_0/a_39870_n840# pd_div_0/divbuf_0/a_40350_n840# 0.07fF
C7911 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_39870_n1540# 0.19fF
C7912 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45150_n1540# 0.19fF
C7913 pll_full_0/divbuf_1/a_14910_n840# pll_full_0/divbuf_1/a_14910_n1540# 0.01fF
C7914 pll_full_0/divbuf_1/a_45150_n840# pll_full_0/divbuf_1/a_45630_n840# 0.07fF
C7915 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C7916 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 0.63fF
C7917 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C7918 divbuf_0/a_24960_n1600# divbuf_0/a_24990_n840# 0.04fF
C7919 divbuf_0/a_8272_170# divbuf_0/OUT3 0.19fF
C7920 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/prescaler_0/Out 0.15fF
C7921 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.64fF
C7922 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19230_n840# 0.04fF
C7923 divbuf_2/a_58110_n1540# divbuf_2/a_58590_n1540# 0.11fF
C7924 divbuf_1/a_37440_n1600# divbuf_1/a_37920_n1600# 0.26fF
C7925 divbuf_1/a_28292_n240# divbuf_1/a_28350_n840# 0.04fF
C7926 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/a_29790_n840# 0.04fF
C7927 ro_div_0/divbuf_0/a_38880_n1600# ro_div_0/divbuf_0/a_39360_n1600# 0.26fF
C7928 divbuf_3/a_28320_n1600# divbuf_3/a_28800_n1600# 0.26fF
C7929 divbuf_3/a_19072_n240# divbuf_3/a_19230_n840# 0.02fF
C7930 ro_div_0/divbuf_0/a_31230_n1540# ro_div_0/divbuf_0/a_31710_n1540# 0.11fF
C7931 pll_full_0/divbuf_1/a_1842_n240# pll_full_0/divbuf_1/a_1950_n840# 0.03fF
C7932 divbuf_3/a_20670_n1540# divbuf_3/a_21150_n1540# 0.11fF
C7933 divbuf_3/a_51390_n840# divbuf_3/a_51390_n1540# 0.01fF
C7934 divbuf_0/a_22472_170# divbuf_0/a_22472_n240# 0.01fF
C7935 divbuf_0/a_1352_n240# divbuf_0/a_1842_n240# 0.04fF
C7936 divbuf_2/a_28292_n240# divbuf_2/OUT4 0.04fF
C7937 divbuf_2/a_55680_n1600# divbuf_2/a_55710_n840# 0.04fF
C7938 divbuf_1/a_37502_n240# divbuf_1/OUT4 0.04fF
C7939 divbuf_1/a_29760_n1600# divbuf_1/a_29790_n1540# 0.19fF
C7940 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/a_36532_170# 0.07fF
C7941 divbuf_1/a_3912_170# divbuf_1/a_3912_n240# 0.01fF
C7942 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n1540# 0.19fF
C7943 divbuf_0/a_6332_n240# divbuf_0/OUT3 0.04fF
C7944 divbuf_0/a_14430_n840# divbuf_0/a_14910_n840# 0.07fF
C7945 pll_full_0/divbuf_0/a_8670_n840# pll_full_0/divbuf_0/a_9150_n840# 0.07fF
C7946 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/OUT4 0.19fF
C7947 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_8670_n1540# 0.19fF
C7948 divbuf_1/a_27360_n1600# divbuf_1/a_27390_n840# 0.04fF
C7949 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Qbar1 0.38fF
C7950 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_28830_n840# 0.04fF
C7951 ro_div_0/divbuf_0/a_14702_170# ro_div_0/divbuf_0/OUT4 0.19fF
C7952 divbuf_3/a_18240_n1600# divbuf_3/a_18270_n840# 0.04fF
C7953 divbuf_1/a_21630_n1540# divbuf_1/a_22110_n1540# 0.11fF
C7954 pd_div_0/divbuf_0/a_26400_n1600# pd_div_0/divbuf_0/a_26880_n1600# 0.26fF
C7955 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_17310_n840# 0.02fF
C7956 pll_full_0/divbuf_1/a_31680_n1600# pll_full_0/divbuf_1/a_32160_n1600# 0.26fF
C7957 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/a_22590_n840# 0.03fF
C7958 divbuf_2/a_33622_n240# divbuf_2/a_34112_n240# 0.04fF
C7959 divbuf_2/a_45120_n1600# divbuf_2/a_45150_n1540# 0.19fF
C7960 divbuf_2/a_14910_n840# divbuf_2/a_14910_n1540# 0.01fF
C7961 divbuf_2/a_45150_n840# divbuf_2/a_45630_n840# 0.07fF
C7962 divbuf_1/a_35520_n1600# divbuf_1/OUT4 0.00fF
C7963 pd_div_0/divbuf_0/a_18750_n1540# pd_div_0/divbuf_0/a_19230_n1540# 0.11fF
C7964 pd_div_0/divbuf_0/a_49470_n840# pd_div_0/divbuf_0/a_49470_n1540# 0.01fF
C7965 pll_full_0/divbuf_1/a_24030_n1540# pll_full_0/divbuf_1/a_24510_n1540# 0.11fF
C7966 pll_full_0/divbuf_1/a_54750_n840# pll_full_0/divbuf_1/a_54750_n1540# 0.01fF
C7967 divbuf_1/a_4392_n240# divbuf_1/a_4882_n240# 0.04fF
C7968 ro_div_0/divbuf_0/a_26352_170# ro_div_0/divbuf_0/a_26352_n240# 0.01fF
C7969 ro_div_0/divbuf_0/a_5852_n240# ro_div_0/divbuf_0/a_6332_n240# 0.05fF
C7970 pll_full_0/divbuf_0/a_35082_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C7971 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59070_n840# 0.04fF
C7972 divbuf_3/a_35082_170# divbuf_3/a_35562_170# 0.07fF
C7973 divbuf_3/a_15672_170# divbuf_3/a_15672_n240# 0.01fF
C7974 divbuf_1/a_16830_n840# divbuf_1/a_17310_n840# 0.07fF
C7975 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18270_n1540# 0.19fF
C7976 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C7977 ro_div_0/divbuf_0/a_18270_n840# ro_div_0/divbuf_0/a_18750_n840# 0.07fF
C7978 ro_div_0/divider_0/and_0/out1 gnd 0.29fF
C7979 divbuf_3/a_7710_n840# divbuf_3/a_8190_n840# 0.07fF
C7980 divbuf_3/a_32172_170# divbuf_3/OUT4 0.19fF
C7981 divbuf_3/a_7680_n1600# divbuf_3/a_7710_n1540# 0.19fF
C7982 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16350_n840# 0.04fF
C7983 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_21630_n840# 0.04fF
C7984 divbuf_3/a_60510_n1540# divbuf_3/a_60990_n1540# 0.11fF
C7985 divbuf_2/a_1842_n240# divbuf_2/a_1950_n840# 0.03fF
C7986 divbuf_1/a_39390_n840# divbuf_1/a_39390_n1540# 0.01fF
C7987 divbuf_0/a_960_n1600# divbuf_0/a_1440_n1600# 0.26fF
C7988 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/a_37502_n240# 0.05fF
C7989 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n1540# 0.19fF
C7990 divbuf_0/a_54270_n840# divbuf_0/a_54750_n840# 0.07fF
C7991 divbuf_0/a_24030_n840# divbuf_0/a_24030_n1540# 0.01fF
C7992 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48510_n1540# 0.19fF
C7993 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C7994 pll_full_0/divbuf_0/a_18270_n840# pll_full_0/divbuf_0/a_18270_n1540# 0.01fF
C7995 pll_full_0/divbuf_0/a_48510_n840# pll_full_0/divbuf_0/a_48990_n840# 0.07fF
C7996 pd_div_0/divbuf_0/a_33142_170# pd_div_0/divbuf_0/a_33622_170# 0.07fF
C7997 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C7998 pll_full_0/divbuf_1/a_19072_170# pll_full_0/divbuf_1/a_19072_n240# 0.01fF
C7999 pll_full_0/divbuf_1/a_38472_170# pll_full_0/divbuf_1/a_38962_170# 0.07fF
C8000 divbuf_3/a_33142_n240# divbuf_3/OUT4 0.04fF
C8001 divbuf_3/a_58080_n1600# divbuf_3/a_58110_n840# 0.04fF
C8002 divbuf_1/a_1352_170# divbuf_1/a_1842_170# 0.07fF
C8003 pd_div_0/divbuf_0/a_5790_n840# pd_div_0/divbuf_0/a_6270_n840# 0.07fF
C8004 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8005 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_5790_n1540# 0.19fF
C8006 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/and_0/OUT 0.06fF
C8007 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C8008 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C8009 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8010 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11070_n1540# 0.19fF
C8011 pll_full_0/divbuf_1/a_11070_n840# pll_full_0/divbuf_1/a_11550_n840# 0.07fF
C8012 divbuf_2/a_31680_n1600# divbuf_2/a_32160_n1600# 0.26fF
C8013 divbuf_2/a_22472_n240# divbuf_2/a_22590_n840# 0.03fF
C8014 divbuf_2/a_24030_n1540# divbuf_2/a_24510_n1540# 0.11fF
C8015 divbuf_2/a_54750_n840# divbuf_2/a_54750_n1540# 0.01fF
C8016 pd_div_0/divbuf_0/a_58590_n1540# pd_div_0/divbuf_0/a_59070_n1540# 0.11fF
C8017 divbuf_0/a_11802_n240# divbuf_0/a_11550_n840# 0.02fF
C8018 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 0.26fF
C8019 divbuf_1/a_3360_n1600# divbuf_1/a_3840_n1600# 0.26fF
C8020 ro_div_0/divbuf_0/a_4800_n1600# ro_div_0/divbuf_0/a_5280_n1600# 0.26fF
C8021 divbuf_3/a_36052_n240# divbuf_3/a_36532_n240# 0.05fF
C8022 divbuf_1/a_56670_n840# divbuf_1/a_57150_n840# 0.07fF
C8023 ro_div_0/divbuf_0/a_58110_n840# ro_div_0/divbuf_0/a_58590_n840# 0.07fF
C8024 ro_div_0/divbuf_0/a_27870_n840# ro_div_0/divbuf_0/a_27870_n1540# 0.01fF
C8025 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58110_n1540# 0.19fF
C8026 divbuf_3/a_47520_n1600# divbuf_3/a_47550_n1540# 0.19fF
C8027 divbuf_3/a_31200_n1600# divbuf_3/OUT4 0.00fF
C8028 divbuf_3/a_17310_n840# divbuf_3/a_17310_n1540# 0.01fF
C8029 divbuf_3/a_47550_n840# divbuf_3/a_48030_n840# 0.07fF
C8030 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56190_n840# 0.04fF
C8031 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8032 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C8033 divbuf_2/a_21600_n1600# divbuf_2/a_21630_n840# 0.04fF
C8034 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8035 divbuf_1/a_16152_170# divbuf_1/a_15672_170# 0.07fF
C8036 divbuf_0/a_31682_n240# divbuf_0/a_31710_n840# 0.05fF
C8037 divbuf_0/a_40800_n1600# divbuf_0/a_41280_n1600# 0.26fF
C8038 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/A 0.03fF
C8039 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C8040 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/a_25950_n840# 0.03fF
C8041 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/a_35520_n1600# 0.26fF
C8042 divbuf_1/a_14222_n240# divbuf_1/a_13950_n840# 0.01fF
C8043 ro_div_0/divbuf_0/a_15672_n240# ro_div_0/divbuf_0/a_15390_n840# 0.01fF
C8044 divbuf_0/a_33150_n1540# divbuf_0/a_33630_n1540# 0.11fF
C8045 pll_full_0/divbuf_0/a_27390_n1540# pll_full_0/divbuf_0/a_27870_n1540# 0.11fF
C8046 pll_full_0/divbuf_0/a_58110_n840# pll_full_0/divbuf_0/a_58110_n1540# 0.01fF
C8047 pd_div_0/divbuf_0/a_34112_n240# pd_div_0/divbuf_0/a_34592_n240# 0.05fF
C8048 pll_full_0/divbuf_1/a_39442_n240# pll_full_0/divbuf_1/a_39932_n240# 0.04fF
C8049 divbuf_3/a_10590_n840# divbuf_3/OUT4 0.03fF
C8050 divbuf_2/a_19072_170# divbuf_2/a_19072_n240# 0.01fF
C8051 divbuf_2/a_38472_170# divbuf_2/a_38962_170# 0.07fF
C8052 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_45630_n1540# 0.19fF
C8053 pd_div_0/divbuf_0/a_15390_n840# pd_div_0/divbuf_0/a_15390_n1540# 0.01fF
C8054 pd_div_0/divbuf_0/a_45630_n840# pd_div_0/divbuf_0/a_46110_n840# 0.07fF
C8055 divbuf_0/a_5852_170# divbuf_0/a_5852_n240# 0.01fF
C8056 divbuf_2/a_38962_170# divbuf_2/OUT4 0.19fF
C8057 divbuf_2/a_11040_n1600# divbuf_2/a_11070_n1540# 0.19fF
C8058 divbuf_2/a_11070_n840# divbuf_2/a_11550_n840# 0.07fF
C8059 divbuf_1/a_8762_n240# divbuf_1/OUT3 0.04fF
C8060 pll_full_0/divbuf_1/a_20670_n840# pll_full_0/divbuf_1/a_20670_n1540# 0.01fF
C8061 pll_full_0/divbuf_1/a_50910_n840# pll_full_0/divbuf_1/a_51390_n840# 0.07fF
C8062 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_50910_n1540# 0.19fF
C8063 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_0/Z2 0.23fF
C8064 gnd pd_div_0/divider_0/prescaler_0/nand_1/z1 0.16fF
C8065 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/clk 0.12fF
C8066 ro_div_0/ro_complete_0/cbank_2/switch_1/vin ro_div_0/ro_complete_0/cbank_2/v 1.30fF
C8067 divbuf_0/a_14702_170# divbuf_0/OUT4 0.19fF
C8068 divbuf_0/a_30720_n1600# divbuf_0/a_30750_n840# 0.04fF
C8069 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_24990_n840# 0.04fF
C8070 pll_full_0/divbuf_0/a_1352_170# pll_full_0/divbuf_0/OUT2 0.23fF
C8071 divbuf_2/OUT4 divbuf_2/OUT5 0.26fF
C8072 divbuf_1/a_43200_n1600# divbuf_1/a_43680_n1600# 0.26fF
C8073 divbuf_1/a_34112_n240# divbuf_1/a_34110_n840# 0.06fF
C8074 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/a_35550_n840# 0.05fF
C8075 ro_div_0/divbuf_0/a_44640_n1600# ro_div_0/divbuf_0/a_45120_n1600# 0.26fF
C8076 divbuf_3/a_24892_n240# divbuf_3/a_24990_n840# 0.03fF
C8077 divbuf_3/a_34080_n1600# divbuf_3/a_34560_n1600# 0.26fF
C8078 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/a_2430_n840# 0.03fF
C8079 ro_div_0/divbuf_0/a_36990_n1540# ro_div_0/divbuf_0/a_37470_n1540# 0.11fF
C8080 divbuf_3/a_26430_n1540# divbuf_3/a_26910_n1540# 0.11fF
C8081 divbuf_3/a_57150_n840# divbuf_3/a_57150_n1540# 0.01fF
C8082 divbuf_0/a_28292_170# divbuf_0/a_28292_n240# 0.01fF
C8083 divbuf_0/a_7792_n240# divbuf_0/a_8272_n240# 0.05fF
C8084 pll_full_0/divbuf_0/a_1352_n240# pll_full_0/divbuf_0/a_1842_n240# 0.04fF
C8085 pll_full_0/divbuf_0/a_22472_170# pll_full_0/divbuf_0/a_22472_n240# 0.01fF
C8086 divbuf_2/a_39932_n240# divbuf_2/OUT4 0.04fF
C8087 divbuf_1/a_35520_n1600# divbuf_1/a_35550_n1540# 0.19fF
C8088 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n1540# 0.19fF
C8089 divbuf_0/a_18092_n240# divbuf_0/OUT4 0.04fF
C8090 divbuf_0/a_20190_n840# divbuf_0/a_20670_n840# 0.07fF
C8091 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14430_n1540# 0.19fF
C8092 pll_full_0/divbuf_0/a_14430_n840# pll_full_0/divbuf_0/a_14910_n840# 0.07fF
C8093 pll_full_0/divbuf_0/a_6332_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C8094 divbuf_1/a_33120_n1600# divbuf_1/a_33150_n840# 0.04fF
C8095 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/a_6332_170# 0.07fF
C8096 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_34590_n840# 0.04fF
C8097 ro_div_0/divbuf_0/a_24892_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8098 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 gnd 0.27fF
C8099 gnd pll_full_0/pd_0/DIV 0.01fF
C8100 pll_full_0/divbuf_1/a_3422_170# pll_full_0/divbuf_1/a_3912_170# 0.07fF
C8101 divbuf_3/a_3422_170# divbuf_3/OUT3 0.23fF
C8102 divbuf_3/a_24000_n1600# divbuf_3/a_24030_n840# 0.04fF
C8103 divbuf_1/a_27390_n1540# divbuf_1/a_27870_n1540# 0.11fF
C8104 pd_div_0/divbuf_0/a_32160_n1600# pd_div_0/divbuf_0/a_32640_n1600# 0.26fF
C8105 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/a_23070_n840# 0.03fF
C8106 pll_full_0/divbuf_1/a_37440_n1600# pll_full_0/divbuf_1/a_37920_n1600# 0.26fF
C8107 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/a_28350_n840# 0.04fF
C8108 divbuf_2/a_39442_n240# divbuf_2/a_39932_n240# 0.04fF
C8109 divbuf_2/a_20670_n840# divbuf_2/a_20670_n1540# 0.01fF
C8110 divbuf_2/a_50910_n840# divbuf_2/a_51390_n840# 0.07fF
C8111 divbuf_2/a_50880_n1600# divbuf_2/a_50910_n1540# 0.19fF
C8112 pd_div_0/divbuf_0/a_24510_n1540# pd_div_0/divbuf_0/a_24990_n1540# 0.11fF
C8113 pd_div_0/divbuf_0/a_55230_n840# pd_div_0/divbuf_0/a_55230_n1540# 0.01fF
C8114 pll_full_0/divbuf_1/a_29790_n1540# pll_full_0/divbuf_1/a_30270_n1540# 0.11fF
C8115 pll_full_0/divbuf_1/a_60510_n840# pll_full_0/divbuf_1/a_60510_n1540# 0.01fF
C8116 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/a_32172_n240# 0.01fF
C8117 ro_div_0/divbuf_0/a_12282_n240# ro_div_0/divbuf_0/a_12772_n240# 0.04fF
C8118 divbuf_3/a_21502_170# divbuf_3/a_21502_n240# 0.01fF
C8119 divbuf_3/a_40902_170# divbuf_3/a_41382_170# 0.07fF
C8120 divbuf_1/a_22590_n840# divbuf_1/a_23070_n840# 0.07fF
C8121 ro_div_0/divbuf_0/a_24030_n840# ro_div_0/divbuf_0/a_24510_n840# 0.07fF
C8122 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24030_n1540# 0.19fF
C8123 ro_div_0/divbuf_0/a_25862_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8124 divbuf_3/a_4392_n240# divbuf_3/OUT3 0.04fF
C8125 divbuf_3/a_13440_n1600# divbuf_3/a_13470_n1540# 0.19fF
C8126 divbuf_3/a_13470_n840# divbuf_3/a_13950_n840# 0.07fF
C8127 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22110_n840# 0.04fF
C8128 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C8129 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/a2 0.09fF
C8130 pll_full_0/divbuf_1/a_10212_170# pll_full_0/divbuf_1/OUT3 0.19fF
C8131 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27390_n840# 0.04fF
C8132 divbuf_0/a_6720_n1600# divbuf_0/a_7200_n1600# 0.26fF
C8133 divbuf_1/a_14430_n1540# divbuf_1/a_14910_n1540# 0.11fF
C8134 divbuf_1/a_45150_n840# divbuf_1/a_45150_n1540# 0.01fF
C8135 pll_full_0/divbuf_0/a_960_n1600# pll_full_0/divbuf_0/a_1440_n1600# 0.26fF
C8136 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n1540# 0.19fF
C8137 divbuf_0/a_60030_n840# divbuf_0/a_60510_n840# 0.07fF
C8138 divbuf_0/a_29790_n840# divbuf_0/a_29790_n1540# 0.01fF
C8139 pll_full_0/divbuf_0/a_24030_n840# pll_full_0/divbuf_0/a_24030_n1540# 0.01fF
C8140 pll_full_0/divbuf_0/a_54270_n840# pll_full_0/divbuf_0/a_54750_n840# 0.07fF
C8141 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54270_n1540# 0.19fF
C8142 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/a_19562_n240# 0.01fF
C8143 pd_div_0/divbuf_0/a_492_n240# pd_div_0/divbuf_0/a_480_n1600# 0.00fF
C8144 pd_div_0/divbuf_0/a_38962_170# pd_div_0/divbuf_0/a_39442_170# 0.07fF
C8145 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C8146 pll_full_0/divbuf_1/a_4392_n240# pll_full_0/divbuf_1/a_4882_n240# 0.04fF
C8147 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/a_24892_n240# 0.01fF
C8148 divbuf_2/a_3422_170# divbuf_2/a_3912_170# 0.07fF
C8149 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8150 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_11550_n1540# 0.19fF
C8151 pd_div_0/divbuf_0/a_11550_n840# pd_div_0/divbuf_0/a_12030_n840# 0.07fF
C8152 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/clk 0.01fF
C8153 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C8154 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/tspc_0/Z2 0.01fF
C8155 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C8156 divbuf_0/a_19562_170# divbuf_0/a_20042_170# 0.07fF
C8157 pll_full_0/divbuf_1/a_16830_n840# pll_full_0/divbuf_1/a_17310_n840# 0.07fF
C8158 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/OUT4 0.07fF
C8159 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_16830_n1540# 0.19fF
C8160 divbuf_2/a_37440_n1600# divbuf_2/a_37920_n1600# 0.26fF
C8161 divbuf_2/a_28292_n240# divbuf_2/a_28350_n840# 0.04fF
C8162 divbuf_1/a_30712_170# divbuf_1/OUT4 0.19fF
C8163 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C8164 divbuf_2/a_29790_n1540# divbuf_2/a_30270_n1540# 0.11fF
C8165 divbuf_2/a_60510_n840# divbuf_2/a_60510_n1540# 0.01fF
C8166 divbuf_0/a_17612_n240# divbuf_0/a_17310_n840# 0.00fF
C8167 pll_full_0/divbuf_0/a_11802_n240# pll_full_0/divbuf_0/a_11550_n840# 0.02fF
C8168 divbuf_1/a_9120_n1600# divbuf_1/a_9600_n1600# 0.26fF
C8169 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/a_11040_n1600# 0.26fF
C8170 divbuf_3/a_0_n1600# divbuf_3/a_480_n1600# 0.26fF
C8171 divbuf_1/a_1470_n1540# divbuf_1/a_1950_n1540# 0.11fF
C8172 ro_div_0/divbuf_0/a_33630_n840# ro_div_0/divbuf_0/a_33630_n1540# 0.01fF
C8173 ro_div_0/divbuf_0/a_2910_n1540# ro_div_0/divbuf_0/a_3390_n1540# 0.11fF
C8174 divbuf_3/a_23070_n840# divbuf_3/a_23070_n1540# 0.01fF
C8175 divbuf_3/a_53310_n840# divbuf_3/a_53790_n840# 0.07fF
C8176 divbuf_3/a_53280_n1600# divbuf_3/a_53310_n1540# 0.19fF
C8177 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8178 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.44fF
C8179 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C8180 divbuf_0/a_12772_170# divbuf_0/a_13252_170# 0.07fF
C8181 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C8182 divbuf_2/a_10212_170# divbuf_2/OUT3 0.19fF
C8183 divbuf_2/a_27360_n1600# divbuf_2/a_27390_n840# 0.04fF
C8184 ro_div_0/ro_complete_0/cbank_0/switch_3/vin ro_div_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C8185 gnd pll_full_0/divider_0/tspc_1/a_630_n680# 0.62fF
C8186 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/nor_0/B 0.06fF
C8187 divbuf_0/a_46560_n1600# divbuf_0/a_47040_n1600# 0.26fF
C8188 divbuf_0/a_10212_170# divbuf_0/OUT4 0.07fF
C8189 divbuf_0/a_37502_n240# divbuf_0/a_37470_n840# 0.05fF
C8190 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/Out 0.12fF
C8191 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C8192 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C8193 pll_full_0/divbuf_0/a_40800_n1600# pll_full_0/divbuf_0/a_41280_n1600# 0.26fF
C8194 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/a_31710_n840# 0.05fF
C8195 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_510_n840# 0.04fF
C8196 divbuf_0/a_38910_n1540# divbuf_0/a_39390_n1540# 0.11fF
C8197 pll_full_0/divbuf_0/a_33150_n1540# pll_full_0/divbuf_0/a_33630_n1540# 0.11fF
C8198 pd_div_0/divbuf_0/a_39932_n240# pd_div_0/divbuf_0/a_40412_n240# 0.05fF
C8199 pll_full_0/divbuf_1/a_3360_n1600# pll_full_0/divbuf_1/a_3840_n1600# 0.26fF
C8200 divbuf_2/a_4392_n240# divbuf_2/a_4882_n240# 0.04fF
C8201 divbuf_2/a_24892_170# divbuf_2/a_24892_n240# 0.01fF
C8202 pd_div_0/divbuf_0/a_21150_n840# pd_div_0/divbuf_0/a_21150_n1540# 0.01fF
C8203 pd_div_0/divbuf_0/a_51390_n840# pd_div_0/divbuf_0/a_51870_n840# 0.07fF
C8204 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51390_n1540# 0.19fF
C8205 divbuf_0/a_13742_170# divbuf_0/a_13742_n240# 0.01fF
C8206 divbuf_2/a_16830_n840# divbuf_2/a_17310_n840# 0.07fF
C8207 divbuf_2/a_11312_n240# divbuf_2/OUT4 0.07fF
C8208 divbuf_2/a_16800_n1600# divbuf_2/a_16830_n1540# 0.19fF
C8209 divbuf_1/a_20532_n240# divbuf_1/OUT4 0.04fF
C8210 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_56670_n1540# 0.19fF
C8211 pll_full_0/divbuf_1/a_26430_n840# pll_full_0/divbuf_1/a_26430_n1540# 0.01fF
C8212 pll_full_0/divbuf_1/a_56670_n840# pll_full_0/divbuf_1/a_57150_n840# 0.07fF
C8213 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/a_19072_170# 0.07fF
C8214 divbuf_1/a_8272_170# divbuf_1/a_8272_n240# 0.01fF
C8215 divbuf_1/a_13252_170# divbuf_1/a_13742_170# 0.07fF
C8216 gnd pd_div_0/divider_0/and_0/Z1 0.32fF
C8217 divbuf_0/a_36480_n1600# divbuf_0/a_36510_n840# 0.04fF
C8218 divbuf_0/a_28772_170# divbuf_0/OUT4 0.19fF
C8219 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C8220 pll_full_0/divbuf_0/a_18582_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8221 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_30750_n840# 0.04fF
C8222 divbuf_3/a_5852_170# divbuf_3/a_6332_170# 0.07fF
C8223 divbuf_1/a_39932_n240# divbuf_1/a_39870_n840# 0.04fF
C8224 divbuf_1/a_48960_n1600# divbuf_1/a_49440_n1600# 0.26fF
C8225 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/OUT3 0.19fF
C8226 ro_div_0/divbuf_0/a_50400_n1600# ro_div_0/divbuf_0/a_50880_n1600# 0.26fF
C8227 ro_div_0/divbuf_0/a_41382_n240# ro_div_0/divbuf_0/a_41310_n840# 0.03fF
C8228 divbuf_3/a_39840_n1600# divbuf_3/a_40320_n1600# 0.26fF
C8229 divbuf_3/a_30712_n240# divbuf_3/a_30750_n840# 0.05fF
C8230 ro_div_0/divbuf_0/a_42750_n1540# ro_div_0/divbuf_0/a_43230_n1540# 0.11fF
C8231 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/a_13950_n840# 0.01fF
C8232 divbuf_3/a_32190_n1540# divbuf_3/a_32670_n1540# 0.11fF
C8233 divbuf_0/a_34112_170# divbuf_0/a_34112_n240# 0.01fF
C8234 divbuf_0/a_14222_n240# divbuf_0/a_14702_n240# 0.05fF
C8235 pll_full_0/divbuf_0/a_7792_n240# pll_full_0/divbuf_0/a_8272_n240# 0.05fF
C8236 pll_full_0/divbuf_0/a_28292_170# pll_full_0/divbuf_0/a_28292_n240# 0.01fF
C8237 divbuf_2/a_10080_n1600# divbuf_2/OUT3 0.00fF
C8238 divbuf_1/a_41280_n1600# divbuf_1/a_41310_n1540# 0.19fF
C8239 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n1540# 0.19fF
C8240 ro_div_0/divbuf_0/a_18582_170# ro_div_0/divbuf_0/a_18582_n240# 0.01fF
C8241 divbuf_0/a_29742_n240# divbuf_0/OUT4 0.04fF
C8242 divbuf_0/a_25950_n840# divbuf_0/a_26430_n840# 0.07fF
C8243 pll_full_0/divbuf_0/a_20190_n840# pll_full_0/divbuf_0/a_20670_n840# 0.07fF
C8244 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8245 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20190_n1540# 0.19fF
C8246 divbuf_1/a_38880_n1600# divbuf_1/a_38910_n840# 0.04fF
C8247 pd_div_0/pd_0/tspc_r_1/Z4 pd_div_0/pd_0/tspc_r_1/z5 0.04fF
C8248 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40350_n840# 0.04fF
C8249 ro_div_0/divbuf_0/a_36532_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8250 pll_full_0/divbuf_1/a_9242_170# pll_full_0/divbuf_1/a_9732_170# 0.07fF
C8251 divbuf_3/a_15182_170# divbuf_3/OUT4 0.19fF
C8252 divbuf_3/a_29760_n1600# divbuf_3/a_29790_n840# 0.04fF
C8253 divbuf_1/a_33150_n1540# divbuf_1/a_33630_n1540# 0.11fF
C8254 pd_div_0/divbuf_0/a_37920_n1600# pd_div_0/divbuf_0/a_38400_n1600# 0.26fF
C8255 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/a_28830_n840# 0.04fF
C8256 pll_full_0/divbuf_1/a_43200_n1600# pll_full_0/divbuf_1/a_43680_n1600# 0.26fF
C8257 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/a_34110_n840# 0.06fF
C8258 divbuf_2/a_3360_n1600# divbuf_2/a_3840_n1600# 0.26fF
C8259 divbuf_2/a_56640_n1600# divbuf_2/a_56670_n1540# 0.19fF
C8260 divbuf_2/a_26430_n840# divbuf_2/a_26430_n1540# 0.01fF
C8261 divbuf_2/a_56670_n840# divbuf_2/a_57150_n840# 0.07fF
C8262 pd_div_0/divbuf_0/a_30270_n1540# pd_div_0/divbuf_0/a_30750_n1540# 0.11fF
C8263 pd_div_0/divbuf_0/a_60990_n840# pd_div_0/divbuf_0/a_60990_n1540# 0.01fF
C8264 pll_full_0/divbuf_1/a_35550_n1540# pll_full_0/divbuf_1/a_36030_n1540# 0.11fF
C8265 divbuf_1/a_16642_n240# divbuf_1/a_17122_n240# 0.05fF
C8266 divbuf_1/a_36532_170# divbuf_1/a_36532_n240# 0.01fF
C8267 ro_div_0/divbuf_0/a_37992_170# ro_div_0/divbuf_0/a_37992_n240# 0.01fF
C8268 ro_div_0/divbuf_0/a_18092_n240# ro_div_0/divbuf_0/a_18582_n240# 0.04fF
C8269 divbuf_3/a_6822_n240# divbuf_3/a_7302_n240# 0.05fF
C8270 divbuf_3/a_27322_170# divbuf_3/a_27322_n240# 0.01fF
C8271 divbuf_1/a_28350_n840# divbuf_1/a_28830_n840# 0.07fF
C8272 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_29790_n1540# 0.19fF
C8273 ro_div_0/divbuf_0/a_29790_n840# ro_div_0/divbuf_0/a_30270_n840# 0.07fF
C8274 ro_div_0/divbuf_0/a_37502_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8275 divbuf_3/a_19230_n840# divbuf_3/a_19710_n840# 0.07fF
C8276 divbuf_3/a_16152_n240# divbuf_3/OUT4 0.04fF
C8277 divbuf_3/a_19200_n1600# divbuf_3/a_19230_n1540# 0.19fF
C8278 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_27870_n840# 0.04fF
C8279 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/OUT3 0.19fF
C8280 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C8281 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C8282 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8283 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33150_n840# 0.04fF
C8284 pll_full_0/pd_0/R pll_full_0/pd_0/REF 0.61fF
C8285 divbuf_2/a_14222_n240# divbuf_2/a_13950_n840# 0.01fF
C8286 divbuf_0/a_12480_n1600# divbuf_0/a_12960_n1600# 0.26fF
C8287 divbuf_1/a_50910_n840# divbuf_1/a_50910_n1540# 0.01fF
C8288 pll_full_0/divbuf_0/a_6720_n1600# pll_full_0/divbuf_0/a_7200_n1600# 0.26fF
C8289 divbuf_0/a_35550_n840# divbuf_0/a_35550_n1540# 0.01fF
C8290 divbuf_0/a_4830_n1540# divbuf_0/a_5310_n1540# 0.11fF
C8291 pll_full_0/divbuf_0/a_29790_n840# pll_full_0/divbuf_0/a_29790_n1540# 0.01fF
C8292 pll_full_0/divbuf_0/a_60030_n840# pll_full_0/divbuf_0/a_60510_n840# 0.07fF
C8293 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60030_n1540# 0.19fF
C8294 pd_div_0/divbuf_0/a_4882_n240# pd_div_0/divbuf_0/a_5362_n240# 0.05fF
C8295 pd_div_0/divbuf_0/a_25382_170# pd_div_0/divbuf_0/a_25382_n240# 0.01fF
C8296 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C8297 pll_full_0/divbuf_1/a_30712_170# pll_full_0/divbuf_1/a_30712_n240# 0.01fF
C8298 divbuf_2/a_9242_170# divbuf_2/a_9732_170# 0.07fF
C8299 pd_div_0/divbuf_0/a_17310_n840# pd_div_0/divbuf_0/a_17790_n840# 0.07fF
C8300 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8301 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17310_n1540# 0.19fF
C8302 ro_div_0/divider_0/tspc_2/Z1 ro_div_0/divider_0/tspc_2/Z4 0.00fF
C8303 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8304 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_22590_n1540# 0.19fF
C8305 pll_full_0/divbuf_1/a_22590_n840# pll_full_0/divbuf_1/a_23070_n840# 0.07fF
C8306 divbuf_2/a_43200_n1600# divbuf_2/a_43680_n1600# 0.26fF
C8307 divbuf_2/a_34112_n240# divbuf_2/a_34110_n840# 0.06fF
C8308 divbuf_1/a_2322_170# divbuf_1/OUT2 0.19fF
C8309 divbuf_0/a_2400_n1600# divbuf_0/a_2430_n840# 0.04fF
C8310 divbuf_2/a_35550_n1540# divbuf_2/a_36030_n1540# 0.11fF
C8311 divbuf_1/a_32652_170# divbuf_1/a_33142_170# 0.07fF
C8312 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C8313 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C8314 pll_full_0/divbuf_0/a_17612_n240# pll_full_0/divbuf_0/a_17310_n840# 0.00fF
C8315 divbuf_1/a_14880_n1600# divbuf_1/a_15360_n1600# 0.26fF
C8316 divbuf_1/a_5362_n240# divbuf_1/a_5310_n840# 0.04fF
C8317 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/a_6750_n840# 0.03fF
C8318 ro_div_0/divbuf_0/a_16320_n1600# ro_div_0/divbuf_0/a_16800_n1600# 0.26fF
C8319 divbuf_3/a_5760_n1600# divbuf_3/a_6240_n1600# 0.26fF
C8320 divbuf_1/a_7230_n1540# divbuf_1/a_7710_n1540# 0.11fF
C8321 ro_div_0/divbuf_0/a_39390_n840# ro_div_0/divbuf_0/a_39390_n1540# 0.01fF
C8322 ro_div_0/divbuf_0/a_8670_n1540# ro_div_0/divbuf_0/a_9150_n1540# 0.11fF
C8323 divbuf_3/a_59040_n1600# divbuf_3/a_59070_n1540# 0.19fF
C8324 divbuf_3/a_28830_n840# divbuf_3/a_28830_n1540# 0.01fF
C8325 divbuf_3/a_59070_n840# divbuf_3/a_59550_n840# 0.07fF
C8326 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/OUT3 0.00fF
C8327 divbuf_0/a_10212_170# divbuf_0/a_10212_n240# 0.01fF
C8328 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C8329 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/a_15182_170# 0.07fF
C8330 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C8331 divbuf_2/a_21982_170# divbuf_2/OUT4 0.19fF
C8332 divbuf_2/a_33120_n1600# divbuf_2/a_33150_n840# 0.04fF
C8333 divbuf_1/a_27802_170# divbuf_1/OUT4 0.19fF
C8334 gnd pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.63fF
C8335 pd_div_0/divider_0/nor_1/Z1 pd_div_0/divider_0/and_0/B 0.18fF
C8336 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/nor_0/B 0.47fF
C8337 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/Z2 0.36fF
C8338 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_0/Z3 0.05fF
C8339 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C8340 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/clk 0.01fF
C8341 divbuf_0/a_7792_170# divbuf_0/OUT3 0.19fF
C8342 divbuf_0/a_52320_n1600# divbuf_0/a_52800_n1600# 0.26fF
C8343 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C8344 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/a_37470_n840# 0.05fF
C8345 pll_full_0/divbuf_0/a_46560_n1600# pll_full_0/divbuf_0/a_47040_n1600# 0.26fF
C8346 divbuf_1/a_4800_n1600# divbuf_1/a_4830_n840# 0.04fF
C8347 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6270_n840# 0.04fF
C8348 divbuf_0/a_44670_n1540# divbuf_0/a_45150_n1540# 0.11fF
C8349 pll_full_0/divbuf_0/a_38910_n1540# pll_full_0/divbuf_0/a_39390_n1540# 0.11fF
C8350 divbuf_3/a_16642_n240# divbuf_3/a_16350_n840# 0.00fF
C8351 pd_div_0/divbuf_0/a_3840_n1600# pd_div_0/divbuf_0/a_4320_n1600# 0.26fF
C8352 pll_full_0/divbuf_1/a_9120_n1600# pll_full_0/divbuf_1/a_9600_n1600# 0.26fF
C8353 divbuf_2/a_30712_170# divbuf_2/a_30712_n240# 0.01fF
C8354 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57150_n1540# 0.19fF
C8355 pd_div_0/divbuf_0/a_26910_n840# pd_div_0/divbuf_0/a_26910_n1540# 0.01fF
C8356 pd_div_0/divbuf_0/a_57150_n840# pd_div_0/divbuf_0/a_57630_n840# 0.07fF
C8357 pll_full_0/divbuf_1/a_1470_n1540# pll_full_0/divbuf_1/a_1950_n1540# 0.11fF
C8358 pll_full_0/divbuf_1/a_32190_n840# pll_full_0/divbuf_1/a_32190_n1540# 0.01fF
C8359 pll_full_0/divbuf_1/a_60480_n1600# pll_full_0/divbuf_1/OUT5 0.26fF
C8360 pll_full_0/divbuf_0/a_14702_170# pll_full_0/divbuf_0/a_14702_n240# 0.01fF
C8361 divbuf_2/a_22952_n240# divbuf_2/OUT4 0.04fF
C8362 divbuf_2/a_22560_n1600# divbuf_2/a_22590_n1540# 0.19fF
C8363 divbuf_2/a_22590_n840# divbuf_2/a_23070_n840# 0.07fF
C8364 divbuf_1/a_32172_n240# divbuf_1/OUT4 0.04fF
C8365 ro_div_0/divbuf_0/a_22952_170# ro_div_0/divbuf_0/a_23442_170# 0.07fF
C8366 divbuf_1/a_10212_170# divbuf_1/a_10212_n240# 0.01fF
C8367 divbuf_0/a_42240_n1600# divbuf_0/a_42270_n840# 0.04fF
C8368 divbuf_0/a_40412_170# divbuf_0/OUT4 0.19fF
C8369 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8370 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36510_n840# 0.04fF
C8371 divbuf_3/a_12282_170# divbuf_3/a_12772_170# 0.07fF
C8372 divbuf_1/a_54720_n1600# divbuf_1/a_55200_n1600# 0.26fF
C8373 ro_div_0/divbuf_0/a_6822_170# ro_div_0/divbuf_0/OUT3 0.19fF
C8374 ro_div_0/divbuf_0/a_56160_n1600# ro_div_0/divbuf_0/a_56640_n1600# 0.26fF
C8375 divbuf_3/a_36532_n240# divbuf_3/a_36510_n840# 0.05fF
C8376 divbuf_3/a_45600_n1600# divbuf_3/a_46080_n1600# 0.26fF
C8377 pd_div_0/divbuf_0/a_14702_n240# pd_div_0/divbuf_0/a_14430_n840# 0.01fF
C8378 ro_div_0/divbuf_0/a_48510_n1540# ro_div_0/divbuf_0/a_48990_n1540# 0.11fF
C8379 divbuf_3/a_37950_n1540# divbuf_3/a_38430_n1540# 0.11fF
C8380 divbuf_0/a_20042_n240# divbuf_0/a_20532_n240# 0.04fF
C8381 divbuf_0/a_39932_170# divbuf_0/a_39932_n240# 0.01fF
C8382 pll_full_0/divbuf_0/a_14222_n240# pll_full_0/divbuf_0/a_14702_n240# 0.05fF
C8383 pll_full_0/divbuf_0/a_34112_170# pll_full_0/divbuf_0/a_34112_n240# 0.01fF
C8384 divbuf_2/a_21120_n1600# divbuf_2/OUT4 0.00fF
C8385 divbuf_1/a_47040_n1600# divbuf_1/a_47070_n1540# 0.19fF
C8386 divbuf_1/a_16830_n840# divbuf_1/a_16830_n1540# 0.01fF
C8387 divbuf_1/a_20532_170# divbuf_1/a_20532_n240# 0.01fF
C8388 divbuf_0/a_41382_n240# divbuf_0/OUT4 0.04fF
C8389 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n1540# 0.19fF
C8390 divbuf_0/a_31710_n840# divbuf_0/a_32190_n840# 0.07fF
C8391 divbuf_0/a_1470_n840# divbuf_0/a_1470_n1540# 0.01fF
C8392 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_25950_n1540# 0.19fF
C8393 pll_full_0/divbuf_0/a_25950_n840# pll_full_0/divbuf_0/a_26430_n840# 0.07fF
C8394 pll_full_0/divbuf_0/a_29742_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8395 divbuf_1/a_44640_n1600# divbuf_1/a_44670_n840# 0.04fF
C8396 pd_div_0/divbuf_0/a_7302_170# pd_div_0/divbuf_0/a_7792_170# 0.07fF
C8397 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46110_n840# 0.04fF
C8398 ro_div_0/divbuf_0/a_8762_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C8399 ro_div_0/divider_0/tspc_2/a_630_n680# gnd 0.61fF
C8400 pll_full_0/divbuf_1/a_15672_170# pll_full_0/divbuf_1/a_16152_170# 0.07fF
C8401 divbuf_3/a_26832_170# divbuf_3/OUT4 0.19fF
C8402 divbuf_3/a_35520_n1600# divbuf_3/a_35550_n840# 0.04fF
C8403 divbuf_1/a_38910_n1540# divbuf_1/a_39390_n1540# 0.11fF
C8404 pd_div_0/divbuf_0/a_43680_n1600# pd_div_0/divbuf_0/a_44160_n1600# 0.26fF
C8405 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/a_34590_n840# 0.06fF
C8406 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/switch_3/vin 0.20fF
C8407 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/a_39870_n840# 0.04fF
C8408 pll_full_0/divbuf_1/a_48960_n1600# pll_full_0/divbuf_1/a_49440_n1600# 0.26fF
C8409 divbuf_2/a_9120_n1600# divbuf_2/a_9600_n1600# 0.26fF
C8410 divbuf_2/a_1470_n1540# divbuf_2/a_1950_n1540# 0.11fF
C8411 divbuf_2/a_32190_n840# divbuf_2/a_32190_n1540# 0.01fF
C8412 divbuf_2/a_60480_n1600# divbuf_2/OUT5 0.26fF
C8413 pd_div_0/divbuf_0/a_36030_n1540# pd_div_0/divbuf_0/a_36510_n1540# 0.11fF
C8414 pll_full_0/divbuf_1/a_41310_n1540# pll_full_0/divbuf_1/a_41790_n1540# 0.11fF
C8415 divbuf_1/a_22472_n240# divbuf_1/a_22952_n240# 0.05fF
C8416 ro_div_0/divbuf_0/a_23922_n240# ro_div_0/divbuf_0/a_24412_n240# 0.04fF
C8417 divbuf_3/a_13252_n240# divbuf_3/a_13742_n240# 0.04fF
C8418 divbuf_3/a_33142_170# divbuf_3/a_33142_n240# 0.01fF
C8419 divbuf_1/a_3870_n840# divbuf_1/a_3870_n1540# 0.01fF
C8420 divbuf_1/a_34110_n840# divbuf_1/a_34590_n840# 0.07fF
C8421 pd_div_0/divbuf_0/a_14702_170# pd_div_0/divbuf_0/a_14702_n240# 0.01fF
C8422 pd_div_0/divbuf_0/a_9242_170# pd_div_0/divbuf_0/a_9242_n240# 0.01fF
C8423 ro_div_0/divbuf_0/a_35550_n840# ro_div_0/divbuf_0/a_36030_n840# 0.07fF
C8424 ro_div_0/divbuf_0/a_5310_n840# ro_div_0/divbuf_0/a_5310_n1540# 0.01fF
C8425 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_35550_n1540# 0.19fF
C8426 divbuf_3/a_27802_n240# divbuf_3/OUT4 0.04fF
C8427 divbuf_3/a_24960_n1600# divbuf_3/a_24990_n1540# 0.19fF
C8428 divbuf_3/a_24990_n840# divbuf_3/a_25470_n840# 0.07fF
C8429 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_33630_n840# 0.04fF
C8430 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8431 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C8432 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C8433 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C8434 ro_div_0/divider_0/tspc_0/a_630_n680# ro_div_0/divider_0/nor_1/A 0.35fF
C8435 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/nor_0/B 0.00fF
C8436 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8437 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_38910_n840# 0.04fF
C8438 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C8439 divbuf_0/a_8762_n240# divbuf_0/a_8670_n840# 0.03fF
C8440 divbuf_0/a_18240_n1600# divbuf_0/a_18720_n1600# 0.26fF
C8441 pll_full_0/divbuf_0/a_12480_n1600# pll_full_0/divbuf_0/a_12960_n1600# 0.26fF
C8442 divbuf_1/a_56670_n840# divbuf_1/a_56670_n1540# 0.01fF
C8443 divbuf_0/a_41310_n840# divbuf_0/a_41310_n1540# 0.01fF
C8444 divbuf_0/a_10590_n1540# divbuf_0/a_11070_n1540# 0.11fF
C8445 pll_full_0/divbuf_0/a_4830_n1540# pll_full_0/divbuf_0/a_5310_n1540# 0.11fF
C8446 pll_full_0/divbuf_0/a_35550_n840# pll_full_0/divbuf_0/a_35550_n1540# 0.01fF
C8447 pd_div_0/divbuf_0/a_11312_n240# pd_div_0/divbuf_0/a_11802_n240# 0.04fF
C8448 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/a_31202_n240# 0.01fF
C8449 pll_full_0/divbuf_1/a_16642_n240# pll_full_0/divbuf_1/a_17122_n240# 0.05fF
C8450 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/a_36532_n240# 0.01fF
C8451 divbuf_2/a_15672_170# divbuf_2/a_16152_170# 0.07fF
C8452 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8453 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23070_n1540# 0.19fF
C8454 pd_div_0/divbuf_0/a_23070_n840# pd_div_0/divbuf_0/a_23550_n840# 0.07fF
C8455 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8456 pll_full_0/divbuf_1/a_28350_n840# pll_full_0/divbuf_1/a_28830_n840# 0.07fF
C8457 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28350_n1540# 0.19fF
C8458 divbuf_2/a_39932_n240# divbuf_2/a_39870_n840# 0.04fF
C8459 divbuf_2/a_48960_n1600# divbuf_2/a_49440_n1600# 0.26fF
C8460 divbuf_0/a_8160_n1600# divbuf_0/a_8190_n840# 0.04fF
C8461 divbuf_2/a_41310_n1540# divbuf_2/a_41790_n1540# 0.11fF
C8462 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/nor_1/B 0.22fF
C8463 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C8464 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C8465 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2430_n840# 0.04fF
C8466 divbuf_1/a_20640_n1600# divbuf_1/a_21120_n1600# 0.26fF
C8467 divbuf_1/a_11312_n240# divbuf_1/a_11550_n840# 0.02fF
C8468 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_12990_n840# 0.02fF
C8469 ro_div_0/divbuf_0/a_22080_n1600# ro_div_0/divbuf_0/a_22560_n1600# 0.26fF
C8470 divbuf_3/a_11520_n1600# divbuf_3/a_12000_n1600# 0.26fF
C8471 divbuf_1/a_12990_n1540# divbuf_1/a_13470_n1540# 0.11fF
C8472 ro_div_0/divbuf_0/a_45150_n840# ro_div_0/divbuf_0/a_45150_n1540# 0.01fF
C8473 ro_div_0/divbuf_0/a_14430_n1540# ro_div_0/divbuf_0/a_14910_n1540# 0.11fF
C8474 divbuf_3/a_3870_n1540# divbuf_3/a_4350_n1540# 0.11fF
C8475 divbuf_3/a_34590_n840# divbuf_3/a_34590_n1540# 0.01fF
C8476 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C8477 divbuf_0/a_24892_170# divbuf_0/a_25382_170# 0.07fF
C8478 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C8479 pll_full_0/divbuf_0/a_5852_170# pll_full_0/divbuf_0/a_5852_n240# 0.01fF
C8480 divbuf_2/a_33622_170# divbuf_2/OUT4 0.19fF
C8481 divbuf_2/a_38880_n1600# divbuf_2/a_38910_n840# 0.04fF
C8482 divbuf_1/a_3422_n240# divbuf_1/OUT3 0.07fF
C8483 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/a_1842_170# 0.07fF
C8484 divbuf_0/a_58080_n1600# divbuf_0/a_58560_n1600# 0.26fF
C8485 divbuf_0/a_11802_170# divbuf_0/OUT4 0.19fF
C8486 gnd pll_full_0/divider_0/prescaler_0/nand_1/z1 0.16fF
C8487 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C8488 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C8489 pll_full_0/divbuf_0/a_52320_n1600# pll_full_0/divbuf_0/a_52800_n1600# 0.26fF
C8490 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8491 divbuf_1/a_10560_n1600# divbuf_1/a_10590_n840# 0.04fF
C8492 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12030_n840# 0.04fF
C8493 divbuf_0/a_50430_n1540# divbuf_0/a_50910_n1540# 0.11fF
C8494 pll_full_0/divbuf_0/a_44670_n1540# pll_full_0/divbuf_0/a_45150_n1540# 0.11fF
C8495 divbuf_3/a_1440_n1600# divbuf_3/a_1470_n840# 0.04fF
C8496 pd_div_0/divbuf_0/a_9600_n1600# pd_div_0/divbuf_0/a_10080_n1600# 0.26fF
C8497 pll_full_0/divbuf_1/a_14880_n1600# pll_full_0/divbuf_1/a_15360_n1600# 0.26fF
C8498 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/a_5310_n840# 0.04fF
C8499 divbuf_2/a_16642_n240# divbuf_2/a_17122_n240# 0.05fF
C8500 divbuf_2/a_36532_170# divbuf_2/a_36532_n240# 0.01fF
C8501 pd_div_0/divbuf_0/a_1950_n1540# pd_div_0/divbuf_0/a_2430_n1540# 0.11fF
C8502 pd_div_0/divbuf_0/a_32670_n840# pd_div_0/divbuf_0/a_32670_n1540# 0.01fF
C8503 pll_full_0/divbuf_1/a_7230_n1540# pll_full_0/divbuf_1/a_7710_n1540# 0.11fF
C8504 pll_full_0/divbuf_1/a_37950_n840# pll_full_0/divbuf_1/a_37950_n1540# 0.01fF
C8505 divbuf_2/a_34592_n240# divbuf_2/OUT4 0.04fF
C8506 divbuf_2/a_28350_n840# divbuf_2/a_28830_n840# 0.07fF
C8507 divbuf_2/a_28320_n1600# divbuf_2/a_28350_n1540# 0.19fF
C8508 divbuf_1/a_2880_n1600# divbuf_1/OUT2 0.00fF
C8509 ro_div_0/divbuf_0/a_28772_170# ro_div_0/divbuf_0/a_29262_170# 0.07fF
C8510 divbuf_3/a_18092_170# divbuf_3/a_18582_170# 0.07fF
C8511 divbuf_1/a_33622_170# divbuf_1/a_33622_n240# 0.01fF
C8512 divbuf_1/a_23922_170# divbuf_1/a_24412_170# 0.07fF
C8513 divbuf_0/a_48000_n1600# divbuf_0/a_48030_n840# 0.04fF
C8514 divbuf_0/a_12772_n240# divbuf_0/OUT4 0.04fF
C8515 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8516 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42270_n840# 0.04fF
C8517 pd_div_0/pd_0/tspc_r_0/Z2 pd_div_0/pd_0/tspc_r_0/Z4 0.14fF
C8518 ro_div_0/divbuf_0/a_1470_n840# ro_div_0/divbuf_0/a_1950_n840# 0.07fF
C8519 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1470_n1540# 0.19fF
C8520 divbuf_3/a_51360_n1600# divbuf_3/a_51840_n1600# 0.26fF
C8521 ro_div_0/divbuf_0/a_54270_n1540# ro_div_0/divbuf_0/a_54750_n1540# 0.11fF
C8522 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_4830_n840# 0.04fF
C8523 divbuf_3/a_43710_n1540# divbuf_3/a_44190_n1540# 0.11fF
C8524 divbuf_0/a_25862_n240# divbuf_0/a_26352_n240# 0.04fF
C8525 pll_full_0/divbuf_0/a_39932_170# pll_full_0/divbuf_0/a_39932_n240# 0.01fF
C8526 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/a_20532_n240# 0.04fF
C8527 divbuf_2/a_32640_n1600# divbuf_2/OUT4 0.00fF
C8528 divbuf_1/a_22590_n840# divbuf_1/a_22590_n1540# 0.01fF
C8529 divbuf_1/a_52800_n1600# divbuf_1/a_52830_n1540# 0.19fF
C8530 divbuf_1/a_26352_170# divbuf_1/a_26352_n240# 0.01fF
C8531 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n1540# 0.19fF
C8532 divbuf_0/a_37470_n840# divbuf_0/a_37950_n840# 0.07fF
C8533 divbuf_0/a_7230_n840# divbuf_0/a_7230_n1540# 0.01fF
C8534 divbuf_0/a_11040_n1600# divbuf_0/OUT4 0.00fF
C8535 pll_full_0/divbuf_0/a_1470_n840# pll_full_0/divbuf_0/a_1470_n1540# 0.01fF
C8536 pll_full_0/divbuf_0/a_31710_n840# pll_full_0/divbuf_0/a_32190_n840# 0.07fF
C8537 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_31710_n1540# 0.19fF
C8538 pll_full_0/divbuf_0/a_41382_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8539 divbuf_1/a_50400_n1600# divbuf_1/a_50430_n840# 0.04fF
C8540 pd_div_0/divbuf_0/a_16152_170# pd_div_0/divbuf_0/a_16642_170# 0.07fF
C8541 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_51870_n840# 0.04fF
C8542 ro_div_0/divbuf_0/a_20532_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8543 pll_full_0/divbuf_1/a_21502_170# pll_full_0/divbuf_1/a_21982_170# 0.07fF
C8544 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C8545 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C8546 divbuf_3/a_38472_170# divbuf_3/OUT4 0.19fF
C8547 divbuf_3/a_41280_n1600# divbuf_3/a_41310_n840# 0.04fF
C8548 divbuf_1/a_44670_n1540# divbuf_1/a_45150_n1540# 0.11fF
C8549 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/a_40350_n840# 0.04fF
C8550 pd_div_0/divbuf_0/a_49440_n1600# pd_div_0/divbuf_0/a_49920_n1600# 0.26fF
C8551 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C8552 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/tspc_1/a_630_n680# 0.01fF
C8553 pll_full_0/divbuf_1/a_54720_n1600# pll_full_0/divbuf_1/a_55200_n1600# 0.26fF
C8554 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/OUT3 0.19fF
C8555 divbuf_2/a_14880_n1600# divbuf_2/a_15360_n1600# 0.26fF
C8556 divbuf_2/a_5362_n240# divbuf_2/a_5310_n840# 0.04fF
C8557 pd_div_0/divbuf_0/a_41790_n1540# pd_div_0/divbuf_0/a_42270_n1540# 0.11fF
C8558 divbuf_2/a_7230_n1540# divbuf_2/a_7710_n1540# 0.11fF
C8559 divbuf_2/a_37950_n840# divbuf_2/a_37950_n1540# 0.01fF
C8560 pll_full_0/divbuf_1/a_47070_n1540# pll_full_0/divbuf_1/a_47550_n1540# 0.11fF
C8561 ro_div_0/divbuf_0/a_29742_n240# ro_div_0/divbuf_0/a_30232_n240# 0.04fF
C8562 divbuf_1/a_28292_n240# divbuf_1/a_28772_n240# 0.05fF
C8563 divbuf_3/a_38962_170# divbuf_3/a_38962_n240# 0.01fF
C8564 divbuf_3/a_19072_n240# divbuf_3/a_19562_n240# 0.04fF
C8565 divbuf_1/a_9630_n840# divbuf_1/a_9630_n1540# 0.01fF
C8566 divbuf_1/a_39870_n840# divbuf_1/a_40350_n840# 0.07fF
C8567 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41310_n1540# 0.19fF
C8568 ro_div_0/divbuf_0/a_41310_n840# ro_div_0/divbuf_0/a_41790_n840# 0.07fF
C8569 ro_div_0/divbuf_0/a_11070_n840# ro_div_0/divbuf_0/a_11070_n1540# 0.01fF
C8570 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/a_480_n1600# 0.00fF
C8571 divbuf_3/a_39442_n240# divbuf_3/OUT4 0.04fF
C8572 divbuf_3/a_30750_n840# divbuf_3/a_31230_n840# 0.07fF
C8573 divbuf_3/a_510_n840# divbuf_3/a_510_n1540# 0.01fF
C8574 divbuf_3/a_30720_n1600# divbuf_3/a_30750_n1540# 0.19fF
C8575 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8576 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39390_n840# 0.04fF
C8577 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 ro_div_0/divider_0/prescaler_0/Out 0.08fF
C8578 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 ro_div_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C8579 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z3 0.45fF
C8580 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C8581 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_44670_n840# 0.04fF
C8582 divbuf_2/a_4800_n1600# divbuf_2/a_4830_n840# 0.04fF
C8583 divbuf_0/a_14702_n240# divbuf_0/a_14910_n840# 0.02fF
C8584 divbuf_0/a_24000_n1600# divbuf_0/a_24480_n1600# 0.26fF
C8585 pll_full_0/divbuf_0/a_18240_n1600# pll_full_0/divbuf_0/a_18720_n1600# 0.26fF
C8586 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/a_8670_n840# 0.03fF
C8587 divbuf_0/a_47070_n840# divbuf_0/a_47070_n1540# 0.01fF
C8588 divbuf_0/a_16350_n1540# divbuf_0/a_16830_n1540# 0.11fF
C8589 pll_full_0/divbuf_0/a_10590_n1540# pll_full_0/divbuf_0/a_11070_n1540# 0.11fF
C8590 pll_full_0/divbuf_0/a_41310_n840# pll_full_0/divbuf_0/a_41310_n1540# 0.01fF
C8591 pd_div_0/divbuf_0/a_17122_n240# pd_div_0/divbuf_0/a_17612_n240# 0.04fF
C8592 pd_div_0/divbuf_0/a_37022_170# pd_div_0/divbuf_0/a_37022_n240# 0.01fF
C8593 pll_full_0/divbuf_1/a_22472_n240# pll_full_0/divbuf_1/a_22952_n240# 0.05fF
C8594 divbuf_2/a_21502_170# divbuf_2/a_21982_170# 0.07fF
C8595 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8596 pd_div_0/divbuf_0/a_28830_n840# pd_div_0/divbuf_0/a_29310_n840# 0.07fF
C8597 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_28830_n1540# 0.19fF
C8598 divbuf_0/a_17612_170# divbuf_0/a_17612_n240# 0.01fF
C8599 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34110_n1540# 0.19fF
C8600 pll_full_0/divbuf_1/a_3870_n840# pll_full_0/divbuf_1/a_3870_n1540# 0.01fF
C8601 pll_full_0/divbuf_1/a_34110_n840# pll_full_0/divbuf_1/a_34590_n840# 0.07fF
C8602 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C8603 divbuf_2/a_54720_n1600# divbuf_2/a_55200_n1600# 0.26fF
C8604 divbuf_2/a_4882_170# divbuf_2/OUT3 0.19fF
C8605 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C8606 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/a4 0.12fF
C8607 divbuf_0/a_13920_n1600# divbuf_0/a_13950_n840# 0.04fF
C8608 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8190_n840# 0.04fF
C8609 divbuf_2/a_47070_n1540# divbuf_2/a_47550_n1540# 0.11fF
C8610 divbuf_1/a_9732_170# divbuf_1/a_10212_170# 0.07fF
C8611 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/nor_1/A 0.21fF
C8612 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C8613 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_0/D 0.16fF
C8614 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.05fF
C8615 divbuf_1/a_26400_n1600# divbuf_1/a_26880_n1600# 0.26fF
C8616 divbuf_1/a_17122_n240# divbuf_1/a_17310_n840# 0.02fF
C8617 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/a_18750_n840# 0.02fF
C8618 ro_div_0/divbuf_0/a_27840_n1600# ro_div_0/divbuf_0/a_28320_n1600# 0.26fF
C8619 divbuf_3/a_17280_n1600# divbuf_3/a_17760_n1600# 0.26fF
C8620 divbuf_3/a_7792_n240# divbuf_3/a_7710_n840# 0.03fF
C8621 ro_div_0/divbuf_0/a_50910_n840# ro_div_0/divbuf_0/a_50910_n1540# 0.01fF
C8622 ro_div_0/divbuf_0/a_20190_n1540# ro_div_0/divbuf_0/a_20670_n1540# 0.11fF
C8623 divbuf_3/a_9630_n1540# divbuf_3/a_10110_n1540# 0.11fF
C8624 divbuf_3/a_40350_n840# divbuf_3/a_40350_n1540# 0.01fF
C8625 divbuf_2/a_492_n240# divbuf_2/a_480_n1600# 0.00fF
C8626 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C8627 divbuf_0/a_30712_170# divbuf_0/a_31202_170# 0.07fF
C8628 divbuf_0/a_11312_170# divbuf_0/a_11312_n240# 0.01fF
C8629 pll_full_0/divbuf_0/a_24892_170# pll_full_0/divbuf_0/a_25382_170# 0.07fF
C8630 divbuf_2/a_5852_n240# divbuf_2/OUT3 0.04fF
C8631 divbuf_2/a_44640_n1600# divbuf_2/a_44670_n840# 0.04fF
C8632 divbuf_1/a_15182_n240# divbuf_1/OUT4 0.04fF
C8633 divbuf_1/a_18720_n1600# divbuf_1/a_18750_n1540# 0.19fF
C8634 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n1540# 0.19fF
C8635 divbuf_0/a_23442_170# divbuf_0/OUT4 0.19fF
C8636 divbuf_0/a_3390_n840# divbuf_0/a_3870_n840# 0.07fF
C8637 gnd pll_full_0/divider_0/and_0/Z1 0.32fF
C8638 pd_div_0/divider_0/and_0/OUT pd_div_0/divider_0/and_0/Z1 0.04fF
C8639 pd_div_0/divider_0/tspc_2/a_630_n680# pd_div_0/bufin 0.04fF
C8640 pd_div_0/divider_0/nor_0/B pd_div_0/divider_0/tspc_2/Z2 0.40fF
C8641 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/clk 0.05fF
C8642 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C8643 pll_full_0/divbuf_0/a_58080_n1600# pll_full_0/divbuf_0/a_58560_n1600# 0.26fF
C8644 divbuf_1/a_16320_n1600# divbuf_1/a_16350_n840# 0.04fF
C8645 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/OUT4 0.07fF
C8646 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_17790_n840# 0.04fF
C8647 divbuf_0/a_56190_n1540# divbuf_0/a_56670_n1540# 0.11fF
C8648 pll_full_0/divbuf_0/a_50430_n1540# pll_full_0/divbuf_0/a_50910_n1540# 0.11fF
C8649 divbuf_3/a_7200_n1600# divbuf_3/a_7230_n840# 0.04fF
C8650 pd_div_0/divbuf_0/a_15360_n1600# pd_div_0/divbuf_0/a_15840_n1600# 0.26fF
C8651 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/a_5790_n840# 0.04fF
C8652 pll_full_0/divbuf_1/a_20640_n1600# pll_full_0/divbuf_1/a_21120_n1600# 0.26fF
C8653 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11550_n840# 0.02fF
C8654 divbuf_2/a_22472_n240# divbuf_2/a_22952_n240# 0.05fF
C8655 pd_div_0/divbuf_0/a_7710_n1540# pd_div_0/divbuf_0/a_8190_n1540# 0.11fF
C8656 pd_div_0/divbuf_0/a_38430_n840# pd_div_0/divbuf_0/a_38430_n1540# 0.01fF
C8657 pll_full_0/divbuf_1/a_12990_n1540# pll_full_0/divbuf_1/a_13470_n1540# 0.11fF
C8658 pll_full_0/divbuf_1/a_43710_n840# pll_full_0/divbuf_1/a_43710_n1540# 0.01fF
C8659 divbuf_2/a_34080_n1600# divbuf_2/a_34110_n1540# 0.19fF
C8660 divbuf_2/a_3870_n840# divbuf_2/a_3870_n1540# 0.01fF
C8661 divbuf_2/a_34110_n840# divbuf_2/a_34590_n840# 0.07fF
C8662 divbuf_1/a_13440_n1600# divbuf_1/OUT4 0.00fF
C8663 ro_div_0/divbuf_0/a_34592_170# ro_div_0/divbuf_0/a_35082_170# 0.07fF
C8664 divbuf_3/a_3912_170# divbuf_3/a_3912_n240# 0.01fF
C8665 divbuf_3/a_23922_170# divbuf_3/a_24412_170# 0.07fF
C8666 divbuf_1/a_29742_170# divbuf_1/a_30232_170# 0.07fF
C8667 divbuf_0/a_53760_n1600# divbuf_0/a_53790_n840# 0.04fF
C8668 divbuf_0/a_24412_n240# divbuf_0/OUT4 0.04fF
C8669 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8670 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48030_n840# 0.04fF
C8671 divbuf_1/a_5790_n840# divbuf_1/a_6270_n840# 0.07fF
C8672 divbuf_1/a_5760_n1600# divbuf_1/a_5790_n1540# 0.19fF
C8673 pd_div_0/pd_0/R pd_div_0/pd_0/and_pd_0/Out1 0.33fF
C8674 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z4 0.02fF
C8675 pd_div_0/pd_0/UP pd_div_0/pd_0/tspc_r_1/Qbar 0.21fF
C8676 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7230_n1540# 0.19fF
C8677 ro_div_0/divbuf_0/a_31202_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8678 ro_div_0/divbuf_0/a_7230_n840# ro_div_0/divbuf_0/a_7710_n840# 0.07fF
C8679 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 gnd 0.27fF
C8680 divbuf_3/a_9732_170# divbuf_3/OUT3 0.19fF
C8681 divbuf_3/a_57120_n1600# divbuf_3/a_57600_n1600# 0.26fF
C8682 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5310_n840# 0.04fF
C8683 ro_div_0/divbuf_0/a_60030_n1540# ro_div_0/divbuf_0/a_60510_n1540# 0.11fF
C8684 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_10590_n840# 0.04fF
C8685 divbuf_3/a_49470_n1540# divbuf_3/a_49950_n1540# 0.11fF
C8686 divbuf_0/a_31682_n240# divbuf_0/a_32172_n240# 0.04fF
C8687 pll_full_0/divbuf_0/a_25862_n240# pll_full_0/divbuf_0/a_26352_n240# 0.04fF
C8688 divbuf_1/a_58560_n1600# divbuf_1/a_58590_n1540# 0.19fF
C8689 divbuf_1/a_28350_n840# divbuf_1/a_28350_n1540# 0.01fF
C8690 divbuf_0/a_22560_n1600# divbuf_0/OUT4 0.01fF
C8691 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n1540# 0.19fF
C8692 divbuf_0/a_43230_n840# divbuf_0/a_43710_n840# 0.07fF
C8693 divbuf_0/a_12990_n840# divbuf_0/a_12990_n1540# 0.01fF
C8694 pll_full_0/divbuf_0/a_11040_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C8695 pll_full_0/divbuf_0/a_7230_n840# pll_full_0/divbuf_0/a_7230_n1540# 0.01fF
C8696 pll_full_0/divbuf_0/a_37470_n840# pll_full_0/divbuf_0/a_37950_n840# 0.07fF
C8697 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37470_n1540# 0.19fF
C8698 divbuf_1/a_56160_n1600# divbuf_1/a_56190_n840# 0.04fF
C8699 pd_div_0/divbuf_0/a_21982_170# pd_div_0/divbuf_0/a_22472_170# 0.07fF
C8700 pd_div_0/divbuf_0/a_5852_170# pd_div_0/divbuf_0/a_5852_n240# 0.01fF
C8701 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_57630_n840# 0.04fF
C8702 ro_div_0/divbuf_0/a_32172_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8703 pll_full_0/divbuf_1/a_7302_170# pll_full_0/divbuf_1/a_7302_n240# 0.01fF
C8704 pll_full_0/divbuf_1/a_27322_170# pll_full_0/divbuf_1/a_27802_170# 0.07fF
C8705 divbuf_3/a_10212_n240# divbuf_3/OUT4 0.04fF
C8706 divbuf_3/a_47040_n1600# divbuf_3/a_47070_n840# 0.04fF
C8707 divbuf_1/a_50430_n1540# divbuf_1/a_50910_n1540# 0.11fF
C8708 pd_div_0/divbuf_0/a_55200_n1600# pd_div_0/divbuf_0/a_55680_n1600# 0.26fF
C8709 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8710 ro_div_0/divider_0/tspc_0/Z4 ro_div_0/divider_0/tspc_0/a_630_n680# 0.12fF
C8711 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8712 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C8713 divbuf_2/a_20640_n1600# divbuf_2/a_21120_n1600# 0.26fF
C8714 divbuf_2/a_11312_n240# divbuf_2/a_11550_n840# 0.02fF
C8715 pd_div_0/divbuf_0/a_47550_n1540# pd_div_0/divbuf_0/a_48030_n1540# 0.11fF
C8716 divbuf_2/a_12990_n1540# divbuf_2/a_13470_n1540# 0.11fF
C8717 divbuf_2/a_43710_n840# divbuf_2/a_43710_n1540# 0.01fF
C8718 pll_full_0/divbuf_1/a_52830_n1540# pll_full_0/divbuf_1/a_53310_n1540# 0.11fF
C8719 ro_div_0/divbuf_0/a_35562_n240# ro_div_0/divbuf_0/a_36052_n240# 0.04fF
C8720 divbuf_1/a_34112_n240# divbuf_1/a_34592_n240# 0.05fF
C8721 divbuf_3/a_24892_n240# divbuf_3/a_25382_n240# 0.04fF
C8722 divbuf_1/a_45630_n840# divbuf_1/a_46110_n840# 0.07fF
C8723 ro_div_0/divbuf_0/a_47070_n840# ro_div_0/divbuf_0/a_47550_n840# 0.07fF
C8724 ro_div_0/divbuf_0/a_16830_n840# ro_div_0/divbuf_0/a_16830_n1540# 0.01fF
C8725 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47070_n1540# 0.19fF
C8726 divbuf_3/a_36480_n1600# divbuf_3/a_36510_n1540# 0.19fF
C8727 divbuf_3/a_9600_n1600# divbuf_3/OUT3 0.00fF
C8728 divbuf_3/a_6270_n840# divbuf_3/a_6270_n1540# 0.01fF
C8729 divbuf_3/a_36510_n840# divbuf_3/a_36990_n840# 0.07fF
C8730 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C8731 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45150_n840# 0.04fF
C8732 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.45fF
C8733 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8734 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50430_n840# 0.04fF
C8735 pll_full_0/divbuf_0/a_9732_170# pll_full_0/divbuf_0/a_10212_170# 0.07fF
C8736 divbuf_2/a_10560_n1600# divbuf_2/a_10590_n840# 0.04fF
C8737 cp_0/upbar cp_0/down 0.02fF
C8738 divbuf_0/a_20532_n240# divbuf_0/a_20670_n840# 0.03fF
C8739 divbuf_0/a_29760_n1600# divbuf_0/a_30240_n1600# 0.26fF
C8740 pll_full_0/divbuf_0/a_24000_n1600# pll_full_0/divbuf_0/a_24480_n1600# 0.26fF
C8741 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_14910_n840# 0.02fF
C8742 divbuf_1/a_2322_n240# divbuf_1/a_2430_n840# 0.03fF
C8743 divbuf_0/a_52830_n840# divbuf_0/a_52830_n1540# 0.01fF
C8744 divbuf_0/a_22110_n1540# divbuf_0/a_22590_n1540# 0.11fF
C8745 pll_full_0/divbuf_0/a_16350_n1540# pll_full_0/divbuf_0/a_16830_n1540# 0.11fF
C8746 pll_full_0/divbuf_0/a_47070_n840# pll_full_0/divbuf_0/a_47070_n1540# 0.01fF
C8747 pd_div_0/divbuf_0/a_22952_n240# pd_div_0/divbuf_0/a_23442_n240# 0.04fF
C8748 pll_full_0/divbuf_1/a_28292_n240# pll_full_0/divbuf_1/a_28772_n240# 0.05fF
C8749 divbuf_2/a_7302_170# divbuf_2/a_7302_n240# 0.01fF
C8750 divbuf_2/a_27322_170# divbuf_2/a_27802_170# 0.07fF
C8751 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_34590_n1540# 0.19fF
C8752 pd_div_0/divbuf_0/a_4350_n840# pd_div_0/divbuf_0/a_4350_n1540# 0.01fF
C8753 pd_div_0/divbuf_0/a_34590_n840# pd_div_0/divbuf_0/a_35070_n840# 0.07fF
C8754 divbuf_0/a_9242_170# divbuf_0/a_9242_n240# 0.01fF
C8755 pll_full_0/divbuf_1/a_9630_n840# pll_full_0/divbuf_1/a_9630_n1540# 0.01fF
C8756 pll_full_0/divbuf_1/a_39870_n840# pll_full_0/divbuf_1/a_40350_n840# 0.07fF
C8757 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_39870_n1540# 0.19fF
C8758 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C8759 divbuf_2/a_16642_170# divbuf_2/OUT4 0.19fF
C8760 divbuf_1/a_22472_170# divbuf_1/OUT4 0.19fF
C8761 ro_div_0/ro_complete_0/cbank_1/switch_1/vin ro_div_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C8762 ro_div_0/divbuf_0/a_12772_170# ro_div_0/divbuf_0/a_13252_170# 0.07fF
C8763 ro_div_0/divbuf_0/a_5852_170# ro_div_0/divbuf_0/a_6332_170# 0.07fF
C8764 divbuf_0/a_19680_n1600# divbuf_0/a_19710_n840# 0.04fF
C8765 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_13950_n840# 0.04fF
C8766 divbuf_2/a_52830_n1540# divbuf_2/a_53310_n1540# 0.11fF
C8767 divbuf_1/a_6332_170# divbuf_1/a_6822_170# 0.07fF
C8768 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/nor_1/A 0.15fF
C8769 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C8770 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C8771 divbuf_1/a_32160_n1600# divbuf_1/a_32640_n1600# 0.26fF
C8772 divbuf_1/a_22952_n240# divbuf_1/a_23070_n840# 0.03fF
C8773 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/a_24510_n840# 0.03fF
C8774 ro_div_0/divbuf_0/a_33600_n1600# ro_div_0/divbuf_0/a_34080_n1600# 0.26fF
C8775 divbuf_3/a_13742_n240# divbuf_3/a_13950_n840# 0.02fF
C8776 divbuf_3/a_23040_n1600# divbuf_3/a_23520_n1600# 0.26fF
C8777 ro_div_0/divbuf_0/a_56670_n840# ro_div_0/divbuf_0/a_56670_n1540# 0.01fF
C8778 ro_div_0/divbuf_0/a_25950_n1540# ro_div_0/divbuf_0/a_26430_n1540# 0.11fF
C8779 divbuf_3/a_15390_n1540# divbuf_3/a_15870_n1540# 0.11fF
C8780 divbuf_3/a_46110_n840# divbuf_3/a_46110_n1540# 0.01fF
C8781 divbuf_0/a_36532_170# divbuf_0/a_37022_170# 0.07fF
C8782 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/a_31202_170# 0.07fF
C8783 divbuf_2/a_17612_n240# divbuf_2/OUT4 0.04fF
C8784 divbuf_2/a_50400_n1600# divbuf_2/a_50430_n840# 0.04fF
C8785 divbuf_1/a_26832_n240# divbuf_1/OUT4 0.04fF
C8786 divbuf_1/a_24480_n1600# divbuf_1/a_24510_n1540# 0.19fF
C8787 ro_div_0/divbuf_0/a_4392_170# ro_div_0/divbuf_0/a_4392_n240# 0.01fF
C8788 ro_div_0/divbuf_0/a_10212_170# ro_div_0/divbuf_0/a_10212_n240# 0.01fF
C8789 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n1540# 0.19fF
C8790 divbuf_0/a_35082_170# divbuf_0/OUT4 0.19fF
C8791 divbuf_0/a_9150_n840# divbuf_0/a_9630_n840# 0.07fF
C8792 pll_full_0/divbuf_0/a_3390_n840# pll_full_0/divbuf_0/a_3870_n840# 0.07fF
C8793 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8794 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3390_n1540# 0.19fF
C8795 divbuf_1/a_22080_n1600# divbuf_1/a_22110_n840# 0.04fF
C8796 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_23550_n840# 0.04fF
C8797 pll_full_0/divbuf_0/a_56190_n1540# pll_full_0/divbuf_0/a_56670_n1540# 0.11fF
C8798 divbuf_3/a_12960_n1600# divbuf_3/a_12990_n840# 0.04fF
C8799 divbuf_1/a_16350_n1540# divbuf_1/a_16830_n1540# 0.11fF
C8800 pd_div_0/divbuf_0/a_21120_n1600# pd_div_0/divbuf_0/a_21600_n1600# 0.26fF
C8801 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_12030_n840# 0.02fF
C8802 pll_full_0/divbuf_1/a_26400_n1600# pll_full_0/divbuf_1/a_26880_n1600# 0.26fF
C8803 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_17310_n840# 0.02fF
C8804 divbuf_2/a_28292_n240# divbuf_2/a_28772_n240# 0.05fF
C8805 pd_div_0/divbuf_0/a_13470_n1540# pd_div_0/divbuf_0/a_13950_n1540# 0.11fF
C8806 pd_div_0/divbuf_0/a_44190_n840# pd_div_0/divbuf_0/a_44190_n1540# 0.01fF
C8807 pll_full_0/divbuf_1/a_18750_n1540# pll_full_0/divbuf_1/a_19230_n1540# 0.11fF
C8808 pll_full_0/divbuf_1/a_49470_n840# pll_full_0/divbuf_1/a_49470_n1540# 0.01fF
C8809 divbuf_2/a_9630_n840# divbuf_2/a_9630_n1540# 0.01fF
C8810 divbuf_2/a_39870_n840# divbuf_2/a_40350_n840# 0.07fF
C8811 divbuf_2/a_39840_n1600# divbuf_2/a_39870_n1540# 0.19fF
C8812 divbuf_1/a_24960_n1600# divbuf_1/OUT4 0.00fF
C8813 ro_div_0/divbuf_0/a_40412_170# ro_div_0/divbuf_0/a_40902_170# 0.07fF
C8814 ro_div_0/divbuf_0/a_21012_170# ro_div_0/divbuf_0/a_21012_n240# 0.01fF
C8815 divbuf_0/a_59520_n1600# divbuf_0/a_59550_n840# 0.04fF
C8816 divbuf_0/a_36052_n240# divbuf_0/OUT4 0.04fF
C8817 divbuf_3/a_9732_170# divbuf_3/a_9732_n240# 0.01fF
C8818 divbuf_3/a_29742_170# divbuf_3/a_30232_170# 0.07fF
C8819 divbuf_1/a_38962_170# divbuf_1/a_39442_170# 0.07fF
C8820 pll_full_0/divbuf_0/a_24412_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8821 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_53790_n840# 0.04fF
C8822 divbuf_1/a_11520_n1600# divbuf_1/a_11550_n1540# 0.19fF
C8823 divbuf_1/a_11550_n840# divbuf_1/a_12030_n840# 0.07fF
C8824 ro_div_0/ro_complete_0/a5 ro_div_0/divider_0/clk 0.10fF
C8825 ro_div_0/divbuf_0/a_12990_n840# ro_div_0/divbuf_0/a_13470_n840# 0.07fF
C8826 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/IN 0.13fF
C8827 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_12990_n1540# 0.19fF
C8828 ro_div_0/divbuf_0/a_3422_n240# ro_div_0/divbuf_0/OUT3 0.07fF
C8829 ro_div_0/divider_0/prescaler_0/nand_0/z1 gnd 0.16fF
C8830 divbuf_3/a_21502_170# divbuf_3/OUT4 0.19fF
C8831 divbuf_3/a_2400_n1600# divbuf_3/a_2430_n1540# 0.19fF
C8832 divbuf_3/a_2430_n840# divbuf_3/a_2910_n840# 0.07fF
C8833 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11070_n840# 0.04fF
C8834 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16350_n840# 0.04fF
C8835 divbuf_3/a_55230_n1540# divbuf_3/a_55710_n1540# 0.11fF
C8836 divbuf_0/a_37502_n240# divbuf_0/a_37992_n240# 0.04fF
C8837 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/a_32172_n240# 0.04fF
C8838 divbuf_1/a_34110_n840# divbuf_1/a_34110_n1540# 0.01fF
C8839 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n1540# 0.19fF
C8840 divbuf_0/a_48990_n840# divbuf_0/a_49470_n840# 0.07fF
C8841 divbuf_0/a_18750_n840# divbuf_0/a_18750_n1540# 0.01fF
C8842 divbuf_0/a_34080_n1600# divbuf_0/OUT4 0.01fF
C8843 pll_full_0/divbuf_0/a_12990_n840# pll_full_0/divbuf_0/a_12990_n1540# 0.01fF
C8844 pll_full_0/divbuf_0/a_43230_n840# pll_full_0/divbuf_0/a_43710_n840# 0.07fF
C8845 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43230_n1540# 0.19fF
C8846 pll_full_0/divbuf_0/a_22560_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C8847 pd_div_0/divbuf_0/a_27802_170# pd_div_0/divbuf_0/a_28292_170# 0.07fF
C8848 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/OUT2 0.00fF
C8849 pll_full_0/divbuf_1/a_13742_170# pll_full_0/divbuf_1/a_13742_n240# 0.01fF
C8850 pll_full_0/divbuf_1/a_33142_170# pll_full_0/divbuf_1/a_33622_170# 0.07fF
C8851 divbuf_3/a_22472_n240# divbuf_3/OUT4 0.04fF
C8852 divbuf_3/a_52800_n1600# divbuf_3/a_52830_n840# 0.04fF
C8853 divbuf_1/a_56190_n1540# divbuf_1/a_56670_n1540# 0.11fF
C8854 pd_div_0/divbuf_0/a_510_n840# pd_div_0/divbuf_0/a_990_n840# 0.07fF
C8855 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/OUT4 0.19fF
C8856 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_510_n1540# 0.19fF
C8857 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C8858 pll_full_0/divbuf_1/a_5790_n840# pll_full_0/divbuf_1/a_6270_n840# 0.07fF
C8859 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/OUT4 0.19fF
C8860 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_5790_n1540# 0.19fF
C8861 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C8862 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C8863 divbuf_2/a_26400_n1600# divbuf_2/a_26880_n1600# 0.26fF
C8864 divbuf_2/a_17122_n240# divbuf_2/a_17310_n840# 0.02fF
C8865 pd_div_0/divbuf_0/a_53310_n1540# pd_div_0/divbuf_0/a_53790_n1540# 0.11fF
C8866 pll_full_0/divbuf_1/a_58590_n1540# pll_full_0/divbuf_1/a_59070_n1540# 0.11fF
C8867 divbuf_2/a_18750_n1540# divbuf_2/a_19230_n1540# 0.11fF
C8868 divbuf_2/a_49470_n840# divbuf_2/a_49470_n1540# 0.01fF
C8869 divbuf_3/a_30712_n240# divbuf_3/a_31202_n240# 0.04fF
C8870 divbuf_1/a_39932_n240# divbuf_1/a_40412_n240# 0.05fF
C8871 divbuf_1/a_51390_n840# divbuf_1/a_51870_n840# 0.07fF
C8872 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_52830_n1540# 0.19fF
C8873 ro_div_0/divbuf_0/a_52830_n840# ro_div_0/divbuf_0/a_53310_n840# 0.07fF
C8874 ro_div_0/divbuf_0/a_22590_n840# ro_div_0/divbuf_0/a_22590_n1540# 0.01fF
C8875 divbuf_3/a_20640_n1600# divbuf_3/OUT4 0.00fF
C8876 divbuf_3/a_12030_n840# divbuf_3/a_12030_n1540# 0.01fF
C8877 divbuf_3/a_42270_n840# divbuf_3/a_42750_n840# 0.07fF
C8878 divbuf_3/a_42240_n1600# divbuf_3/a_42270_n1540# 0.19fF
C8879 divbuf_1/a_1352_170# divbuf_1/a_1352_n240# 0.01fF
C8880 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C8881 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_50910_n840# 0.04fF
C8882 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56190_n840# 0.04fF
C8883 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C8884 divbuf_2/a_16320_n1600# divbuf_2/a_16350_n840# 0.04fF
C8885 pd_div_0/divider_0/nor_0/Z1 pd_div_0/divider_0/nor_1/B 0.18fF
C8886 ro_div_0/divbuf_0/a_8762_170# ro_div_0/divbuf_0/a_9242_170# 0.07fF
C8887 divbuf_0/a_26352_n240# divbuf_0/a_26430_n840# 0.04fF
C8888 divbuf_0/a_35520_n1600# divbuf_0/a_36000_n1600# 0.26fF
C8889 divbuf_0/a_19072_170# divbuf_0/OUT4 0.19fF
C8890 pll_full_0/divbuf_0/a_29760_n1600# pll_full_0/divbuf_0/a_30240_n1600# 0.26fF
C8891 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/a_20670_n840# 0.03fF
C8892 divbuf_0/a_58590_n840# divbuf_0/a_58590_n1540# 0.01fF
C8893 divbuf_0/a_27870_n1540# divbuf_0/a_28350_n1540# 0.11fF
C8894 pll_full_0/divbuf_0/a_22110_n1540# pll_full_0/divbuf_0/a_22590_n1540# 0.11fF
C8895 pll_full_0/divbuf_0/a_52830_n840# pll_full_0/divbuf_0/a_52830_n1540# 0.01fF
C8896 pd_div_0/divbuf_0/a_28772_n240# pd_div_0/divbuf_0/a_29262_n240# 0.04fF
C8897 pll_full_0/divbuf_1/a_34112_n240# pll_full_0/divbuf_1/a_34592_n240# 0.05fF
C8898 divbuf_3/a_990_n840# divbuf_3/OUT2 0.02fF
C8899 divbuf_2/a_13742_170# divbuf_2/a_13742_n240# 0.01fF
C8900 divbuf_2/a_33142_170# divbuf_2/a_33622_170# 0.07fF
C8901 pd_div_0/divbuf_0/a_10110_n840# pd_div_0/divbuf_0/a_10110_n1540# 0.01fF
C8902 pd_div_0/divbuf_0/a_40350_n840# pd_div_0/divbuf_0/a_40830_n840# 0.07fF
C8903 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40350_n1540# 0.19fF
C8904 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_45630_n1540# 0.19fF
C8905 pll_full_0/divbuf_1/a_15390_n840# pll_full_0/divbuf_1/a_15390_n1540# 0.01fF
C8906 pll_full_0/divbuf_1/a_45630_n840# pll_full_0/divbuf_1/a_46110_n840# 0.07fF
C8907 divbuf_2/a_5790_n840# divbuf_2/a_6270_n840# 0.07fF
C8908 divbuf_2/a_28292_170# divbuf_2/OUT4 0.19fF
C8909 divbuf_2/a_5760_n1600# divbuf_2/a_5790_n1540# 0.19fF
C8910 divbuf_1/a_37502_170# divbuf_1/OUT4 0.19fF
C8911 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C8912 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C8913 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/clk 0.01fF
C8914 ro_div_0/ro_complete_0/cbank_0/switch_5/vin ro_div_0/ro_complete_0/a0 0.09fF
C8915 divbuf_0/a_25440_n1600# divbuf_0/a_25470_n840# 0.04fF
C8916 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_19710_n840# 0.04fF
C8917 divbuf_2/a_58590_n1540# divbuf_2/a_59070_n1540# 0.11fF
C8918 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_0/Z2 0.23fF
C8919 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C8920 divbuf_1/a_37920_n1600# divbuf_1/a_38400_n1600# 0.26fF
C8921 divbuf_1/a_28772_n240# divbuf_1/a_28830_n840# 0.04fF
C8922 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/a_30270_n840# 0.05fF
C8923 ro_div_0/divbuf_0/a_39360_n1600# ro_div_0/divbuf_0/a_39840_n1600# 0.26fF
C8924 divbuf_3/a_28800_n1600# divbuf_3/a_29280_n1600# 0.26fF
C8925 divbuf_3/a_19562_n240# divbuf_3/a_19710_n840# 0.03fF
C8926 ro_div_0/divbuf_0/a_31710_n1540# ro_div_0/divbuf_0/a_32190_n1540# 0.11fF
C8927 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/a_2430_n840# 0.03fF
C8928 divbuf_3/a_21150_n1540# divbuf_3/a_21630_n1540# 0.11fF
C8929 divbuf_3/a_51870_n840# divbuf_3/a_51870_n1540# 0.01fF
C8930 divbuf_0/a_22952_170# divbuf_0/a_22952_n240# 0.01fF
C8931 divbuf_0/a_1842_n240# divbuf_0/a_2322_n240# 0.05fF
C8932 pll_full_0/divbuf_0/a_36532_170# pll_full_0/divbuf_0/a_37022_170# 0.07fF
C8933 divbuf_2/a_56160_n1600# divbuf_2/a_56190_n840# 0.04fF
C8934 divbuf_2/a_29262_n240# divbuf_2/OUT4 0.04fF
C8935 divbuf_1/a_38472_n240# divbuf_1/OUT4 0.04fF
C8936 divbuf_1/a_30240_n1600# divbuf_1/a_30270_n1540# 0.19fF
C8937 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n1540# 0.19fF
C8938 divbuf_0/a_7302_n240# divbuf_0/OUT3 0.04fF
C8939 divbuf_0/a_14910_n840# divbuf_0/a_15390_n840# 0.07fF
C8940 pll_full_0/divbuf_0/a_9150_n840# pll_full_0/divbuf_0/a_9630_n840# 0.07fF
C8941 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/OUT4 0.19fF
C8942 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9150_n1540# 0.19fF
C8943 divbuf_1/a_11312_170# divbuf_1/a_11312_n240# 0.01fF
C8944 divbuf_1/a_27840_n1600# divbuf_1/a_27870_n840# 0.04fF
C8945 divbuf_1/a_22110_n1540# divbuf_1/a_22590_n1540# 0.11fF
C8946 pd_div_0/div pd_div_0/pd_0/tspc_r_0/Z1 0.17fF
C8947 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/DOWN 0.11fF
C8948 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29310_n840# 0.04fF
C8949 ro_div_0/divbuf_0/a_15672_170# ro_div_0/divbuf_0/OUT4 0.19fF
C8950 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C8951 divbuf_3/a_18720_n1600# divbuf_3/a_18750_n840# 0.04fF
C8952 pd_div_0/divbuf_0/a_26880_n1600# pd_div_0/divbuf_0/a_27360_n1600# 0.26fF
C8953 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_17790_n840# 0.02fF
C8954 pll_full_0/divbuf_1/a_32160_n1600# pll_full_0/divbuf_1/a_32640_n1600# 0.26fF
C8955 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/a_23070_n840# 0.03fF
C8956 divbuf_2/a_34112_n240# divbuf_2/a_34592_n240# 0.05fF
C8957 pd_div_0/divbuf_0/a_19230_n1540# pd_div_0/divbuf_0/a_19710_n1540# 0.11fF
C8958 pd_div_0/divbuf_0/a_49950_n840# pd_div_0/divbuf_0/a_49950_n1540# 0.01fF
C8959 pll_full_0/divbuf_1/a_24510_n1540# pll_full_0/divbuf_1/a_24990_n1540# 0.11fF
C8960 pll_full_0/divbuf_1/a_55230_n840# pll_full_0/divbuf_1/a_55230_n1540# 0.01fF
C8961 divbuf_2/a_45600_n1600# divbuf_2/a_45630_n1540# 0.19fF
C8962 divbuf_2/a_15390_n840# divbuf_2/a_15390_n1540# 0.01fF
C8963 divbuf_2/a_45630_n840# divbuf_2/a_46110_n840# 0.07fF
C8964 divbuf_1/a_36480_n1600# divbuf_1/OUT4 0.00fF
C8965 ro_div_0/divbuf_0/a_6332_n240# ro_div_0/divbuf_0/a_6822_n240# 0.04fF
C8966 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/a_26832_n240# 0.01fF
C8967 divbuf_3/a_16152_170# divbuf_3/a_16152_n240# 0.01fF
C8968 divbuf_3/a_35562_170# divbuf_3/a_36052_170# 0.07fF
C8969 divbuf_1/a_4882_n240# divbuf_1/a_5362_n240# 0.05fF
C8970 pll_full_0/divbuf_0/a_36052_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C8971 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_59550_n840# 0.04fF
C8972 divbuf_1/a_17310_n840# divbuf_1/a_17790_n840# 0.07fF
C8973 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_18750_n1540# 0.19fF
C8974 ro_div_0/divbuf_0/a_15182_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C8975 ro_div_0/divbuf_0/a_18750_n840# ro_div_0/divbuf_0/a_19230_n840# 0.07fF
C8976 ro_div_0/divider_0/clk gnd 0.07fF
C8977 divbuf_0/a_1842_170# divbuf_0/a_2322_170# 0.07fF
C8978 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.32fF
C8979 divbuf_3/a_8190_n840# divbuf_3/a_8670_n840# 0.07fF
C8980 divbuf_3/a_33142_170# divbuf_3/OUT4 0.19fF
C8981 divbuf_3/a_8160_n1600# divbuf_3/a_8190_n1540# 0.19fF
C8982 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_16830_n840# 0.04fF
C8983 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22110_n840# 0.04fF
C8984 divbuf_2/a_2322_n240# divbuf_2/a_2430_n840# 0.03fF
C8985 divbuf_0/a_1440_n1600# divbuf_0/a_1920_n1600# 0.26fF
C8986 pll_full_0/divbuf_0/a_37502_n240# pll_full_0/divbuf_0/a_37992_n240# 0.04fF
C8987 divbuf_1/a_39870_n840# divbuf_1/a_39870_n1540# 0.01fF
C8988 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n1540# 0.19fF
C8989 divbuf_0/a_54750_n840# divbuf_0/a_55230_n840# 0.07fF
C8990 divbuf_0/a_24510_n840# divbuf_0/a_24510_n1540# 0.01fF
C8991 pll_full_0/divbuf_0/a_34080_n1600# pll_full_0/divbuf_0/OUT4 0.01fF
C8992 pll_full_0/divbuf_0/a_18750_n840# pll_full_0/divbuf_0/a_18750_n1540# 0.01fF
C8993 pll_full_0/divbuf_0/a_48990_n840# pll_full_0/divbuf_0/a_49470_n840# 0.07fF
C8994 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_48990_n1540# 0.19fF
C8995 pd_div_0/divbuf_0/a_33622_170# pd_div_0/divbuf_0/a_34112_170# 0.07fF
C8996 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C8997 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/a_19562_n240# 0.01fF
C8998 pll_full_0/divbuf_1/a_38962_170# pll_full_0/divbuf_1/a_39442_170# 0.07fF
C8999 divbuf_3/a_34112_n240# divbuf_3/OUT4 0.04fF
C9000 divbuf_3/a_58560_n1600# divbuf_3/a_58590_n840# 0.04fF
C9001 pd_div_0/divbuf_0/a_6270_n840# pd_div_0/divbuf_0/a_6750_n840# 0.07fF
C9002 pd_div_0/divbuf_0/a_29262_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9003 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6270_n1540# 0.19fF
C9004 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/clk 0.11fF
C9005 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9006 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_11550_n1540# 0.19fF
C9007 pll_full_0/divbuf_1/a_11550_n840# pll_full_0/divbuf_1/a_12030_n840# 0.07fF
C9008 divbuf_2/a_32160_n1600# divbuf_2/a_32640_n1600# 0.26fF
C9009 divbuf_2/a_22952_n240# divbuf_2/a_23070_n840# 0.03fF
C9010 pd_div_0/divbuf_0/a_59070_n1540# pd_div_0/divbuf_0/a_59550_n1540# 0.11fF
C9011 divbuf_0/a_12282_n240# divbuf_0/a_12030_n840# 0.02fF
C9012 divbuf_2/a_24510_n1540# divbuf_2/a_24990_n1540# 0.11fF
C9013 divbuf_2/a_55230_n840# divbuf_2/a_55230_n1540# 0.01fF
C9014 ro_div_0/divbuf_0/a_5280_n1600# ro_div_0/divbuf_0/a_5760_n1600# 0.26fF
C9015 divbuf_3/a_36532_n240# divbuf_3/a_37022_n240# 0.04fF
C9016 divbuf_1/a_3840_n1600# divbuf_1/a_4320_n1600# 0.26fF
C9017 divbuf_1/a_57150_n840# divbuf_1/a_57630_n840# 0.07fF
C9018 ro_div_0/divbuf_0/a_58590_n840# ro_div_0/divbuf_0/a_59070_n840# 0.07fF
C9019 ro_div_0/divbuf_0/a_28350_n840# ro_div_0/divbuf_0/a_28350_n1540# 0.01fF
C9020 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_58590_n1540# 0.19fF
C9021 divbuf_3/a_48000_n1600# divbuf_3/a_48030_n1540# 0.19fF
C9022 divbuf_3/a_32160_n1600# divbuf_3/OUT4 0.00fF
C9023 divbuf_3/a_17790_n840# divbuf_3/a_17790_n1540# 0.01fF
C9024 divbuf_3/a_48030_n840# divbuf_3/a_48510_n840# 0.07fF
C9025 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9026 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_56670_n840# 0.04fF
C9027 divbuf_0/a_7792_170# divbuf_0/a_7302_170# 0.07fF
C9028 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9029 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C9030 divbuf_2/a_22080_n1600# divbuf_2/a_22110_n840# 0.04fF
C9031 divbuf_1/a_5852_170# divbuf_1/a_5362_170# 0.07fF
C9032 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/Z3 0.45fF
C9033 divbuf_0/a_32172_n240# divbuf_0/a_32190_n840# 0.06fF
C9034 divbuf_0/a_41280_n1600# divbuf_0/a_41760_n1600# 0.26fF
C9035 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C9036 pll_full_0/divbuf_0/a_35520_n1600# pll_full_0/divbuf_0/a_36000_n1600# 0.26fF
C9037 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/a_26430_n840# 0.04fF
C9038 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/a_15870_n840# 0.01fF
C9039 divbuf_1/a_14702_n240# divbuf_1/a_14430_n840# 0.01fF
C9040 divbuf_0/a_33630_n1540# divbuf_0/a_34110_n1540# 0.11fF
C9041 pll_full_0/divbuf_0/a_27870_n1540# pll_full_0/divbuf_0/a_28350_n1540# 0.11fF
C9042 pll_full_0/divbuf_0/a_58590_n840# pll_full_0/divbuf_0/a_58590_n1540# 0.01fF
C9043 pd_div_0/divbuf_0/a_34592_n240# pd_div_0/divbuf_0/a_35082_n240# 0.04fF
C9044 pll_full_0/divbuf_1/a_39932_n240# pll_full_0/divbuf_1/a_40412_n240# 0.05fF
C9045 divbuf_2/a_19562_170# divbuf_2/a_19562_n240# 0.01fF
C9046 divbuf_2/a_38962_170# divbuf_2/a_39442_170# 0.07fF
C9047 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46110_n1540# 0.19fF
C9048 pd_div_0/divbuf_0/a_15870_n840# pd_div_0/divbuf_0/a_15870_n1540# 0.01fF
C9049 pd_div_0/divbuf_0/a_46110_n840# pd_div_0/divbuf_0/a_46590_n840# 0.07fF
C9050 pll_full_0/divbuf_1/a_21150_n840# pll_full_0/divbuf_1/a_21150_n1540# 0.01fF
C9051 pll_full_0/divbuf_1/a_51390_n840# pll_full_0/divbuf_1/a_51870_n840# 0.07fF
C9052 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51390_n1540# 0.19fF
C9053 divbuf_2/a_39932_170# divbuf_2/OUT4 0.19fF
C9054 divbuf_2/a_11520_n1600# divbuf_2/a_11550_n1540# 0.19fF
C9055 divbuf_2/a_11550_n840# divbuf_2/a_12030_n840# 0.07fF
C9056 divbuf_1/a_9732_n240# divbuf_1/OUT3 0.04fF
C9057 divbuf_0/a_15672_170# divbuf_0/OUT4 0.19fF
C9058 divbuf_0/a_31200_n1600# divbuf_0/a_31230_n840# 0.04fF
C9059 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25470_n840# 0.04fF
C9060 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/a_36030_n840# 0.05fF
C9061 ro_div_0/divbuf_0/a_45120_n1600# ro_div_0/divbuf_0/a_45600_n1600# 0.26fF
C9062 divbuf_1/a_43680_n1600# divbuf_1/a_44160_n1600# 0.26fF
C9063 divbuf_1/a_34592_n240# divbuf_1/a_34590_n840# 0.06fF
C9064 divbuf_3/a_25382_n240# divbuf_3/a_25470_n840# 0.03fF
C9065 divbuf_3/a_34560_n1600# divbuf_3/a_35040_n1600# 0.26fF
C9066 ro_div_0/divbuf_0/a_37470_n1540# ro_div_0/divbuf_0/a_37950_n1540# 0.11fF
C9067 io_clamp_low[0] io_clamp_high[0] 0.53fF
C9068 divbuf_3/a_26910_n1540# divbuf_3/a_27390_n1540# 0.11fF
C9069 divbuf_3/a_57630_n840# divbuf_3/a_57630_n1540# 0.01fF
C9070 divbuf_0/a_28772_170# divbuf_0/a_28772_n240# 0.01fF
C9071 divbuf_0/a_8272_n240# divbuf_0/a_8762_n240# 0.04fF
C9072 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/a_2322_n240# 0.05fF
C9073 pll_full_0/divbuf_0/a_22952_170# pll_full_0/divbuf_0/a_22952_n240# 0.01fF
C9074 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/a_960_n1600# 0.00fF
C9075 divbuf_2/a_480_n1600# divbuf_2/IN 0.00fF
C9076 divbuf_2/a_40902_n240# divbuf_2/OUT4 0.04fF
C9077 divbuf_1/a_36000_n1600# divbuf_1/a_36030_n1540# 0.19fF
C9078 divbuf_1/a_8640_n1600# divbuf_1/OUT3 0.00fF
C9079 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n1540# 0.19fF
C9080 divbuf_0/a_19072_n240# divbuf_0/OUT4 0.04fF
C9081 divbuf_0/a_20670_n840# divbuf_0/a_21150_n840# 0.07fF
C9082 pll_full_0/divbuf_0/a_14910_n840# pll_full_0/divbuf_0/a_15390_n840# 0.07fF
C9083 pll_full_0/divbuf_0/a_7302_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C9084 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_14910_n1540# 0.19fF
C9085 divbuf_1/a_33600_n1600# divbuf_1/a_33630_n840# 0.04fF
C9086 divbuf_1/a_27870_n1540# divbuf_1/a_28350_n1540# 0.11fF
C9087 pd_div_0/pd_0/R pd_div_0/pd_0/tspc_r_1/Z2 0.21fF
C9088 ro_div_0/divbuf_0/a_35040_n1600# ro_div_0/divbuf_0/a_35070_n840# 0.04fF
C9089 ro_div_0/divbuf_0/a_25862_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9090 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.44fF
C9091 pll_full_0/divbuf_1/a_3912_170# pll_full_0/divbuf_1/a_4392_170# 0.07fF
C9092 divbuf_3/a_4392_170# divbuf_3/OUT3 0.19fF
C9093 divbuf_3/a_24480_n1600# divbuf_3/a_24510_n840# 0.04fF
C9094 pd_div_0/divbuf_0/a_32640_n1600# pd_div_0/divbuf_0/a_33120_n1600# 0.26fF
C9095 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/a_23550_n840# 0.03fF
C9096 pll_full_0/divbuf_1/a_37920_n1600# pll_full_0/divbuf_1/a_38400_n1600# 0.26fF
C9097 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/a_28830_n840# 0.04fF
C9098 divbuf_2/a_39932_n240# divbuf_2/a_40412_n240# 0.05fF
C9099 pd_div_0/divbuf_0/a_24990_n1540# pd_div_0/divbuf_0/a_25470_n1540# 0.11fF
C9100 pd_div_0/divbuf_0/a_55710_n840# pd_div_0/divbuf_0/a_55710_n1540# 0.01fF
C9101 pll_full_0/divbuf_1/a_30270_n1540# pll_full_0/divbuf_1/a_30750_n1540# 0.11fF
C9102 pll_full_0/divbuf_1/a_60990_n840# pll_full_0/divbuf_1/a_60990_n1540# 0.01fF
C9103 divbuf_2/a_21150_n840# divbuf_2/a_21150_n1540# 0.01fF
C9104 divbuf_2/a_51390_n840# divbuf_2/a_51870_n840# 0.07fF
C9105 divbuf_2/a_51360_n1600# divbuf_2/a_51390_n1540# 0.19fF
C9106 ro_div_0/divbuf_0/a_12772_n240# ro_div_0/divbuf_0/a_13252_n240# 0.05fF
C9107 ro_div_0/divbuf_0/a_32652_170# ro_div_0/divbuf_0/a_32652_n240# 0.01fF
C9108 divbuf_3/a_21982_170# divbuf_3/a_21982_n240# 0.01fF
C9109 divbuf_1/a_11312_n240# divbuf_1/a_11802_n240# 0.04fF
C9110 divbuf_1/a_23070_n840# divbuf_1/a_23550_n840# 0.07fF
C9111 ro_div_0/divbuf_0/a_24510_n840# ro_div_0/divbuf_0/a_24990_n840# 0.07fF
C9112 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24510_n1540# 0.19fF
C9113 ro_div_0/divbuf_0/a_26832_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9114 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C9115 divbuf_3/a_5362_n240# divbuf_3/OUT3 0.04fF
C9116 divbuf_3/a_13920_n1600# divbuf_3/a_13950_n1540# 0.19fF
C9117 divbuf_3/a_13950_n840# divbuf_3/a_14430_n840# 0.07fF
C9118 pd_div_0/divbuf_0/a_1352_170# pd_div_0/divbuf_0/OUT2 0.23fF
C9119 pd_div_0/divbuf_0/a_22560_n1600# pd_div_0/divbuf_0/a_22590_n840# 0.04fF
C9120 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C9121 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/nor_1/B 0.35fF
C9122 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/OUT4 0.23fF
C9123 pll_full_0/divbuf_1/a_27840_n1600# pll_full_0/divbuf_1/a_27870_n840# 0.04fF
C9124 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C9125 divbuf_0/a_7200_n1600# divbuf_0/a_7680_n1600# 0.26fF
C9126 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/a_1920_n1600# 0.26fF
C9127 divbuf_1/a_45630_n840# divbuf_1/a_45630_n1540# 0.01fF
C9128 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n1540# 0.19fF
C9129 divbuf_0/a_60510_n840# divbuf_0/a_60990_n840# 0.07fF
C9130 divbuf_0/a_30270_n840# divbuf_0/a_30270_n1540# 0.01fF
C9131 pll_full_0/divbuf_0/a_24510_n840# pll_full_0/divbuf_0/a_24510_n1540# 0.01fF
C9132 pll_full_0/divbuf_0/a_54750_n840# pll_full_0/divbuf_0/a_55230_n840# 0.07fF
C9133 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_54750_n1540# 0.19fF
C9134 pd_div_0/divbuf_0/a_20042_170# pd_div_0/divbuf_0/a_20042_n240# 0.01fF
C9135 pd_div_0/divbuf_0/a_39442_170# pd_div_0/divbuf_0/a_39932_170# 0.07fF
C9136 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C9137 pll_full_0/divbuf_1/a_4882_n240# pll_full_0/divbuf_1/a_5362_n240# 0.05fF
C9138 pll_full_0/divbuf_1/a_25382_170# pll_full_0/divbuf_1/a_25382_n240# 0.01fF
C9139 divbuf_2/a_3912_170# divbuf_2/a_4392_170# 0.07fF
C9140 divbuf_1/a_31682_170# divbuf_1/OUT4 0.19fF
C9141 pd_div_0/divbuf_0/a_1352_n240# pd_div_0/divbuf_0/OUT2 0.07fF
C9142 pd_div_0/divbuf_0/a_40902_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9143 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12030_n1540# 0.19fF
C9144 pd_div_0/divbuf_0/a_12030_n840# pd_div_0/divbuf_0/a_12510_n840# 0.07fF
C9145 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C9146 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C9147 pll_full_0/divbuf_1/a_17310_n840# pll_full_0/divbuf_1/a_17790_n840# 0.07fF
C9148 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9149 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17310_n1540# 0.19fF
C9150 divbuf_2/a_37920_n1600# divbuf_2/a_38400_n1600# 0.26fF
C9151 divbuf_2/a_28772_n240# divbuf_2/a_28830_n840# 0.04fF
C9152 divbuf_1/a_16152_170# divbuf_1/a_16642_170# 0.07fF
C9153 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C9154 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C9155 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C9156 divbuf_0/a_18092_n240# divbuf_0/a_17790_n840# 0.00fF
C9157 pll_full_0/divbuf_0/a_12282_n240# pll_full_0/divbuf_0/a_12030_n840# 0.02fF
C9158 divbuf_2/a_30270_n1540# divbuf_2/a_30750_n1540# 0.11fF
C9159 divbuf_2/a_60990_n840# divbuf_2/a_60990_n1540# 0.01fF
C9160 ro_div_0/divbuf_0/a_11040_n1600# ro_div_0/divbuf_0/a_11520_n1600# 0.26fF
C9161 divbuf_3/a_480_n1600# divbuf_3/a_960_n1600# 0.26fF
C9162 divbuf_1/a_9600_n1600# divbuf_1/a_10080_n1600# 0.26fF
C9163 divbuf_1/a_1950_n1540# divbuf_1/a_2430_n1540# 0.11fF
C9164 ro_div_0/divbuf_0/a_34110_n840# ro_div_0/divbuf_0/a_34110_n1540# 0.01fF
C9165 ro_div_0/divbuf_0/a_3390_n1540# ro_div_0/divbuf_0/a_3870_n1540# 0.11fF
C9166 divbuf_3/a_23550_n840# divbuf_3/a_23550_n1540# 0.01fF
C9167 divbuf_3/a_53790_n840# divbuf_3/a_54270_n840# 0.07fF
C9168 divbuf_3/a_53760_n1600# divbuf_3/a_53790_n1540# 0.19fF
C9169 divbuf_1/a_8762_170# divbuf_1/OUT3 0.19fF
C9170 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/OUT5 0.04fF
C9171 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C9172 divbuf_0/a_13252_170# divbuf_0/a_13742_170# 0.07fF
C9173 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/OUT3 0.00fF
C9174 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/a_6822_170# 0.07fF
C9175 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C9176 divbuf_2/a_11312_170# divbuf_2/OUT4 0.23fF
C9177 divbuf_2/a_27840_n1600# divbuf_2/a_27870_n840# 0.04fF
C9178 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/and_0/OUT 0.05fF
C9179 pd_div_0/divider_0/nor_1/Z1 gnd 0.01fF
C9180 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/a3 0.13fF
C9181 divbuf_0/a_47040_n1600# divbuf_0/a_47520_n1600# 0.26fF
C9182 divbuf_0/a_37992_n240# divbuf_0/a_37950_n840# 0.04fF
C9183 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C9184 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/nor_0/B 0.47fF
C9185 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C9186 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_0/Z3 0.05fF
C9187 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C9188 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C9189 pll_full_0/divbuf_0/a_41280_n1600# pll_full_0/divbuf_0/a_41760_n1600# 0.26fF
C9190 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/a_32190_n840# 0.06fF
C9191 ro_div_0/divbuf_0/a_960_n1600# ro_div_0/divbuf_0/a_990_n840# 0.04fF
C9192 divbuf_3/a_11312_n240# divbuf_3/a_11070_n840# 0.02fF
C9193 divbuf_0/a_39390_n1540# divbuf_0/a_39870_n1540# 0.11fF
C9194 pll_full_0/divbuf_0/a_33630_n1540# pll_full_0/divbuf_0/a_34110_n1540# 0.11fF
C9195 pd_div_0/divbuf_0/a_40412_n240# pd_div_0/divbuf_0/a_40902_n240# 0.04fF
C9196 pll_full_0/divbuf_1/a_3840_n1600# pll_full_0/divbuf_1/a_4320_n1600# 0.26fF
C9197 divbuf_2/a_4882_n240# divbuf_2/a_5362_n240# 0.05fF
C9198 divbuf_2/a_25382_170# divbuf_2/a_25382_n240# 0.01fF
C9199 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/bufin 0.00fF
C9200 pd_div_0/divbuf_0/a_21630_n840# pd_div_0/divbuf_0/a_21630_n1540# 0.01fF
C9201 pd_div_0/divbuf_0/a_51870_n840# pd_div_0/divbuf_0/a_52350_n840# 0.07fF
C9202 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_51870_n1540# 0.19fF
C9203 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57150_n1540# 0.19fF
C9204 pll_full_0/divbuf_1/a_26910_n840# pll_full_0/divbuf_1/a_26910_n1540# 0.01fF
C9205 pll_full_0/divbuf_1/a_57150_n840# pll_full_0/divbuf_1/a_57630_n840# 0.07fF
C9206 divbuf_2/a_17310_n840# divbuf_2/a_17790_n840# 0.07fF
C9207 divbuf_2/a_12282_n240# divbuf_2/OUT4 0.04fF
C9208 divbuf_2/a_17280_n1600# divbuf_2/a_17310_n1540# 0.19fF
C9209 divbuf_1/a_21502_n240# divbuf_1/OUT4 0.04fF
C9210 divbuf_1/a_13742_170# divbuf_1/a_14222_170# 0.07fF
C9211 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/a_19562_170# 0.07fF
C9212 divbuf_0/a_36960_n1600# divbuf_0/a_36990_n840# 0.04fF
C9213 divbuf_0/a_29742_170# divbuf_0/OUT4 0.19fF
C9214 pll_full_0/divbuf_0/a_19562_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9215 pll_full_0/divbuf_0/a_31200_n1600# pll_full_0/divbuf_0/a_31230_n840# 0.04fF
C9216 pll_full_0/divbuf_0/a_1842_170# pll_full_0/divbuf_0/OUT2 0.19fF
C9217 divbuf_3/a_6332_170# divbuf_3/a_6822_170# 0.07fF
C9218 ro_div_0/divbuf_0/a_50880_n1600# ro_div_0/divbuf_0/a_51360_n1600# 0.26fF
C9219 divbuf_1/a_40412_n240# divbuf_1/a_40350_n840# 0.04fF
C9220 divbuf_1/a_49440_n1600# divbuf_1/a_49920_n1600# 0.26fF
C9221 divbuf_3/a_40320_n1600# divbuf_3/a_40800_n1600# 0.26fF
C9222 divbuf_3/a_31202_n240# divbuf_3/a_31230_n840# 0.05fF
C9223 ro_div_0/divbuf_0/a_43230_n1540# ro_div_0/divbuf_0/a_43710_n1540# 0.11fF
C9224 pll_full_0/divbuf_1/a_14702_n240# pll_full_0/divbuf_1/a_14430_n840# 0.01fF
C9225 divbuf_3/a_32670_n1540# divbuf_3/a_33150_n1540# 0.11fF
C9226 divbuf_0/a_34592_170# divbuf_0/a_34592_n240# 0.01fF
C9227 divbuf_0/a_14702_n240# divbuf_0/a_15182_n240# 0.05fF
C9228 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/a_8762_n240# 0.04fF
C9229 pll_full_0/divbuf_0/a_28772_170# pll_full_0/divbuf_0/a_28772_n240# 0.01fF
C9230 divbuf_2/a_11040_n1600# divbuf_2/OUT3 0.00fF
C9231 divbuf_1/a_19680_n1600# divbuf_1/OUT4 0.00fF
C9232 divbuf_1/a_41760_n1600# divbuf_1/a_41790_n1540# 0.19fF
C9233 ro_div_0/divbuf_0/a_19072_170# ro_div_0/divbuf_0/a_19072_n240# 0.01fF
C9234 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n1540# 0.19fF
C9235 divbuf_0/a_30712_n240# divbuf_0/OUT4 0.04fF
C9236 divbuf_0/a_26430_n840# divbuf_0/a_26910_n840# 0.07fF
C9237 pll_full_0/divbuf_0/a_20670_n840# pll_full_0/divbuf_0/a_21150_n840# 0.07fF
C9238 pll_full_0/divbuf_0/a_19072_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9239 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_20670_n1540# 0.19fF
C9240 ro_div_0/ro_complete_0/cbank_1/switch_3/vin ro_div_0/divider_0/clk 1.30fF
C9241 ro_div_0/divbuf_0/a_40800_n1600# ro_div_0/divbuf_0/a_40830_n840# 0.04fF
C9242 ro_div_0/divbuf_0/a_37502_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9243 divbuf_1/a_39360_n1600# divbuf_1/a_39390_n840# 0.04fF
C9244 divbuf_1/a_33630_n1540# divbuf_1/a_34110_n1540# 0.11fF
C9245 pd_div_0/pd_0/UP pd_div_0/pd_0/and_pd_0/Z1 0.06fF
C9246 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 gnd 0.27fF
C9247 pll_full_0/divbuf_1/a_9732_170# pll_full_0/divbuf_1/a_10212_170# 0.07fF
C9248 divbuf_3/a_16152_170# divbuf_3/OUT4 0.19fF
C9249 divbuf_3/a_30240_n1600# divbuf_3/a_30270_n840# 0.04fF
C9250 pd_div_0/divbuf_0/a_38400_n1600# pd_div_0/divbuf_0/a_38880_n1600# 0.26fF
C9251 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/a_29310_n840# 0.04fF
C9252 pll_full_0/divbuf_1/a_43680_n1600# pll_full_0/divbuf_1/a_44160_n1600# 0.26fF
C9253 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/a_34590_n840# 0.06fF
C9254 divbuf_2/a_3840_n1600# divbuf_2/a_4320_n1600# 0.26fF
C9255 pd_div_0/divbuf_0/a_30750_n1540# pd_div_0/divbuf_0/a_31230_n1540# 0.11fF
C9256 pll_full_0/divbuf_1/a_36030_n1540# pll_full_0/divbuf_1/a_36510_n1540# 0.11fF
C9257 divbuf_2/a_57120_n1600# divbuf_2/a_57150_n1540# 0.19fF
C9258 divbuf_2/a_26910_n840# divbuf_2/a_26910_n1540# 0.01fF
C9259 divbuf_2/a_57150_n840# divbuf_2/a_57630_n840# 0.07fF
C9260 ro_div_0/divbuf_0/a_18582_n240# ro_div_0/divbuf_0/a_19072_n240# 0.04fF
C9261 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/a_38472_n240# 0.01fF
C9262 divbuf_3/a_7302_n240# divbuf_3/a_7792_n240# 0.04fF
C9263 divbuf_3/a_27802_170# divbuf_3/a_27802_n240# 0.01fF
C9264 divbuf_1/a_17122_n240# divbuf_1/a_17612_n240# 0.04fF
C9265 divbuf_1/a_37022_170# divbuf_1/a_37022_n240# 0.01fF
C9266 divbuf_1/a_28830_n840# divbuf_1/a_29310_n840# 0.07fF
C9267 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30270_n1540# 0.19fF
C9268 ro_div_0/divbuf_0/a_30270_n840# ro_div_0/divbuf_0/a_30750_n840# 0.07fF
C9269 ro_div_0/divbuf_0/a_38472_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9270 divbuf_3/a_19710_n840# divbuf_3/a_20190_n840# 0.07fF
C9271 divbuf_3/a_17122_n240# divbuf_3/OUT4 0.04fF
C9272 divbuf_3/a_19680_n1600# divbuf_3/a_19710_n1540# 0.19fF
C9273 pd_div_0/divbuf_0/a_28320_n1600# pd_div_0/divbuf_0/a_28350_n840# 0.04fF
C9274 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/OUT3 0.19fF
C9275 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C9276 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/a_33630_n840# 0.04fF
C9277 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9278 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C9279 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar1 0.30fF
C9280 divbuf_2/a_14702_n240# divbuf_2/a_14430_n840# 0.01fF
C9281 divbuf_0/a_3422_n240# divbuf_0/a_3390_n840# 0.05fF
C9282 divbuf_0/a_12960_n1600# divbuf_0/a_13440_n1600# 0.26fF
C9283 pll_full_0/divbuf_0/a_7200_n1600# pll_full_0/divbuf_0/a_7680_n1600# 0.26fF
C9284 divbuf_1/a_51390_n840# divbuf_1/a_51390_n1540# 0.01fF
C9285 divbuf_0/a_36030_n840# divbuf_0/a_36030_n1540# 0.01fF
C9286 divbuf_0/a_5310_n1540# divbuf_0/a_5790_n1540# 0.11fF
C9287 pll_full_0/divbuf_0/a_30270_n840# pll_full_0/divbuf_0/a_30270_n1540# 0.01fF
C9288 pll_full_0/divbuf_0/a_60510_n840# pll_full_0/divbuf_0/a_60990_n840# 0.07fF
C9289 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/a_60510_n1540# 0.19fF
C9290 divbuf_2/a_9732_170# divbuf_2/a_10212_170# 0.07fF
C9291 pd_div_0/divbuf_0/a_5362_n240# pd_div_0/divbuf_0/a_5852_n240# 0.04fF
C9292 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/a_25862_n240# 0.01fF
C9293 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C9294 pll_full_0/divbuf_1/a_11312_n240# pll_full_0/divbuf_1/a_11802_n240# 0.04fF
C9295 pll_full_0/divbuf_1/a_31202_170# pll_full_0/divbuf_1/a_31202_n240# 0.01fF
C9296 pd_div_0/divbuf_0/a_17790_n840# pd_div_0/divbuf_0/a_18270_n840# 0.07fF
C9297 pd_div_0/divbuf_0/a_13252_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9298 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_17790_n1540# 0.19fF
C9299 ro_div_0/divider_0/tspc_2/Z3 ro_div_0/divider_0/tspc_2/Z4 0.65fF
C9300 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9301 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23070_n1540# 0.19fF
C9302 pll_full_0/divbuf_1/a_23070_n840# pll_full_0/divbuf_1/a_23550_n840# 0.07fF
C9303 divbuf_2/a_43680_n1600# divbuf_2/a_44160_n1600# 0.26fF
C9304 divbuf_2/a_34592_n240# divbuf_2/a_34590_n840# 0.06fF
C9305 divbuf_1/a_33142_170# divbuf_1/a_33622_170# 0.07fF
C9306 divbuf_0/a_2880_n1600# divbuf_0/a_2910_n840# 0.04fF
C9307 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/nor_1/B 0.22fF
C9308 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C9309 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C9310 pll_full_0/divbuf_0/a_18092_n240# pll_full_0/divbuf_0/a_17790_n840# 0.00fF
C9311 divbuf_2/a_36030_n1540# divbuf_2/a_36510_n1540# 0.11fF
C9312 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/a_7230_n840# 0.03fF
C9313 ro_div_0/divbuf_0/a_16800_n1600# ro_div_0/divbuf_0/a_17280_n1600# 0.26fF
C9314 divbuf_3/a_6240_n1600# divbuf_3/a_6720_n1600# 0.26fF
C9315 divbuf_1/a_15360_n1600# divbuf_1/a_15840_n1600# 0.26fF
C9316 divbuf_1/a_5852_n240# divbuf_1/a_5790_n840# 0.04fF
C9317 divbuf_1/a_7710_n1540# divbuf_1/a_8190_n1540# 0.11fF
C9318 ro_div_0/divbuf_0/a_39870_n840# ro_div_0/divbuf_0/a_39870_n1540# 0.01fF
C9319 ro_div_0/divbuf_0/a_9150_n1540# ro_div_0/divbuf_0/a_9630_n1540# 0.11fF
C9320 divbuf_3/a_59520_n1600# divbuf_3/a_59550_n1540# 0.19fF
C9321 divbuf_3/a_29310_n840# divbuf_3/a_29310_n1540# 0.01fF
C9322 divbuf_3/a_59550_n840# divbuf_3/a_60030_n840# 0.07fF
C9323 divbuf_1/a_28772_170# divbuf_1/OUT4 0.19fF
C9324 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C9325 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C9326 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/a_15672_170# 0.07fF
C9327 divbuf_2/a_33600_n1600# divbuf_2/a_33630_n840# 0.04fF
C9328 divbuf_2/a_22952_170# divbuf_2/OUT4 0.19fF
C9329 divbuf_1/a_2322_170# divbuf_1/a_1842_170# 0.07fF
C9330 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/tspc_1/Z4 0.02fF
C9331 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_2/Z2 0.20fF
C9332 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 gnd 0.17fF
C9333 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C9334 divbuf_0/a_2322_170# divbuf_0/OUT3 0.07fF
C9335 divbuf_0/a_52800_n1600# divbuf_0/a_53280_n1600# 0.26fF
C9336 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/a_37950_n840# 0.04fF
C9337 pll_full_0/divbuf_0/a_9242_170# pll_full_0/divbuf_0/OUT3 0.19fF
C9338 pll_full_0/divbuf_0/a_47040_n1600# pll_full_0/divbuf_0/a_47520_n1600# 0.26fF
C9339 ro_div_0/divbuf_0/a_6720_n1600# ro_div_0/divbuf_0/a_6750_n840# 0.04fF
C9340 divbuf_0/a_45150_n1540# divbuf_0/a_45630_n1540# 0.11fF
C9341 divbuf_3/a_17122_n240# divbuf_3/a_16830_n840# 0.00fF
C9342 divbuf_1/a_5280_n1600# divbuf_1/a_5310_n840# 0.04fF
C9343 pll_full_0/divbuf_0/a_39390_n1540# pll_full_0/divbuf_0/a_39870_n1540# 0.11fF
C9344 pd_div_0/divbuf_0/a_4320_n1600# pd_div_0/divbuf_0/a_4800_n1600# 0.26fF
C9345 pll_full_0/divbuf_1/a_9600_n1600# pll_full_0/divbuf_1/a_10080_n1600# 0.26fF
C9346 divbuf_2/a_11312_n240# divbuf_2/a_11802_n240# 0.04fF
C9347 divbuf_2/a_31202_170# divbuf_2/a_31202_n240# 0.01fF
C9348 divbuf_1/a_33142_n240# divbuf_1/OUT4 0.04fF
C9349 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_57630_n1540# 0.19fF
C9350 pd_div_0/divbuf_0/a_27390_n840# pd_div_0/divbuf_0/a_27390_n1540# 0.01fF
C9351 pd_div_0/divbuf_0/a_57630_n840# pd_div_0/divbuf_0/a_58110_n840# 0.07fF
C9352 pll_full_0/divbuf_1/a_1950_n1540# pll_full_0/divbuf_1/a_2430_n1540# 0.11fF
C9353 pll_full_0/divbuf_1/a_32670_n840# pll_full_0/divbuf_1/a_32670_n1540# 0.01fF
C9354 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/OUT 0.07fF
C9355 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/a_15182_n240# 0.01fF
C9356 divbuf_2/a_23922_n240# divbuf_2/OUT4 0.04fF
C9357 divbuf_2/a_23040_n1600# divbuf_2/a_23070_n1540# 0.19fF
C9358 divbuf_2/a_23070_n840# divbuf_2/a_23550_n840# 0.07fF
C9359 ro_div_0/divbuf_0/a_23442_170# ro_div_0/divbuf_0/a_23922_170# 0.07fF
C9360 divbuf_0/a_42720_n1600# divbuf_0/a_42750_n840# 0.04fF
C9361 divbuf_0/a_41382_170# divbuf_0/OUT4 0.19fF
C9362 divbuf_0/a_1842_n240# divbuf_0/OUT2 0.04fF
C9363 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9364 pll_full_0/divbuf_0/a_36960_n1600# pll_full_0/divbuf_0/a_36990_n840# 0.04fF
C9365 divbuf_3/a_12772_170# divbuf_3/a_13252_170# 0.07fF
C9366 ro_div_0/divbuf_0/a_56640_n1600# ro_div_0/divbuf_0/a_57120_n1600# 0.26fF
C9367 divbuf_3/a_37022_n240# divbuf_3/a_36990_n840# 0.05fF
C9368 divbuf_3/a_46080_n1600# divbuf_3/a_46560_n1600# 0.26fF
C9369 divbuf_1/a_55200_n1600# divbuf_1/a_55680_n1600# 0.26fF
C9370 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/a_14910_n840# 0.01fF
C9371 ro_div_0/divbuf_0/a_48990_n1540# ro_div_0/divbuf_0/a_49470_n1540# 0.11fF
C9372 divbuf_3/a_38430_n1540# divbuf_3/a_38910_n1540# 0.11fF
C9373 divbuf_0/a_20532_n240# divbuf_0/a_21012_n240# 0.05fF
C9374 divbuf_0/a_40412_170# divbuf_0/a_40412_n240# 0.01fF
C9375 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/a_15182_n240# 0.05fF
C9376 pll_full_0/divbuf_0/a_34592_170# pll_full_0/divbuf_0/a_34592_n240# 0.01fF
C9377 divbuf_2/a_22080_n1600# divbuf_2/OUT4 0.01fF
C9378 divbuf_1/a_47520_n1600# divbuf_1/a_47550_n1540# 0.19fF
C9379 divbuf_1/a_31200_n1600# divbuf_1/OUT4 0.00fF
C9380 divbuf_1/a_17310_n840# divbuf_1/a_17310_n1540# 0.01fF
C9381 divbuf_1/a_21012_170# divbuf_1/a_21012_n240# 0.01fF
C9382 divbuf_0/a_1440_n1600# divbuf_0/OUT2 0.01fF
C9383 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n1540# 0.19fF
C9384 divbuf_0/a_32190_n840# divbuf_0/a_32670_n840# 0.07fF
C9385 divbuf_0/a_1950_n840# divbuf_0/a_1950_n1540# 0.01fF
C9386 pll_full_0/divbuf_0/a_26430_n840# pll_full_0/divbuf_0/a_26910_n840# 0.07fF
C9387 pll_full_0/divbuf_0/a_30712_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9388 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26430_n1540# 0.19fF
C9389 ro_div_0/ro_complete_0/cbank_0/v ro_div_0/divider_0/clk 1.27fF
C9390 ro_div_0/divbuf_0/a_46560_n1600# ro_div_0/divbuf_0/a_46590_n840# 0.04fF
C9391 ro_div_0/divbuf_0/a_9732_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C9392 divbuf_1/a_39390_n1540# divbuf_1/a_39870_n1540# 0.11fF
C9393 divbuf_1/a_45120_n1600# divbuf_1/a_45150_n840# 0.04fF
C9394 pd_div_0/divbuf_0/a_7792_170# pd_div_0/divbuf_0/a_8272_170# 0.07fF
C9395 ro_div_0/divider_0/nor_0/B gnd 1.23fF
C9396 pll_full_0/divbuf_1/a_16152_170# pll_full_0/divbuf_1/a_16642_170# 0.07fF
C9397 divbuf_3/a_27802_170# divbuf_3/OUT4 0.19fF
C9398 divbuf_3/a_36000_n1600# divbuf_3/a_36030_n840# 0.04fF
C9399 pd_div_0/divbuf_0/a_44160_n1600# pd_div_0/divbuf_0/a_44640_n1600# 0.26fF
C9400 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/a_35070_n840# 0.05fF
C9401 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/a_40350_n840# 0.04fF
C9402 pll_full_0/divbuf_1/a_49440_n1600# pll_full_0/divbuf_1/a_49920_n1600# 0.26fF
C9403 divbuf_2/a_9600_n1600# divbuf_2/a_10080_n1600# 0.26fF
C9404 pd_div_0/divbuf_0/a_36510_n1540# pd_div_0/divbuf_0/a_36990_n1540# 0.11fF
C9405 pll_full_0/divbuf_1/a_41790_n1540# pll_full_0/divbuf_1/a_42270_n1540# 0.11fF
C9406 divbuf_2/a_1950_n1540# divbuf_2/a_2430_n1540# 0.11fF
C9407 divbuf_2/a_32670_n840# divbuf_2/a_32670_n1540# 0.01fF
C9408 divbuf_2/a_510_n840# divbuf_2/OUT 0.07fF
C9409 divbuf_1/a_10590_n840# divbuf_1/OUT4 0.03fF
C9410 divbuf_1/a_22952_n240# divbuf_1/a_23442_n240# 0.04fF
C9411 ro_div_0/divbuf_0/a_24412_n240# ro_div_0/divbuf_0/a_24892_n240# 0.05fF
C9412 divbuf_3/a_13742_n240# divbuf_3/a_14222_n240# 0.05fF
C9413 divbuf_3/a_33622_170# divbuf_3/a_33622_n240# 0.01fF
C9414 ro_div_0/divbuf_0/a_36030_n840# ro_div_0/divbuf_0/a_36510_n840# 0.07fF
C9415 ro_div_0/divbuf_0/a_5790_n840# ro_div_0/divbuf_0/a_5790_n1540# 0.01fF
C9416 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C9417 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36030_n1540# 0.19fF
C9418 divbuf_1/a_4350_n840# divbuf_1/a_4350_n1540# 0.01fF
C9419 divbuf_1/a_34590_n840# divbuf_1/a_35070_n840# 0.07fF
C9420 pd_div_0/divbuf_0/a_9732_170# pd_div_0/divbuf_0/a_9732_n240# 0.01fF
C9421 divbuf_3/a_28772_n240# divbuf_3/OUT4 0.04fF
C9422 divbuf_3/a_25440_n1600# divbuf_3/a_25470_n1540# 0.19fF
C9423 divbuf_3/a_25470_n840# divbuf_3/a_25950_n840# 0.07fF
C9424 pd_div_0/divbuf_0/a_23922_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9425 pd_div_0/divbuf_0/a_34080_n1600# pd_div_0/divbuf_0/a_34110_n840# 0.04fF
C9426 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C9427 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C9428 pll_full_0/divbuf_1/a_34592_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9429 pll_full_0/divbuf_1/a_39360_n1600# pll_full_0/divbuf_1/a_39390_n840# 0.04fF
C9430 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C9431 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C9432 divbuf_0/a_9242_n240# divbuf_0/a_9150_n840# 0.03fF
C9433 divbuf_0/a_18720_n1600# divbuf_0/a_19200_n1600# 0.26fF
C9434 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/a_13440_n1600# 0.26fF
C9435 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/a_3390_n840# 0.05fF
C9436 divbuf_1/a_57150_n840# divbuf_1/a_57150_n1540# 0.01fF
C9437 divbuf_0/a_41790_n840# divbuf_0/a_41790_n1540# 0.01fF
C9438 divbuf_0/a_11070_n1540# divbuf_0/a_11550_n1540# 0.11fF
C9439 pll_full_0/divbuf_0/a_5310_n1540# pll_full_0/divbuf_0/a_5790_n1540# 0.11fF
C9440 pll_full_0/divbuf_0/a_36030_n840# pll_full_0/divbuf_0/a_36030_n1540# 0.01fF
C9441 divbuf_2/a_16152_170# divbuf_2/a_16642_170# 0.07fF
C9442 pd_div_0/divbuf_0/a_11802_n240# pd_div_0/divbuf_0/a_12282_n240# 0.05fF
C9443 pd_div_0/divbuf_0/a_31682_170# pd_div_0/divbuf_0/a_31682_n240# 0.01fF
C9444 pll_full_0/divbuf_1/a_17122_n240# pll_full_0/divbuf_1/a_17612_n240# 0.04fF
C9445 pll_full_0/divbuf_1/a_37022_170# pll_full_0/divbuf_1/a_37022_n240# 0.01fF
C9446 divbuf_1/a_15182_170# divbuf_1/OUT4 0.19fF
C9447 pd_div_0/divbuf_0/a_24892_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9448 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_23550_n1540# 0.19fF
C9449 pd_div_0/divbuf_0/a_23550_n840# pd_div_0/divbuf_0/a_24030_n840# 0.07fF
C9450 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9451 pll_full_0/divbuf_1/a_28830_n840# pll_full_0/divbuf_1/a_29310_n840# 0.07fF
C9452 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_28830_n1540# 0.19fF
C9453 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C9454 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C9455 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C9456 divbuf_2/a_40412_n240# divbuf_2/a_40350_n840# 0.04fF
C9457 divbuf_2/a_49440_n1600# divbuf_2/a_49920_n1600# 0.26fF
C9458 divbuf_1/a_5852_170# divbuf_1/a_6332_170# 0.07fF
C9459 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C9460 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C9461 divbuf_0/a_8640_n1600# divbuf_0/a_8670_n840# 0.04fF
C9462 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/A 0.21fF
C9463 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C9464 pll_full_0/divbuf_0/a_2880_n1600# pll_full_0/divbuf_0/a_2910_n840# 0.04fF
C9465 divbuf_2/a_41790_n1540# divbuf_2/a_42270_n1540# 0.11fF
C9466 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_13470_n840# 0.02fF
C9467 ro_div_0/divbuf_0/a_22560_n1600# ro_div_0/divbuf_0/a_23040_n1600# 0.26fF
C9468 divbuf_3/a_12000_n1600# divbuf_3/a_12480_n1600# 0.26fF
C9469 divbuf_1/a_21120_n1600# divbuf_1/a_21600_n1600# 0.26fF
C9470 divbuf_1/a_11802_n240# divbuf_1/a_12030_n840# 0.02fF
C9471 divbuf_1/a_13470_n1540# divbuf_1/a_13950_n1540# 0.11fF
C9472 ro_div_0/divbuf_0/a_45630_n840# ro_div_0/divbuf_0/a_45630_n1540# 0.01fF
C9473 ro_div_0/divbuf_0/a_14910_n1540# ro_div_0/divbuf_0/a_15390_n1540# 0.11fF
C9474 divbuf_3/a_4350_n1540# divbuf_3/a_4830_n1540# 0.11fF
C9475 divbuf_3/a_35070_n840# divbuf_3/a_35070_n1540# 0.01fF
C9476 divbuf_1/a_4392_n240# divbuf_1/OUT3 0.04fF
C9477 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C9478 divbuf_0/a_25382_170# divbuf_0/a_25862_170# 0.07fF
C9479 pll_full_0/divbuf_1/a_33600_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C9480 pll_full_0/divbuf_0/a_3912_170# pll_full_0/divbuf_0/a_3912_n240# 0.01fF
C9481 divbuf_2/a_34592_170# divbuf_2/OUT4 0.19fF
C9482 divbuf_2/a_39360_n1600# divbuf_2/a_39390_n840# 0.04fF
C9483 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/Out 0.01fF
C9484 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C9485 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/clk 0.14fF
C9486 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C9487 divbuf_0/a_58560_n1600# divbuf_0/a_59040_n1600# 0.26fF
C9488 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C9489 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C9490 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Z2 0.40fF
C9491 pll_full_0/divider_0/prescaler_0/tspc_0/Q pll_full_0/divider_0/clk 0.05fF
C9492 pll_full_0/divbuf_0/a_52800_n1600# pll_full_0/divbuf_0/a_53280_n1600# 0.26fF
C9493 pll_full_0/divbuf_0/a_13742_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9494 ro_div_0/divbuf_0/a_12480_n1600# ro_div_0/divbuf_0/a_12510_n840# 0.04fF
C9495 divbuf_0/a_50910_n1540# divbuf_0/a_51390_n1540# 0.11fF
C9496 divbuf_3/a_1920_n1600# divbuf_3/a_1950_n840# 0.04fF
C9497 divbuf_1/a_11040_n1600# divbuf_1/a_11070_n840# 0.04fF
C9498 pll_full_0/divbuf_0/a_45150_n1540# pll_full_0/divbuf_0/a_45630_n1540# 0.11fF
C9499 pd_div_0/divbuf_0/a_10080_n1600# pd_div_0/divbuf_0/a_10560_n1600# 0.26fF
C9500 pll_full_0/divbuf_1/a_15360_n1600# pll_full_0/divbuf_1/a_15840_n1600# 0.26fF
C9501 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/a_5790_n840# 0.04fF
C9502 divbuf_2/a_17122_n240# divbuf_2/a_17612_n240# 0.04fF
C9503 divbuf_2/a_37022_170# divbuf_2/a_37022_n240# 0.01fF
C9504 pd_div_0/divbuf_0/a_2430_n1540# pd_div_0/divbuf_0/a_2910_n1540# 0.11fF
C9505 pd_div_0/divbuf_0/a_33150_n840# pd_div_0/divbuf_0/a_33150_n1540# 0.01fF
C9506 pd_div_0/divbuf_0/a_2910_n840# pd_div_0/divbuf_0/OUT3 0.03fF
C9507 pll_full_0/divbuf_1/a_7710_n1540# pll_full_0/divbuf_1/a_8190_n1540# 0.11fF
C9508 pll_full_0/divbuf_1/a_38430_n840# pll_full_0/divbuf_1/a_38430_n1540# 0.01fF
C9509 divbuf_2/a_35562_n240# divbuf_2/OUT4 0.04fF
C9510 divbuf_2/a_28830_n840# divbuf_2/a_29310_n840# 0.07fF
C9511 divbuf_2/a_28800_n1600# divbuf_2/a_28830_n1540# 0.19fF
C9512 divbuf_1/a_24412_170# divbuf_1/a_24892_170# 0.07fF
C9513 ro_div_0/divbuf_0/a_29262_170# ro_div_0/divbuf_0/a_29742_170# 0.07fF
C9514 divbuf_0/a_48480_n1600# divbuf_0/a_48510_n840# 0.04fF
C9515 divbuf_0/a_13742_n240# divbuf_0/OUT4 0.04fF
C9516 pll_full_0/divbuf_0/a_1842_n240# pll_full_0/divbuf_0/OUT2 0.04fF
C9517 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9518 pll_full_0/divbuf_0/a_42720_n1600# pll_full_0/divbuf_0/a_42750_n840# 0.04fF
C9519 divbuf_3/a_18582_170# divbuf_3/a_19072_170# 0.07fF
C9520 ro_div_0/divbuf_0/a_1950_n840# ro_div_0/divbuf_0/a_2430_n840# 0.07fF
C9521 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_1950_n1540# 0.19fF
C9522 ro_div_0/divbuf_0/a_20532_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9523 divbuf_3/a_51840_n1600# divbuf_3/a_52320_n1600# 0.26fF
C9524 divbuf_1/a_510_n840# divbuf_1/a_990_n840# 0.07fF
C9525 divbuf_1/a_480_n1600# divbuf_1/a_510_n1540# 0.19fF
C9526 ro_div_0/divider_0/tspc_0/Q gnd 0.33fF
C9527 ro_div_0/divbuf_0/a_54750_n1540# ro_div_0/divbuf_0/a_55230_n1540# 0.11fF
C9528 pll_full_0/divbuf_1/a_5280_n1600# pll_full_0/divbuf_1/a_5310_n840# 0.04fF
C9529 divbuf_3/a_44190_n1540# divbuf_3/a_44670_n1540# 0.11fF
C9530 divbuf_1/a_23070_n840# divbuf_1/a_23070_n1540# 0.01fF
C9531 divbuf_1/a_53280_n1600# divbuf_1/a_53310_n1540# 0.19fF
C9532 pd_div_0/divbuf_0/a_41790_n840# pd_div_0/divbuf_0/OUT5 0.03fF
C9533 divbuf_0/a_26352_n240# divbuf_0/a_26832_n240# 0.05fF
C9534 pll_full_0/divbuf_0/a_40412_170# pll_full_0/divbuf_0/a_40412_n240# 0.01fF
C9535 pll_full_0/divbuf_0/a_20532_n240# pll_full_0/divbuf_0/a_21012_n240# 0.05fF
C9536 divbuf_2/a_33600_n1600# divbuf_2/OUT4 0.01fF
C9537 divbuf_1/a_26832_170# divbuf_1/a_26832_n240# 0.01fF
C9538 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n1540# 0.19fF
C9539 divbuf_0/a_37950_n840# divbuf_0/a_38430_n840# 0.07fF
C9540 divbuf_0/a_7710_n840# divbuf_0/a_7710_n1540# 0.01fF
C9541 divbuf_0/a_12000_n1600# divbuf_0/OUT4 0.00fF
C9542 pll_full_0/divbuf_0/a_1950_n840# pll_full_0/divbuf_0/a_1950_n1540# 0.01fF
C9543 pll_full_0/divbuf_0/a_32190_n840# pll_full_0/divbuf_0/a_32670_n840# 0.07fF
C9544 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32190_n1540# 0.19fF
C9545 pll_full_0/divbuf_0/a_1440_n1600# pll_full_0/divbuf_0/OUT2 0.01fF
C9546 ro_div_0/divbuf_0/a_52320_n1600# ro_div_0/divbuf_0/a_52350_n840# 0.04fF
C9547 ro_div_0/divbuf_0/a_21502_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9548 divbuf_3/a_39442_170# divbuf_3/OUT4 0.19fF
C9549 divbuf_3/a_41760_n1600# divbuf_3/a_41790_n840# 0.04fF
C9550 divbuf_1/a_50880_n1600# divbuf_1/a_50910_n840# 0.04fF
C9551 divbuf_1/a_45150_n1540# divbuf_1/a_45630_n1540# 0.11fF
C9552 pd_div_0/divbuf_0/a_16642_170# pd_div_0/divbuf_0/a_17122_170# 0.07fF
C9553 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/a_1352_n240# 0.01fF
C9554 pll_full_0/divbuf_1/a_21982_170# pll_full_0/divbuf_1/a_22472_170# 0.07fF
C9555 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/a_40830_n840# 0.03fF
C9556 pd_div_0/divbuf_0/a_49920_n1600# pd_div_0/divbuf_0/a_50400_n1600# 0.26fF
C9557 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C9558 io_clamp_high[2] io_analog[6] 0.53fF
C9559 pll_full_0/divbuf_1/a_55200_n1600# pll_full_0/divbuf_1/a_55680_n1600# 0.26fF
C9560 pll_full_0/divbuf_1/a_5852_170# pll_full_0/divbuf_1/OUT3 0.19fF
C9561 divbuf_2/a_15360_n1600# divbuf_2/a_15840_n1600# 0.26fF
C9562 divbuf_2/a_5852_n240# divbuf_2/a_5790_n840# 0.04fF
C9563 pd_div_0/divbuf_0/a_42270_n1540# pd_div_0/divbuf_0/a_42750_n1540# 0.11fF
C9564 pll_full_0/divbuf_1/a_47550_n1540# pll_full_0/divbuf_1/a_48030_n1540# 0.11fF
C9565 divbuf_2/a_7710_n1540# divbuf_2/a_8190_n1540# 0.11fF
C9566 divbuf_2/a_38430_n840# divbuf_2/a_38430_n1540# 0.01fF
C9567 divbuf_1/a_28772_n240# divbuf_1/a_29262_n240# 0.04fF
C9568 ro_div_0/divbuf_0/a_30232_n240# ro_div_0/divbuf_0/a_30712_n240# 0.05fF
C9569 divbuf_3/a_39442_170# divbuf_3/a_39442_n240# 0.01fF
C9570 divbuf_3/a_19562_n240# divbuf_3/a_20042_n240# 0.05fF
C9571 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_41790_n1540# 0.19fF
C9572 ro_div_0/divbuf_0/a_41790_n840# ro_div_0/divbuf_0/a_42270_n840# 0.07fF
C9573 ro_div_0/divbuf_0/a_11550_n840# ro_div_0/divbuf_0/a_11550_n1540# 0.01fF
C9574 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C9575 divbuf_1/a_10110_n840# divbuf_1/a_10110_n1540# 0.01fF
C9576 divbuf_1/a_40350_n840# divbuf_1/a_40830_n840# 0.07fF
C9577 divbuf_3/a_40412_n240# divbuf_3/OUT4 0.04fF
C9578 divbuf_3/a_990_n840# divbuf_3/a_990_n1540# 0.01fF
C9579 divbuf_3/a_31230_n840# divbuf_3/a_31710_n840# 0.07fF
C9580 divbuf_3/a_31200_n1600# divbuf_3/a_31230_n1540# 0.19fF
C9581 pd_div_0/divbuf_0/a_35562_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9582 pd_div_0/divbuf_0/a_39840_n1600# pd_div_0/divbuf_0/a_39870_n840# 0.04fF
C9583 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/clk 0.11fF
C9584 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 ro_div_0/divider_0/prescaler_0/Out 0.11fF
C9585 ro_div_0/divider_0/tspc_1/Q ro_div_0/divider_0/tspc_2/Z4 0.15fF
C9586 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C9587 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C9588 pll_full_0/divbuf_1/a_45120_n1600# pll_full_0/divbuf_1/a_45150_n840# 0.04fF
C9589 divbuf_2/a_5280_n1600# divbuf_2/a_5310_n840# 0.04fF
C9590 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C9591 divbuf_0/a_15182_n240# divbuf_0/a_15390_n840# 0.02fF
C9592 divbuf_0/a_24480_n1600# divbuf_0/a_24960_n1600# 0.26fF
C9593 pll_full_0/divbuf_0/a_18720_n1600# pll_full_0/divbuf_0/a_19200_n1600# 0.26fF
C9594 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/a_9150_n840# 0.03fF
C9595 divbuf_0/a_47550_n840# divbuf_0/a_47550_n1540# 0.01fF
C9596 divbuf_0/a_16830_n1540# divbuf_0/a_17310_n1540# 0.11fF
C9597 pll_full_0/divbuf_0/a_11070_n1540# pll_full_0/divbuf_0/a_11550_n1540# 0.11fF
C9598 pll_full_0/divbuf_0/a_41790_n840# pll_full_0/divbuf_0/a_41790_n1540# 0.01fF
C9599 divbuf_2/a_1352_170# divbuf_2/a_1352_n240# 0.01fF
C9600 divbuf_2/a_21982_170# divbuf_2/a_22472_170# 0.07fF
C9601 pd_div_0/divbuf_0/a_17612_n240# pd_div_0/divbuf_0/a_18092_n240# 0.05fF
C9602 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/a_37502_n240# 0.01fF
C9603 pll_full_0/divbuf_1/a_22952_n240# pll_full_0/divbuf_1/a_23442_n240# 0.04fF
C9604 pd_div_0/divbuf_0/a_36532_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9605 pd_div_0/divbuf_0/a_29310_n840# pd_div_0/divbuf_0/a_29790_n840# 0.07fF
C9606 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29310_n1540# 0.19fF
C9607 divbuf_0/a_18092_170# divbuf_0/a_18092_n240# 0.01fF
C9608 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_34590_n1540# 0.19fF
C9609 pll_full_0/divbuf_1/a_4350_n840# pll_full_0/divbuf_1/a_4350_n1540# 0.01fF
C9610 pll_full_0/divbuf_1/a_34590_n840# pll_full_0/divbuf_1/a_35070_n840# 0.07fF
C9611 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_12282_170# 0.07fF
C9612 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C9613 divbuf_2/a_55200_n1600# divbuf_2/a_55680_n1600# 0.26fF
C9614 divbuf_2/a_5852_170# divbuf_2/OUT3 0.19fF
C9615 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z2 1.07fF
C9616 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/tspc_1/Z3 0.38fF
C9617 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C9618 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C9619 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C9620 ro_div_0/divbuf_0/a_7792_170# ro_div_0/divbuf_0/a_7302_170# 0.07fF
C9621 divbuf_0/a_14400_n1600# divbuf_0/a_14430_n840# 0.04fF
C9622 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_1/A 0.15fF
C9623 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C9624 gnd pll_full_0/divider_0/nor_1/Z1 0.01fF
C9625 pll_full_0/divbuf_0/a_8640_n1600# pll_full_0/divbuf_0/a_8670_n840# 0.04fF
C9626 divbuf_2/a_47550_n1540# divbuf_2/a_48030_n1540# 0.11fF
C9627 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/a_19230_n840# 0.02fF
C9628 ro_div_0/divbuf_0/a_28320_n1600# ro_div_0/divbuf_0/a_28800_n1600# 0.26fF
C9629 divbuf_3/a_17760_n1600# divbuf_3/a_18240_n1600# 0.26fF
C9630 divbuf_3/a_8272_n240# divbuf_3/a_8190_n840# 0.03fF
C9631 divbuf_1/a_26880_n1600# divbuf_1/a_27360_n1600# 0.26fF
C9632 divbuf_1/a_17612_n240# divbuf_1/a_17790_n840# 0.02fF
C9633 ro_div_0/divbuf_0/a_51390_n840# ro_div_0/divbuf_0/a_51390_n1540# 0.01fF
C9634 ro_div_0/divbuf_0/a_20670_n1540# ro_div_0/divbuf_0/a_21150_n1540# 0.11fF
C9635 divbuf_3/a_10110_n1540# divbuf_3/a_10590_n1540# 0.11fF
C9636 divbuf_3/a_40830_n840# divbuf_3/a_40830_n1540# 0.01fF
C9637 divbuf_1/a_16152_n240# divbuf_1/OUT4 0.04fF
C9638 divbuf_1/a_19200_n1600# divbuf_1/a_19230_n1540# 0.19fF
C9639 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/OUT4 0.01fF
C9640 divbuf_0/a_7302_170# divbuf_0/a_7302_n240# 0.01fF
C9641 divbuf_0/a_31202_170# divbuf_0/a_31682_170# 0.07fF
C9642 divbuf_0/a_11802_170# divbuf_0/a_11802_n240# 0.01fF
C9643 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/a_25862_170# 0.07fF
C9644 divbuf_2/a_6822_n240# divbuf_2/OUT3 0.04fF
C9645 divbuf_2/a_45120_n1600# divbuf_2/a_45150_n840# 0.04fF
C9646 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z3 0.06fF
C9647 pd_div_0/divider_0/nor_0/B pd_div_0/bufin 0.29fF
C9648 pd_div_0/divider_0/prescaler_0/tspc_2/D pd_div_0/divider_0/clk 0.29fF
C9649 gnd pd_div_0/divider_0/prescaler_0/Out 0.46fF
C9650 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n1540# 0.19fF
C9651 divbuf_0/a_24412_170# divbuf_0/OUT4 0.19fF
C9652 divbuf_0/a_3870_n840# divbuf_0/a_4350_n840# 0.07fF
C9653 pll_full_0/divbuf_0/a_58560_n1600# pll_full_0/divbuf_0/a_59040_n1600# 0.26fF
C9654 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/OUT3 0.19fF
C9655 ro_div_0/divbuf_0/a_18240_n1600# ro_div_0/divbuf_0/a_18270_n840# 0.04fF
C9656 divbuf_0/a_56670_n1540# divbuf_0/a_57150_n1540# 0.11fF
C9657 pll_full_0/divbuf_0/a_50910_n1540# pll_full_0/divbuf_0/a_51390_n1540# 0.11fF
C9658 divbuf_3/a_7680_n1600# divbuf_3/a_7710_n840# 0.04fF
C9659 divbuf_1/a_16800_n1600# divbuf_1/a_16830_n840# 0.04fF
C9660 pd_div_0/divbuf_0/a_15840_n1600# pd_div_0/divbuf_0/a_16320_n1600# 0.26fF
C9661 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/a_6270_n840# 0.04fF
C9662 pll_full_0/divbuf_1/a_21120_n1600# pll_full_0/divbuf_1/a_21600_n1600# 0.26fF
C9663 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_12030_n840# 0.02fF
C9664 divbuf_2/a_22952_n240# divbuf_2/a_23442_n240# 0.04fF
C9665 pd_div_0/divbuf_0/a_8190_n1540# pd_div_0/divbuf_0/a_8670_n1540# 0.11fF
C9666 pd_div_0/divbuf_0/a_38910_n840# pd_div_0/divbuf_0/a_38910_n1540# 0.01fF
C9667 pll_full_0/divbuf_1/a_13470_n1540# pll_full_0/divbuf_1/a_13950_n1540# 0.11fF
C9668 pll_full_0/divbuf_1/a_44190_n840# pll_full_0/divbuf_1/a_44190_n1540# 0.01fF
C9669 divbuf_2/a_34560_n1600# divbuf_2/a_34590_n1540# 0.19fF
C9670 divbuf_2/a_4350_n840# divbuf_2/a_4350_n1540# 0.01fF
C9671 divbuf_2/a_34590_n840# divbuf_2/a_35070_n840# 0.07fF
C9672 ro_div_0/divbuf_0/a_35082_170# ro_div_0/divbuf_0/a_35562_170# 0.07fF
C9673 divbuf_0/a_54240_n1600# divbuf_0/a_54270_n840# 0.04fF
C9674 divbuf_0/a_25382_n240# divbuf_0/OUT4 0.04fF
C9675 pll_full_0/divbuf_0/a_13742_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9676 pll_full_0/divbuf_0/a_48480_n1600# pll_full_0/divbuf_0/a_48510_n840# 0.04fF
C9677 divbuf_3/a_4392_170# divbuf_3/a_4392_n240# 0.01fF
C9678 divbuf_3/a_24412_170# divbuf_3/a_24892_170# 0.07fF
C9679 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/z5 0.11fF
C9680 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_7710_n1540# 0.19fF
C9681 ro_div_0/divbuf_0/a_32172_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9682 ro_div_0/divbuf_0/a_7710_n840# ro_div_0/divbuf_0/a_8190_n840# 0.07fF
C9683 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.44fF
C9684 divbuf_3/a_10212_170# divbuf_3/OUT4 0.07fF
C9685 divbuf_3/a_57600_n1600# divbuf_3/a_58080_n1600# 0.26fF
C9686 divbuf_1/a_6270_n840# divbuf_1/a_6750_n840# 0.07fF
C9687 divbuf_1/a_6240_n1600# divbuf_1/a_6270_n1540# 0.19fF
C9688 pd_div_0/divbuf_0/a_5760_n1600# pd_div_0/divbuf_0/a_5790_n840# 0.04fF
C9689 ro_div_0/divbuf_0/a_60510_n1540# ro_div_0/divbuf_0/a_60990_n1540# 0.11fF
C9690 pll_full_0/divbuf_1/a_11040_n1600# pll_full_0/divbuf_1/a_11070_n840# 0.04fF
C9691 divbuf_3/a_49950_n1540# divbuf_3/a_50430_n1540# 0.11fF
C9692 divbuf_1/a_59040_n1600# divbuf_1/a_59070_n1540# 0.19fF
C9693 divbuf_1/a_28830_n840# divbuf_1/a_28830_n1540# 0.01fF
C9694 divbuf_0/a_32172_n240# divbuf_0/a_32652_n240# 0.05fF
C9695 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/a_26832_n240# 0.05fF
C9696 divbuf_0/a_23520_n1600# divbuf_0/OUT4 0.00fF
C9697 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n1540# 0.19fF
C9698 divbuf_0/a_43710_n840# divbuf_0/a_44190_n840# 0.07fF
C9699 divbuf_0/a_13470_n840# divbuf_0/a_13470_n1540# 0.01fF
C9700 pll_full_0/divbuf_0/a_12000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C9701 pll_full_0/divbuf_0/a_7710_n840# pll_full_0/divbuf_0/a_7710_n1540# 0.01fF
C9702 pll_full_0/divbuf_0/a_37950_n840# pll_full_0/divbuf_0/a_38430_n840# 0.07fF
C9703 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_37950_n1540# 0.19fF
C9704 ro_div_0/divbuf_0/a_58080_n1600# ro_div_0/divbuf_0/a_58110_n840# 0.04fF
C9705 ro_div_0/divbuf_0/a_33142_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9706 divbuf_3/a_11802_n240# divbuf_3/OUT4 0.04fF
C9707 divbuf_3/a_47520_n1600# divbuf_3/a_47550_n840# 0.04fF
C9708 divbuf_1/a_50910_n1540# divbuf_1/a_51390_n1540# 0.11fF
C9709 divbuf_1/a_56640_n1600# divbuf_1/a_56670_n840# 0.04fF
C9710 pd_div_0/divbuf_0/a_22472_170# pd_div_0/divbuf_0/a_22952_170# 0.07fF
C9711 pd_div_0/divbuf_0/a_6332_170# pd_div_0/divbuf_0/a_6332_n240# 0.01fF
C9712 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/a_7792_n240# 0.01fF
C9713 pll_full_0/divbuf_1/a_27802_170# pll_full_0/divbuf_1/a_28292_170# 0.07fF
C9714 pd_div_0/divbuf_0/a_55680_n1600# pd_div_0/divbuf_0/a_56160_n1600# 0.26fF
C9715 pd_div_0/divbuf_0/a_14222_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9716 ro_div_0/divider_0/prescaler_0/m1_2700_2190# ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C9717 ro_div_0/divider_0/tspc_1/a_630_n680# ro_div_0/divider_0/tspc_1/Z3 0.05fF
C9718 divbuf_0/a_6332_170# divbuf_0/a_6822_170# 0.07fF
C9719 pll_full_0/divbuf_1/a_510_n840# pll_full_0/divbuf_1/a_990_n840# 0.07fF
C9720 pll_full_0/divbuf_1/a_17612_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9721 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_510_n1540# 0.19fF
C9722 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C9723 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C9724 divbuf_2/a_21120_n1600# divbuf_2/a_21600_n1600# 0.26fF
C9725 divbuf_2/a_11802_n240# divbuf_2/a_12030_n840# 0.02fF
C9726 pd_div_0/divbuf_0/a_48030_n1540# pd_div_0/divbuf_0/a_48510_n1540# 0.11fF
C9727 pll_full_0/divbuf_1/a_53310_n1540# pll_full_0/divbuf_1/a_53790_n1540# 0.11fF
C9728 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_510_n1540# 0.11fF
C9729 divbuf_2/a_13470_n1540# divbuf_2/a_13950_n1540# 0.11fF
C9730 divbuf_2/a_44190_n840# divbuf_2/a_44190_n1540# 0.01fF
C9731 divbuf_1/a_34592_n240# divbuf_1/a_35082_n240# 0.04fF
C9732 ro_div_0/divbuf_0/a_36052_n240# ro_div_0/divbuf_0/a_36532_n240# 0.05fF
C9733 divbuf_3/a_25382_n240# divbuf_3/a_25862_n240# 0.05fF
C9734 ro_div_0/divbuf_0/a_47550_n840# ro_div_0/divbuf_0/a_48030_n840# 0.07fF
C9735 ro_div_0/divbuf_0/a_17310_n840# ro_div_0/divbuf_0/a_17310_n1540# 0.01fF
C9736 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C9737 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_47550_n1540# 0.19fF
C9738 divbuf_3/a_36960_n1600# divbuf_3/a_36990_n1540# 0.19fF
C9739 divbuf_3/a_10560_n1600# divbuf_3/OUT3 0.01fF
C9740 divbuf_3/a_6750_n840# divbuf_3/a_6750_n1540# 0.01fF
C9741 divbuf_3/a_36990_n840# divbuf_3/a_37470_n840# 0.07fF
C9742 divbuf_1/a_46110_n840# divbuf_1/a_46590_n840# 0.07fF
C9743 pd_div_0/divbuf_0/a_7792_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C9744 pd_div_0/divbuf_0/a_45600_n1600# pd_div_0/divbuf_0/a_45630_n840# 0.04fF
C9745 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C9746 pll_full_0/divbuf_1/a_18582_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9747 pll_full_0/divbuf_1/a_50880_n1600# pll_full_0/divbuf_1/a_50910_n840# 0.04fF
C9748 divbuf_2/a_11040_n1600# divbuf_2/a_11070_n840# 0.04fF
C9749 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C9750 divbuf_0/a_21012_n240# divbuf_0/a_21150_n840# 0.03fF
C9751 divbuf_0/a_30240_n1600# divbuf_0/a_30720_n1600# 0.26fF
C9752 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_1/B 0.18fF
C9753 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/a_24960_n1600# 0.26fF
C9754 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_15390_n840# 0.02fF
C9755 divbuf_0/a_53310_n840# divbuf_0/a_53310_n1540# 0.01fF
C9756 divbuf_0/a_22590_n1540# divbuf_0/a_23070_n1540# 0.11fF
C9757 pll_full_0/divbuf_0/a_16830_n1540# pll_full_0/divbuf_0/a_17310_n1540# 0.11fF
C9758 pll_full_0/divbuf_0/a_47550_n840# pll_full_0/divbuf_0/a_47550_n1540# 0.01fF
C9759 ro_div_0/divbuf_0/a_10590_n840# ro_div_0/divbuf_0/OUT4 0.03fF
C9760 divbuf_2/a_7792_170# divbuf_2/a_7792_n240# 0.01fF
C9761 divbuf_2/a_27802_170# divbuf_2/a_28292_170# 0.07fF
C9762 pd_div_0/divbuf_0/a_23442_n240# pd_div_0/divbuf_0/a_23922_n240# 0.05fF
C9763 pll_full_0/divbuf_1/a_28772_n240# pll_full_0/divbuf_1/a_29262_n240# 0.04fF
C9764 divbuf_1/a_23442_170# divbuf_1/OUT4 0.19fF
C9765 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35070_n1540# 0.19fF
C9766 pd_div_0/divbuf_0/a_4830_n840# pd_div_0/divbuf_0/a_4830_n1540# 0.01fF
C9767 pd_div_0/divbuf_0/a_35070_n840# pd_div_0/divbuf_0/a_35550_n840# 0.07fF
C9768 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C9769 pll_full_0/divbuf_1/a_10110_n840# pll_full_0/divbuf_1/a_10110_n1540# 0.01fF
C9770 pll_full_0/divbuf_1/a_40350_n840# pll_full_0/divbuf_1/a_40830_n840# 0.07fF
C9771 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40350_n1540# 0.19fF
C9772 divbuf_2/a_510_n840# divbuf_2/a_990_n840# 0.07fF
C9773 divbuf_2/a_17612_170# divbuf_2/OUT4 0.19fF
C9774 divbuf_2/a_480_n1600# divbuf_2/a_510_n1540# 0.19fF
C9775 divbuf_1/a_11312_170# divbuf_1/a_11802_170# 0.07fF
C9776 pd_div_0/divider_0/tspc_1/Z2 pd_div_0/divider_0/tspc_1/Z4 0.36fF
C9777 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/and_0/OUT 0.06fF
C9778 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C9779 pd_div_0/divider_0/prescaler_0/m1_2700_2190# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C9780 ro_div_0/divbuf_0/a_13252_170# ro_div_0/divbuf_0/a_13742_170# 0.07fF
C9781 divbuf_0/a_6822_170# divbuf_0/OUT3 0.19fF
C9782 divbuf_0/a_20160_n1600# divbuf_0/a_20190_n840# 0.04fF
C9783 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C9784 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C9785 gnd pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.17fF
C9786 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C9787 pll_full_0/divbuf_0/a_14400_n1600# pll_full_0/divbuf_0/a_14430_n840# 0.04fF
C9788 divbuf_2/a_53310_n1540# divbuf_2/a_53790_n1540# 0.11fF
C9789 divbuf_1/a_32640_n1600# divbuf_1/a_33120_n1600# 0.26fF
C9790 divbuf_1/a_23442_n240# divbuf_1/a_23550_n840# 0.03fF
C9791 ro_div_0/divbuf_0/a_34080_n1600# ro_div_0/divbuf_0/a_34560_n1600# 0.26fF
C9792 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/a_24990_n840# 0.03fF
C9793 divbuf_3/a_14222_n240# divbuf_3/a_14430_n840# 0.02fF
C9794 divbuf_3/a_23520_n1600# divbuf_3/a_24000_n1600# 0.26fF
C9795 ro_div_0/divbuf_0/a_57150_n840# ro_div_0/divbuf_0/a_57150_n1540# 0.01fF
C9796 ro_div_0/divbuf_0/a_26430_n1540# ro_div_0/divbuf_0/a_26910_n1540# 0.11fF
C9797 divbuf_3/a_15870_n1540# divbuf_3/a_16350_n1540# 0.11fF
C9798 divbuf_3/a_46590_n840# divbuf_3/a_46590_n1540# 0.01fF
C9799 divbuf_1/a_27802_n240# divbuf_1/OUT4 0.04fF
C9800 divbuf_1/a_24960_n1600# divbuf_1/a_24990_n1540# 0.19fF
C9801 divbuf_0/a_37022_170# divbuf_0/a_37502_170# 0.07fF
C9802 divbuf_0/a_492_n240# divbuf_0/a_480_n1600# 0.00fF
C9803 pll_full_0/divbuf_0/a_31202_170# pll_full_0/divbuf_0/a_31682_170# 0.07fF
C9804 divbuf_2/a_18582_n240# divbuf_2/OUT4 0.04fF
C9805 divbuf_2/a_50880_n1600# divbuf_2/a_50910_n840# 0.04fF
C9806 pd_div_0/divider_0/and_0/out1 pd_div_0/divider_0/and_0/Z1 0.36fF
C9807 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n1540# 0.19fF
C9808 divbuf_0/a_36052_170# divbuf_0/OUT4 0.19fF
C9809 divbuf_0/a_9630_n840# divbuf_0/a_10110_n840# 0.07fF
C9810 pll_full_0/divbuf_0/a_3870_n840# pll_full_0/divbuf_0/a_4350_n840# 0.07fF
C9811 pll_full_0/divbuf_0/a_24412_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9812 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_3870_n1540# 0.19fF
C9813 ro_div_0/divbuf_0/a_24000_n1600# ro_div_0/divbuf_0/a_24030_n840# 0.04fF
C9814 divbuf_0/a_60990_n1540# divbuf_0/OUT5 0.19fF
C9815 pll_full_0/divbuf_0/a_56670_n1540# pll_full_0/divbuf_0/a_57150_n1540# 0.11fF
C9816 divbuf_3/a_13440_n1600# divbuf_3/a_13470_n840# 0.04fF
C9817 divbuf_1/a_16830_n1540# divbuf_1/a_17310_n1540# 0.11fF
C9818 divbuf_1/a_22560_n1600# divbuf_1/a_22590_n840# 0.04fF
C9819 divbuf_2/a_28772_n240# divbuf_2/a_29262_n240# 0.04fF
C9820 pd_div_0/divbuf_0/a_21600_n1600# pd_div_0/divbuf_0/a_22080_n1600# 0.26fF
C9821 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12510_n840# 0.02fF
C9822 pll_full_0/divbuf_1/a_26880_n1600# pll_full_0/divbuf_1/a_27360_n1600# 0.26fF
C9823 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_17790_n840# 0.02fF
C9824 pd_div_0/divbuf_0/a_13950_n1540# pd_div_0/divbuf_0/a_14430_n1540# 0.11fF
C9825 pd_div_0/divbuf_0/a_44670_n840# pd_div_0/divbuf_0/a_44670_n1540# 0.01fF
C9826 pll_full_0/divbuf_1/a_19230_n1540# pll_full_0/divbuf_1/a_19710_n1540# 0.11fF
C9827 pll_full_0/divbuf_1/a_49950_n840# pll_full_0/divbuf_1/a_49950_n1540# 0.01fF
C9828 divbuf_2/a_10110_n840# divbuf_2/a_10110_n1540# 0.01fF
C9829 divbuf_2/a_40350_n840# divbuf_2/a_40830_n840# 0.07fF
C9830 divbuf_2/a_40320_n1600# divbuf_2/a_40350_n1540# 0.19fF
C9831 divbuf_1/a_39442_170# divbuf_1/a_39932_170# 0.07fF
C9832 ro_div_0/divbuf_0/a_40902_170# ro_div_0/divbuf_0/a_41382_170# 0.07fF
C9833 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/a_21502_n240# 0.01fF
C9834 divbuf_0/a_60000_n1600# divbuf_0/a_60030_n840# 0.04fF
C9835 divbuf_0/a_37022_n240# divbuf_0/OUT4 0.04fF
C9836 pll_full_0/divbuf_0/a_25382_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9837 pll_full_0/divbuf_0/a_54240_n1600# pll_full_0/divbuf_0/a_54270_n840# 0.04fF
C9838 divbuf_3/a_10212_170# divbuf_3/a_10212_n240# 0.01fF
C9839 divbuf_3/a_30232_170# divbuf_3/a_30712_170# 0.07fF
C9840 ro_div_0/divbuf_0/a_13470_n840# ro_div_0/divbuf_0/a_13950_n840# 0.07fF
C9841 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13470_n1540# 0.19fF
C9842 ro_div_0/divbuf_0/a_4392_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C9843 ro_div_0/divider_0/prescaler_0/tspc_1/Q gnd 0.83fF
C9844 divbuf_3/a_22472_170# divbuf_3/OUT4 0.19fF
C9845 divbuf_3/a_2880_n1600# divbuf_3/a_2910_n1540# 0.19fF
C9846 divbuf_3/a_2910_n840# divbuf_3/a_3390_n840# 0.07fF
C9847 divbuf_1/a_12000_n1600# divbuf_1/a_12030_n1540# 0.19fF
C9848 divbuf_1/a_12030_n840# divbuf_1/a_12510_n840# 0.07fF
C9849 pd_div_0/divbuf_0/a_11520_n1600# pd_div_0/divbuf_0/a_11550_n840# 0.04fF
C9850 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C9851 pll_full_0/divbuf_1/a_16800_n1600# pll_full_0/divbuf_1/a_16830_n840# 0.04fF
C9852 divbuf_3/a_55710_n1540# divbuf_3/a_56190_n1540# 0.11fF
C9853 divbuf_1/a_34590_n840# divbuf_1/a_34590_n1540# 0.01fF
C9854 divbuf_0/a_37992_n240# divbuf_0/a_38472_n240# 0.05fF
C9855 pll_full_0/divbuf_0/a_32172_n240# pll_full_0/divbuf_0/a_32652_n240# 0.05fF
C9856 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n1540# 0.19fF
C9857 divbuf_0/a_49470_n840# divbuf_0/a_49950_n840# 0.07fF
C9858 divbuf_0/a_19230_n840# divbuf_0/a_19230_n1540# 0.01fF
C9859 divbuf_0/a_35040_n1600# divbuf_0/OUT4 0.00fF
C9860 pll_full_0/divbuf_0/a_13470_n840# pll_full_0/divbuf_0/a_13470_n1540# 0.01fF
C9861 pll_full_0/divbuf_0/a_43710_n840# pll_full_0/divbuf_0/a_44190_n840# 0.07fF
C9862 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_43710_n1540# 0.19fF
C9863 pll_full_0/divbuf_0/a_23520_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C9864 pd_div_0/divbuf_0/a_28292_170# pd_div_0/divbuf_0/a_28772_170# 0.07fF
C9865 divbuf_3/a_23442_n240# divbuf_3/OUT4 0.04fF
C9866 divbuf_3/a_53280_n1600# divbuf_3/a_53310_n840# 0.04fF
C9867 divbuf_1/a_56670_n1540# divbuf_1/a_57150_n1540# 0.11fF
C9868 pll_full_0/divbuf_1/a_14222_170# pll_full_0/divbuf_1/a_14222_n240# 0.01fF
C9869 pll_full_0/divbuf_1/a_33622_170# pll_full_0/divbuf_1/a_34112_170# 0.07fF
C9870 pd_div_0/divbuf_0/a_18582_170# pd_div_0/divbuf_0/OUT4 0.19fF
C9871 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_990_n1540# 0.19fF
C9872 pd_div_0/divbuf_0/a_990_n840# pd_div_0/divbuf_0/a_1470_n840# 0.07fF
C9873 pll_full_0/divbuf_1/a_6270_n840# pll_full_0/divbuf_1/a_6750_n840# 0.07fF
C9874 pll_full_0/divbuf_1/a_29262_170# pll_full_0/divbuf_1/OUT4 0.19fF
C9875 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6270_n1540# 0.19fF
C9876 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C9877 divbuf_2/a_26880_n1600# divbuf_2/a_27360_n1600# 0.26fF
C9878 divbuf_2/a_17612_n240# divbuf_2/a_17790_n840# 0.02fF
C9879 pd_div_0/divbuf_0/a_53790_n1540# pd_div_0/divbuf_0/a_54270_n1540# 0.11fF
C9880 pll_full_0/divbuf_1/a_59070_n1540# pll_full_0/divbuf_1/a_59550_n1540# 0.11fF
C9881 divbuf_2/a_19230_n1540# divbuf_2/a_19710_n1540# 0.11fF
C9882 divbuf_2/a_49950_n840# divbuf_2/a_49950_n1540# 0.01fF
C9883 divbuf_1/a_40412_n240# divbuf_1/a_40902_n240# 0.04fF
C9884 ro_div_0/divbuf_0/a_0_n1600# ro_div_0/divbuf_0/a_480_n1600# 0.26fF
C9885 divbuf_3/a_31202_n240# divbuf_3/a_31682_n240# 0.05fF
C9886 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53310_n1540# 0.19fF
C9887 ro_div_0/divbuf_0/a_53310_n840# ro_div_0/divbuf_0/a_53790_n840# 0.07fF
C9888 ro_div_0/divbuf_0/a_23070_n840# ro_div_0/divbuf_0/a_23070_n1540# 0.01fF
C9889 divbuf_3/a_21600_n1600# divbuf_3/OUT4 0.01fF
C9890 divbuf_3/a_12510_n840# divbuf_3/a_12510_n1540# 0.01fF
C9891 divbuf_3/a_42750_n840# divbuf_3/a_43230_n840# 0.07fF
C9892 divbuf_3/a_42720_n1600# divbuf_3/a_42750_n1540# 0.19fF
C9893 divbuf_1/a_51870_n840# divbuf_1/a_52350_n840# 0.07fF
C9894 pd_div_0/divbuf_0/a_19562_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C9895 pd_div_0/divbuf_0/a_51360_n1600# pd_div_0/divbuf_0/a_51390_n840# 0.04fF
C9896 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/clk 0.51fF
C9897 pll_full_0/divbuf_1/a_30232_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C9898 pll_full_0/divbuf_1/a_56640_n1600# pll_full_0/divbuf_1/a_56670_n840# 0.04fF
C9899 divbuf_2/a_16800_n1600# divbuf_2/a_16830_n840# 0.04fF
C9900 divbuf_0/a_26832_n240# divbuf_0/a_26910_n840# 0.04fF
C9901 divbuf_0/a_36000_n1600# divbuf_0/a_36480_n1600# 0.26fF
C9902 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C9903 pll_full_0/divbuf_0/a_30240_n1600# pll_full_0/divbuf_0/a_30720_n1600# 0.26fF
C9904 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/a_21150_n840# 0.03fF
C9905 divbuf_0/a_59070_n840# divbuf_0/a_59070_n1540# 0.01fF
C9906 divbuf_0/a_28350_n1540# divbuf_0/a_28830_n1540# 0.11fF
C9907 pll_full_0/divbuf_0/a_22590_n1540# pll_full_0/divbuf_0/a_23070_n1540# 0.11fF
C9908 pll_full_0/divbuf_0/a_53310_n840# pll_full_0/divbuf_0/a_53310_n1540# 0.01fF
C9909 divbuf_2/a_14222_170# divbuf_2/a_14222_n240# 0.01fF
C9910 divbuf_2/a_33622_170# divbuf_2/a_34112_170# 0.07fF
C9911 pd_div_0/divbuf_0/a_29262_n240# pd_div_0/divbuf_0/a_29742_n240# 0.05fF
C9912 pll_full_0/divbuf_1/a_34592_n240# pll_full_0/divbuf_1/a_35082_n240# 0.04fF
C9913 divbuf_1/a_38472_170# divbuf_1/OUT4 0.19fF
C9914 pd_div_0/divbuf_0/a_10590_n840# pd_div_0/divbuf_0/a_10590_n1540# 0.01fF
C9915 pd_div_0/divbuf_0/a_40830_n840# pd_div_0/divbuf_0/a_41310_n840# 0.07fF
C9916 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_40830_n1540# 0.19fF
C9917 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46110_n1540# 0.19fF
C9918 pll_full_0/divbuf_1/a_15870_n840# pll_full_0/divbuf_1/a_15870_n1540# 0.01fF
C9919 pll_full_0/divbuf_1/a_46110_n840# pll_full_0/divbuf_1/a_46590_n840# 0.07fF
C9920 divbuf_2/a_6270_n840# divbuf_2/a_6750_n840# 0.07fF
C9921 divbuf_2/a_29262_170# divbuf_2/OUT4 0.19fF
C9922 divbuf_2/a_6240_n1600# divbuf_2/a_6270_n1540# 0.19fF
C9923 divbuf_1/a_11802_170# divbuf_1/a_12282_170# 0.07fF
C9924 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z1 0.01fF
C9925 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 gnd 0.16fF
C9926 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C9927 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C9928 pd_div_0/divider_0/nor_1/B pd_div_0/divider_0/and_0/A 0.26fF
C9929 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_2/v 0.05fF
C9930 divbuf_0/a_25920_n1600# divbuf_0/a_25950_n840# 0.04fF
C9931 pll_full_0/divbuf_0/a_20160_n1600# pll_full_0/divbuf_0/a_20190_n840# 0.04fF
C9932 divbuf_2/a_59070_n1540# divbuf_2/a_59550_n1540# 0.11fF
C9933 divbuf_1/a_38400_n1600# divbuf_1/a_38880_n1600# 0.26fF
C9934 divbuf_1/a_29262_n240# divbuf_1/a_29310_n840# 0.04fF
C9935 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/a_30750_n840# 0.05fF
C9936 ro_div_0/divbuf_0/a_39840_n1600# ro_div_0/divbuf_0/a_40320_n1600# 0.26fF
C9937 divbuf_3/a_29280_n1600# divbuf_3/a_29760_n1600# 0.26fF
C9938 divbuf_3/a_20042_n240# divbuf_3/a_20190_n840# 0.03fF
C9939 ro_div_0/divbuf_0/a_32190_n1540# ro_div_0/divbuf_0/a_32670_n1540# 0.11fF
C9940 divbuf_3/a_21630_n1540# divbuf_3/a_22110_n1540# 0.11fF
C9941 divbuf_3/a_52350_n840# divbuf_3/a_52350_n1540# 0.01fF
C9942 divbuf_1/a_39442_n240# divbuf_1/OUT4 0.04fF
C9943 divbuf_1/a_30720_n1600# divbuf_1/a_30750_n1540# 0.19fF
C9944 divbuf_0/a_23442_170# divbuf_0/a_23442_n240# 0.01fF
C9945 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/a_37502_170# 0.07fF
C9946 divbuf_2/a_30232_n240# divbuf_2/OUT4 0.04fF
C9947 divbuf_2/a_56640_n1600# divbuf_2/a_56670_n840# 0.04fF
C9948 divbuf_1/a_11802_170# divbuf_1/a_11802_n240# 0.01fF
C9949 divbuf_1/a_4882_170# divbuf_1/a_4882_n240# 0.01fF
C9950 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n1540# 0.19fF
C9951 divbuf_0/a_8272_n240# divbuf_0/OUT3 0.04fF
C9952 divbuf_0/a_15390_n840# divbuf_0/a_15870_n840# 0.07fF
C9953 pll_full_0/divbuf_0/a_9630_n840# pll_full_0/divbuf_0/a_10110_n840# 0.07fF
C9954 pll_full_0/divbuf_0/a_36052_170# pll_full_0/divbuf_0/OUT4 0.19fF
C9955 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_9630_n1540# 0.19fF
C9956 divbuf_1/a_28320_n1600# divbuf_1/a_28350_n840# 0.04fF
C9957 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/tspc_r_0/Z2 0.25fF
C9958 ro_div_0/divbuf_0/a_29760_n1600# ro_div_0/divbuf_0/a_29790_n840# 0.04fF
C9959 ro_div_0/divbuf_0/a_16642_170# ro_div_0/divbuf_0/OUT4 0.19fF
C9960 ro_div_0/divider_0/nor_0/Z1 gnd 0.01fF
C9961 pll_full_0/divbuf_0/a_60990_n1540# pll_full_0/divbuf_0/OUT5 0.19fF
C9962 divbuf_3/a_19200_n1600# divbuf_3/a_19230_n840# 0.04fF
C9963 divbuf_1/a_22590_n1540# divbuf_1/a_23070_n1540# 0.11fF
C9964 divbuf_2/a_34592_n240# divbuf_2/a_35082_n240# 0.04fF
C9965 pd_div_0/divbuf_0/a_27360_n1600# pd_div_0/divbuf_0/a_27840_n1600# 0.26fF
C9966 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_18270_n840# 0.02fF
C9967 pll_full_0/divbuf_1/a_32640_n1600# pll_full_0/divbuf_1/a_33120_n1600# 0.26fF
C9968 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/a_23550_n840# 0.03fF
C9969 pd_div_0/divbuf_0/a_19710_n1540# pd_div_0/divbuf_0/a_20190_n1540# 0.11fF
C9970 pd_div_0/divbuf_0/a_50430_n840# pd_div_0/divbuf_0/a_50430_n1540# 0.01fF
C9971 pll_full_0/divbuf_1/a_24990_n1540# pll_full_0/divbuf_1/a_25470_n1540# 0.11fF
C9972 pll_full_0/divbuf_1/a_55710_n840# pll_full_0/divbuf_1/a_55710_n1540# 0.01fF
C9973 divbuf_2/a_46080_n1600# divbuf_2/a_46110_n1540# 0.19fF
C9974 divbuf_2/a_15870_n840# divbuf_2/a_15870_n1540# 0.01fF
C9975 divbuf_2/a_46110_n840# divbuf_2/a_46590_n840# 0.07fF
C9976 divbuf_1/a_5362_n240# divbuf_1/a_5852_n240# 0.04fF
C9977 ro_div_0/divbuf_0/a_27322_170# ro_div_0/divbuf_0/a_27322_n240# 0.01fF
C9978 ro_div_0/divbuf_0/a_6822_n240# ro_div_0/divbuf_0/a_7302_n240# 0.05fF
C9979 pll_full_0/divbuf_0/a_37022_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C9980 pll_full_0/divbuf_0/a_60000_n1600# pll_full_0/divbuf_0/a_60030_n840# 0.04fF
C9981 divbuf_3/a_16642_170# divbuf_3/a_16642_n240# 0.01fF
C9982 divbuf_3/a_36052_170# divbuf_3/a_36532_170# 0.07fF
C9983 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19230_n1540# 0.19fF
C9984 ro_div_0/divbuf_0/a_16152_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C9985 ro_div_0/divbuf_0/a_19230_n840# ro_div_0/divbuf_0/a_19710_n840# 0.07fF
C9986 ro_div_0/divider_0/tspc_0/Z3 gnd 0.27fF
C9987 divbuf_3/a_8670_n840# divbuf_3/a_9150_n840# 0.07fF
C9988 divbuf_3/a_34112_170# divbuf_3/OUT4 0.19fF
C9989 divbuf_3/a_8640_n1600# divbuf_3/a_8670_n1540# 0.19fF
C9990 divbuf_1/a_17790_n840# divbuf_1/a_18270_n840# 0.07fF
C9991 pd_div_0/divbuf_0/a_17280_n1600# pd_div_0/divbuf_0/a_17310_n840# 0.04fF
C9992 pll_full_0/divbuf_1/a_22560_n1600# pll_full_0/divbuf_1/a_22590_n840# 0.04fF
C9993 divbuf_1/a_40350_n840# divbuf_1/a_40350_n1540# 0.01fF
C9994 divbuf_0/a_1920_n1600# divbuf_0/a_2400_n1600# 0.26fF
C9995 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/a_38472_n240# 0.05fF
C9996 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n1540# 0.19fF
C9997 divbuf_0/a_55230_n840# divbuf_0/a_55710_n840# 0.07fF
C9998 divbuf_0/a_24990_n840# divbuf_0/a_24990_n1540# 0.01fF
C9999 pll_full_0/divbuf_0/a_35040_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C10000 pll_full_0/divbuf_0/a_19230_n840# pll_full_0/divbuf_0/a_19230_n1540# 0.01fF
C10001 pll_full_0/divbuf_0/a_49470_n840# pll_full_0/divbuf_0/a_49950_n840# 0.07fF
C10002 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49470_n1540# 0.19fF
C10003 pd_div_0/divbuf_0/a_34112_170# pd_div_0/divbuf_0/a_34592_170# 0.07fF
C10004 divbuf_3/a_35082_n240# divbuf_3/OUT4 0.04fF
C10005 divbuf_3/a_59040_n1600# divbuf_3/a_59070_n840# 0.04fF
C10006 divbuf_1/a_60990_n1540# divbuf_1/OUT5 0.19fF
C10007 pll_full_0/divbuf_1/a_20042_170# pll_full_0/divbuf_1/a_20042_n240# 0.01fF
C10008 pll_full_0/divbuf_1/a_39442_170# pll_full_0/divbuf_1/a_39932_170# 0.07fF
C10009 pd_div_0/divbuf_0/a_6750_n840# pd_div_0/divbuf_0/a_7230_n840# 0.07fF
C10010 pd_div_0/divbuf_0/a_30232_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10011 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_6750_n1540# 0.19fF
C10012 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C10013 pll_full_0/divbuf_1/a_1352_n240# pll_full_0/divbuf_1/OUT2 0.07fF
C10014 pll_full_0/divbuf_1/a_40902_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10015 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12030_n1540# 0.19fF
C10016 pll_full_0/divbuf_1/a_12030_n840# pll_full_0/divbuf_1/a_12510_n840# 0.07fF
C10017 divbuf_2/a_32640_n1600# divbuf_2/a_33120_n1600# 0.26fF
C10018 divbuf_2/a_23442_n240# divbuf_2/a_23550_n840# 0.03fF
C10019 pd_div_0/divbuf_0/a_59550_n1540# pd_div_0/divbuf_0/a_60030_n1540# 0.11fF
C10020 divbuf_0/a_12772_n240# divbuf_0/a_12510_n840# 0.01fF
C10021 divbuf_2/a_24990_n1540# divbuf_2/a_25470_n1540# 0.11fF
C10022 divbuf_2/a_55710_n840# divbuf_2/a_55710_n1540# 0.01fF
C10023 divbuf_1/a_4320_n1600# divbuf_1/a_4800_n1600# 0.26fF
C10024 ro_div_0/divbuf_0/a_5760_n1600# ro_div_0/divbuf_0/a_6240_n1600# 0.26fF
C10025 divbuf_3/a_37022_n240# divbuf_3/a_37502_n240# 0.05fF
C10026 ro_div_0/divbuf_0/a_59070_n840# ro_div_0/divbuf_0/a_59550_n840# 0.07fF
C10027 ro_div_0/divbuf_0/a_28830_n840# ro_div_0/divbuf_0/a_28830_n1540# 0.01fF
C10028 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59070_n1540# 0.19fF
C10029 divbuf_3/a_48480_n1600# divbuf_3/a_48510_n1540# 0.19fF
C10030 divbuf_3/a_33120_n1600# divbuf_3/OUT4 0.01fF
C10031 divbuf_3/a_18270_n840# divbuf_3/a_18270_n1540# 0.01fF
C10032 divbuf_3/a_48510_n840# divbuf_3/a_48990_n840# 0.07fF
C10033 divbuf_1/a_57630_n840# divbuf_1/a_58110_n840# 0.07fF
C10034 pd_div_0/divbuf_0/a_31202_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10035 pd_div_0/divbuf_0/a_57120_n1600# pd_div_0/divbuf_0/a_57150_n840# 0.04fF
C10036 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/OUT5 0.04fF
C10037 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C10038 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C10039 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C10040 divbuf_2/a_492_n240# divbuf_2/IN 0.13fF
C10041 divbuf_2/a_22560_n1600# divbuf_2/a_22590_n840# 0.04fF
C10042 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C10043 divbuf_0/a_32652_n240# divbuf_0/a_32670_n840# 0.06fF
C10044 divbuf_0/a_41760_n1600# divbuf_0/a_42240_n1600# 0.26fF
C10045 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C10046 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/a_36480_n1600# 0.26fF
C10047 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/a_26910_n840# 0.04fF
C10048 divbuf_1/a_15182_n240# divbuf_1/a_14910_n840# 0.01fF
C10049 ro_div_0/divbuf_0/a_16642_n240# ro_div_0/divbuf_0/a_16350_n840# 0.00fF
C10050 divbuf_0/a_34110_n1540# divbuf_0/a_34590_n1540# 0.11fF
C10051 pll_full_0/divbuf_0/a_28350_n1540# pll_full_0/divbuf_0/a_28830_n1540# 0.11fF
C10052 pll_full_0/divbuf_0/a_59070_n840# pll_full_0/divbuf_0/a_59070_n1540# 0.01fF
C10053 divbuf_2/a_20042_170# divbuf_2/a_20042_n240# 0.01fF
C10054 divbuf_2/a_39442_170# divbuf_2/a_39932_170# 0.07fF
C10055 pd_div_0/divbuf_0/a_35082_n240# pd_div_0/divbuf_0/a_35562_n240# 0.05fF
C10056 pll_full_0/divbuf_1/a_40412_n240# pll_full_0/divbuf_1/a_40902_n240# 0.04fF
C10057 divbuf_1/a_10212_n240# divbuf_1/OUT4 0.04fF
C10058 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_46590_n1540# 0.19fF
C10059 pd_div_0/divbuf_0/a_16350_n840# pd_div_0/divbuf_0/a_16350_n1540# 0.01fF
C10060 pd_div_0/divbuf_0/a_46590_n840# pd_div_0/divbuf_0/a_47070_n840# 0.07fF
C10061 pll_full_0/divbuf_1/a_21630_n840# pll_full_0/divbuf_1/a_21630_n1540# 0.01fF
C10062 pll_full_0/divbuf_1/a_51870_n840# pll_full_0/divbuf_1/a_52350_n840# 0.07fF
C10063 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_51870_n1540# 0.19fF
C10064 divbuf_2/a_1352_n240# divbuf_2/OUT2 0.07fF
C10065 divbuf_2/a_40902_170# divbuf_2/OUT4 0.19fF
C10066 divbuf_2/a_12000_n1600# divbuf_2/a_12030_n1540# 0.19fF
C10067 divbuf_2/a_12030_n840# divbuf_2/a_12510_n840# 0.07fF
C10068 divbuf_1/a_12282_170# divbuf_1/a_12772_170# 0.07fF
C10069 pd_div_0/divider_0/nor_1/A pd_div_0/divider_0/and_0/B 0.08fF
C10070 divbuf_0/a_16642_170# divbuf_0/OUT4 0.19fF
C10071 divbuf_0/a_31680_n1600# divbuf_0/a_31710_n840# 0.04fF
C10072 gnd pll_full_0/divider_0/prescaler_0/Out 0.46fF
C10073 pll_full_0/divbuf_0/a_25920_n1600# pll_full_0/divbuf_0/a_25950_n840# 0.04fF
C10074 pll_full_0/divbuf_0/a_6332_170# pll_full_0/divbuf_0/OUT3 0.19fF
C10075 divbuf_1/a_44160_n1600# divbuf_1/a_44640_n1600# 0.26fF
C10076 divbuf_1/a_35082_n240# divbuf_1/a_35070_n840# 0.05fF
C10077 ro_div_0/divbuf_0/a_45600_n1600# ro_div_0/divbuf_0/a_46080_n1600# 0.26fF
C10078 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/a_36510_n840# 0.05fF
C10079 divbuf_3/a_25862_n240# divbuf_3/a_25950_n840# 0.03fF
C10080 divbuf_3/a_35040_n1600# divbuf_3/a_35520_n1600# 0.26fF
C10081 ro_div_0/divbuf_0/a_37950_n1540# ro_div_0/divbuf_0/a_38430_n1540# 0.11fF
C10082 divbuf_3/a_27390_n1540# divbuf_3/a_27870_n1540# 0.11fF
C10083 divbuf_3/a_58110_n840# divbuf_3/a_58110_n1540# 0.01fF
C10084 divbuf_1/a_36480_n1600# divbuf_1/a_36510_n1540# 0.19fF
C10085 divbuf_1/a_9600_n1600# divbuf_1/OUT3 0.00fF
C10086 divbuf_0/a_29262_170# divbuf_0/a_29262_n240# 0.01fF
C10087 divbuf_0/a_8762_n240# divbuf_0/a_9242_n240# 0.05fF
C10088 pll_full_0/divbuf_0/a_23442_170# pll_full_0/divbuf_0/a_23442_n240# 0.01fF
C10089 divbuf_2/a_41382_n240# divbuf_2/OUT5 0.04fF
C10090 divbuf_2/a_960_n1600# divbuf_2/OUT2 0.00fF
C10091 divbuf_1/a_12282_170# divbuf_1/a_12282_n240# 0.01fF
C10092 divbuf_0/a_21120_n1600# divbuf_0/a_21150_n1540# 0.19fF
C10093 divbuf_0/a_20042_n240# divbuf_0/OUT4 0.04fF
C10094 divbuf_0/a_21150_n840# divbuf_0/a_21630_n840# 0.07fF
C10095 pll_full_0/divbuf_0/a_15390_n840# pll_full_0/divbuf_0/a_15870_n840# 0.07fF
C10096 pll_full_0/divbuf_0/a_8272_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C10097 pll_full_0/divbuf_0/a_15360_n1600# pll_full_0/divbuf_0/a_15390_n1540# 0.19fF
C10098 divbuf_1/a_34080_n1600# divbuf_1/a_34110_n840# 0.04fF
C10099 pd_div_0/pd_0/REF pd_div_0/pd_0/tspc_r_1/Z3 0.65fF
C10100 ro_div_0/divbuf_0/a_35520_n1600# ro_div_0/divbuf_0/a_35550_n840# 0.04fF
C10101 ro_div_0/divbuf_0/a_26832_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10102 ro_div_0/divider_0/nor_1/B gnd 1.17fF
C10103 pll_full_0/divbuf_1/a_4392_170# pll_full_0/divbuf_1/a_4882_170# 0.07fF
C10104 divbuf_3/a_5362_170# divbuf_3/OUT3 0.19fF
C10105 divbuf_3/a_24960_n1600# divbuf_3/a_24990_n840# 0.04fF
C10106 divbuf_1/a_28350_n1540# divbuf_1/a_28830_n1540# 0.11fF
C10107 divbuf_2/a_40412_n240# divbuf_2/a_40902_n240# 0.04fF
C10108 pd_div_0/divbuf_0/a_33120_n1600# pd_div_0/divbuf_0/a_33600_n1600# 0.26fF
C10109 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/a_24030_n840# 0.03fF
C10110 pll_full_0/divbuf_1/a_38400_n1600# pll_full_0/divbuf_1/a_38880_n1600# 0.26fF
C10111 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/a_29310_n840# 0.04fF
C10112 pd_div_0/divbuf_0/a_25470_n1540# pd_div_0/divbuf_0/a_25950_n1540# 0.11fF
C10113 pd_div_0/divbuf_0/a_56190_n840# pd_div_0/divbuf_0/a_56190_n1540# 0.01fF
C10114 pll_full_0/divbuf_1/a_30750_n1540# pll_full_0/divbuf_1/a_31230_n1540# 0.11fF
C10115 divbuf_2/a_21630_n840# divbuf_2/a_21630_n1540# 0.01fF
C10116 divbuf_2/a_51870_n840# divbuf_2/a_52350_n840# 0.07fF
C10117 divbuf_2/a_51840_n1600# divbuf_2/a_51870_n1540# 0.19fF
C10118 divbuf_1/a_11802_n240# divbuf_1/a_12282_n240# 0.05fF
C10119 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/a_33142_n240# 0.01fF
C10120 ro_div_0/divbuf_0/a_13252_n240# ro_div_0/divbuf_0/a_13742_n240# 0.04fF
C10121 divbuf_3/a_1352_n240# divbuf_3/a_1842_n240# 0.04fF
C10122 divbuf_3/a_22472_170# divbuf_3/a_22472_n240# 0.01fF
C10123 divbuf_3/a_492_n240# divbuf_3/a_960_n1600# 0.00fF
C10124 ro_div_0/divbuf_0/a_24990_n840# ro_div_0/divbuf_0/a_25470_n840# 0.07fF
C10125 ro_div_0/divbuf_0/a_24960_n1600# ro_div_0/divbuf_0/a_24990_n1540# 0.19fF
C10126 ro_div_0/divbuf_0/a_27802_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10127 divbuf_3/a_14400_n1600# divbuf_3/a_14430_n1540# 0.19fF
C10128 divbuf_3/a_14430_n840# divbuf_3/a_14910_n840# 0.07fF
C10129 divbuf_3/a_6332_n240# divbuf_3/OUT3 0.04fF
C10130 divbuf_1/a_23550_n840# divbuf_1/a_24030_n840# 0.07fF
C10131 pd_div_0/divbuf_0/a_23040_n1600# pd_div_0/divbuf_0/a_23070_n840# 0.04fF
C10132 pll_full_0/divbuf_1/a_12282_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10133 pll_full_0/divbuf_1/a_28320_n1600# pll_full_0/divbuf_1/a_28350_n840# 0.04fF
C10134 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C10135 divbuf_1/a_46110_n840# divbuf_1/a_46110_n1540# 0.01fF
C10136 divbuf_0/a_7680_n1600# divbuf_0/a_8160_n1600# 0.26fF
C10137 pll_full_0/divbuf_0/a_1920_n1600# pll_full_0/divbuf_0/a_2400_n1600# 0.26fF
C10138 ro_div_0/divbuf_0/a_492_n240# ro_div_0/divbuf_0/a_510_n840# 0.00fF
C10139 divbuf_0/a_30750_n840# divbuf_0/a_30750_n1540# 0.01fF
C10140 pll_full_0/divbuf_0/a_24990_n840# pll_full_0/divbuf_0/a_24990_n1540# 0.01fF
C10141 pll_full_0/divbuf_0/a_55230_n840# pll_full_0/divbuf_0/a_55710_n840# 0.07fF
C10142 pll_full_0/divbuf_0/a_55200_n1600# pll_full_0/divbuf_0/a_55230_n1540# 0.19fF
C10143 pd_div_0/divbuf_0/a_20532_170# pd_div_0/divbuf_0/a_20532_n240# 0.01fF
C10144 pd_div_0/divbuf_0/a_39932_170# pd_div_0/divbuf_0/a_40412_170# 0.07fF
C10145 pll_full_0/divbuf_1/a_5362_n240# pll_full_0/divbuf_1/a_5852_n240# 0.04fF
C10146 pll_full_0/divbuf_1/a_25862_170# pll_full_0/divbuf_1/a_25862_n240# 0.01fF
C10147 divbuf_2/a_4392_170# divbuf_2/a_4882_170# 0.07fF
C10148 divbuf_2/a_38400_n1600# divbuf_2/a_38880_n1600# 0.26fF
C10149 divbuf_2/a_29262_n240# divbuf_2/a_29310_n840# 0.04fF
C10150 divbuf_1/a_32652_170# divbuf_1/OUT4 0.19fF
C10151 pd_div_0/divbuf_0/a_2322_n240# pd_div_0/divbuf_0/OUT2 0.04fF
C10152 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/a_12510_n1540# 0.19fF
C10153 pd_div_0/divbuf_0/a_41382_170# pd_div_0/divbuf_0/OUT5 0.07fF
C10154 pd_div_0/divbuf_0/a_12510_n840# pd_div_0/divbuf_0/a_12990_n840# 0.07fF
C10155 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/clk 0.11fF
C10156 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 ro_div_0/divider_0/prescaler_0/Out 0.05fF
C10157 ro_div_0/divider_0/prescaler_0/tspc_0/Q ro_div_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C10158 pll_full_0/divbuf_1/a_17790_n840# pll_full_0/divbuf_1/a_18270_n840# 0.07fF
C10159 pll_full_0/divbuf_1/a_13252_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10160 pll_full_0/divbuf_1/a_17760_n1600# pll_full_0/divbuf_1/a_17790_n1540# 0.19fF
C10161 divbuf_1/a_16642_170# divbuf_1/a_17122_170# 0.07fF
C10162 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C10163 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C10164 pll_full_0/divbuf_0/a_12772_n240# pll_full_0/divbuf_0/a_12510_n840# 0.01fF
C10165 divbuf_2/a_30750_n1540# divbuf_2/a_31230_n1540# 0.11fF
C10166 divbuf_1/a_10080_n1600# divbuf_1/a_10560_n1600# 0.26fF
C10167 ro_div_0/divbuf_0/a_11520_n1600# ro_div_0/divbuf_0/a_12000_n1600# 0.26fF
C10168 divbuf_3/a_960_n1600# divbuf_3/a_1440_n1600# 0.26fF
C10169 ro_div_0/divbuf_0/a_34590_n840# ro_div_0/divbuf_0/a_34590_n1540# 0.01fF
C10170 ro_div_0/divbuf_0/a_3870_n1540# ro_div_0/divbuf_0/a_4350_n1540# 0.11fF
C10171 divbuf_3/a_24030_n840# divbuf_3/a_24030_n1540# 0.01fF
C10172 divbuf_3/a_54270_n840# divbuf_3/a_54750_n840# 0.07fF
C10173 divbuf_3/a_54240_n1600# divbuf_3/a_54270_n1540# 0.19fF
C10174 divbuf_1/a_2430_n1540# divbuf_1/a_2910_n1540# 0.11fF
C10175 pd_div_0/divbuf_0/a_1920_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C10176 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C10177 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C10178 pll_full_0/divbuf_0/a_6822_170# pll_full_0/divbuf_0/a_7302_170# 0.07fF
C10179 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C10180 divbuf_2/a_12282_170# divbuf_2/OUT4 0.19fF
C10181 divbuf_2/a_28320_n1600# divbuf_2/a_28350_n840# 0.04fF
C10182 pd_div_0/divider_0/tspc_1/Z1 pd_div_0/divider_0/tspc_1/Z4 0.00fF
C10183 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C10184 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C10185 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C10186 divbuf_0/a_3912_170# divbuf_0/OUT3 0.19fF
C10187 divbuf_0/a_47520_n1600# divbuf_0/a_48000_n1600# 0.26fF
C10188 divbuf_0/a_38472_n240# divbuf_0/a_38430_n840# 0.04fF
C10189 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/tspc_1/Z4 0.02fF
C10190 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_2/Z2 0.20fF
C10191 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C10192 pll_full_0/divbuf_0/a_41760_n1600# pll_full_0/divbuf_0/a_42240_n1600# 0.26fF
C10193 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/a_32670_n840# 0.06fF
C10194 divbuf_0/a_39870_n1540# divbuf_0/a_40350_n1540# 0.11fF
C10195 ro_div_0/divbuf_0/a_1440_n1600# ro_div_0/divbuf_0/a_1470_n840# 0.04fF
C10196 pll_full_0/divbuf_0/a_34110_n1540# pll_full_0/divbuf_0/a_34590_n1540# 0.11fF
C10197 divbuf_3/a_11802_n240# divbuf_3/a_11550_n840# 0.02fF
C10198 pd_div_0/divbuf_0/a_40902_n240# pd_div_0/divbuf_0/a_41382_n240# 0.05fF
C10199 divbuf_2/a_5362_n240# divbuf_2/a_5852_n240# 0.04fF
C10200 divbuf_2/a_25862_170# divbuf_2/a_25862_n240# 0.01fF
C10201 pll_full_0/divbuf_1/a_4320_n1600# pll_full_0/divbuf_1/a_4800_n1600# 0.26fF
C10202 divbuf_1/a_22472_n240# divbuf_1/OUT4 0.04fF
C10203 pd_div_0/divbuf_0/a_22110_n840# pd_div_0/divbuf_0/a_22110_n1540# 0.01fF
C10204 pd_div_0/divbuf_0/a_52350_n840# pd_div_0/divbuf_0/a_52830_n840# 0.07fF
C10205 pd_div_0/divbuf_0/a_52320_n1600# pd_div_0/divbuf_0/a_52350_n1540# 0.19fF
C10206 pll_full_0/divbuf_1/a_57600_n1600# pll_full_0/divbuf_1/a_57630_n1540# 0.19fF
C10207 pll_full_0/divbuf_1/a_27390_n840# pll_full_0/divbuf_1/a_27390_n1540# 0.01fF
C10208 pll_full_0/divbuf_1/a_57630_n840# pll_full_0/divbuf_1/a_58110_n840# 0.07fF
C10209 divbuf_2/a_17790_n840# divbuf_2/a_18270_n840# 0.07fF
C10210 divbuf_2/a_13252_n240# divbuf_2/OUT4 0.04fF
C10211 divbuf_2/a_17760_n1600# divbuf_2/a_17790_n1540# 0.19fF
C10212 divbuf_1/a_7302_170# divbuf_1/a_7302_n240# 0.01fF
C10213 ro_div_0/divbuf_0/a_4882_170# ro_div_0/divbuf_0/a_4882_n240# 0.01fF
C10214 divbuf_0/a_37440_n1600# divbuf_0/a_37470_n840# 0.04fF
C10215 divbuf_0/a_30712_170# divbuf_0/OUT4 0.19fF
C10216 pll_full_0/divbuf_0/a_31680_n1600# pll_full_0/divbuf_0/a_31710_n840# 0.04fF
C10217 divbuf_3/a_6822_170# divbuf_3/a_7302_170# 0.07fF
C10218 divbuf_1/a_40902_n240# divbuf_1/a_40830_n840# 0.03fF
C10219 divbuf_1/a_49920_n1600# divbuf_1/a_50400_n1600# 0.26fF
C10220 ro_div_0/divbuf_0/a_2322_170# ro_div_0/divbuf_0/OUT3 0.07fF
C10221 ro_div_0/divbuf_0/a_51360_n1600# ro_div_0/divbuf_0/a_51840_n1600# 0.26fF
C10222 divbuf_3/a_40800_n1600# divbuf_3/a_41280_n1600# 0.26fF
C10223 divbuf_3/a_31682_n240# divbuf_3/a_31710_n840# 0.05fF
C10224 ro_div_0/divbuf_0/a_43710_n1540# ro_div_0/divbuf_0/a_44190_n1540# 0.11fF
C10225 divbuf_3/a_33150_n1540# divbuf_3/a_33630_n1540# 0.11fF
C10226 pll_full_0/divbuf_1/a_15182_n240# pll_full_0/divbuf_1/a_14910_n840# 0.01fF
C10227 divbuf_1/a_20640_n1600# divbuf_1/OUT4 0.00fF
C10228 divbuf_1/a_42240_n1600# divbuf_1/a_42270_n1540# 0.19fF
C10229 divbuf_0/a_35082_170# divbuf_0/a_35082_n240# 0.01fF
C10230 divbuf_0/a_15182_n240# divbuf_0/a_15672_n240# 0.04fF
C10231 pll_full_0/divbuf_0/a_8762_n240# pll_full_0/divbuf_0/a_9242_n240# 0.05fF
C10232 pll_full_0/divbuf_0/a_29262_170# pll_full_0/divbuf_0/a_29262_n240# 0.01fF
C10233 divbuf_2/a_11520_n1600# divbuf_2/OUT4 0.01fF
C10234 ro_div_0/divbuf_0/a_19562_170# ro_div_0/divbuf_0/a_19562_n240# 0.01fF
C10235 divbuf_0/a_26880_n1600# divbuf_0/a_26910_n1540# 0.19fF
C10236 divbuf_0/a_31682_n240# divbuf_0/OUT4 0.04fF
C10237 divbuf_0/a_26910_n840# divbuf_0/a_27390_n840# 0.07fF
C10238 pll_full_0/divbuf_0/a_21150_n840# pll_full_0/divbuf_0/a_21630_n840# 0.07fF
C10239 pll_full_0/divbuf_0/a_20042_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10240 pll_full_0/divbuf_0/a_21120_n1600# pll_full_0/divbuf_0/a_21150_n1540# 0.19fF
C10241 divbuf_1/a_39840_n1600# divbuf_1/a_39870_n840# 0.04fF
C10242 pd_div_0/divbuf_0/a_12772_170# pd_div_0/divbuf_0/a_13252_170# 0.07fF
C10243 ro_div_0/divbuf_0/a_41280_n1600# ro_div_0/divbuf_0/a_41310_n840# 0.04fF
C10244 ro_div_0/divbuf_0/a_38472_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10245 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.44fF
C10246 divbuf_3/a_17122_170# divbuf_3/OUT4 0.19fF
C10247 divbuf_3/a_30720_n1600# divbuf_3/a_30750_n840# 0.04fF
C10248 divbuf_1/a_34110_n1540# divbuf_1/a_34590_n1540# 0.11fF
C10249 divbuf_2/a_4320_n1600# divbuf_2/a_4800_n1600# 0.26fF
C10250 pd_div_0/divbuf_0/a_38880_n1600# pd_div_0/divbuf_0/a_39360_n1600# 0.26fF
C10251 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/a_29790_n840# 0.04fF
C10252 pll_full_0/divbuf_1/a_44160_n1600# pll_full_0/divbuf_1/a_44640_n1600# 0.26fF
C10253 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/a_35070_n840# 0.05fF
C10254 divbuf_1/a_990_n840# divbuf_1/OUT2 0.02fF
C10255 pd_div_0/divbuf_0/a_31230_n1540# pd_div_0/divbuf_0/a_31710_n1540# 0.11fF
C10256 pll_full_0/divbuf_1/a_36510_n1540# pll_full_0/divbuf_1/a_36990_n1540# 0.11fF
C10257 divbuf_2/a_57600_n1600# divbuf_2/a_57630_n1540# 0.19fF
C10258 divbuf_2/a_27390_n840# divbuf_2/a_27390_n1540# 0.01fF
C10259 divbuf_2/a_57630_n840# divbuf_2/a_58110_n840# 0.07fF
C10260 divbuf_1/a_17612_n240# divbuf_1/a_18092_n240# 0.05fF
C10261 divbuf_1/a_37502_170# divbuf_1/a_37502_n240# 0.01fF
C10262 ro_div_0/divbuf_0/a_19072_n240# ro_div_0/divbuf_0/a_19562_n240# 0.04fF
C10263 ro_div_0/divbuf_0/a_38962_170# ro_div_0/divbuf_0/a_38962_n240# 0.01fF
C10264 divbuf_3/a_7792_n240# divbuf_3/a_8272_n240# 0.05fF
C10265 divbuf_3/a_28292_170# divbuf_3/a_28292_n240# 0.01fF
C10266 divbuf_1/a_29310_n840# divbuf_1/a_29790_n840# 0.07fF
C10267 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/a_3422_n240# 0.01fF
C10268 ro_div_0/divbuf_0/a_30720_n1600# ro_div_0/divbuf_0/a_30750_n1540# 0.19fF
C10269 ro_div_0/divbuf_0/a_510_n840# ro_div_0/divbuf_0/a_510_n1540# 0.01fF
C10270 ro_div_0/divbuf_0/a_30750_n840# ro_div_0/divbuf_0/a_31230_n840# 0.07fF
C10271 ro_div_0/divbuf_0/a_39442_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10272 divbuf_3/a_20190_n840# divbuf_3/a_20670_n840# 0.07fF
C10273 divbuf_3/a_18092_n240# divbuf_3/OUT4 0.04fF
C10274 divbuf_3/a_20160_n1600# divbuf_3/a_20190_n1540# 0.19fF
C10275 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C10276 divbuf_2/a_15182_n240# divbuf_2/a_14910_n840# 0.01fF
C10277 pd_div_0/divbuf_0/a_28800_n1600# pd_div_0/divbuf_0/a_28830_n840# 0.04fF
C10278 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/OUT4 0.07fF
C10279 pll_full_0/divbuf_1/a_23922_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10280 pll_full_0/divbuf_1/a_34080_n1600# pll_full_0/divbuf_1/a_34110_n840# 0.04fF
C10281 divbuf_1/a_51870_n840# divbuf_1/a_51870_n1540# 0.01fF
C10282 divbuf_0/a_3912_n240# divbuf_0/a_3870_n840# 0.04fF
C10283 divbuf_0/a_13440_n1600# divbuf_0/a_13920_n1600# 0.26fF
C10284 pll_full_0/divbuf_0/a_7680_n1600# pll_full_0/divbuf_0/a_8160_n1600# 0.26fF
C10285 divbuf_0/a_36510_n840# divbuf_0/a_36510_n1540# 0.01fF
C10286 divbuf_0/a_5790_n1540# divbuf_0/a_6270_n1540# 0.11fF
C10287 pll_full_0/divbuf_0/a_30750_n840# pll_full_0/divbuf_0/a_30750_n1540# 0.01fF
C10288 pd_div_0/divbuf_0/a_5852_n240# pd_div_0/divbuf_0/a_6332_n240# 0.05fF
C10289 pd_div_0/divbuf_0/a_26352_170# pd_div_0/divbuf_0/a_26352_n240# 0.01fF
C10290 pll_full_0/divbuf_1/a_11802_n240# pll_full_0/divbuf_1/a_12282_n240# 0.05fF
C10291 pll_full_0/divbuf_1/a_31682_170# pll_full_0/divbuf_1/a_31682_n240# 0.01fF
C10292 divbuf_2/a_44160_n1600# divbuf_2/a_44640_n1600# 0.26fF
C10293 divbuf_2/a_35082_n240# divbuf_2/a_35070_n840# 0.05fF
C10294 divbuf_1/a_10212_170# divbuf_1/OUT3 0.19fF
C10295 pd_div_0/divbuf_0/a_18270_n840# pd_div_0/divbuf_0/a_18750_n840# 0.07fF
C10296 pd_div_0/divbuf_0/a_14222_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10297 pd_div_0/divbuf_0/a_18240_n1600# pd_div_0/divbuf_0/a_18270_n1540# 0.19fF
C10298 pll_full_0/divbuf_1/a_24892_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10299 pll_full_0/divbuf_1/a_23520_n1600# pll_full_0/divbuf_1/a_23550_n1540# 0.19fF
C10300 pll_full_0/divbuf_1/a_23550_n840# pll_full_0/divbuf_1/a_24030_n840# 0.07fF
C10301 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_4392_170# 0.07fF
C10302 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C10303 divbuf_0/a_3360_n1600# divbuf_0/a_3390_n840# 0.04fF
C10304 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C10305 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C10306 divbuf_2/a_36510_n1540# divbuf_2/a_36990_n1540# 0.11fF
C10307 divbuf_1/a_15840_n1600# divbuf_1/a_16320_n1600# 0.26fF
C10308 divbuf_1/a_6332_n240# divbuf_1/a_6270_n840# 0.04fF
C10309 ro_div_0/divbuf_0/a_7792_n240# ro_div_0/divbuf_0/a_7710_n840# 0.03fF
C10310 ro_div_0/divbuf_0/a_17280_n1600# ro_div_0/divbuf_0/a_17760_n1600# 0.26fF
C10311 divbuf_3/a_6720_n1600# divbuf_3/a_7200_n1600# 0.26fF
C10312 ro_div_0/divbuf_0/a_40350_n840# ro_div_0/divbuf_0/a_40350_n1540# 0.01fF
C10313 ro_div_0/divbuf_0/a_9630_n1540# ro_div_0/divbuf_0/a_10110_n1540# 0.11fF
C10314 divbuf_3/a_29790_n840# divbuf_3/a_29790_n1540# 0.01fF
C10315 divbuf_3/a_60030_n840# divbuf_3/a_60510_n840# 0.07fF
C10316 divbuf_3/a_60000_n1600# divbuf_3/a_60030_n1540# 0.19fF
C10317 divbuf_1/a_8190_n1540# divbuf_1/a_8670_n1540# 0.11fF
C10318 divbuf_2/a_23922_170# divbuf_2/OUT4 0.19fF
C10319 divbuf_2/a_34080_n1600# divbuf_2/a_34110_n840# 0.04fF
C10320 divbuf_1/a_29742_170# divbuf_1/OUT4 0.19fF
C10321 pd_div_0/divbuf_0/a_12480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C10322 divbuf_0/a_20042_170# divbuf_0/a_20532_170# 0.07fF
C10323 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C10324 pll_full_0/divbuf_0/a_7792_170# pll_full_0/divbuf_0/a_7792_n240# 0.01fF
C10325 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/a_16152_170# 0.07fF
C10326 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C10327 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C10328 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 pd_div_0/divider_0/and_0/OUT 0.06fF
C10329 divbuf_0/a_53280_n1600# divbuf_0/a_53760_n1600# 0.26fF
C10330 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.01fF
C10331 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.19fF
C10332 gnd pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.16fF
C10333 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C10334 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/a_38430_n840# 0.04fF
C10335 pll_full_0/divbuf_0/a_10212_170# pll_full_0/divbuf_0/OUT3 0.19fF
C10336 pll_full_0/divbuf_0/a_47520_n1600# pll_full_0/divbuf_0/a_48000_n1600# 0.26fF
C10337 divbuf_1/a_5760_n1600# divbuf_1/a_5790_n840# 0.04fF
C10338 ro_div_0/divbuf_0/a_7200_n1600# ro_div_0/divbuf_0/a_7230_n840# 0.04fF
C10339 divbuf_0/a_45630_n1540# divbuf_0/a_46110_n1540# 0.11fF
C10340 pll_full_0/divbuf_0/a_39870_n1540# pll_full_0/divbuf_0/a_40350_n1540# 0.11fF
C10341 divbuf_3/a_17612_n240# divbuf_3/a_17310_n840# 0.00fF
C10342 pd_div_0/divbuf_0/a_4800_n1600# pd_div_0/divbuf_0/a_5280_n1600# 0.26fF
C10343 divbuf_2/a_11802_n240# divbuf_2/a_12282_n240# 0.05fF
C10344 divbuf_2/a_31682_170# divbuf_2/a_31682_n240# 0.01fF
C10345 pll_full_0/divbuf_1/a_10080_n1600# pll_full_0/divbuf_1/a_10560_n1600# 0.26fF
C10346 divbuf_1/a_34112_n240# divbuf_1/OUT4 0.04fF
C10347 pd_div_0/divbuf_0/a_58080_n1600# pd_div_0/divbuf_0/a_58110_n1540# 0.19fF
C10348 pd_div_0/divbuf_0/a_27870_n840# pd_div_0/divbuf_0/a_27870_n1540# 0.01fF
C10349 pd_div_0/divbuf_0/a_58110_n840# pd_div_0/divbuf_0/a_58590_n840# 0.07fF
C10350 pll_full_0/divbuf_1/a_2430_n1540# pll_full_0/divbuf_1/a_2910_n1540# 0.11fF
C10351 pll_full_0/divbuf_1/a_33150_n840# pll_full_0/divbuf_1/a_33150_n1540# 0.01fF
C10352 pll_full_0/divbuf_1/a_2910_n840# pll_full_0/divbuf_1/OUT3 0.03fF
C10353 pll_full_0/divbuf_0/a_15672_170# pll_full_0/divbuf_0/a_15672_n240# 0.01fF
C10354 divbuf_2/a_24892_n240# divbuf_2/OUT4 0.04fF
C10355 divbuf_2/a_23520_n1600# divbuf_2/a_23550_n1540# 0.19fF
C10356 divbuf_2/a_23550_n840# divbuf_2/a_24030_n840# 0.07fF
C10357 divbuf_1/a_19072_170# divbuf_1/a_19562_170# 0.07fF
C10358 ro_div_0/divbuf_0/a_23922_170# ro_div_0/divbuf_0/a_24412_170# 0.07fF
C10359 ro_div_0/divbuf_0/a_1352_170# ro_div_0/divbuf_0/a_1352_n240# 0.01fF
C10360 divbuf_0/a_43200_n1600# divbuf_0/a_43230_n840# 0.04fF
C10361 divbuf_0/a_2322_n240# divbuf_0/OUT3 0.04fF
C10362 pll_full_0/divbuf_0/a_30712_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10363 pll_full_0/divbuf_0/a_37440_n1600# pll_full_0/divbuf_0/a_37470_n840# 0.04fF
C10364 divbuf_3/a_13252_170# divbuf_3/a_13742_170# 0.07fF
C10365 divbuf_1/a_55680_n1600# divbuf_1/a_56160_n1600# 0.26fF
C10366 ro_div_0/divbuf_0/a_57120_n1600# ro_div_0/divbuf_0/a_57600_n1600# 0.26fF
C10367 ro_div_0/divbuf_0/a_11312_170# ro_div_0/divbuf_0/OUT4 0.23fF
C10368 divbuf_3/a_37502_n240# divbuf_3/a_37470_n840# 0.05fF
C10369 divbuf_3/a_46560_n1600# divbuf_3/a_47040_n1600# 0.26fF
C10370 pd_div_0/divbuf_0/a_15672_n240# pd_div_0/divbuf_0/a_15390_n840# 0.01fF
C10371 ro_div_0/divbuf_0/a_49470_n1540# ro_div_0/divbuf_0/a_49950_n1540# 0.11fF
C10372 divbuf_3/a_38910_n1540# divbuf_3/a_39390_n1540# 0.11fF
C10373 divbuf_1/a_48000_n1600# divbuf_1/a_48030_n1540# 0.19fF
C10374 divbuf_1/a_32160_n1600# divbuf_1/OUT4 0.00fF
C10375 divbuf_1/a_17790_n840# divbuf_1/a_17790_n1540# 0.01fF
C10376 divbuf_0/a_21012_n240# divbuf_0/a_21502_n240# 0.04fF
C10377 divbuf_0/a_40902_170# divbuf_0/a_40902_n240# 0.01fF
C10378 pll_full_0/divbuf_1/a_41790_n840# pll_full_0/divbuf_1/OUT5 0.03fF
C10379 pll_full_0/divbuf_0/a_15182_n240# pll_full_0/divbuf_0/a_15672_n240# 0.04fF
C10380 pll_full_0/divbuf_0/a_35082_170# pll_full_0/divbuf_0/a_35082_n240# 0.01fF
C10381 divbuf_2/a_23040_n1600# divbuf_2/OUT4 0.01fF
C10382 divbuf_1/a_21502_170# divbuf_1/a_21502_n240# 0.01fF
C10383 divbuf_0/a_2400_n1600# divbuf_0/OUT2 0.00fF
C10384 divbuf_0/a_32640_n1600# divbuf_0/a_32670_n1540# 0.19fF
C10385 divbuf_0/a_32670_n840# divbuf_0/a_33150_n840# 0.07fF
C10386 divbuf_0/a_2430_n840# divbuf_0/a_2430_n1540# 0.01fF
C10387 pll_full_0/divbuf_0/a_26910_n840# pll_full_0/divbuf_0/a_27390_n840# 0.07fF
C10388 pll_full_0/divbuf_0/a_31682_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10389 pll_full_0/divbuf_0/a_26880_n1600# pll_full_0/divbuf_0/a_26910_n1540# 0.19fF
C10390 divbuf_1/a_45600_n1600# divbuf_1/a_45630_n840# 0.04fF
C10391 pd_div_0/divbuf_0/a_8272_170# pd_div_0/divbuf_0/a_8762_170# 0.07fF
C10392 ro_div_0/divbuf_0/a_47040_n1600# ro_div_0/divbuf_0/a_47070_n840# 0.04fF
C10393 ro_div_0/divbuf_0/a_10212_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10394 ro_div_0/divider_0/tspc_2/Z2 gnd 0.16fF
C10395 pll_full_0/divbuf_1/a_16642_170# pll_full_0/divbuf_1/a_17122_170# 0.07fF
C10396 divbuf_3/a_28772_170# divbuf_3/OUT4 0.19fF
C10397 divbuf_3/a_36480_n1600# divbuf_3/a_36510_n840# 0.04fF
C10398 divbuf_1/a_39870_n1540# divbuf_1/a_40350_n1540# 0.11fF
C10399 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_3/vin 0.20fF
C10400 divbuf_2/a_10080_n1600# divbuf_2/a_10560_n1600# 0.26fF
C10401 pd_div_0/divbuf_0/a_44640_n1600# pd_div_0/divbuf_0/a_45120_n1600# 0.26fF
C10402 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/a_35550_n840# 0.05fF
C10403 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/a_40830_n840# 0.03fF
C10404 pll_full_0/divbuf_1/a_49920_n1600# pll_full_0/divbuf_1/a_50400_n1600# 0.26fF
C10405 pd_div_0/divbuf_0/a_36990_n1540# pd_div_0/divbuf_0/a_37470_n1540# 0.11fF
C10406 pll_full_0/divbuf_1/a_42270_n1540# pll_full_0/divbuf_1/a_42750_n1540# 0.11fF
C10407 divbuf_2/a_2430_n1540# divbuf_2/a_2910_n1540# 0.11fF
C10408 divbuf_2/a_33150_n840# divbuf_2/a_33150_n1540# 0.01fF
C10409 divbuf_2/a_2910_n840# divbuf_2/OUT3 0.03fF
C10410 divbuf_1/a_23442_n240# divbuf_1/a_23922_n240# 0.05fF
C10411 ro_div_0/divbuf_0/a_24892_n240# ro_div_0/divbuf_0/a_25382_n240# 0.04fF
C10412 divbuf_3/a_14222_n240# divbuf_3/a_14702_n240# 0.05fF
C10413 divbuf_3/a_34112_170# divbuf_3/a_34112_n240# 0.01fF
C10414 divbuf_1/a_4830_n840# divbuf_1/a_4830_n1540# 0.01fF
C10415 divbuf_1/a_35070_n840# divbuf_1/a_35550_n840# 0.07fF
C10416 pd_div_0/divbuf_0/a_10212_170# pd_div_0/divbuf_0/a_10212_n240# 0.01fF
C10417 ro_div_0/divbuf_0/a_36510_n840# ro_div_0/divbuf_0/a_36990_n840# 0.07fF
C10418 ro_div_0/divbuf_0/a_6270_n840# ro_div_0/divbuf_0/a_6270_n1540# 0.01fF
C10419 ro_div_0/divbuf_0/a_9600_n1600# ro_div_0/divbuf_0/OUT3 0.00fF
C10420 ro_div_0/divbuf_0/a_36480_n1600# ro_div_0/divbuf_0/a_36510_n1540# 0.19fF
C10421 divbuf_3/a_25920_n1600# divbuf_3/a_25950_n1540# 0.19fF
C10422 divbuf_3/a_25950_n840# divbuf_3/a_26430_n840# 0.07fF
C10423 divbuf_3/a_29742_n240# divbuf_3/OUT4 0.04fF
C10424 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C10425 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C10426 divbuf_0/a_1842_170# divbuf_0/OUT2 0.19fF
C10427 pd_div_0/divbuf_0/a_24892_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10428 pd_div_0/divbuf_0/a_34560_n1600# pd_div_0/divbuf_0/a_34590_n840# 0.04fF
C10429 pll_full_0/divbuf_1/a_35562_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10430 pll_full_0/divbuf_1/a_39840_n1600# pll_full_0/divbuf_1/a_39870_n840# 0.04fF
C10431 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C10432 divbuf_1/a_57630_n840# divbuf_1/a_57630_n1540# 0.01fF
C10433 pd_0/DIV pd_0/R 0.51fF
C10434 divbuf_0/a_9732_n240# divbuf_0/a_9630_n840# 0.03fF
C10435 divbuf_0/a_19200_n1600# divbuf_0/a_19680_n1600# 0.26fF
C10436 pll_full_0/divbuf_0/a_13440_n1600# pll_full_0/divbuf_0/a_13920_n1600# 0.26fF
C10437 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/a_3870_n840# 0.04fF
C10438 divbuf_2/a_41790_n840# divbuf_2/OUT5 0.03fF
C10439 divbuf_0/a_42270_n840# divbuf_0/a_42270_n1540# 0.01fF
C10440 divbuf_0/a_11550_n1540# divbuf_0/a_12030_n1540# 0.11fF
C10441 pll_full_0/divbuf_0/a_5790_n1540# pll_full_0/divbuf_0/a_6270_n1540# 0.11fF
C10442 pll_full_0/divbuf_0/a_36510_n840# pll_full_0/divbuf_0/a_36510_n1540# 0.01fF
C10443 pd_div_0/divbuf_0/a_12282_n240# pd_div_0/divbuf_0/a_12772_n240# 0.04fF
C10444 pd_div_0/divbuf_0/a_32172_170# pd_div_0/divbuf_0/a_32172_n240# 0.01fF
C10445 pll_full_0/divbuf_1/a_17612_n240# pll_full_0/divbuf_1/a_18092_n240# 0.05fF
C10446 pll_full_0/divbuf_1/a_37502_170# pll_full_0/divbuf_1/a_37502_n240# 0.01fF
C10447 divbuf_2/a_16642_170# divbuf_2/a_17122_170# 0.07fF
C10448 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C10449 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C10450 divbuf_0/a_6822_170# divbuf_0/a_7302_170# 0.07fF
C10451 divbuf_2/a_40902_n240# divbuf_2/a_40830_n840# 0.03fF
C10452 divbuf_2/a_49920_n1600# divbuf_2/a_50400_n1600# 0.26fF
C10453 divbuf_1/a_3912_170# divbuf_1/OUT3 0.19fF
C10454 pd_div_0/divbuf_0/a_25862_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10455 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/a_24030_n1540# 0.19fF
C10456 pd_div_0/divbuf_0/a_24030_n840# pd_div_0/divbuf_0/a_24510_n840# 0.07fF
C10457 pll_full_0/divbuf_1/a_36532_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10458 pll_full_0/divbuf_1/a_29310_n840# pll_full_0/divbuf_1/a_29790_n840# 0.07fF
C10459 pll_full_0/divbuf_1/a_29280_n1600# pll_full_0/divbuf_1/a_29310_n1540# 0.19fF
C10460 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C10461 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C10462 divbuf_0/a_9120_n1600# divbuf_0/a_9150_n840# 0.04fF
C10463 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C10464 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C10465 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C10466 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C10467 pll_full_0/divbuf_0/a_3360_n1600# pll_full_0/divbuf_0/a_3390_n840# 0.04fF
C10468 divbuf_2/a_42270_n1540# divbuf_2/a_42750_n1540# 0.11fF
C10469 divbuf_1/a_21600_n1600# divbuf_1/a_22080_n1600# 0.26fF
C10470 divbuf_1/a_12282_n240# divbuf_1/a_12510_n840# 0.02fF
C10471 ro_div_0/divbuf_0/a_23040_n1600# ro_div_0/divbuf_0/a_23520_n1600# 0.26fF
C10472 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_13950_n840# 0.02fF
C10473 divbuf_3/a_12480_n1600# divbuf_3/a_12960_n1600# 0.26fF
C10474 ro_div_0/divbuf_0/a_46110_n840# ro_div_0/divbuf_0/a_46110_n1540# 0.01fF
C10475 ro_div_0/divbuf_0/a_15390_n1540# ro_div_0/divbuf_0/a_15870_n1540# 0.11fF
C10476 divbuf_3/a_4830_n1540# divbuf_3/a_5310_n1540# 0.11fF
C10477 divbuf_3/a_35550_n840# divbuf_3/a_35550_n1540# 0.01fF
C10478 divbuf_1/a_13950_n1540# divbuf_1/a_14430_n1540# 0.11fF
C10479 divbuf_2/a_35562_170# divbuf_2/OUT4 0.19fF
C10480 divbuf_2/a_39840_n1600# divbuf_2/a_39870_n840# 0.04fF
C10481 divbuf_1/a_5362_n240# divbuf_1/OUT3 0.04fF
C10482 pd_div_0/divbuf_0/a_24000_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C10483 divbuf_0/a_25862_170# divbuf_0/a_26352_170# 0.07fF
C10484 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/OUT4 0.01fF
C10485 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/a_20532_170# 0.07fF
C10486 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/tspc_0/Z2 0.01fF
C10487 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C10488 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/clk 0.01fF
C10489 divbuf_0/a_59040_n1600# divbuf_0/a_59520_n1600# 0.26fF
C10490 divbuf_0/a_13252_170# divbuf_0/OUT4 0.19fF
C10491 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C10492 pll_full_0/divider_0/nor_0/B pll_full_0/divbuf_0/IN 0.29fF
C10493 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.29fF
C10494 pll_full_0/divbuf_0/a_53280_n1600# pll_full_0/divbuf_0/a_53760_n1600# 0.26fF
C10495 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C10496 divbuf_1/a_11520_n1600# divbuf_1/a_11550_n840# 0.04fF
C10497 divbuf_0/a_51390_n1540# divbuf_0/a_51870_n1540# 0.11fF
C10498 ro_div_0/divbuf_0/a_12960_n1600# ro_div_0/divbuf_0/a_12990_n840# 0.04fF
C10499 ro_div_0/divbuf_0/a_8272_170# ro_div_0/divbuf_0/OUT3 0.19fF
C10500 pll_full_0/divbuf_0/a_45630_n1540# pll_full_0/divbuf_0/a_46110_n1540# 0.11fF
C10501 divbuf_3/a_2400_n1600# divbuf_3/a_2430_n840# 0.04fF
C10502 pd_div_0/divbuf_0/a_10560_n1600# pd_div_0/divbuf_0/a_11040_n1600# 0.26fF
C10503 pll_full_0/divbuf_1/a_15840_n1600# pll_full_0/divbuf_1/a_16320_n1600# 0.26fF
C10504 pll_full_0/divbuf_1/a_6332_n240# pll_full_0/divbuf_1/a_6270_n840# 0.04fF
C10505 divbuf_2/a_17612_n240# divbuf_2/a_18092_n240# 0.05fF
C10506 divbuf_2/a_37502_170# divbuf_2/a_37502_n240# 0.01fF
C10507 pd_div_0/divbuf_0/a_2910_n1540# pd_div_0/divbuf_0/a_3390_n1540# 0.11fF
C10508 pd_div_0/divbuf_0/a_33630_n840# pd_div_0/divbuf_0/a_33630_n1540# 0.01fF
C10509 pll_full_0/divbuf_1/a_8190_n1540# pll_full_0/divbuf_1/a_8670_n1540# 0.11fF
C10510 pll_full_0/divbuf_1/a_38910_n840# pll_full_0/divbuf_1/a_38910_n1540# 0.01fF
C10511 divbuf_2/a_36532_n240# divbuf_2/OUT4 0.04fF
C10512 divbuf_2/a_29310_n840# divbuf_2/a_29790_n840# 0.07fF
C10513 divbuf_2/a_29280_n1600# divbuf_2/a_29310_n1540# 0.19fF
C10514 divbuf_1/a_14702_170# divbuf_1/a_14702_n240# 0.01fF
C10515 divbuf_1/a_24892_170# divbuf_1/a_25382_170# 0.07fF
C10516 ro_div_0/divbuf_0/a_29742_170# ro_div_0/divbuf_0/a_30232_170# 0.07fF
C10517 divbuf_0/a_48960_n1600# divbuf_0/a_48990_n840# 0.04fF
C10518 divbuf_0/a_14702_n240# divbuf_0/OUT4 0.04fF
C10519 pll_full_0/divbuf_0/a_2322_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C10520 pll_full_0/divbuf_0/a_43200_n1600# pll_full_0/divbuf_0/a_43230_n840# 0.04fF
C10521 divbuf_3/a_19072_170# divbuf_3/a_19562_170# 0.07fF
C10522 divbuf_1/a_960_n1600# divbuf_1/a_990_n1540# 0.19fF
C10523 divbuf_1/a_990_n840# divbuf_1/a_1470_n840# 0.07fF
C10524 ro_div_0/divbuf_0/a_2430_n840# ro_div_0/divbuf_0/a_2910_n840# 0.07fF
C10525 ro_div_0/divbuf_0/a_2400_n1600# ro_div_0/divbuf_0/a_2430_n1540# 0.19fF
C10526 ro_div_0/divbuf_0/a_21502_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10527 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 0.22fF
C10528 divbuf_0/a_1842_170# divbuf_0/a_1352_170# 0.07fF
C10529 divbuf_3/a_52320_n1600# divbuf_3/a_52800_n1600# 0.26fF
C10530 pd_div_0/divbuf_0/a_480_n1600# pd_div_0/divbuf_0/a_510_n840# 0.04fF
C10531 ro_div_0/divbuf_0/a_55230_n1540# ro_div_0/divbuf_0/a_55710_n1540# 0.11fF
C10532 divbuf_3/a_44670_n1540# divbuf_3/a_45150_n1540# 0.11fF
C10533 pll_full_0/divbuf_1/a_5760_n1600# pll_full_0/divbuf_1/a_5790_n840# 0.04fF
C10534 divbuf_1/a_23550_n840# divbuf_1/a_23550_n1540# 0.01fF
C10535 divbuf_1/a_53760_n1600# divbuf_1/a_53790_n1540# 0.19fF
C10536 divbuf_0/a_26832_n240# divbuf_0/a_27322_n240# 0.04fF
C10537 pll_full_0/divbuf_0/a_40902_170# pll_full_0/divbuf_0/a_40902_n240# 0.01fF
C10538 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/a_21502_n240# 0.04fF
C10539 divbuf_2/a_34560_n1600# divbuf_2/OUT4 0.01fF
C10540 divbuf_1/a_27322_170# divbuf_1/a_27322_n240# 0.01fF
C10541 divbuf_0/a_38400_n1600# divbuf_0/a_38430_n1540# 0.19fF
C10542 divbuf_0/a_38430_n840# divbuf_0/a_38910_n840# 0.07fF
C10543 divbuf_0/a_8190_n840# divbuf_0/a_8190_n1540# 0.01fF
C10544 divbuf_0/a_12960_n1600# divbuf_0/OUT4 0.00fF
C10545 pll_full_0/divbuf_0/a_2430_n840# pll_full_0/divbuf_0/a_2430_n1540# 0.01fF
C10546 pll_full_0/divbuf_0/a_32670_n840# pll_full_0/divbuf_0/a_33150_n840# 0.07fF
C10547 pll_full_0/divbuf_0/a_32640_n1600# pll_full_0/divbuf_0/a_32670_n1540# 0.19fF
C10548 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/OUT2 0.00fF
C10549 divbuf_1/a_51360_n1600# divbuf_1/a_51390_n840# 0.04fF
C10550 pd_div_0/divbuf_0/a_17122_170# pd_div_0/divbuf_0/a_17612_170# 0.07fF
C10551 ro_div_0/divbuf_0/a_52800_n1600# ro_div_0/divbuf_0/a_52830_n840# 0.04fF
C10552 ro_div_0/divbuf_0/a_22472_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10553 pll_full_0/divbuf_1/a_1842_170# pll_full_0/divbuf_1/a_1842_n240# 0.01fF
C10554 pll_full_0/divbuf_1/a_22472_170# pll_full_0/divbuf_1/a_22952_170# 0.07fF
C10555 divbuf_3/a_40412_170# divbuf_3/OUT4 0.19fF
C10556 divbuf_3/a_42240_n1600# divbuf_3/a_42270_n840# 0.04fF
C10557 divbuf_1/a_45630_n1540# divbuf_1/a_46110_n1540# 0.11fF
C10558 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/nor_1/B 0.06fF
C10559 divbuf_2/a_15840_n1600# divbuf_2/a_16320_n1600# 0.26fF
C10560 divbuf_2/a_6332_n240# divbuf_2/a_6270_n840# 0.04fF
C10561 pd_div_0/divbuf_0/a_41382_n240# pd_div_0/divbuf_0/a_41310_n840# 0.03fF
C10562 pd_div_0/divbuf_0/a_50400_n1600# pd_div_0/divbuf_0/a_50880_n1600# 0.26fF
C10563 io_clamp_low[1] io_analog[5] 0.53fF
C10564 pll_full_0/divbuf_1/a_55680_n1600# pll_full_0/divbuf_1/a_56160_n1600# 0.26fF
C10565 pll_full_0/divbuf_1/a_6822_170# pll_full_0/divbuf_1/OUT3 0.19fF
C10566 pd_div_0/divbuf_0/a_42750_n1540# pd_div_0/divbuf_0/a_43230_n1540# 0.11fF
C10567 pll_full_0/divbuf_1/a_48030_n1540# pll_full_0/divbuf_1/a_48510_n1540# 0.11fF
C10568 divbuf_2/a_8190_n1540# divbuf_2/a_8670_n1540# 0.11fF
C10569 divbuf_2/a_38910_n840# divbuf_2/a_38910_n1540# 0.01fF
C10570 divbuf_1/a_29262_n240# divbuf_1/a_29742_n240# 0.05fF
C10571 ro_div_0/divbuf_0/a_30712_n240# ro_div_0/divbuf_0/a_31202_n240# 0.04fF
C10572 divbuf_3/a_39932_170# divbuf_3/a_39932_n240# 0.01fF
C10573 divbuf_3/a_20042_n240# divbuf_3/a_20532_n240# 0.04fF
C10574 divbuf_1/a_10590_n840# divbuf_1/a_10590_n1540# 0.01fF
C10575 divbuf_1/a_40830_n840# divbuf_1/a_41310_n840# 0.07fF
C10576 ro_div_0/divbuf_0/a_42240_n1600# ro_div_0/divbuf_0/a_42270_n1540# 0.19fF
C10577 ro_div_0/divbuf_0/a_42270_n840# ro_div_0/divbuf_0/a_42750_n840# 0.07fF
C10578 ro_div_0/divbuf_0/a_12030_n840# ro_div_0/divbuf_0/a_12030_n1540# 0.01fF
C10579 ro_div_0/divbuf_0/a_20640_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C10580 divbuf_3/a_1470_n840# divbuf_3/a_1470_n1540# 0.01fF
C10581 divbuf_3/a_31710_n840# divbuf_3/a_32190_n840# 0.07fF
C10582 divbuf_3/a_31680_n1600# divbuf_3/a_31710_n1540# 0.19fF
C10583 divbuf_3/a_41382_n240# divbuf_3/OUT4 0.04fF
C10584 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 ro_div_0/divider_0/prescaler_0/Out 0.28fF
C10585 divbuf_0/a_17122_170# divbuf_0/a_16642_170# 0.07fF
C10586 divbuf_2/a_5760_n1600# divbuf_2/a_5790_n840# 0.04fF
C10587 divbuf_1/a_16152_170# divbuf_1/OUT4 0.19fF
C10588 pd_div_0/divbuf_0/a_36532_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10589 pd_div_0/divbuf_0/a_40320_n1600# pd_div_0/divbuf_0/a_40350_n840# 0.04fF
C10590 pd_div_0/divbuf_0/a_492_n240# pd_div_0/bufin 0.13fF
C10591 pll_full_0/divbuf_1/a_7792_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C10592 pll_full_0/divbuf_1/a_45600_n1600# pll_full_0/divbuf_1/a_45630_n840# 0.04fF
C10593 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C10594 divbuf_0/a_15672_n240# divbuf_0/a_15870_n840# 0.02fF
C10595 divbuf_0/a_24960_n1600# divbuf_0/a_25440_n1600# 0.26fF
C10596 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/a_19680_n1600# 0.26fF
C10597 pll_full_0/divbuf_0/a_9732_n240# pll_full_0/divbuf_0/a_9630_n840# 0.03fF
C10598 divbuf_0/a_17310_n1540# divbuf_0/a_17790_n1540# 0.11fF
C10599 divbuf_0/a_48030_n840# divbuf_0/a_48030_n1540# 0.01fF
C10600 pll_full_0/divbuf_0/a_11550_n1540# pll_full_0/divbuf_0/a_12030_n1540# 0.11fF
C10601 pll_full_0/divbuf_0/a_42270_n840# pll_full_0/divbuf_0/a_42270_n1540# 0.01fF
C10602 pd_div_0/divbuf_0/a_18092_n240# pd_div_0/divbuf_0/a_18582_n240# 0.04fF
C10603 pd_div_0/divbuf_0/a_37992_170# pd_div_0/divbuf_0/a_37992_n240# 0.01fF
C10604 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/OUT2 0.02fF
C10605 pll_full_0/divbuf_1/a_23442_n240# pll_full_0/divbuf_1/a_23922_n240# 0.05fF
C10606 divbuf_2/a_1842_170# divbuf_2/a_1842_n240# 0.01fF
C10607 divbuf_2/a_22472_170# divbuf_2/a_22952_170# 0.07fF
C10608 divbuf_0/a_18582_170# divbuf_0/a_18582_n240# 0.01fF
C10609 divbuf_2/a_55680_n1600# divbuf_2/a_56160_n1600# 0.26fF
C10610 divbuf_2/a_6822_170# divbuf_2/OUT3 0.19fF
C10611 divbuf_1/a_13742_170# divbuf_1/OUT4 0.19fF
C10612 pd_div_0/divbuf_0/a_37502_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10613 pd_div_0/divbuf_0/a_29790_n840# pd_div_0/divbuf_0/a_30270_n840# 0.07fF
C10614 pd_div_0/divbuf_0/a_29760_n1600# pd_div_0/divbuf_0/a_29790_n1540# 0.19fF
C10615 pll_full_0/divbuf_1/a_35040_n1600# pll_full_0/divbuf_1/a_35070_n1540# 0.19fF
C10616 pll_full_0/divbuf_1/a_4830_n840# pll_full_0/divbuf_1/a_4830_n1540# 0.01fF
C10617 pll_full_0/divbuf_1/a_35070_n840# pll_full_0/divbuf_1/a_35550_n840# 0.07fF
C10618 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C10619 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C10620 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C10621 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/a5 0.09fF
C10622 ro_div_0/ro_complete_0/cbank_0/switch_1/vin ro_div_0/ro_complete_0/a4 0.09fF
C10623 ro_div_0/ro_complete_0/a2 ro_div_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C10624 divbuf_0/a_14880_n1600# divbuf_0/a_14910_n840# 0.04fF
C10625 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C10626 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C10627 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C10628 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C10629 pll_full_0/divbuf_0/a_9120_n1600# pll_full_0/divbuf_0/a_9150_n840# 0.04fF
C10630 divbuf_2/a_48030_n1540# divbuf_2/a_48510_n1540# 0.11fF
C10631 divbuf_1/a_27360_n1600# divbuf_1/a_27840_n1600# 0.26fF
C10632 divbuf_1/a_18092_n240# divbuf_1/a_18270_n840# 0.02fF
C10633 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/a_19710_n840# 0.03fF
C10634 ro_div_0/divbuf_0/a_28800_n1600# ro_div_0/divbuf_0/a_29280_n1600# 0.26fF
C10635 divbuf_3/a_18240_n1600# divbuf_3/a_18720_n1600# 0.26fF
C10636 divbuf_3/a_8762_n240# divbuf_3/a_8670_n840# 0.03fF
C10637 ro_div_0/divbuf_0/a_51870_n840# ro_div_0/divbuf_0/a_51870_n1540# 0.01fF
C10638 ro_div_0/divbuf_0/a_21150_n1540# ro_div_0/divbuf_0/a_21630_n1540# 0.11fF
C10639 divbuf_3/a_10590_n1540# divbuf_3/a_11070_n1540# 0.11fF
C10640 divbuf_3/a_41310_n840# divbuf_3/a_41310_n1540# 0.01fF
C10641 divbuf_0/a_31682_170# divbuf_0/a_32172_170# 0.07fF
C10642 divbuf_0/a_12282_170# divbuf_0/a_12282_n240# 0.01fF
C10643 divbuf_2/a_7792_n240# divbuf_2/OUT3 0.04fF
C10644 divbuf_2/a_45600_n1600# divbuf_2/a_45630_n840# 0.04fF
C10645 divbuf_1/a_17122_n240# divbuf_1/OUT4 0.04fF
C10646 divbuf_1/a_19680_n1600# divbuf_1/a_19710_n1540# 0.19fF
C10647 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C10648 pll_full_0/divbuf_0/a_12772_170# pll_full_0/divbuf_0/a_12772_n240# 0.01fF
C10649 pll_full_0/divbuf_0/a_25862_170# pll_full_0/divbuf_0/a_26352_170# 0.07fF
C10650 pd_div_0/divider_0/tspc_2/Z1 pd_div_0/divider_0/tspc_2/Z4 0.00fF
C10651 gnd pd_div_0/divider_0/tspc_0/Z2 0.16fF
C10652 divbuf_0/a_4320_n1600# divbuf_0/a_4350_n1540# 0.19fF
C10653 divbuf_0/a_25382_170# divbuf_0/OUT4 0.19fF
C10654 divbuf_0/a_4350_n840# divbuf_0/a_4830_n840# 0.07fF
C10655 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C10656 pll_full_0/divbuf_0/a_15182_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10657 pll_full_0/divbuf_0/a_59040_n1600# pll_full_0/divbuf_0/a_59520_n1600# 0.26fF
C10658 divbuf_1/a_17280_n1600# divbuf_1/a_17310_n840# 0.04fF
C10659 ro_div_0/divbuf_0/a_18720_n1600# ro_div_0/divbuf_0/a_18750_n840# 0.04fF
C10660 divbuf_0/a_57150_n1540# divbuf_0/a_57630_n1540# 0.11fF
C10661 pll_full_0/divbuf_0/a_51390_n1540# pll_full_0/divbuf_0/a_51870_n1540# 0.11fF
C10662 divbuf_3/a_8160_n1600# divbuf_3/a_8190_n840# 0.04fF
C10663 pd_div_0/divbuf_0/a_16320_n1600# pd_div_0/divbuf_0/a_16800_n1600# 0.26fF
C10664 pd_div_0/divbuf_0/a_6822_n240# pd_div_0/divbuf_0/a_6750_n840# 0.03fF
C10665 pll_full_0/divbuf_1/a_21600_n1600# pll_full_0/divbuf_1/a_22080_n1600# 0.26fF
C10666 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12510_n840# 0.02fF
C10667 divbuf_2/a_23442_n240# divbuf_2/a_23922_n240# 0.05fF
C10668 divbuf_2/a_35040_n1600# divbuf_2/a_35070_n1540# 0.19fF
C10669 divbuf_2/a_4830_n840# divbuf_2/a_4830_n1540# 0.01fF
C10670 divbuf_2/a_35070_n840# divbuf_2/a_35550_n840# 0.07fF
C10671 pd_div_0/divbuf_0/a_8670_n1540# pd_div_0/divbuf_0/a_9150_n1540# 0.11fF
C10672 pd_div_0/divbuf_0/a_39390_n840# pd_div_0/divbuf_0/a_39390_n1540# 0.01fF
C10673 pll_full_0/divbuf_1/a_13950_n1540# pll_full_0/divbuf_1/a_14430_n1540# 0.11fF
C10674 pll_full_0/divbuf_1/a_44670_n840# pll_full_0/divbuf_1/a_44670_n1540# 0.01fF
C10675 divbuf_1/a_34112_170# divbuf_1/a_34592_170# 0.07fF
C10676 ro_div_0/divbuf_0/a_35562_170# ro_div_0/divbuf_0/a_36052_170# 0.07fF
C10677 divbuf_0/a_54720_n1600# divbuf_0/a_54750_n840# 0.04fF
C10678 divbuf_0/a_26352_n240# divbuf_0/OUT4 0.04fF
C10679 pll_full_0/divbuf_0/a_14702_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10680 pll_full_0/divbuf_0/a_48960_n1600# pll_full_0/divbuf_0/a_48990_n840# 0.04fF
C10681 divbuf_3/a_4882_170# divbuf_3/a_4882_n240# 0.01fF
C10682 divbuf_3/a_24892_170# divbuf_3/a_25382_170# 0.07fF
C10683 divbuf_1/a_6750_n840# divbuf_1/a_7230_n840# 0.07fF
C10684 divbuf_1/a_6720_n1600# divbuf_1/a_6750_n1540# 0.19fF
C10685 pd_div_0/pd_0/UP pd_div_0/pd_0/tspc_r_1/z5 0.03fF
C10686 ro_div_0/divbuf_0/a_8160_n1600# ro_div_0/divbuf_0/a_8190_n1540# 0.19fF
C10687 ro_div_0/divbuf_0/a_33142_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10688 ro_div_0/divbuf_0/a_8190_n840# ro_div_0/divbuf_0/a_8670_n840# 0.07fF
C10689 ro_div_0/divider_0/tspc_1/Z3 gnd 0.27fF
C10690 divbuf_3/a_11802_170# divbuf_3/OUT4 0.19fF
C10691 divbuf_3/a_58080_n1600# divbuf_3/a_58560_n1600# 0.26fF
C10692 pd_div_0/divbuf_0/a_6240_n1600# pd_div_0/divbuf_0/a_6270_n840# 0.04fF
C10693 divbuf_3/a_50430_n1540# divbuf_3/a_50910_n1540# 0.11fF
C10694 pll_full_0/divbuf_1/a_11520_n1600# pll_full_0/divbuf_1/a_11550_n840# 0.04fF
C10695 divbuf_1/a_59520_n1600# divbuf_1/a_59550_n1540# 0.19fF
C10696 divbuf_1/a_29310_n840# divbuf_1/a_29310_n1540# 0.01fF
C10697 divbuf_0/a_32652_n240# divbuf_0/a_33142_n240# 0.04fF
C10698 pll_full_0/divbuf_0/a_26832_n240# pll_full_0/divbuf_0/a_27322_n240# 0.04fF
C10699 divbuf_0/a_13950_n840# divbuf_0/a_13950_n1540# 0.01fF
C10700 divbuf_0/a_44190_n840# divbuf_0/a_44670_n840# 0.07fF
C10701 divbuf_0/a_24480_n1600# divbuf_0/OUT4 0.00fF
C10702 divbuf_0/a_44160_n1600# divbuf_0/a_44190_n1540# 0.19fF
C10703 pll_full_0/divbuf_0/a_12960_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C10704 pll_full_0/divbuf_0/a_8190_n840# pll_full_0/divbuf_0/a_8190_n1540# 0.01fF
C10705 pll_full_0/divbuf_0/a_38430_n840# pll_full_0/divbuf_0/a_38910_n840# 0.07fF
C10706 pll_full_0/divbuf_0/a_38400_n1600# pll_full_0/divbuf_0/a_38430_n1540# 0.19fF
C10707 divbuf_1/a_57120_n1600# divbuf_1/a_57150_n840# 0.04fF
C10708 pd_div_0/divbuf_0/a_22952_170# pd_div_0/divbuf_0/a_23442_170# 0.07fF
C10709 ro_div_0/divbuf_0/a_58560_n1600# ro_div_0/divbuf_0/a_58590_n840# 0.04fF
C10710 ro_div_0/divbuf_0/a_34112_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10711 pll_full_0/divbuf_1/a_8272_170# pll_full_0/divbuf_1/a_8272_n240# 0.01fF
C10712 pll_full_0/divbuf_1/a_28292_170# pll_full_0/divbuf_1/a_28772_170# 0.07fF
C10713 divbuf_3/a_12772_n240# divbuf_3/OUT4 0.04fF
C10714 divbuf_3/a_48000_n1600# divbuf_3/a_48030_n840# 0.04fF
C10715 divbuf_1/a_51390_n1540# divbuf_1/a_51870_n1540# 0.11fF
C10716 pd_div_0/divbuf_0/a_56160_n1600# pd_div_0/divbuf_0/a_56640_n1600# 0.26fF
C10717 pd_div_0/divbuf_0/a_3422_170# pd_div_0/divbuf_0/OUT3 0.23fF
C10718 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C10719 divbuf_2/a_21600_n1600# divbuf_2/a_22080_n1600# 0.26fF
C10720 divbuf_2/a_12282_n240# divbuf_2/a_12510_n840# 0.02fF
C10721 pll_full_0/divbuf_1/a_18582_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10722 pll_full_0/divbuf_1/a_960_n1600# pll_full_0/divbuf_1/a_990_n1540# 0.19fF
C10723 pll_full_0/divbuf_1/a_990_n840# pll_full_0/divbuf_1/a_1470_n840# 0.07fF
C10724 pd_div_0/divbuf_0/a_48510_n1540# pd_div_0/divbuf_0/a_48990_n1540# 0.11fF
C10725 pll_full_0/divbuf_1/a_53790_n1540# pll_full_0/divbuf_1/a_54270_n1540# 0.11fF
C10726 divbuf_2/a_13950_n1540# divbuf_2/a_14430_n1540# 0.11fF
C10727 divbuf_2/a_44670_n840# divbuf_2/a_44670_n1540# 0.01fF
C10728 divbuf_1/a_35082_n240# divbuf_1/a_35562_n240# 0.05fF
C10729 ro_div_0/divbuf_0/a_36532_n240# ro_div_0/divbuf_0/a_37022_n240# 0.04fF
C10730 divbuf_3/a_25862_n240# divbuf_3/a_26352_n240# 0.04fF
C10731 divbuf_1/a_46590_n840# divbuf_1/a_47070_n840# 0.07fF
C10732 ro_div_0/divbuf_0/a_48030_n840# ro_div_0/divbuf_0/a_48510_n840# 0.07fF
C10733 ro_div_0/divbuf_0/a_17790_n840# ro_div_0/divbuf_0/a_17790_n1540# 0.01fF
C10734 ro_div_0/divbuf_0/a_32160_n1600# ro_div_0/divbuf_0/OUT4 0.00fF
C10735 ro_div_0/divbuf_0/a_48000_n1600# ro_div_0/divbuf_0/a_48030_n1540# 0.19fF
C10736 divbuf_3/a_11040_n1600# divbuf_3/OUT4 0.00fF
C10737 divbuf_3/a_7230_n840# divbuf_3/a_7230_n1540# 0.01fF
C10738 divbuf_3/a_37470_n840# divbuf_3/a_37950_n840# 0.07fF
C10739 divbuf_3/a_37440_n1600# divbuf_3/a_37470_n1540# 0.19fF
C10740 ro_div_0/divider_0/prescaler_0/tspc_1/Q ro_div_0/divider_0/prescaler_0/Out 0.91fF
C10741 ro_div_0/divider_0/and_0/OUT ro_div_0/divider_0/and_0/B 0.01fF
C10742 divbuf_2/a_11520_n1600# divbuf_2/a_11550_n840# 0.04fF
C10743 pd_div_0/divbuf_0/a_8762_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C10744 pd_div_0/divbuf_0/a_46080_n1600# pd_div_0/divbuf_0/a_46110_n840# 0.04fF
C10745 pll_full_0/divbuf_1/a_19562_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10746 pll_full_0/divbuf_1/a_51360_n1600# pll_full_0/divbuf_1/a_51390_n840# 0.04fF
C10747 divbuf_0/a_21502_n240# divbuf_0/a_21630_n840# 0.03fF
C10748 divbuf_0/a_30720_n1600# divbuf_0/a_31200_n1600# 0.26fF
C10749 pll_full_0/divbuf_0/a_24960_n1600# pll_full_0/divbuf_0/a_25440_n1600# 0.26fF
C10750 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_15870_n840# 0.02fF
C10751 divbuf_0/a_53790_n840# divbuf_0/a_53790_n1540# 0.01fF
C10752 divbuf_0/a_23070_n1540# divbuf_0/a_23550_n1540# 0.11fF
C10753 pll_full_0/divbuf_0/a_17310_n1540# pll_full_0/divbuf_0/a_17790_n1540# 0.11fF
C10754 pll_full_0/divbuf_0/a_48030_n840# pll_full_0/divbuf_0/a_48030_n1540# 0.01fF
C10755 pd_div_0/divbuf_0/a_23922_n240# pd_div_0/divbuf_0/a_24412_n240# 0.04fF
C10756 pll_full_0/divbuf_1/a_29262_n240# pll_full_0/divbuf_1/a_29742_n240# 0.05fF
C10757 divbuf_2/a_8272_170# divbuf_2/a_8272_n240# 0.01fF
C10758 divbuf_2/a_28292_170# divbuf_2/a_28772_170# 0.07fF
C10759 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C10760 divbuf_2/a_18582_170# divbuf_2/OUT4 0.19fF
C10761 divbuf_2/a_960_n1600# divbuf_2/a_990_n1540# 0.19fF
C10762 divbuf_2/a_990_n840# divbuf_2/a_1470_n840# 0.07fF
C10763 divbuf_1/a_24412_170# divbuf_1/OUT4 0.19fF
C10764 pd_div_0/divbuf_0/a_35520_n1600# pd_div_0/divbuf_0/a_35550_n1540# 0.19fF
C10765 pd_div_0/divbuf_0/a_5310_n840# pd_div_0/divbuf_0/a_5310_n1540# 0.01fF
C10766 pd_div_0/divbuf_0/a_35550_n840# pd_div_0/divbuf_0/a_36030_n840# 0.07fF
C10767 pll_full_0/divbuf_1/a_10590_n840# pll_full_0/divbuf_1/a_10590_n1540# 0.01fF
C10768 pll_full_0/divbuf_1/a_40830_n840# pll_full_0/divbuf_1/a_41310_n840# 0.07fF
C10769 pll_full_0/divbuf_1/a_40800_n1600# pll_full_0/divbuf_1/a_40830_n1540# 0.19fF
C10770 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/nor_0/B 0.00fF
C10771 pd_div_0/divider_0/tspc_0/a_630_n680# pd_div_0/divider_0/nor_1/A 0.35fF
C10772 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C10773 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C10774 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C10775 ro_div_0/divbuf_0/a_13742_170# ro_div_0/divbuf_0/a_14222_170# 0.07fF
C10776 divbuf_0/a_4392_170# divbuf_0/OUT3 0.19fF
C10777 divbuf_0/a_20640_n1600# divbuf_0/a_20670_n840# 0.04fF
C10778 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_2/Z1 0.01fF
C10779 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C10780 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C10781 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/A 0.26fF
C10782 pll_full_0/divbuf_0/a_14880_n1600# pll_full_0/divbuf_0/a_14910_n840# 0.04fF
C10783 divbuf_2/a_53790_n1540# divbuf_2/a_54270_n1540# 0.11fF
C10784 divbuf_1/a_33120_n1600# divbuf_1/a_33600_n1600# 0.26fF
C10785 divbuf_1/a_23922_n240# divbuf_1/a_24030_n840# 0.03fF
C10786 ro_div_0/divbuf_0/a_34560_n1600# ro_div_0/divbuf_0/a_35040_n1600# 0.26fF
C10787 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/a_25470_n840# 0.03fF
C10788 divbuf_3/a_24000_n1600# divbuf_3/a_24480_n1600# 0.26fF
C10789 divbuf_3/a_14702_n240# divbuf_3/a_14910_n840# 0.02fF
C10790 ro_div_0/divbuf_0/a_57630_n840# ro_div_0/divbuf_0/a_57630_n1540# 0.01fF
C10791 ro_div_0/divbuf_0/a_26910_n1540# ro_div_0/divbuf_0/a_27390_n1540# 0.11fF
C10792 divbuf_3/a_16350_n1540# divbuf_3/a_16830_n1540# 0.11fF
C10793 divbuf_3/a_47070_n840# divbuf_3/a_47070_n1540# 0.01fF
C10794 divbuf_0/a_37502_170# divbuf_0/a_37992_170# 0.07fF
C10795 divbuf_2/a_19562_n240# divbuf_2/OUT4 0.04fF
C10796 divbuf_2/a_51360_n1600# divbuf_2/a_51390_n840# 0.04fF
C10797 divbuf_1/a_28772_n240# divbuf_1/OUT4 0.04fF
C10798 divbuf_1/a_25440_n1600# divbuf_1/a_25470_n1540# 0.19fF
C10799 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/a_32172_170# 0.07fF
C10800 divbuf_0/a_10080_n1600# divbuf_0/a_10110_n1540# 0.19fF
C10801 divbuf_0/a_37022_170# divbuf_0/OUT4 0.19fF
C10802 divbuf_0/a_10110_n840# divbuf_0/a_10590_n840# 0.07fF
C10803 pll_full_0/divbuf_0/a_4350_n840# pll_full_0/divbuf_0/a_4830_n840# 0.07fF
C10804 pll_full_0/divbuf_0/a_25382_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10805 pll_full_0/divbuf_0/a_4320_n1600# pll_full_0/divbuf_0/a_4350_n1540# 0.19fF
C10806 divbuf_1/a_23040_n1600# divbuf_1/a_23070_n840# 0.04fF
C10807 ro_div_0/divbuf_0/a_24480_n1600# ro_div_0/divbuf_0/a_24510_n840# 0.04fF
C10808 divbuf_0/OUT2 divbuf_0/OUT3 0.36fF
C10809 pll_full_0/divbuf_0/a_57150_n1540# pll_full_0/divbuf_0/a_57630_n1540# 0.11fF
C10810 divbuf_3/a_13920_n1600# divbuf_3/a_13950_n840# 0.04fF
C10811 divbuf_1/a_17310_n1540# divbuf_1/a_17790_n1540# 0.11fF
C10812 pd_div_0/divbuf_0/a_22080_n1600# pd_div_0/divbuf_0/a_22560_n1600# 0.26fF
C10813 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_12990_n840# 0.02fF
C10814 pll_full_0/divbuf_1/a_27360_n1600# pll_full_0/divbuf_1/a_27840_n1600# 0.26fF
C10815 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_18270_n840# 0.02fF
C10816 divbuf_2/a_29262_n240# divbuf_2/a_29742_n240# 0.05fF
C10817 divbuf_2/a_10590_n840# divbuf_2/a_10590_n1540# 0.01fF
C10818 divbuf_2/a_40830_n840# divbuf_2/a_41310_n840# 0.07fF
C10819 divbuf_2/a_40800_n1600# divbuf_2/a_40830_n1540# 0.19fF
C10820 pd_div_0/divbuf_0/a_14430_n1540# pd_div_0/divbuf_0/a_14910_n1540# 0.11fF
C10821 pd_div_0/divbuf_0/a_45150_n840# pd_div_0/divbuf_0/a_45150_n1540# 0.01fF
C10822 pll_full_0/divbuf_1/a_19710_n1540# pll_full_0/divbuf_1/a_20190_n1540# 0.11fF
C10823 pll_full_0/divbuf_1/a_50430_n840# pll_full_0/divbuf_1/a_50430_n1540# 0.01fF
C10824 divbuf_1/a_39932_170# divbuf_1/a_40412_170# 0.07fF
C10825 ro_div_0/divbuf_0/a_21982_170# ro_div_0/divbuf_0/a_21982_n240# 0.01fF
C10826 divbuf_0/a_60480_n1600# divbuf_0/a_60510_n840# 0.04fF
C10827 divbuf_0/a_37992_n240# divbuf_0/OUT4 0.04fF
C10828 pll_full_0/divbuf_0/a_26352_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10829 pll_full_0/divbuf_0/a_54720_n1600# pll_full_0/divbuf_0/a_54750_n840# 0.04fF
C10830 divbuf_3/a_11312_170# divbuf_3/a_11312_n240# 0.01fF
C10831 divbuf_3/a_30712_170# divbuf_3/a_31202_170# 0.07fF
C10832 divbuf_1/a_12480_n1600# divbuf_1/a_12510_n1540# 0.19fF
C10833 divbuf_1/a_12510_n840# divbuf_1/a_12990_n840# 0.07fF
C10834 ro_div_0/divbuf_0/a_13950_n840# ro_div_0/divbuf_0/a_14430_n840# 0.07fF
C10835 ro_div_0/divbuf_0/a_13920_n1600# ro_div_0/divbuf_0/a_13950_n1540# 0.19fF
C10836 ro_div_0/divbuf_0/a_5362_n240# ro_div_0/divbuf_0/OUT3 0.04fF
C10837 ro_div_0/divider_0/prescaler_0/tspc_0/Q gnd 0.35fF
C10838 divbuf_3/a_3390_n840# divbuf_3/a_3870_n840# 0.07fF
C10839 divbuf_3/a_23442_170# divbuf_3/OUT4 0.19fF
C10840 divbuf_3/a_3360_n1600# divbuf_3/a_3390_n1540# 0.19fF
C10841 pd_div_0/divbuf_0/a_12000_n1600# pd_div_0/divbuf_0/a_12030_n840# 0.04fF
C10842 pll_full_0/divbuf_1/a_17280_n1600# pll_full_0/divbuf_1/a_17310_n840# 0.04fF
C10843 divbuf_3/a_56190_n1540# divbuf_3/a_56670_n1540# 0.11fF
C10844 divbuf_1/a_35070_n840# divbuf_1/a_35070_n1540# 0.01fF
C10845 divbuf_0/a_38472_n240# divbuf_0/a_38962_n240# 0.04fF
C10846 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/a_33142_n240# 0.04fF
C10847 divbuf_0/a_49920_n1600# divbuf_0/a_49950_n1540# 0.19fF
C10848 divbuf_0/a_49950_n840# divbuf_0/a_50430_n840# 0.07fF
C10849 divbuf_0/a_19710_n840# divbuf_0/a_19710_n1540# 0.01fF
C10850 divbuf_0/a_36000_n1600# divbuf_0/OUT4 0.00fF
C10851 pll_full_0/divbuf_0/a_13950_n840# pll_full_0/divbuf_0/a_13950_n1540# 0.01fF
C10852 pll_full_0/divbuf_0/a_44190_n840# pll_full_0/divbuf_0/a_44670_n840# 0.07fF
C10853 pll_full_0/divbuf_0/a_44160_n1600# pll_full_0/divbuf_0/a_44190_n1540# 0.19fF
C10854 pll_full_0/divbuf_0/a_24480_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C10855 pd_div_0/divbuf_0/a_28772_170# pd_div_0/divbuf_0/a_29262_170# 0.07fF
C10856 pll_full_0/divbuf_1/a_14702_170# pll_full_0/divbuf_1/a_14702_n240# 0.01fF
C10857 pll_full_0/divbuf_1/a_34112_170# pll_full_0/divbuf_1/a_34592_170# 0.07fF
C10858 divbuf_3/a_24412_n240# divbuf_3/OUT4 0.04fF
C10859 divbuf_3/a_53760_n1600# divbuf_3/a_53790_n840# 0.04fF
C10860 divbuf_1/a_57150_n1540# divbuf_1/a_57630_n1540# 0.11fF
C10861 pd_div_0/divbuf_0/a_19562_170# pd_div_0/divbuf_0/OUT4 0.19fF
C10862 pd_div_0/divbuf_0/a_1440_n1600# pd_div_0/divbuf_0/a_1470_n1540# 0.19fF
C10863 pd_div_0/divbuf_0/a_1470_n840# pd_div_0/divbuf_0/a_1950_n840# 0.07fF
C10864 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C10865 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C10866 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C10867 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C10868 divbuf_2/a_27360_n1600# divbuf_2/a_27840_n1600# 0.26fF
C10869 divbuf_2/a_18092_n240# divbuf_2/a_18270_n840# 0.02fF
C10870 pll_full_0/divbuf_1/a_6750_n840# pll_full_0/divbuf_1/a_7230_n840# 0.07fF
C10871 pll_full_0/divbuf_1/a_30232_170# pll_full_0/divbuf_1/OUT4 0.19fF
C10872 pll_full_0/divbuf_1/a_6720_n1600# pll_full_0/divbuf_1/a_6750_n1540# 0.19fF
C10873 pd_div_0/divbuf_0/a_54270_n1540# pd_div_0/divbuf_0/a_54750_n1540# 0.11fF
C10874 pll_full_0/divbuf_1/a_59550_n1540# pll_full_0/divbuf_1/a_60030_n1540# 0.11fF
C10875 divbuf_2/a_19710_n1540# divbuf_2/a_20190_n1540# 0.11fF
C10876 divbuf_2/a_50430_n840# divbuf_2/a_50430_n1540# 0.01fF
C10877 divbuf_1/a_40902_n240# divbuf_1/a_41382_n240# 0.05fF
C10878 ro_div_0/divbuf_0/a_480_n1600# ro_div_0/divbuf_0/a_960_n1600# 0.26fF
C10879 divbuf_3/a_31682_n240# divbuf_3/a_32172_n240# 0.04fF
C10880 divbuf_1/a_52350_n840# divbuf_1/a_52830_n840# 0.07fF
C10881 ro_div_0/divbuf_0/a_53760_n1600# ro_div_0/divbuf_0/a_53790_n1540# 0.19fF
C10882 ro_div_0/divbuf_0/a_53790_n840# ro_div_0/divbuf_0/a_54270_n840# 0.07fF
C10883 ro_div_0/divbuf_0/a_23550_n840# ro_div_0/divbuf_0/a_23550_n1540# 0.01fF
C10884 divbuf_3/a_12990_n840# divbuf_3/a_12990_n1540# 0.01fF
C10885 divbuf_3/a_43230_n840# divbuf_3/a_43710_n840# 0.07fF
C10886 divbuf_3/a_43200_n1600# divbuf_3/a_43230_n1540# 0.19fF
C10887 divbuf_3/a_22560_n1600# divbuf_3/OUT4 0.01fF
C10888 pd_div_0/divbuf_0/a_20532_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C10889 pd_div_0/divbuf_0/a_51840_n1600# pd_div_0/divbuf_0/a_51870_n840# 0.04fF
C10890 ro_div_0/divider_0/prescaler_0/Out ro_div_0/divider_0/tspc_0/Z3 0.45fF
C10891 divbuf_0/a_7792_170# divbuf_0/a_8272_170# 0.07fF
C10892 divbuf_2/a_17280_n1600# divbuf_2/a_17310_n840# 0.04fF
C10893 divbuf_1/a_11312_170# divbuf_1/OUT4 0.23fF
C10894 pll_full_0/divbuf_1/a_31202_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C10895 pll_full_0/divbuf_1/a_57120_n1600# pll_full_0/divbuf_1/a_57150_n840# 0.04fF
C10896 pd_div_0/divider_0/tspc_0/Q pd_div_0/divider_0/tspc_1/a_630_n680# 0.01fF
C10897 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C10898 divbuf_0/a_27322_n240# divbuf_0/a_27390_n840# 0.04fF
C10899 divbuf_0/a_36480_n1600# divbuf_0/a_36960_n1600# 0.26fF
C10900 pll_full_0/divbuf_0/a_30720_n1600# pll_full_0/divbuf_0/a_31200_n1600# 0.26fF
C10901 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/a_21630_n840# 0.03fF
C10902 ro_div_0/divbuf_0/a_11312_n240# ro_div_0/divbuf_0/a_11070_n840# 0.02fF
C10903 divbuf_0/a_59550_n840# divbuf_0/a_59550_n1540# 0.01fF
C10904 divbuf_0/a_28830_n1540# divbuf_0/a_29310_n1540# 0.11fF
C10905 pll_full_0/divbuf_0/a_23070_n1540# pll_full_0/divbuf_0/a_23550_n1540# 0.11fF
C10906 pll_full_0/divbuf_0/a_53790_n840# pll_full_0/divbuf_0/a_53790_n1540# 0.01fF
C10907 pd_div_0/divbuf_0/a_29742_n240# pd_div_0/divbuf_0/a_30232_n240# 0.04fF
C10908 pll_full_0/divbuf_1/a_35082_n240# pll_full_0/divbuf_1/a_35562_n240# 0.05fF
C10909 divbuf_2/a_14702_170# divbuf_2/a_14702_n240# 0.01fF
C10910 divbuf_2/a_34112_170# divbuf_2/a_34592_170# 0.07fF
C10911 divbuf_2/a_6750_n840# divbuf_2/a_7230_n840# 0.07fF
C10912 divbuf_2/a_30232_170# divbuf_2/OUT4 0.19fF
C10913 divbuf_2/a_6720_n1600# divbuf_2/a_6750_n1540# 0.19fF
C10914 divbuf_1/a_39442_170# divbuf_1/OUT4 0.19fF
C10915 pd_div_0/divbuf_0/a_11070_n840# pd_div_0/divbuf_0/a_11070_n1540# 0.01fF
C10916 pd_div_0/divbuf_0/a_41310_n840# pd_div_0/divbuf_0/a_41790_n840# 0.07fF
C10917 pd_div_0/divbuf_0/a_41280_n1600# pd_div_0/divbuf_0/a_41310_n1540# 0.19fF
C10918 pll_full_0/divbuf_1/a_46560_n1600# pll_full_0/divbuf_1/a_46590_n1540# 0.19fF
C10919 pll_full_0/divbuf_1/a_16350_n840# pll_full_0/divbuf_1/a_16350_n1540# 0.01fF
C10920 pll_full_0/divbuf_1/a_46590_n840# pll_full_0/divbuf_1/a_47070_n840# 0.07fF
C10921 pd_div_0/divider_0/tspc_1/Q pd_div_0/divider_0/tspc_2/Z3 0.45fF
C10922 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 pd_div_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C10923 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 pd_div_0/divider_0/prescaler_0/Out 0.08fF
C10924 pd_div_0/divider_0/nor_1/A gnd 1.05fF
C10925 divbuf_0/a_4882_170# divbuf_0/OUT3 0.19fF
C10926 divbuf_0/a_26400_n1600# divbuf_0/a_26430_n840# 0.04fF
C10927 pll_full_0/divider_0/nor_1/A pll_full_0/divider_0/and_0/B 0.08fF
C10928 pll_full_0/divbuf_0/a_20640_n1600# pll_full_0/divbuf_0/a_20670_n840# 0.04fF
C10929 divbuf_2/a_59550_n1540# divbuf_2/a_60030_n1540# 0.11fF
C10930 divbuf_1/a_38880_n1600# divbuf_1/a_39360_n1600# 0.26fF
C10931 divbuf_1/a_29742_n240# divbuf_1/a_29790_n840# 0.04fF
C10932 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/a_31230_n840# 0.05fF
C10933 ro_div_0/divbuf_0/a_40320_n1600# ro_div_0/divbuf_0/a_40800_n1600# 0.26fF
C10934 divbuf_3/a_29760_n1600# divbuf_3/a_30240_n1600# 0.26fF
C10935 divbuf_3/a_20532_n240# divbuf_3/a_20670_n840# 0.03fF
C10936 ro_div_0/divbuf_0/a_32670_n1540# ro_div_0/divbuf_0/a_33150_n1540# 0.11fF
C10937 divbuf_3/a_22110_n1540# divbuf_3/a_22590_n1540# 0.11fF
C10938 divbuf_3/a_52830_n840# divbuf_3/a_52830_n1540# 0.01fF
C10939 divbuf_0/a_23922_170# divbuf_0/a_23922_n240# 0.01fF
C10940 divbuf_0/a_3422_n240# divbuf_0/a_3912_n240# 0.04fF
C10941 pll_full_0/divbuf_0/a_37502_170# pll_full_0/divbuf_0/a_37992_170# 0.07fF
C10942 divbuf_2/a_31202_n240# divbuf_2/OUT4 0.04fF
C10943 divbuf_2/a_57120_n1600# divbuf_2/a_57150_n840# 0.04fF
C10944 divbuf_1/a_40412_n240# divbuf_1/OUT4 0.04fF
C10945 divbuf_1/a_31200_n1600# divbuf_1/a_31230_n1540# 0.19fF
C10946 divbuf_0/a_15840_n1600# divbuf_0/a_15870_n1540# 0.19fF
C10947 divbuf_0/a_9242_n240# divbuf_0/OUT3 0.04fF
C10948 divbuf_0/a_15870_n840# divbuf_0/a_16350_n840# 0.07fF
C10949 pll_full_0/divbuf_0/a_10110_n840# pll_full_0/divbuf_0/a_10590_n840# 0.07fF
C10950 pll_full_0/divbuf_0/a_37022_170# pll_full_0/divbuf_0/OUT4 0.19fF
C10951 pll_full_0/divbuf_0/a_10080_n1600# pll_full_0/divbuf_0/a_10110_n1540# 0.19fF
C10952 divbuf_1/a_28800_n1600# divbuf_1/a_28830_n840# 0.04fF
C10953 pd_div_0/pd_0/tspc_r_0/Qbar1 pd_div_0/pd_0/tspc_r_0/Qbar 0.01fF
C10954 pd_div_0/pd_0/tspc_r_0/Z3 pd_div_0/pd_0/R 0.27fF
C10955 ro_div_0/divbuf_0/a_30240_n1600# ro_div_0/divbuf_0/a_30270_n840# 0.04fF
C10956 ro_div_0/divbuf_0/a_17612_170# ro_div_0/divbuf_0/OUT4 0.19fF
C10957 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/OUT3 0.36fF
C10958 divbuf_3/a_19680_n1600# divbuf_3/a_19710_n840# 0.04fF
C10959 divbuf_1/a_23070_n1540# divbuf_1/a_23550_n1540# 0.11fF
C10960 pd_div_0/divbuf_0/a_27840_n1600# pd_div_0/divbuf_0/a_28320_n1600# 0.26fF
C10961 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/a_18750_n840# 0.02fF
C10962 pll_full_0/divbuf_1/a_33120_n1600# pll_full_0/divbuf_1/a_33600_n1600# 0.26fF
C10963 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/a_24030_n840# 0.03fF
C10964 divbuf_2/a_35082_n240# divbuf_2/a_35562_n240# 0.05fF
C10965 divbuf_2/a_46560_n1600# divbuf_2/a_46590_n1540# 0.19fF
C10966 divbuf_2/a_16350_n840# divbuf_2/a_16350_n1540# 0.01fF
C10967 divbuf_2/a_46590_n840# divbuf_2/a_47070_n840# 0.07fF
C10968 pd_div_0/divbuf_0/a_20190_n1540# pd_div_0/divbuf_0/a_20670_n1540# 0.11fF
C10969 pd_div_0/divbuf_0/a_50910_n840# pd_div_0/divbuf_0/a_50910_n1540# 0.01fF
C10970 pll_full_0/divbuf_1/a_25470_n1540# pll_full_0/divbuf_1/a_25950_n1540# 0.11fF
C10971 pll_full_0/divbuf_1/a_56190_n840# pll_full_0/divbuf_1/a_56190_n1540# 0.01fF
C10972 divbuf_1/a_5852_n240# divbuf_1/a_6332_n240# 0.05fF
C10973 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/a_27802_n240# 0.01fF
C10974 ro_div_0/divbuf_0/a_7302_n240# ro_div_0/divbuf_0/a_7792_n240# 0.04fF
C10975 pll_full_0/divbuf_0/a_37992_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C10976 pll_full_0/divbuf_0/a_60480_n1600# pll_full_0/divbuf_0/a_60510_n840# 0.04fF
C10977 divbuf_3/a_17122_170# divbuf_3/a_17122_n240# 0.01fF
C10978 divbuf_3/a_36532_170# divbuf_3/a_37022_170# 0.07fF
C10979 divbuf_1/a_18270_n840# divbuf_1/a_18750_n840# 0.07fF
C10980 ro_div_0/divbuf_0/a_19680_n1600# ro_div_0/divbuf_0/a_19710_n1540# 0.19fF
C10981 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C10982 ro_div_0/divbuf_0/a_19710_n840# ro_div_0/divbuf_0/a_20190_n840# 0.07fF
C10983 ro_div_0/divider_0/and_0/A gnd 0.69fF
C10984 divbuf_3/a_9150_n840# divbuf_3/a_9630_n840# 0.07fF
C10985 divbuf_3/a_35082_170# divbuf_3/OUT4 0.19fF
C10986 divbuf_3/a_9120_n1600# divbuf_3/a_9150_n1540# 0.19fF
C10987 pd_div_0/divbuf_0/a_17760_n1600# pd_div_0/divbuf_0/a_17790_n840# 0.04fF
C10988 pd_div_0/divbuf_0/a_2322_170# pd_div_0/divbuf_0/OUT3 0.07fF
C10989 pll_full_0/divbuf_1/a_1352_170# pll_full_0/divbuf_1/OUT2 0.23fF
C10990 pll_full_0/divbuf_1/a_23040_n1600# pll_full_0/divbuf_1/a_23070_n840# 0.04fF
C10991 divbuf_1/a_40830_n840# divbuf_1/a_40830_n1540# 0.01fF
C10992 divbuf_0/a_2400_n1600# divbuf_0/a_2880_n1600# 0.26fF
C10993 pll_full_0/divbuf_0/a_38472_n240# pll_full_0/divbuf_0/a_38962_n240# 0.04fF
C10994 divbuf_0/a_25470_n840# divbuf_0/a_25470_n1540# 0.01fF
C10995 divbuf_0/a_55710_n840# divbuf_0/a_56190_n840# 0.07fF
C10996 divbuf_0/a_55680_n1600# divbuf_0/a_55710_n1540# 0.19fF
C10997 pll_full_0/divbuf_0/a_36000_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C10998 pll_full_0/divbuf_0/a_19710_n840# pll_full_0/divbuf_0/a_19710_n1540# 0.01fF
C10999 pll_full_0/divbuf_0/a_49950_n840# pll_full_0/divbuf_0/a_50430_n840# 0.07fF
C11000 pll_full_0/divbuf_0/a_49920_n1600# pll_full_0/divbuf_0/a_49950_n1540# 0.19fF
C11001 pd_div_0/divbuf_0/a_15182_170# pd_div_0/divbuf_0/a_15182_n240# 0.01fF
C11002 pd_div_0/divbuf_0/a_34592_170# pd_div_0/divbuf_0/a_35082_170# 0.07fF
C11003 pll_full_0/divbuf_1/a_20532_170# pll_full_0/divbuf_1/a_20532_n240# 0.01fF
C11004 pll_full_0/divbuf_1/a_39932_170# pll_full_0/divbuf_1/a_40412_170# 0.07fF
C11005 divbuf_3/a_36052_n240# divbuf_3/OUT4 0.04fF
C11006 divbuf_3/a_59520_n1600# divbuf_3/a_59550_n840# 0.04fF
C11007 divbuf_1/OUT2 divbuf_1/OUT3 0.36fF
C11008 pd_div_0/divbuf_0/a_7230_n840# pd_div_0/divbuf_0/a_7710_n840# 0.07fF
C11009 pd_div_0/divbuf_0/a_31202_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11010 pd_div_0/divbuf_0/a_7200_n1600# pd_div_0/divbuf_0/a_7230_n1540# 0.19fF
C11011 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C11012 ro_div_0/divider_0/tspc_0/Z1 ro_div_0/divider_0/tspc_0/Z3 0.06fF
C11013 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/a0 0.09fF
C11014 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C11015 pll_full_0/divbuf_1/a_2322_n240# pll_full_0/divbuf_1/OUT2 0.04fF
C11016 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/a_12510_n1540# 0.19fF
C11017 pll_full_0/divbuf_1/a_41382_170# pll_full_0/divbuf_1/OUT5 0.07fF
C11018 pll_full_0/divbuf_1/a_12510_n840# pll_full_0/divbuf_1/a_12990_n840# 0.07fF
C11019 divbuf_2/a_33120_n1600# divbuf_2/a_33600_n1600# 0.26fF
C11020 divbuf_2/a_23922_n240# divbuf_2/a_24030_n840# 0.03fF
C11021 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C11022 pd_0/DOWN pd_0/UP 0.46fF
C11023 divbuf_2/a_25470_n1540# divbuf_2/a_25950_n1540# 0.11fF
C11024 divbuf_2/a_56190_n840# divbuf_2/a_56190_n1540# 0.01fF
C11025 pd_div_0/divbuf_0/a_60030_n1540# pd_div_0/divbuf_0/a_60510_n1540# 0.11fF
C11026 divbuf_0/a_13252_n240# divbuf_0/a_12990_n840# 0.01fF
C11027 divbuf_1/a_4800_n1600# divbuf_1/a_5280_n1600# 0.26fF
C11028 ro_div_0/divbuf_0/a_6240_n1600# ro_div_0/divbuf_0/a_6720_n1600# 0.26fF
C11029 divbuf_3/a_37502_n240# divbuf_3/a_37992_n240# 0.04fF
C11030 divbuf_1/a_58110_n840# divbuf_1/a_58590_n840# 0.07fF
C11031 ro_div_0/divbuf_0/a_59550_n840# ro_div_0/divbuf_0/a_60030_n840# 0.07fF
C11032 ro_div_0/divbuf_0/a_29310_n840# ro_div_0/divbuf_0/a_29310_n1540# 0.01fF
C11033 ro_div_0/divbuf_0/a_59520_n1600# ro_div_0/divbuf_0/a_59550_n1540# 0.19fF
C11034 divbuf_3/a_34080_n1600# divbuf_3/OUT4 0.01fF
C11035 divbuf_3/a_18750_n840# divbuf_3/a_18750_n1540# 0.01fF
C11036 divbuf_3/a_48990_n840# divbuf_3/a_49470_n840# 0.07fF
C11037 divbuf_3/a_48960_n1600# divbuf_3/a_48990_n1540# 0.19fF
C11038 pd_div_0/divbuf_0/a_32172_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11039 pd_div_0/divbuf_0/a_57600_n1600# pd_div_0/divbuf_0/a_57630_n840# 0.04fF
C11040 divbuf_0/a_3422_170# divbuf_0/a_3422_n240# 0.01fF
C11041 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C11042 divbuf_2/a_1352_170# divbuf_2/OUT2 0.23fF
C11043 divbuf_2/a_23040_n1600# divbuf_2/a_23070_n840# 0.04fF
C11044 divbuf_1/a_12282_170# divbuf_1/OUT4 0.19fF
C11045 pll_full_0/divbuf_1/a_0_n1600# pll_full_0/divbuf_1/OUT 0.26fF
C11046 pll_full_0/divbuf_1/a_1920_n1600# pll_full_0/divbuf_1/OUT2 0.00fF
C11047 pd_div_0/divider_0/tspc_0/Z4 pd_div_0/divider_0/tspc_0/a_630_n680# 0.12fF
C11048 divbuf_0/a_33142_n240# divbuf_0/a_33150_n840# 0.06fF
C11049 divbuf_0/a_42240_n1600# divbuf_0/a_42720_n1600# 0.26fF
C11050 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C11051 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# 0.01fF
C11052 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C11053 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Q 0.20fF
C11054 pll_full_0/divbuf_0/a_36480_n1600# pll_full_0/divbuf_0/a_36960_n1600# 0.26fF
C11055 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/a_27390_n840# 0.04fF
C11056 divbuf_1/a_15672_n240# divbuf_1/a_15390_n840# 0.01fF
C11057 ro_div_0/divbuf_0/a_17122_n240# ro_div_0/divbuf_0/a_16830_n840# 0.00fF
C11058 divbuf_0/a_34590_n1540# divbuf_0/a_35070_n1540# 0.11fF
C11059 pll_full_0/divbuf_0/a_28830_n1540# pll_full_0/divbuf_0/a_29310_n1540# 0.11fF
C11060 pll_full_0/divbuf_0/a_59550_n840# pll_full_0/divbuf_0/a_59550_n1540# 0.01fF
C11061 pd_div_0/divbuf_0/a_35562_n240# pd_div_0/divbuf_0/a_36052_n240# 0.04fF
C11062 pll_full_0/divbuf_1/a_40902_n240# pll_full_0/divbuf_1/a_41382_n240# 0.05fF
C11063 divbuf_2/a_20532_170# divbuf_2/a_20532_n240# 0.01fF
C11064 divbuf_2/a_39932_170# divbuf_2/a_40412_170# 0.07fF
C11065 pd_div_0/divbuf_0/a_47040_n1600# pd_div_0/divbuf_0/a_47070_n1540# 0.19fF
C11066 pd_div_0/divbuf_0/a_16830_n840# pd_div_0/divbuf_0/a_16830_n1540# 0.01fF
C11067 pd_div_0/divbuf_0/a_47070_n840# pd_div_0/divbuf_0/a_47550_n840# 0.07fF
C11068 divbuf_2/a_2322_n240# divbuf_2/OUT2 0.04fF
C11069 divbuf_2/a_12480_n1600# divbuf_2/a_12510_n1540# 0.19fF
C11070 divbuf_2/a_41382_170# divbuf_2/OUT5 0.07fF
C11071 divbuf_2/a_12510_n840# divbuf_2/a_12990_n840# 0.07fF
C11072 divbuf_1/a_11802_n240# divbuf_1/OUT4 0.04fF
C11073 pll_full_0/divbuf_1/a_22110_n840# pll_full_0/divbuf_1/a_22110_n1540# 0.01fF
C11074 pll_full_0/divbuf_1/a_52350_n840# pll_full_0/divbuf_1/a_52830_n840# 0.07fF
C11075 pll_full_0/divbuf_1/a_52320_n1600# pll_full_0/divbuf_1/a_52350_n1540# 0.19fF
C11076 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C11077 gnd pll_full_0/divider_0/tspc_0/Z2 0.16fF
C11078 divbuf_0/a_32160_n1600# divbuf_0/a_32190_n840# 0.04fF
C11079 divbuf_0/a_20042_170# divbuf_0/OUT4 0.19fF
C11080 pll_full_0/divbuf_0/a_26400_n1600# pll_full_0/divbuf_0/a_26430_n840# 0.04fF
C11081 pll_full_0/divbuf_0/a_7302_170# pll_full_0/divbuf_0/OUT3 0.19fF
C11082 divbuf_1/a_44640_n1600# divbuf_1/a_45120_n1600# 0.26fF
C11083 divbuf_1/a_35562_n240# divbuf_1/a_35550_n840# 0.05fF
C11084 ro_div_0/divbuf_0/a_46080_n1600# ro_div_0/divbuf_0/a_46560_n1600# 0.26fF
C11085 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/a_36990_n840# 0.05fF
C11086 divbuf_3/a_35520_n1600# divbuf_3/a_36000_n1600# 0.26fF
C11087 divbuf_3/a_26352_n240# divbuf_3/a_26430_n840# 0.04fF
C11088 ro_div_0/divbuf_0/a_38430_n1540# ro_div_0/divbuf_0/a_38910_n1540# 0.11fF
C11089 divbuf_3/a_27870_n1540# divbuf_3/a_28350_n1540# 0.11fF
C11090 divbuf_3/a_58590_n840# divbuf_3/a_58590_n1540# 0.01fF
C11091 divbuf_0/a_29742_170# divbuf_0/a_29742_n240# 0.01fF
C11092 divbuf_0/a_9242_n240# divbuf_0/a_9732_n240# 0.04fF
C11093 pll_full_0/divbuf_0/a_3422_n240# pll_full_0/divbuf_0/a_3912_n240# 0.04fF
C11094 pll_full_0/divbuf_0/a_23922_170# pll_full_0/divbuf_0/a_23922_n240# 0.01fF
C11095 divbuf_2/a_0_n1600# divbuf_2/OUT 0.26fF
C11096 divbuf_2/a_1920_n1600# divbuf_2/OUT2 0.00fF
C11097 divbuf_1/a_36960_n1600# divbuf_1/a_36990_n1540# 0.19fF
C11098 divbuf_1/a_10560_n1600# divbuf_1/OUT3 0.01fF
C11099 divbuf_1/a_12772_170# divbuf_1/a_12772_n240# 0.01fF
C11100 divbuf_0/a_21630_n840# divbuf_0/a_22110_n840# 0.07fF
C11101 divbuf_0/a_21600_n1600# divbuf_0/a_21630_n1540# 0.19fF
C11102 divbuf_0/a_21012_n240# divbuf_0/OUT4 0.04fF
C11103 pll_full_0/divbuf_0/a_15870_n840# pll_full_0/divbuf_0/a_16350_n840# 0.07fF
C11104 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C11105 pll_full_0/divbuf_0/a_15840_n1600# pll_full_0/divbuf_0/a_15870_n1540# 0.19fF
C11106 divbuf_1/a_34560_n1600# divbuf_1/a_34590_n840# 0.04fF
C11107 pd_div_0/pd_0/tspc_r_1/Z3 pd_div_0/pd_0/tspc_r_1/Qbar1 0.38fF
C11108 ro_div_0/divbuf_0/a_36000_n1600# ro_div_0/divbuf_0/a_36030_n840# 0.04fF
C11109 ro_div_0/divbuf_0/a_27802_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11110 ro_div_0/divider_0/prescaler_0/m1_2700_2190# gnd 0.22fF
C11111 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C11112 pll_full_0/divbuf_1/a_4882_170# pll_full_0/divbuf_1/a_5362_170# 0.07fF
C11113 divbuf_3/a_6332_170# divbuf_3/OUT3 0.19fF
C11114 divbuf_3/a_25440_n1600# divbuf_3/a_25470_n840# 0.04fF
C11115 divbuf_1/a_28830_n1540# divbuf_1/a_29310_n1540# 0.11fF
C11116 pd_div_0/divbuf_0/a_33600_n1600# pd_div_0/divbuf_0/a_34080_n1600# 0.26fF
C11117 pd_div_0/divbuf_0/a_24412_n240# pd_div_0/divbuf_0/a_24510_n840# 0.03fF
C11118 pll_full_0/divbuf_1/a_38880_n1600# pll_full_0/divbuf_1/a_39360_n1600# 0.26fF
C11119 pll_full_0/divbuf_1/a_29742_n240# pll_full_0/divbuf_1/a_29790_n840# 0.04fF
C11120 divbuf_2/a_40902_n240# divbuf_2/a_41382_n240# 0.05fF
C11121 divbuf_2/a_22110_n840# divbuf_2/a_22110_n1540# 0.01fF
C11122 divbuf_2/a_52350_n840# divbuf_2/a_52830_n840# 0.07fF
C11123 divbuf_2/a_52320_n1600# divbuf_2/a_52350_n1540# 0.19fF
C11124 pd_div_0/divbuf_0/a_25950_n1540# pd_div_0/divbuf_0/a_26430_n1540# 0.11fF
C11125 pd_div_0/divbuf_0/a_56670_n840# pd_div_0/divbuf_0/a_56670_n1540# 0.01fF
C11126 pll_full_0/divbuf_1/a_31230_n1540# pll_full_0/divbuf_1/a_31710_n1540# 0.11fF
C11127 divbuf_1/a_12282_n240# divbuf_1/a_12772_n240# 0.04fF
C11128 ro_div_0/divbuf_0/a_33622_170# ro_div_0/divbuf_0/a_33622_n240# 0.01fF
C11129 ro_div_0/divbuf_0/a_13742_n240# ro_div_0/divbuf_0/a_14222_n240# 0.05fF
C11130 divbuf_0/a_19200_n1600# divbuf_0/OUT4 0.00fF
C11131 divbuf_3/a_1842_n240# divbuf_3/a_2322_n240# 0.05fF
C11132 divbuf_3/a_22952_170# divbuf_3/a_22952_n240# 0.01fF
C11133 divbuf_1/a_24030_n840# divbuf_1/a_24510_n840# 0.07fF
C11134 ro_div_0/divbuf_0/a_25470_n840# ro_div_0/divbuf_0/a_25950_n840# 0.07fF
C11135 ro_div_0/divbuf_0/a_25440_n1600# ro_div_0/divbuf_0/a_25470_n1540# 0.19fF
C11136 ro_div_0/divbuf_0/a_28772_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11137 divbuf_3/a_14910_n840# divbuf_3/a_15390_n840# 0.07fF
C11138 divbuf_3/a_7302_n240# divbuf_3/OUT3 0.04fF
C11139 divbuf_3/a_14880_n1600# divbuf_3/a_14910_n1540# 0.19fF
C11140 pd_div_0/divbuf_0/a_23520_n1600# pd_div_0/divbuf_0/a_23550_n840# 0.04fF
C11141 pll_full_0/divbuf_1/a_13252_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11142 pll_full_0/divbuf_1/a_28800_n1600# pll_full_0/divbuf_1/a_28830_n840# 0.04fF
C11143 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C11144 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C11145 divbuf_0/a_8160_n1600# divbuf_0/a_8640_n1600# 0.26fF
C11146 divbuf_1/a_46590_n840# divbuf_1/a_46590_n1540# 0.01fF
C11147 pll_full_0/divbuf_0/a_2400_n1600# pll_full_0/divbuf_0/a_2880_n1600# 0.26fF
C11148 divbuf_0/a_31230_n840# divbuf_0/a_31230_n1540# 0.01fF
C11149 divbuf_0/a_510_n1540# divbuf_0/a_990_n1540# 0.11fF
C11150 pll_full_0/divbuf_0/a_25470_n840# pll_full_0/divbuf_0/a_25470_n1540# 0.01fF
C11151 pll_full_0/divbuf_0/a_55710_n840# pll_full_0/divbuf_0/a_56190_n840# 0.07fF
C11152 pll_full_0/divbuf_0/a_55680_n1600# pll_full_0/divbuf_0/a_55710_n1540# 0.19fF
C11153 pd_div_0/divbuf_0/a_21012_170# pd_div_0/divbuf_0/a_21012_n240# 0.01fF
C11154 pd_div_0/divbuf_0/a_40412_170# pd_div_0/divbuf_0/a_40902_170# 0.07fF
C11155 pll_full_0/divbuf_1/a_5852_n240# pll_full_0/divbuf_1/a_6332_n240# 0.05fF
C11156 pll_full_0/divbuf_1/a_26352_170# pll_full_0/divbuf_1/a_26352_n240# 0.01fF
C11157 divbuf_2/a_4882_170# divbuf_2/a_5362_170# 0.07fF
C11158 pd_div_0/divbuf_0/a_3422_n240# pd_div_0/divbuf_0/OUT3 0.07fF
C11159 pd_div_0/divbuf_0/a_12960_n1600# pd_div_0/divbuf_0/a_12990_n1540# 0.19fF
C11160 pd_div_0/divbuf_0/a_12990_n840# pd_div_0/divbuf_0/a_13470_n840# 0.07fF
C11161 ro_div_0/divider_0/prescaler_0/tspc_2/D ro_div_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C11162 pll_full_0/divbuf_1/a_18270_n840# pll_full_0/divbuf_1/a_18750_n840# 0.07fF
C11163 pll_full_0/divbuf_1/a_14222_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11164 pll_full_0/divbuf_1/a_18240_n1600# pll_full_0/divbuf_1/a_18270_n1540# 0.19fF
C11165 divbuf_2/a_38880_n1600# divbuf_2/a_39360_n1600# 0.26fF
C11166 divbuf_2/a_29742_n240# divbuf_2/a_29790_n840# 0.04fF
C11167 divbuf_1/a_33622_170# divbuf_1/OUT4 0.19fF
C11168 divbuf_2/a_31230_n1540# divbuf_2/a_31710_n1540# 0.11fF
C11169 divbuf_1/a_17122_170# divbuf_1/a_17612_170# 0.07fF
C11170 pll_full_0/divbuf_0/a_13252_n240# pll_full_0/divbuf_0/a_12990_n840# 0.01fF
C11171 divbuf_1/a_10560_n1600# divbuf_1/a_11040_n1600# 0.26fF
C11172 ro_div_0/divbuf_0/a_12000_n1600# ro_div_0/divbuf_0/a_12480_n1600# 0.26fF
C11173 divbuf_3/a_1440_n1600# divbuf_3/a_1920_n1600# 0.26fF
C11174 divbuf_1/a_2910_n1540# divbuf_1/a_3390_n1540# 0.11fF
C11175 ro_div_0/divbuf_0/a_35070_n840# ro_div_0/divbuf_0/a_35070_n1540# 0.01fF
C11176 ro_div_0/divbuf_0/a_4350_n1540# ro_div_0/divbuf_0/a_4830_n1540# 0.11fF
C11177 divbuf_3/a_24510_n840# divbuf_3/a_24510_n1540# 0.01fF
C11178 divbuf_3/a_54750_n840# divbuf_3/a_55230_n840# 0.07fF
C11179 divbuf_3/a_54720_n1600# divbuf_3/a_54750_n1540# 0.19fF
C11180 pd_div_0/divbuf_0/a_2880_n1600# pd_div_0/divbuf_0/OUT2 0.00fF
C11181 pll_full_0/divbuf_1/a_12480_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C11182 divbuf_2/a_13252_170# divbuf_2/OUT4 0.19fF
C11183 divbuf_2/a_28800_n1600# divbuf_2/a_28830_n840# 0.04fF
C11184 divbuf_1/a_19072_170# divbuf_1/OUT4 0.19fF
C11185 ro_div_0/ro_complete_0/cbank_0/switch_0/vin ro_div_0/ro_complete_0/cbank_0/v 1.30fF
C11186 divbuf_1/a_7302_170# divbuf_1/a_6822_170# 0.07fF
C11187 pd_div_0/divider_0/tspc_0/Z4 gnd 0.44fF
C11188 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# pd_div_0/divider_0/prescaler_0/tspc_0/Q 0.04fF
C11189 divbuf_0/a_48000_n1600# divbuf_0/a_48480_n1600# 0.26fF
C11190 divbuf_0/a_492_n240# divbuf_0/IN 0.13fF
C11191 divbuf_0/a_38962_n240# divbuf_0/a_38910_n840# 0.04fF
C11192 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C11193 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C11194 pll_full_0/divbuf_0/a_42240_n1600# pll_full_0/divbuf_0/a_42720_n1600# 0.26fF
C11195 pll_full_0/divbuf_0/a_33142_n240# pll_full_0/divbuf_0/a_33150_n840# 0.06fF
C11196 divbuf_1/a_480_n1600# divbuf_1/a_510_n840# 0.04fF
C11197 ro_div_0/divbuf_0/a_1920_n1600# ro_div_0/divbuf_0/a_1950_n840# 0.04fF
C11198 divbuf_0/a_40350_n1540# divbuf_0/a_40830_n1540# 0.11fF
C11199 pll_full_0/divbuf_0/a_34590_n1540# pll_full_0/divbuf_0/a_35070_n1540# 0.11fF
C11200 divbuf_3/a_12282_n240# divbuf_3/a_12030_n840# 0.02fF
C11201 pll_full_0/divbuf_1/a_4800_n1600# pll_full_0/divbuf_1/a_5280_n1600# 0.26fF
C11202 divbuf_2/a_5852_n240# divbuf_2/a_6332_n240# 0.05fF
C11203 divbuf_2/a_26352_170# divbuf_2/a_26352_n240# 0.01fF
C11204 pd_div_0/divbuf_0/a_22590_n840# pd_div_0/divbuf_0/a_22590_n1540# 0.01fF
C11205 pd_div_0/divbuf_0/a_52830_n840# pd_div_0/divbuf_0/a_53310_n840# 0.07fF
C11206 pd_div_0/divbuf_0/a_52800_n1600# pd_div_0/divbuf_0/a_52830_n1540# 0.19fF
C11207 divbuf_0/a_14222_170# divbuf_0/a_14222_n240# 0.01fF
C11208 divbuf_2/a_18270_n840# divbuf_2/a_18750_n840# 0.07fF
C11209 divbuf_2/a_14222_n240# divbuf_2/OUT4 0.04fF
C11210 divbuf_2/a_18240_n1600# divbuf_2/a_18270_n1540# 0.19fF
C11211 divbuf_1/a_23442_n240# divbuf_1/OUT4 0.04fF
C11212 pll_full_0/divbuf_1/a_58080_n1600# pll_full_0/divbuf_1/a_58110_n1540# 0.19fF
C11213 pll_full_0/divbuf_1/a_27870_n840# pll_full_0/divbuf_1/a_27870_n1540# 0.01fF
C11214 pll_full_0/divbuf_1/a_58110_n840# pll_full_0/divbuf_1/a_58590_n840# 0.07fF
C11215 ro_div_0/divbuf_0/a_5362_170# ro_div_0/divbuf_0/a_5362_n240# 0.01fF
C11216 divbuf_1/a_2322_170# divbuf_1/a_2322_n240# 0.01fF
C11217 divbuf_0/a_37920_n1600# divbuf_0/a_37950_n840# 0.04fF
C11218 divbuf_0/a_31682_170# divbuf_0/OUT4 0.19fF
C11219 pll_full_0/divbuf_0/a_20042_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11220 pll_full_0/divbuf_0/a_32160_n1600# pll_full_0/divbuf_0/a_32190_n840# 0.04fF
C11221 divbuf_3/a_7302_170# divbuf_3/a_7792_170# 0.07fF
C11222 divbuf_1/a_41382_n240# divbuf_1/a_41310_n840# 0.03fF
C11223 divbuf_1/a_50400_n1600# divbuf_1/a_50880_n1600# 0.26fF
C11224 ro_div_0/divbuf_0/a_51840_n1600# ro_div_0/divbuf_0/a_52320_n1600# 0.26fF
C11225 divbuf_3/a_41280_n1600# divbuf_3/a_41760_n1600# 0.26fF
C11226 divbuf_3/a_32172_n240# divbuf_3/a_32190_n840# 0.06fF
C11227 ro_div_0/divbuf_0/a_44190_n1540# ro_div_0/divbuf_0/a_44670_n1540# 0.11fF
C11228 pll_full_0/divbuf_1/a_15672_n240# pll_full_0/divbuf_1/a_15390_n840# 0.01fF
C11229 divbuf_3/a_33630_n1540# divbuf_3/a_34110_n1540# 0.11fF
C11230 divbuf_0/a_35562_170# divbuf_0/a_35562_n240# 0.01fF
C11231 divbuf_0/a_15672_n240# divbuf_0/a_16152_n240# 0.05fF
C11232 pll_full_0/divbuf_0/a_9242_n240# pll_full_0/divbuf_0/a_9732_n240# 0.04fF
C11233 pll_full_0/divbuf_0/a_29742_170# pll_full_0/divbuf_0/a_29742_n240# 0.01fF
C11234 divbuf_2/a_12480_n1600# divbuf_2/OUT4 0.00fF
C11235 divbuf_1/a_21600_n1600# divbuf_1/OUT4 0.01fF
C11236 divbuf_1/a_42720_n1600# divbuf_1/a_42750_n1540# 0.19fF
C11237 divbuf_0/a_27360_n1600# divbuf_0/a_27390_n1540# 0.19fF
C11238 divbuf_0/a_27390_n840# divbuf_0/a_27870_n840# 0.07fF
C11239 divbuf_0/a_32652_n240# divbuf_0/OUT4 0.04fF
C11240 pll_full_0/divbuf_0/a_21630_n840# pll_full_0/divbuf_0/a_22110_n840# 0.07fF
C11241 pll_full_0/divbuf_0/a_21012_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11242 pll_full_0/divbuf_0/a_21600_n1600# pll_full_0/divbuf_0/a_21630_n1540# 0.19fF
C11243 divbuf_1/a_40320_n1600# divbuf_1/a_40350_n840# 0.04fF
C11244 pd_div_0/divbuf_0/a_4392_170# pd_div_0/divbuf_0/a_3912_170# 0.07fF
C11245 pd_div_0/divbuf_0/a_13252_170# pd_div_0/divbuf_0/a_13742_170# 0.07fF
C11246 pd_div_0/pd_0/tspc_r_1/Qbar pd_div_0/pd_0/and_pd_0/Z1 0.02fF
C11247 ro_div_0/divbuf_0/a_41760_n1600# ro_div_0/divbuf_0/a_41790_n840# 0.04fF
C11248 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11249 pll_full_0/divbuf_1/a_11312_170# pll_full_0/divbuf_1/a_11802_170# 0.07fF
C11250 divbuf_3/a_18092_170# divbuf_3/OUT4 0.19fF
C11251 divbuf_3/a_31200_n1600# divbuf_3/a_31230_n840# 0.04fF
C11252 divbuf_1/a_34590_n1540# divbuf_1/a_35070_n1540# 0.11fF
C11253 pd_div_0/divbuf_0/a_39360_n1600# pd_div_0/divbuf_0/a_39840_n1600# 0.26fF
C11254 pd_div_0/divbuf_0/a_30232_n240# pd_div_0/divbuf_0/a_30270_n840# 0.05fF
C11255 pll_full_0/divbuf_1/a_44640_n1600# pll_full_0/divbuf_1/a_45120_n1600# 0.26fF
C11256 pll_full_0/divbuf_1/a_35562_n240# pll_full_0/divbuf_1/a_35550_n840# 0.05fF
C11257 divbuf_2/a_4800_n1600# divbuf_2/a_5280_n1600# 0.26fF
C11258 divbuf_2/a_58080_n1600# divbuf_2/a_58110_n1540# 0.19fF
C11259 divbuf_2/a_27870_n840# divbuf_2/a_27870_n1540# 0.01fF
C11260 divbuf_2/a_58110_n840# divbuf_2/a_58590_n840# 0.07fF
C11261 pd_div_0/divbuf_0/a_31710_n1540# pd_div_0/divbuf_0/a_32190_n1540# 0.11fF
C11262 pll_full_0/divbuf_1/a_36990_n1540# pll_full_0/divbuf_1/a_37470_n1540# 0.11fF
C11263 divbuf_1/a_18092_n240# divbuf_1/a_18582_n240# 0.04fF
C11264 divbuf_1/a_37992_170# divbuf_1/a_37992_n240# 0.01fF
C11265 divbuf_1/a_492_n240# divbuf_1/a_510_n840# 0.00fF
C11266 ro_div_0/divbuf_0/a_19562_n240# ro_div_0/divbuf_0/a_20042_n240# 0.05fF
C11267 ro_div_0/divbuf_0/a_39442_170# ro_div_0/divbuf_0/a_39442_n240# 0.01fF
C11268 pll_full_0/divbuf_0/a_19200_n1600# pll_full_0/divbuf_0/OUT4 0.00fF
C11269 divbuf_3/a_8272_n240# divbuf_3/a_8762_n240# 0.04fF
C11270 divbuf_3/a_28772_170# divbuf_3/a_28772_n240# 0.01fF
C11271 divbuf_1/a_29790_n840# divbuf_1/a_30270_n840# 0.07fF
C11272 pd_div_0/divbuf_0/a_3912_170# pd_div_0/divbuf_0/a_3912_n240# 0.01fF
C11273 ro_div_0/divbuf_0/a_31200_n1600# ro_div_0/divbuf_0/a_31230_n1540# 0.19fF
C11274 ro_div_0/divbuf_0/a_31230_n840# ro_div_0/divbuf_0/a_31710_n840# 0.07fF
C11275 ro_div_0/divbuf_0/a_990_n840# ro_div_0/divbuf_0/a_990_n1540# 0.01fF
C11276 ro_div_0/divbuf_0/a_40412_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11277 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C11278 divbuf_3/a_20670_n840# divbuf_3/a_21150_n840# 0.07fF
C11279 divbuf_3/a_19072_n240# divbuf_3/OUT4 0.04fF
C11280 divbuf_3/a_20640_n1600# divbuf_3/a_20670_n1540# 0.19fF
C11281 pd_div_0/divbuf_0/a_29280_n1600# pd_div_0/divbuf_0/a_29310_n840# 0.04fF
C11282 pd_div_0/divbuf_0/a_11802_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11283 pll_full_0/divbuf_1/a_24892_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11284 pll_full_0/divbuf_1/a_34560_n1600# pll_full_0/divbuf_1/a_34590_n840# 0.04fF
C11285 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C11286 divbuf_2/a_15672_n240# divbuf_2/a_15390_n840# 0.01fF
C11287 ashish_0/a_150_0# ashish_0/von 9.14fF
C11288 divbuf_0/a_4392_n240# divbuf_0/a_4350_n840# 0.04fF
C11289 divbuf_0/a_13920_n1600# divbuf_0/a_14400_n1600# 0.26fF
C11290 divbuf_1/a_52350_n840# divbuf_1/a_52350_n1540# 0.01fF
C11291 pll_full_0/divbuf_0/a_8160_n1600# pll_full_0/divbuf_0/a_8640_n1600# 0.26fF
C11292 divbuf_0/a_36990_n840# divbuf_0/a_36990_n1540# 0.01fF
C11293 divbuf_0/a_6270_n1540# divbuf_0/a_6750_n1540# 0.11fF
C11294 pll_full_0/divbuf_0/a_510_n1540# pll_full_0/divbuf_0/a_990_n1540# 0.11fF
C11295 pll_full_0/divbuf_0/a_31230_n840# pll_full_0/divbuf_0/a_31230_n1540# 0.01fF
C11296 pd_div_0/divbuf_0/a_26832_170# pd_div_0/divbuf_0/a_26832_n240# 0.01fF
C11297 pd_div_0/divbuf_0/a_6332_n240# pd_div_0/divbuf_0/a_6822_n240# 0.04fF
C11298 pll_full_0/divbuf_1/a_12282_n240# pll_full_0/divbuf_1/a_12772_n240# 0.04fF
C11299 pll_full_0/divbuf_1/a_32172_170# pll_full_0/divbuf_1/a_32172_n240# 0.01fF
C11300 divbuf_2/a_11312_170# divbuf_2/a_11802_170# 0.07fF
C11301 pd_div_0/divbuf_0/a_18750_n840# pd_div_0/divbuf_0/a_19230_n840# 0.07fF
C11302 pd_div_0/divbuf_0/a_15182_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11303 pd_div_0/divbuf_0/a_18720_n1600# pd_div_0/divbuf_0/a_18750_n1540# 0.19fF
C11304 pll_full_0/divbuf_1/a_25862_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11305 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/a_24030_n1540# 0.19fF
C11306 pll_full_0/divbuf_1/a_24030_n840# pll_full_0/divbuf_1/a_24510_n840# 0.07fF
C11307 divbuf_2/a_44640_n1600# divbuf_2/a_45120_n1600# 0.26fF
C11308 divbuf_2/a_35562_n240# divbuf_2/a_35550_n840# 0.05fF
C11309 divbuf_0/a_3840_n1600# divbuf_0/a_3870_n840# 0.04fF
C11310 divbuf_2/a_36990_n1540# divbuf_2/a_37470_n1540# 0.11fF
C11311 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C11312 divbuf_1/a_16320_n1600# divbuf_1/a_16800_n1600# 0.26fF
C11313 divbuf_1/a_6822_n240# divbuf_1/a_6750_n840# 0.03fF
C11314 ro_div_0/divbuf_0/a_8272_n240# ro_div_0/divbuf_0/a_8190_n840# 0.03fF
C11315 ro_div_0/divbuf_0/a_17760_n1600# ro_div_0/divbuf_0/a_18240_n1600# 0.26fF
C11316 divbuf_3/a_7200_n1600# divbuf_3/a_7680_n1600# 0.26fF
C11317 divbuf_1/a_8670_n1540# divbuf_1/a_9150_n1540# 0.11fF
C11318 ro_div_0/divbuf_0/a_40830_n840# ro_div_0/divbuf_0/a_40830_n1540# 0.01fF
C11319 ro_div_0/divbuf_0/a_10110_n1540# ro_div_0/divbuf_0/a_10590_n1540# 0.11fF
C11320 divbuf_3/a_30270_n840# divbuf_3/a_30270_n1540# 0.01fF
C11321 divbuf_3/a_60510_n840# divbuf_3/a_60990_n840# 0.07fF
C11322 divbuf_3/a_60480_n1600# divbuf_3/a_60510_n1540# 0.19fF
C11323 pd_div_0/divbuf_0/a_13440_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C11324 divbuf_0/a_4392_170# divbuf_0/a_4392_n240# 0.01fF
C11325 divbuf_0/a_20532_170# divbuf_0/a_21012_170# 0.07fF
C11326 pll_full_0/divbuf_1/a_24000_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C11327 pll_full_0/divbuf_0/a_8272_170# pll_full_0/divbuf_0/a_8272_n240# 0.01fF
C11328 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/a_16642_170# 0.07fF
C11329 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C11330 divbuf_2/a_24892_170# divbuf_2/OUT4 0.19fF
C11331 divbuf_2/a_34560_n1600# divbuf_2/a_34590_n840# 0.04fF
C11332 divbuf_1/a_34112_170# divbuf_1/OUT4 0.19fF
C11333 gnd pll_full_0/divider_0/nor_1/A 1.05fF
C11334 pd_div_0/divider_0/tspc_1/Z2 gnd 0.16fF
C11335 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/clk 0.11fF
C11336 divbuf_0/a_53760_n1600# divbuf_0/a_54240_n1600# 0.26fF
C11337 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C11338 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/D 0.32fF
C11339 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C11340 pll_full_0/divbuf_0/a_38962_n240# pll_full_0/divbuf_0/a_38910_n840# 0.04fF
C11341 pll_full_0/divbuf_0/a_48000_n1600# pll_full_0/divbuf_0/a_48480_n1600# 0.26fF
C11342 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/OUT3 0.19fF
C11343 divbuf_1/a_6240_n1600# divbuf_1/a_6270_n840# 0.04fF
C11344 ro_div_0/divbuf_0/a_7680_n1600# ro_div_0/divbuf_0/a_7710_n840# 0.04fF
C11345 divbuf_0/a_46110_n1540# divbuf_0/a_46590_n1540# 0.11fF
C11346 pll_full_0/divbuf_0/a_40350_n1540# pll_full_0/divbuf_0/a_40830_n1540# 0.11fF
C11347 divbuf_3/a_18092_n240# divbuf_3/a_17790_n840# 0.00fF
C11348 pd_div_0/divbuf_0/a_5280_n1600# pd_div_0/divbuf_0/a_5760_n1600# 0.26fF
C11349 pll_full_0/divbuf_1/a_10560_n1600# pll_full_0/divbuf_1/a_11040_n1600# 0.26fF
C11350 divbuf_2/a_12282_n240# divbuf_2/a_12772_n240# 0.04fF
C11351 divbuf_2/a_32172_170# divbuf_2/a_32172_n240# 0.01fF
C11352 pd_div_0/divbuf_0/a_58560_n1600# pd_div_0/divbuf_0/a_58590_n1540# 0.19fF
C11353 pd_div_0/divbuf_0/a_28350_n840# pd_div_0/divbuf_0/a_28350_n1540# 0.01fF
C11354 pd_div_0/divbuf_0/a_58590_n840# pd_div_0/divbuf_0/a_59070_n840# 0.07fF
C11355 pll_full_0/divbuf_1/a_2910_n1540# pll_full_0/divbuf_1/a_3390_n1540# 0.11fF
C11356 pll_full_0/divbuf_1/a_33630_n840# pll_full_0/divbuf_1/a_33630_n1540# 0.01fF
C11357 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/a_16152_n240# 0.01fF
C11358 divbuf_2/a_25862_n240# divbuf_2/OUT4 0.04fF
C11359 divbuf_2/a_24000_n1600# divbuf_2/a_24030_n1540# 0.19fF
C11360 divbuf_2/a_24030_n840# divbuf_2/a_24510_n840# 0.07fF
C11361 divbuf_1/a_35082_n240# divbuf_1/OUT4 0.04fF
C11362 ro_div_0/divbuf_0/a_24412_170# ro_div_0/divbuf_0/a_24892_170# 0.07fF
C11363 divbuf_1/a_19562_170# divbuf_1/a_20042_170# 0.07fF
C11364 divbuf_0/a_43680_n1600# divbuf_0/a_43710_n840# 0.04fF
C11365 divbuf_0/a_3912_n240# divbuf_0/OUT3 0.04fF
C11366 pll_full_0/divbuf_0/a_31682_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11367 pll_full_0/divbuf_0/a_37920_n1600# pll_full_0/divbuf_0/a_37950_n840# 0.04fF
C11368 divbuf_3/a_13742_170# divbuf_3/a_14222_170# 0.07fF
C11369 divbuf_1/a_56160_n1600# divbuf_1/a_56640_n1600# 0.26fF
C11370 ro_div_0/divbuf_0/a_57600_n1600# ro_div_0/divbuf_0/a_58080_n1600# 0.26fF
C11371 ro_div_0/divbuf_0/a_12282_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11372 divbuf_3/a_37992_n240# divbuf_3/a_37950_n840# 0.04fF
C11373 divbuf_3/a_47040_n1600# divbuf_3/a_47520_n1600# 0.26fF
C11374 pd_div_0/divbuf_0/a_16152_n240# pd_div_0/divbuf_0/a_15870_n840# 0.01fF
C11375 ro_div_0/divbuf_0/a_49950_n1540# ro_div_0/divbuf_0/a_50430_n1540# 0.11fF
C11376 pll_full_0/divbuf_1/a_480_n1600# pll_full_0/divbuf_1/a_510_n840# 0.04fF
C11377 divbuf_3/a_39390_n1540# divbuf_3/a_39870_n1540# 0.11fF
C11378 divbuf_0/a_21502_n240# divbuf_0/a_21982_n240# 0.05fF
C11379 divbuf_0/a_41382_170# divbuf_0/a_41382_n240# 0.01fF
C11380 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/a_16152_n240# 0.05fF
C11381 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_510_n840# 0.07fF
C11382 pll_full_0/divbuf_0/a_35562_170# pll_full_0/divbuf_0/a_35562_n240# 0.01fF
C11383 divbuf_2/a_24000_n1600# divbuf_2/OUT4 0.00fF
C11384 divbuf_1/a_48480_n1600# divbuf_1/a_48510_n1540# 0.19fF
C11385 divbuf_1/a_33120_n1600# divbuf_1/OUT4 0.01fF
C11386 divbuf_1/a_18270_n840# divbuf_1/a_18270_n1540# 0.01fF
C11387 divbuf_1/a_21982_170# divbuf_1/a_21982_n240# 0.01fF
C11388 divbuf_0/a_2910_n840# divbuf_0/a_2910_n1540# 0.01fF
C11389 divbuf_0/a_33150_n840# divbuf_0/a_33630_n840# 0.07fF
C11390 divbuf_0/a_33120_n1600# divbuf_0/a_33150_n1540# 0.19fF
C11391 pll_full_0/divbuf_0/a_32652_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11392 pll_full_0/divbuf_0/a_27390_n840# pll_full_0/divbuf_0/a_27870_n840# 0.07fF
C11393 pll_full_0/divbuf_0/a_27360_n1600# pll_full_0/divbuf_0/a_27390_n1540# 0.19fF
C11394 divbuf_1/a_46080_n1600# divbuf_1/a_46110_n840# 0.04fF
C11395 pd_div_0/divbuf_0/a_8762_170# pd_div_0/divbuf_0/a_9242_170# 0.07fF
C11396 ro_div_0/divbuf_0/a_47520_n1600# ro_div_0/divbuf_0/a_47550_n840# 0.04fF
C11397 ro_div_0/divbuf_0/a_11802_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11398 ro_div_0/divbuf_0/IN gnd 0.29fF
C11399 pll_full_0/divbuf_1/a_17122_170# pll_full_0/divbuf_1/a_17612_170# 0.07fF
C11400 divbuf_3/a_29742_170# divbuf_3/OUT4 0.19fF
C11401 divbuf_3/a_36960_n1600# divbuf_3/a_36990_n840# 0.04fF
C11402 divbuf_1/a_40350_n1540# divbuf_1/a_40830_n1540# 0.11fF
C11403 pd_div_0/divbuf_0/a_45120_n1600# pd_div_0/divbuf_0/a_45600_n1600# 0.26fF
C11404 pd_div_0/divbuf_0/a_36052_n240# pd_div_0/divbuf_0/a_36030_n840# 0.05fF
C11405 pll_full_0/divbuf_1/a_41382_n240# pll_full_0/divbuf_1/a_41310_n840# 0.03fF
C11406 pll_full_0/divbuf_1/a_50400_n1600# pll_full_0/divbuf_1/a_50880_n1600# 0.26fF
C11407 divbuf_2/a_10560_n1600# divbuf_2/a_11040_n1600# 0.26fF
C11408 divbuf_2/a_2910_n1540# divbuf_2/a_3390_n1540# 0.11fF
C11409 divbuf_2/a_33630_n840# divbuf_2/a_33630_n1540# 0.01fF
C11410 pd_div_0/divbuf_0/a_37470_n1540# pd_div_0/divbuf_0/a_37950_n1540# 0.11fF
C11411 pll_full_0/divbuf_1/a_42750_n1540# pll_full_0/divbuf_1/a_43230_n1540# 0.11fF
C11412 divbuf_1/a_23922_n240# divbuf_1/a_24412_n240# 0.04fF
C11413 ro_div_0/divbuf_0/a_25382_n240# ro_div_0/divbuf_0/a_25862_n240# 0.05fF
C11414 divbuf_3/a_14702_n240# divbuf_3/a_15182_n240# 0.05fF
C11415 divbuf_3/a_34592_170# divbuf_3/a_34592_n240# 0.01fF
C11416 divbuf_1/a_5310_n840# divbuf_1/a_5310_n1540# 0.01fF
C11417 divbuf_1/a_35550_n840# divbuf_1/a_36030_n840# 0.07fF
C11418 pd_div_0/divbuf_0/a_11312_170# pd_div_0/divbuf_0/a_11312_n240# 0.01fF
C11419 ro_div_0/divbuf_0/a_36990_n840# ro_div_0/divbuf_0/a_37470_n840# 0.07fF
C11420 ro_div_0/divbuf_0/a_6750_n840# ro_div_0/divbuf_0/a_6750_n1540# 0.01fF
C11421 ro_div_0/divbuf_0/a_10560_n1600# ro_div_0/divbuf_0/OUT3 0.01fF
C11422 ro_div_0/divbuf_0/a_36960_n1600# ro_div_0/divbuf_0/a_36990_n1540# 0.19fF
C11423 divbuf_3/a_26430_n840# divbuf_3/a_26910_n840# 0.07fF
C11424 divbuf_3/a_30712_n240# divbuf_3/OUT4 0.04fF
C11425 divbuf_3/a_26400_n1600# divbuf_3/a_26430_n1540# 0.19fF
C11426 pd_div_0/divbuf_0/a_25862_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11427 pd_div_0/divbuf_0/a_35040_n1600# pd_div_0/divbuf_0/a_35070_n840# 0.04fF
C11428 ro_div_0/divider_0/nor_1/Z1 ro_div_0/divider_0/and_0/A 0.80fF
C11429 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C11430 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/switch_1/vin 0.19fF
C11431 pll_full_0/divbuf_1/a_36532_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11432 pll_full_0/divbuf_1/a_40320_n1600# pll_full_0/divbuf_1/a_40350_n840# 0.04fF
C11433 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C11434 divbuf_2/a_480_n1600# divbuf_2/a_510_n840# 0.04fF
C11435 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C11436 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C11437 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C11438 divbuf_0/a_10212_n240# divbuf_0/a_10110_n840# 0.03fF
C11439 divbuf_0/a_19680_n1600# divbuf_0/a_20160_n1600# 0.26fF
C11440 pll_full_0/divbuf_0/a_13920_n1600# pll_full_0/divbuf_0/a_14400_n1600# 0.26fF
C11441 pll_full_0/divbuf_0/a_4392_n240# pll_full_0/divbuf_0/a_4350_n840# 0.04fF
C11442 divbuf_1/a_58110_n840# divbuf_1/a_58110_n1540# 0.01fF
C11443 divbuf_0/a_42750_n840# divbuf_0/a_42750_n1540# 0.01fF
C11444 divbuf_0/a_12030_n1540# divbuf_0/a_12510_n1540# 0.11fF
C11445 pll_full_0/divbuf_0/a_6270_n1540# pll_full_0/divbuf_0/a_6750_n1540# 0.11fF
C11446 pll_full_0/divbuf_0/a_36990_n840# pll_full_0/divbuf_0/a_36990_n1540# 0.01fF
C11447 pd_div_0/divbuf_0/a_32652_170# pd_div_0/divbuf_0/a_32652_n240# 0.01fF
C11448 pd_div_0/divbuf_0/a_12772_n240# pd_div_0/divbuf_0/a_13252_n240# 0.05fF
C11449 pll_full_0/divbuf_1/a_18092_n240# pll_full_0/divbuf_1/a_18582_n240# 0.04fF
C11450 pll_full_0/divbuf_1/a_37992_170# pll_full_0/divbuf_1/a_37992_n240# 0.01fF
C11451 divbuf_2/a_17122_170# divbuf_2/a_17612_170# 0.07fF
C11452 pd_div_0/divbuf_0/a_26832_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11453 pd_div_0/divbuf_0/a_24480_n1600# pd_div_0/divbuf_0/a_24510_n1540# 0.19fF
C11454 pd_div_0/divbuf_0/a_24510_n840# pd_div_0/divbuf_0/a_24990_n840# 0.07fF
C11455 pll_full_0/divbuf_1/a_37502_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11456 pll_full_0/divbuf_1/a_29790_n840# pll_full_0/divbuf_1/a_30270_n840# 0.07fF
C11457 pll_full_0/divbuf_1/a_29760_n1600# pll_full_0/divbuf_1/a_29790_n1540# 0.19fF
C11458 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C11459 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C11460 divbuf_2/a_41382_n240# divbuf_2/a_41310_n840# 0.03fF
C11461 divbuf_2/a_50400_n1600# divbuf_2/a_50880_n1600# 0.26fF
C11462 divbuf_1/a_4882_170# divbuf_1/OUT3 0.19fF
C11463 ro_div_0/divbuf_0/a_9242_170# ro_div_0/divbuf_0/a_9732_170# 0.07fF
C11464 divbuf_0/a_3422_170# divbuf_0/OUT3 0.23fF
C11465 divbuf_0/a_9600_n1600# divbuf_0/a_9630_n840# 0.04fF
C11466 divbuf_2/a_42750_n1540# divbuf_2/a_43230_n1540# 0.11fF
C11467 pd_div_0/divider_0/tspc_1/a_630_n680# pd_div_0/divider_0/nor_1/B 0.35fF
C11468 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C11469 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C11470 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C11471 pll_full_0/divbuf_0/a_3840_n1600# pll_full_0/divbuf_0/a_3870_n840# 0.04fF
C11472 divbuf_1/a_22080_n1600# divbuf_1/a_22560_n1600# 0.26fF
C11473 divbuf_1/a_12772_n240# divbuf_1/a_12990_n840# 0.02fF
C11474 ro_div_0/divbuf_0/a_23520_n1600# ro_div_0/divbuf_0/a_24000_n1600# 0.26fF
C11475 ro_div_0/divbuf_0/a_14222_n240# ro_div_0/divbuf_0/a_14430_n840# 0.02fF
C11476 divbuf_0/a_60990_n840# divbuf_0/OUT5 0.04fF
C11477 divbuf_3/a_12960_n1600# divbuf_3/a_13440_n1600# 0.26fF
C11478 divbuf_3/a_3422_n240# divbuf_3/a_3390_n840# 0.05fF
C11479 ro_div_0/divbuf_0/a_46590_n840# ro_div_0/divbuf_0/a_46590_n1540# 0.01fF
C11480 ro_div_0/divbuf_0/a_15870_n1540# ro_div_0/divbuf_0/a_16350_n1540# 0.11fF
C11481 divbuf_3/a_5310_n1540# divbuf_3/a_5790_n1540# 0.11fF
C11482 divbuf_3/a_36030_n840# divbuf_3/a_36030_n1540# 0.01fF
C11483 pd_div_0/divbuf_0/a_24960_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C11484 divbuf_0/a_26352_170# divbuf_0/a_26832_170# 0.07fF
C11485 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/OUT4 0.00fF
C11486 pll_full_0/divbuf_0/a_2322_170# pll_full_0/divbuf_0/a_2322_n240# 0.01fF
C11487 pll_full_0/divbuf_0/a_20532_170# pll_full_0/divbuf_0/a_21012_170# 0.07fF
C11488 divbuf_2/a_36532_170# divbuf_2/OUT4 0.19fF
C11489 divbuf_2/a_40320_n1600# divbuf_2/a_40350_n840# 0.04fF
C11490 divbuf_1/a_6332_n240# divbuf_1/OUT3 0.04fF
C11491 divbuf_0/a_59520_n1600# divbuf_0/a_60000_n1600# 0.26fF
C11492 divbuf_1/a_4392_170# divbuf_1/a_4392_n240# 0.01fF
C11493 pd_div_0/divider_0/prescaler_0/tspc_0/Q pd_div_0/divider_0/prescaler_0/tspc_2/D 0.04fF
C11494 pd_div_0/divider_0/prescaler_0/tspc_1/Q pd_div_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C11495 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C11496 pll_full_0/divbuf_0/a_53760_n1600# pll_full_0/divbuf_0/a_54240_n1600# 0.26fF
C11497 divbuf_1/a_12000_n1600# divbuf_1/a_12030_n840# 0.04fF
C11498 ro_div_0/divbuf_0/a_13440_n1600# ro_div_0/divbuf_0/a_13470_n840# 0.04fF
C11499 divbuf_0/a_51870_n1540# divbuf_0/a_52350_n1540# 0.11fF
C11500 pll_full_0/divbuf_0/a_46110_n1540# pll_full_0/divbuf_0/a_46590_n1540# 0.11fF
C11501 divbuf_3/a_2880_n1600# divbuf_3/a_2910_n840# 0.04fF
C11502 pd_div_0/divbuf_0/a_11040_n1600# pd_div_0/divbuf_0/a_11520_n1600# 0.26fF
C11503 pll_full_0/divbuf_1/a_16320_n1600# pll_full_0/divbuf_1/a_16800_n1600# 0.26fF
C11504 pll_full_0/divbuf_1/a_6822_n240# pll_full_0/divbuf_1/a_6750_n840# 0.03fF
C11505 divbuf_2/a_18092_n240# divbuf_2/a_18582_n240# 0.04fF
C11506 divbuf_2/a_37992_170# divbuf_2/a_37992_n240# 0.01fF
C11507 pd_div_0/divbuf_0/a_3390_n1540# pd_div_0/divbuf_0/a_3870_n1540# 0.11fF
C11508 pd_div_0/divbuf_0/a_34110_n840# pd_div_0/divbuf_0/a_34110_n1540# 0.01fF
C11509 pll_full_0/divbuf_1/a_8670_n1540# pll_full_0/divbuf_1/a_9150_n1540# 0.11fF
C11510 pll_full_0/divbuf_1/a_39390_n840# pll_full_0/divbuf_1/a_39390_n1540# 0.01fF
C11511 divbuf_2/a_37502_n240# divbuf_2/OUT4 0.04fF
C11512 divbuf_2/a_29790_n840# divbuf_2/a_30270_n840# 0.07fF
C11513 divbuf_2/a_29760_n1600# divbuf_2/a_29790_n1540# 0.19fF
C11514 ro_div_0/divbuf_0/a_30232_170# ro_div_0/divbuf_0/a_30712_170# 0.07fF
C11515 divbuf_3/a_19562_170# divbuf_3/a_20042_170# 0.07fF
C11516 divbuf_1/a_15182_170# divbuf_1/a_15182_n240# 0.01fF
C11517 divbuf_1/a_25382_170# divbuf_1/a_25862_170# 0.07fF
C11518 divbuf_0/a_49440_n1600# divbuf_0/a_49470_n840# 0.04fF
C11519 divbuf_0/a_15672_n240# divbuf_0/OUT4 0.04fF
C11520 pll_full_0/divbuf_0/a_3912_n240# pll_full_0/divbuf_0/OUT3 0.04fF
C11521 pll_full_0/divbuf_0/a_43680_n1600# pll_full_0/divbuf_0/a_43710_n840# 0.04fF
C11522 divbuf_1/a_1440_n1600# divbuf_1/a_1470_n1540# 0.19fF
C11523 divbuf_1/a_1470_n840# divbuf_1/a_1950_n840# 0.07fF
C11524 ro_div_0/divbuf_0/a_2910_n840# ro_div_0/divbuf_0/a_3390_n840# 0.07fF
C11525 ro_div_0/divbuf_0/a_2880_n1600# ro_div_0/divbuf_0/a_2910_n1540# 0.19fF
C11526 ro_div_0/divbuf_0/a_22472_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11527 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 0.94fF
C11528 divbuf_3/a_52800_n1600# divbuf_3/a_53280_n1600# 0.26fF
C11529 divbuf_3/a_492_n240# divbuf_3/OUT2 0.42fF
C11530 pd_div_0/divbuf_0/a_960_n1600# pd_div_0/divbuf_0/a_990_n840# 0.04fF
C11531 ro_div_0/divbuf_0/a_55710_n1540# ro_div_0/divbuf_0/a_56190_n1540# 0.11fF
C11532 pll_full_0/divbuf_1/a_6240_n1600# pll_full_0/divbuf_1/a_6270_n840# 0.04fF
C11533 divbuf_3/a_45150_n1540# divbuf_3/a_45630_n1540# 0.11fF
C11534 divbuf_0/a_27322_n240# divbuf_0/a_27802_n240# 0.05fF
C11535 pll_full_0/divbuf_0/a_41382_170# pll_full_0/divbuf_0/a_41382_n240# 0.01fF
C11536 pll_full_0/divbuf_0/a_21502_n240# pll_full_0/divbuf_0/a_21982_n240# 0.05fF
C11537 divbuf_2/a_35520_n1600# divbuf_2/OUT4 0.00fF
C11538 divbuf_1/a_24030_n840# divbuf_1/a_24030_n1540# 0.01fF
C11539 divbuf_1/a_54240_n1600# divbuf_1/a_54270_n1540# 0.19fF
C11540 divbuf_1/a_27802_170# divbuf_1/a_27802_n240# 0.01fF
C11541 divbuf_0/a_38880_n1600# divbuf_0/a_38910_n1540# 0.19fF
C11542 divbuf_0/a_38910_n840# divbuf_0/a_39390_n840# 0.07fF
C11543 divbuf_0/a_8670_n840# divbuf_0/a_8670_n1540# 0.01fF
C11544 pll_full_0/divbuf_0/a_2910_n840# pll_full_0/divbuf_0/a_2910_n1540# 0.01fF
C11545 pll_full_0/divbuf_0/a_33150_n840# pll_full_0/divbuf_0/a_33630_n840# 0.07fF
C11546 pll_full_0/divbuf_0/a_33120_n1600# pll_full_0/divbuf_0/a_33150_n1540# 0.19fF
C11547 divbuf_1/a_51840_n1600# divbuf_1/a_51870_n840# 0.04fF
C11548 pd_div_0/divbuf_0/a_17612_170# pd_div_0/divbuf_0/a_18092_170# 0.07fF
C11549 ro_div_0/ro_complete_0/cbank_2/v ro_div_0/divider_0/clk 1.36fF
C11550 ro_div_0/divbuf_0/a_53280_n1600# ro_div_0/divbuf_0/a_53310_n840# 0.04fF
C11551 ro_div_0/divbuf_0/a_23442_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11552 pll_full_0/divbuf_1/a_2322_170# pll_full_0/divbuf_1/a_2322_n240# 0.01fF
C11553 pll_full_0/divbuf_1/a_22952_170# pll_full_0/divbuf_1/a_23442_170# 0.07fF
C11554 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C11555 divbuf_3/a_1842_n240# divbuf_3/OUT2 0.04fF
C11556 divbuf_3/a_41382_170# divbuf_3/OUT4 0.19fF
C11557 divbuf_3/a_42720_n1600# divbuf_3/a_42750_n840# 0.04fF
C11558 divbuf_1/a_46110_n1540# divbuf_1/a_46590_n1540# 0.11fF
C11559 pd_div_0/divbuf_0/a_50880_n1600# pd_div_0/divbuf_0/a_51360_n1600# 0.26fF
C11560 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# ro_div_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C11561 pll_full_0/divbuf_1/a_56160_n1600# pll_full_0/divbuf_1/a_56640_n1600# 0.26fF
C11562 pll_full_0/divbuf_1/a_7792_170# pll_full_0/divbuf_1/OUT3 0.19fF
C11563 divbuf_2/a_16320_n1600# divbuf_2/a_16800_n1600# 0.26fF
C11564 divbuf_2/a_6822_n240# divbuf_2/a_6750_n840# 0.03fF
C11565 pd_div_0/divbuf_0/a_43230_n1540# pd_div_0/divbuf_0/a_43710_n1540# 0.11fF
C11566 divbuf_2/a_8670_n1540# divbuf_2/a_9150_n1540# 0.11fF
C11567 divbuf_2/a_39390_n840# divbuf_2/a_39390_n1540# 0.01fF
C11568 pll_full_0/divbuf_1/a_48510_n1540# pll_full_0/divbuf_1/a_48990_n1540# 0.11fF
C11569 ro_div_0/divbuf_0/a_31202_n240# ro_div_0/divbuf_0/a_31682_n240# 0.05fF
C11570 divbuf_1/a_29742_n240# divbuf_1/a_30232_n240# 0.04fF
C11571 divbuf_3/a_40412_170# divbuf_3/a_40412_n240# 0.01fF
C11572 divbuf_3/a_20532_n240# divbuf_3/a_21012_n240# 0.05fF
C11573 divbuf_1/a_11070_n840# divbuf_1/a_11070_n1540# 0.01fF
C11574 divbuf_1/a_41310_n840# divbuf_1/a_41790_n840# 0.07fF
C11575 ro_div_0/divbuf_0/a_42720_n1600# ro_div_0/divbuf_0/a_42750_n1540# 0.19fF
C11576 ro_div_0/divbuf_0/a_42750_n840# ro_div_0/divbuf_0/a_43230_n840# 0.07fF
C11577 ro_div_0/divbuf_0/a_12510_n840# ro_div_0/divbuf_0/a_12510_n1540# 0.01fF
C11578 ro_div_0/divbuf_0/a_21600_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C11579 divbuf_3/a_1950_n840# divbuf_3/a_1950_n1540# 0.01fF
C11580 divbuf_3/a_32190_n840# divbuf_3/a_32670_n840# 0.07fF
C11581 divbuf_3/a_32160_n1600# divbuf_3/a_32190_n1540# 0.19fF
C11582 divbuf_3/a_1440_n1600# divbuf_3/OUT2 0.01fF
C11583 pd_div_0/divbuf_0/a_37502_170# pd_div_0/divbuf_0/OUT4 0.19fF
C11584 pd_div_0/divbuf_0/a_40800_n1600# pd_div_0/divbuf_0/a_40830_n840# 0.04fF
C11585 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C11586 pll_full_0/divbuf_1/a_8762_n240# pll_full_0/divbuf_1/OUT3 0.04fF
C11587 pll_full_0/divbuf_1/a_46080_n1600# pll_full_0/divbuf_1/a_46110_n840# 0.04fF
C11588 divbuf_2/a_6240_n1600# divbuf_2/a_6270_n840# 0.04fF
C11589 divbuf_1/a_17122_170# divbuf_1/OUT4 0.19fF
C11590 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C11591 divbuf_0/a_16152_n240# divbuf_0/a_16350_n840# 0.02fF
C11592 divbuf_0/a_25440_n1600# divbuf_0/a_25920_n1600# 0.26fF
C11593 pll_full_0/divbuf_0/a_19680_n1600# pll_full_0/divbuf_0/a_20160_n1600# 0.26fF
C11594 pll_full_0/divbuf_0/a_10212_n240# pll_full_0/divbuf_0/a_10110_n840# 0.03fF
C11595 divbuf_0/a_48510_n840# divbuf_0/a_48510_n1540# 0.01fF
C11596 divbuf_0/a_17790_n1540# divbuf_0/a_18270_n1540# 0.11fF
C11597 pll_full_0/divbuf_0/a_12030_n1540# pll_full_0/divbuf_0/a_12510_n1540# 0.11fF
C11598 pll_full_0/divbuf_0/a_42750_n840# pll_full_0/divbuf_0/a_42750_n1540# 0.01fF
C11599 pd_div_0/divbuf_0/a_38472_170# pd_div_0/divbuf_0/a_38472_n240# 0.01fF
C11600 pd_div_0/divbuf_0/a_18582_n240# pd_div_0/divbuf_0/a_19072_n240# 0.04fF
C11601 pll_full_0/divbuf_1/a_23922_n240# pll_full_0/divbuf_1/a_24412_n240# 0.04fF
C11602 divbuf_2/a_2322_170# divbuf_2/a_2322_n240# 0.01fF
C11603 divbuf_2/a_22952_170# divbuf_2/a_23442_170# 0.07fF
C11604 pd_div_0/divbuf_0/a_38472_n240# pd_div_0/divbuf_0/OUT4 0.04fF
C11605 pd_div_0/divbuf_0/a_30270_n840# pd_div_0/divbuf_0/a_30750_n840# 0.07fF
C11606 pd_div_0/divbuf_0/a_30240_n1600# pd_div_0/divbuf_0/a_30270_n1540# 0.19fF
C11607 divbuf_0/a_19072_170# divbuf_0/a_19072_n240# 0.01fF
C11608 pll_full_0/divbuf_1/a_35520_n1600# pll_full_0/divbuf_1/a_35550_n1540# 0.19fF
C11609 pll_full_0/divbuf_1/a_5310_n840# pll_full_0/divbuf_1/a_5310_n1540# 0.01fF
C11610 pll_full_0/divbuf_1/a_35550_n840# pll_full_0/divbuf_1/a_36030_n840# 0.07fF
C11611 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C11612 divbuf_2/a_56160_n1600# divbuf_2/a_56640_n1600# 0.26fF
C11613 divbuf_2/a_7792_170# divbuf_2/OUT3 0.19fF
C11614 divbuf_0/a_15360_n1600# divbuf_0/a_15390_n840# 0.04fF
C11615 gnd pll_full_0/divider_0/tspc_0/Z4 0.44fF
C11616 pll_full_0/divbuf_0/a_9600_n1600# pll_full_0/divbuf_0/a_9630_n840# 0.04fF
C11617 divbuf_2/a_48510_n1540# divbuf_2/a_48990_n1540# 0.11fF
C11618 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C11619 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.00fF
C11620 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/A 0.35fF
C11621 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C11622 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C11623 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C11624 divbuf_1/a_27840_n1600# divbuf_1/a_28320_n1600# 0.26fF
C11625 divbuf_1/a_18582_n240# divbuf_1/a_18750_n840# 0.02fF
C11626 ro_div_0/divbuf_0/a_20042_n240# ro_div_0/divbuf_0/a_20190_n840# 0.03fF
C11627 ro_div_0/divbuf_0/a_29280_n1600# ro_div_0/divbuf_0/a_29760_n1600# 0.26fF
C11628 pll_full_0/divbuf_0/a_60990_n840# pll_full_0/divbuf_0/OUT5 0.04fF
C11629 divbuf_3/a_18720_n1600# divbuf_3/a_19200_n1600# 0.26fF
C11630 divbuf_3/a_9242_n240# divbuf_3/a_9150_n840# 0.03fF
C11631 ro_div_0/divbuf_0/a_52350_n840# ro_div_0/divbuf_0/a_52350_n1540# 0.01fF
C11632 ro_div_0/divbuf_0/a_21630_n1540# ro_div_0/divbuf_0/a_22110_n1540# 0.11fF
C11633 divbuf_3/a_11070_n1540# divbuf_3/a_11550_n1540# 0.11fF
C11634 divbuf_3/a_41790_n840# divbuf_3/a_41790_n1540# 0.01fF
C11635 pd_div_0/divbuf_0/a_36480_n1600# pd_div_0/divbuf_0/OUT4 0.00fF
C11636 divbuf_0/a_32172_170# divbuf_0/a_32652_170# 0.07fF
C11637 pll_full_0/divbuf_0/a_13252_170# pll_full_0/divbuf_0/a_13252_n240# 0.01fF
C11638 pll_full_0/divbuf_0/a_26352_170# pll_full_0/divbuf_0/a_26832_170# 0.07fF
C11639 divbuf_2/a_8762_n240# divbuf_2/OUT3 0.04fF
C11640 divbuf_2/a_46080_n1600# divbuf_2/a_46110_n840# 0.04fF
C11641 divbuf_1/a_18092_n240# divbuf_1/OUT4 0.04fF
C11642 divbuf_1/a_20160_n1600# divbuf_1/a_20190_n1540# 0.19fF
C11643 divbuf_0/a_4800_n1600# divbuf_0/a_4830_n1540# 0.19fF
C11644 divbuf_0/a_26352_170# divbuf_0/OUT4 0.19fF
C11645 divbuf_0/a_4830_n840# divbuf_0/a_5310_n840# 0.07fF
C11646 pd_div_0/divider_0/tspc_2/Z3 pd_div_0/divider_0/tspc_2/Z4 0.65fF
C11647 pll_full_0/divbuf_0/a_16152_170# pll_full_0/divbuf_0/OUT4 0.19fF
C11648 pll_full_0/divbuf_0/a_59520_n1600# pll_full_0/divbuf_0/a_60000_n1600# 0.26fF
C11649 divbuf_1/a_17760_n1600# divbuf_1/a_17790_n840# 0.04fF
C11650 ro_div_0/divbuf_0/a_19200_n1600# ro_div_0/divbuf_0/a_19230_n840# 0.04fF
C11651 divbuf_0/a_57630_n1540# divbuf_0/a_58110_n1540# 0.11fF
C11652 pll_full_0/divbuf_0/a_51870_n1540# pll_full_0/divbuf_0/a_52350_n1540# 0.11fF
C11653 divbuf_3/a_8640_n1600# divbuf_3/a_8670_n840# 0.04fF
C11654 pd_div_0/divbuf_0/a_16800_n1600# pd_div_0/divbuf_0/a_17280_n1600# 0.26fF
C11655 pd_div_0/div pd_div_0/divbuf_0/a_510_n1540# 0.11fF
C11656 pd_div_0/divbuf_0/a_7302_n240# pd_div_0/divbuf_0/a_7230_n840# 0.03fF
C11657 pll_full_0/divbuf_1/a_22080_n1600# pll_full_0/divbuf_1/a_22560_n1600# 0.26fF
C11658 pll_full_0/divbuf_1/a_12772_n240# pll_full_0/divbuf_1/a_12990_n840# 0.02fF
C11659 divbuf_2/a_23922_n240# divbuf_2/a_24412_n240# 0.04fF
C11660 pd_div_0/divbuf_0/a_9150_n1540# pd_div_0/divbuf_0/a_9630_n1540# 0.11fF
C11661 pd_div_0/divbuf_0/a_39870_n840# pd_div_0/divbuf_0/a_39870_n1540# 0.01fF
C11662 pll_full_0/divbuf_1/a_14430_n1540# pll_full_0/divbuf_1/a_14910_n1540# 0.11fF
C11663 pll_full_0/divbuf_1/a_45150_n840# pll_full_0/divbuf_1/a_45150_n1540# 0.01fF
C11664 divbuf_2/a_35520_n1600# divbuf_2/a_35550_n1540# 0.19fF
C11665 divbuf_2/a_5310_n840# divbuf_2/a_5310_n1540# 0.01fF
C11666 divbuf_2/a_35550_n840# divbuf_2/a_36030_n840# 0.07fF
C11667 ro_div_0/divbuf_0/a_36052_170# ro_div_0/divbuf_0/a_36532_170# 0.07fF
C11668 divbuf_0/a_55200_n1600# divbuf_0/a_55230_n840# 0.04fF
C11669 divbuf_0/a_27322_n240# divbuf_0/OUT4 0.04fF
C11670 divbuf_3/a_5362_170# divbuf_3/a_5362_n240# 0.01fF
C11671 divbuf_3/a_25382_170# divbuf_3/a_25862_170# 0.07fF
C11672 divbuf_1/a_34592_170# divbuf_1/a_35082_170# 0.07fF
C11673 divbuf_1/a_8762_170# divbuf_1/a_8762_n240# 0.01fF
C11674 pll_full_0/divbuf_0/a_15672_n240# pll_full_0/divbuf_0/OUT4 0.04fF
C11675 pll_full_0/divbuf_0/a_49440_n1600# pll_full_0/divbuf_0/a_49470_n840# 0.04fF
C11676 divbuf_1/a_7230_n840# divbuf_1/a_7710_n840# 0.07fF
C11677 divbuf_1/a_7200_n1600# divbuf_1/a_7230_n1540# 0.19fF
C11678 pd_div_0/pd_0/tspc_r_1/Z2 pd_div_0/pd_0/tspc_r_1/Z4 0.14fF
C11679 ro_div_0/divbuf_0/a_8640_n1600# ro_div_0/divbuf_0/a_8670_n1540# 0.19fF
C11680 ro_div_0/divbuf_0/a_34112_170# ro_div_0/divbuf_0/OUT4 0.19fF
C11681 ro_div_0/divbuf_0/a_8670_n840# ro_div_0/divbuf_0/a_9150_n840# 0.07fF
C11682 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 0.22fF
C11683 divbuf_3/a_12772_170# divbuf_3/OUT4 0.19fF
C11684 divbuf_3/a_58560_n1600# divbuf_3/a_59040_n1600# 0.26fF
C11685 pd_div_0/divbuf_0/a_6720_n1600# pd_div_0/divbuf_0/a_6750_n840# 0.04fF
C11686 pll_full_0/divbuf_1/a_12000_n1600# pll_full_0/divbuf_1/a_12030_n840# 0.04fF
C11687 divbuf_3/a_50910_n1540# divbuf_3/a_51390_n1540# 0.11fF
C11688 divbuf_0/a_33142_n240# divbuf_0/a_33622_n240# 0.05fF
C11689 pll_full_0/divbuf_0/a_27322_n240# pll_full_0/divbuf_0/a_27802_n240# 0.05fF
C11690 divbuf_1/a_29790_n840# divbuf_1/a_29790_n1540# 0.01fF
C11691 divbuf_1/a_60000_n1600# divbuf_1/a_60030_n1540# 0.19fF
C11692 divbuf_0/a_44670_n840# divbuf_0/a_45150_n840# 0.07fF
C11693 divbuf_0/a_14430_n840# divbuf_0/a_14430_n1540# 0.01fF
C11694 divbuf_0/a_44640_n1600# divbuf_0/a_44670_n1540# 0.19fF
C11695 pll_full_0/divbuf_0/a_8670_n840# pll_full_0/divbuf_0/a_8670_n1540# 0.01fF
C11696 pll_full_0/divbuf_0/a_38910_n840# pll_full_0/divbuf_0/a_39390_n840# 0.07fF
C11697 pll_full_0/divbuf_0/a_38880_n1600# pll_full_0/divbuf_0/a_38910_n1540# 0.19fF
C11698 divbuf_1/a_57600_n1600# divbuf_1/a_57630_n840# 0.04fF
C11699 pd_div_0/divbuf_0/a_23442_170# pd_div_0/divbuf_0/a_23922_170# 0.07fF
C11700 ro_div_0/divbuf_0/a_59040_n1600# ro_div_0/divbuf_0/a_59070_n840# 0.04fF
C11701 ro_div_0/divbuf_0/a_35082_n240# ro_div_0/divbuf_0/OUT4 0.04fF
C11702 pll_full_0/divbuf_1/a_8762_170# pll_full_0/divbuf_1/a_8762_n240# 0.01fF
C11703 pll_full_0/divbuf_1/a_28772_170# pll_full_0/divbuf_1/a_29262_170# 0.07fF
C11704 divbuf_3/a_13742_n240# divbuf_3/OUT4 0.04fF
C11705 divbuf_3/a_48480_n1600# divbuf_3/a_48510_n840# 0.04fF
C11706 divbuf_1/a_51870_n1540# divbuf_1/a_52350_n1540# 0.11fF
C11707 pd_div_0/divbuf_0/a_56640_n1600# pd_div_0/divbuf_0/a_57120_n1600# 0.26fF
C11708 ro_div_0/divider_0/tspc_0/Q ro_div_0/divider_0/nor_1/A 0.55fF
C11709 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C11710 pll_full_0/divbuf_1/a_19562_170# pll_full_0/divbuf_1/OUT4 0.19fF
C11711 pll_full_0/divbuf_1/a_1440_n1600# pll_full_0/divbuf_1/a_1470_n1540# 0.19fF
C11712 pll_full_0/divbuf_1/a_1470_n840# pll_full_0/divbuf_1/a_1950_n840# 0.07fF
C11713 divbuf_2/a_22080_n1600# divbuf_2/a_22560_n1600# 0.26fF
C11714 divbuf_2/a_12772_n240# divbuf_2/a_12990_n840# 0.02fF
C11715 pd_div_0/divbuf_0/a_48990_n1540# pd_div_0/divbuf_0/a_49470_n1540# 0.11fF
C11716 divbuf_0/a_1352_n240# divbuf_0/a_1470_n840# 0.03fF
C11717 divbuf_2/a_14430_n1540# divbuf_2/a_14910_n1540# 0.11fF
C11718 divbuf_2/a_45150_n840# divbuf_2/a_45150_n1540# 0.01fF
C11719 pll_full_0/divbuf_1/a_54270_n1540# pll_full_0/divbuf_1/a_54750_n1540# 0.11fF
C11720 ro_div_0/divbuf_0/a_37022_n240# ro_div_0/divbuf_0/a_37502_n240# 0.05fF
C11721 divbuf_1/a_35562_n240# divbuf_1/a_36052_n240# 0.04fF
C11722 divbuf_3/a_26352_n240# divbuf_3/a_26832_n240# 0.05fF
C11723 divbuf_1/a_47070_n840# divbuf_1/a_47550_n840# 0.07fF
C11724 ro_div_0/divbuf_0/a_48510_n840# ro_div_0/divbuf_0/a_48990_n840# 0.07fF
C11725 ro_div_0/divbuf_0/a_18270_n840# ro_div_0/divbuf_0/a_18270_n1540# 0.01fF
C11726 ro_div_0/divbuf_0/a_33120_n1600# ro_div_0/divbuf_0/OUT4 0.01fF
C11727 ro_div_0/divbuf_0/a_48480_n1600# ro_div_0/divbuf_0/a_48510_n1540# 0.19fF
C11728 divbuf_3/a_12000_n1600# divbuf_3/OUT4 0.00fF
C11729 divbuf_3/a_7710_n840# divbuf_3/a_7710_n1540# 0.01fF
C11730 divbuf_3/a_37950_n840# divbuf_3/a_38430_n840# 0.07fF
C11731 divbuf_3/a_37920_n1600# divbuf_3/a_37950_n1540# 0.19fF
C11732 pd_div_0/divbuf_0/a_9732_n240# pd_div_0/divbuf_0/OUT3 0.04fF
C11733 pd_div_0/divbuf_0/a_46560_n1600# pd_div_0/divbuf_0/a_46590_n840# 0.04fF
C11734 ro_div_0/divider_0/nor_0/B ro_div_0/divider_0/tspc_2/Z1 0.03fF
C11735 ro_div_0/divider_0/tspc_2/a_630_n680# ro_div_0/divider_0/tspc_2/Z3 0.05fF
C11736 pll_full_0/divbuf_1/a_20532_n240# pll_full_0/divbuf_1/OUT4 0.04fF
C11737 pll_full_0/divbuf_1/a_51840_n1600# pll_full_0/divbuf_1/a_51870_n840# 0.04fF
C11738 pll_full_0/divbuf_0/a_4882_170# pll_full_0/divbuf_0/a_5362_170# 0.07fF
C11739 divbuf_2/a_12000_n1600# divbuf_2/a_12030_n840# 0.04fF
C11740 divbuf_0/a_21982_n240# divbuf_0/a_22110_n840# 0.03fF
C11741 divbuf_0/a_31200_n1600# divbuf_0/a_31680_n1600# 0.26fF
C11742 pll_full_0/divbuf_0/a_25440_n1600# pll_full_0/divbuf_0/a_25920_n1600# 0.26fF
C11743 pll_full_0/divbuf_0/a_16152_n240# pll_full_0/divbuf_0/a_16350_n840# 0.02fF
C11744 pll_full_0/divider_0/tspc_0/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C11745 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C11746 divbuf_0/a_54270_n840# divbuf_0/a_54270_n1540# 0.01fF
C11747 divbuf_0/a_23550_n1540# divbuf_0/a_24030_n1540# 0.11fF
Xashish_0 ashish_0/von ashish_0/vop ashish_0/Gnd ashish
Xpd_0 VDD vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xcp_0 vdda1 vdda1 vssa1 cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_div_0/ro_complete_0 ro_div_0/ro_complete_0/a0 ro_div_0/ro_complete_0/a1 ro_div_0/ro_complete_0/a5
+ ro_div_0/ro_complete_0/a4 ro_div_0/ro_complete_0/a3 ro_div_0/ro_complete_0/a2 ro_complete
Xro_div_0/divbuf_0 VDD ro_div_0/divbuf_0/IN ro_div_0/divbuf_0/OUT ro_div_0/divbuf_0/OUT2
+ ro_div_0/divbuf_0/OUT3 ro_div_0/divbuf_0/OUT4 ro_div_0/divbuf_0/OUT5 vssa1 divbuf
Xro_div_0/divider_0 gnd vdd ro_div_0/divbuf_0/IN ro_div_0/divider_0/clk gnd divider
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xdivbuf_0 VDD divbuf_0/IN divbuf_0/OUT divbuf_0/OUT2 divbuf_0/OUT3 divbuf_0/OUT4 divbuf_0/OUT5
+ vssa1 divbuf
Xpd_div_0 pd_div_0/div pd_div_0/bufin pd_div
Xdivbuf_1 VDD divbuf_1/IN divbuf_1/OUT divbuf_1/OUT2 divbuf_1/OUT3 divbuf_1/OUT4 divbuf_1/OUT5
+ vssa1 divbuf
Xdivbuf_2 VDD divbuf_2/IN divbuf_2/OUT divbuf_2/OUT2 divbuf_2/OUT3 divbuf_2/OUT4 divbuf_2/OUT5
+ vssa1 divbuf
Xdivbuf_3 VDD divbuf_3/IN divbuf_3/OUT divbuf_3/OUT2 divbuf_3/OUT3 divbuf_3/OUT4 divbuf_3/OUT5
+ vssa1 divbuf
Xpll_full_0 vdd pll_full
C11748 io_analog[4] vdda1 25.05fF
C11749 io_analog[5] vdda1 25.05fF
C11750 io_analog[6] vdda1 25.05fF
C11751 io_in_3v3[0] vdda1 0.61fF
C11752 io_oeb[26] vdda1 0.61fF
C11753 io_in[0] vdda1 0.61fF
C11754 io_out[26] vdda1 0.61fF
C11755 io_out[0] vdda1 0.61fF
C11756 io_in[26] vdda1 0.61fF
C11757 io_oeb[0] vdda1 0.61fF
C11758 io_in_3v3[26] vdda1 0.61fF
C11759 io_in_3v3[1] vdda1 0.61fF
C11760 io_oeb[25] vdda1 0.61fF
C11761 io_in[1] vdda1 0.61fF
C11762 io_out[25] vdda1 0.61fF
C11763 io_out[1] vdda1 0.61fF
C11764 io_in[25] vdda1 0.61fF
C11765 io_oeb[1] vdda1 0.61fF
C11766 io_in_3v3[25] vdda1 0.61fF
C11767 io_in_3v3[2] vdda1 0.61fF
C11768 io_oeb[24] vdda1 0.61fF
C11769 io_in[2] vdda1 0.61fF
C11770 io_out[24] vdda1 0.61fF
C11771 io_out[2] vdda1 0.61fF
C11772 io_in[24] vdda1 0.61fF
C11773 io_oeb[2] vdda1 0.61fF
C11774 io_in_3v3[24] vdda1 0.61fF
C11775 io_in_3v3[3] vdda1 0.61fF
C11776 gpio_noesd[17] vdda1 0.61fF
C11777 io_in[3] vdda1 0.61fF
C11778 gpio_analog[17] vdda1 0.61fF
C11779 io_out[3] vdda1 0.61fF
C11780 io_oeb[3] vdda1 0.61fF
C11781 io_in_3v3[4] vdda1 0.61fF
C11782 io_in[4] vdda1 0.61fF
C11783 io_out[4] vdda1 0.61fF
C11784 io_oeb[4] vdda1 0.61fF
C11785 io_oeb[23] vdda1 0.61fF
C11786 io_out[23] vdda1 0.61fF
C11787 io_in[23] vdda1 0.61fF
C11788 io_in_3v3[23] vdda1 0.61fF
C11789 gpio_noesd[16] vdda1 0.61fF
C11790 gpio_analog[16] vdda1 0.61fF
C11791 io_in_3v3[5] vdda1 0.61fF
C11792 io_in[5] vdda1 0.61fF
C11793 io_out[5] vdda1 0.61fF
C11794 io_oeb[5] vdda1 0.61fF
C11795 io_oeb[22] vdda1 0.61fF
C11796 io_out[22] vdda1 0.61fF
C11797 io_in[22] vdda1 0.61fF
C11798 io_in_3v3[22] vdda1 0.61fF
C11799 gpio_noesd[15] vdda1 0.61fF
C11800 gpio_analog[15] vdda1 0.61fF
C11801 io_in_3v3[6] vdda1 0.61fF
C11802 io_in[6] vdda1 0.61fF
C11803 io_out[6] vdda1 0.61fF
C11804 io_oeb[6] vdda1 0.61fF
C11805 io_oeb[21] vdda1 0.61fF
C11806 io_out[21] vdda1 0.61fF
C11807 io_in[21] vdda1 0.61fF
C11808 io_in_3v3[21] vdda1 0.61fF
C11809 gpio_noesd[14] vdda1 0.61fF
C11810 gpio_analog[14] vdda1 0.61fF
C11811 vssd2 vdda1 13.04fF
C11812 vssd1 vdda1 13.04fF
C11813 vdda2 vdda1 13.04fF
C11814 io_oeb[20] vdda1 0.61fF
C11815 io_out[20] vdda1 0.61fF
C11816 io_in[20] vdda1 0.61fF
C11817 io_in_3v3[20] vdda1 0.61fF
C11818 gpio_noesd[13] vdda1 0.61fF
C11819 gpio_analog[13] vdda1 0.61fF
C11820 gpio_analog[0] vdda1 0.61fF
C11821 gpio_noesd[0] vdda1 0.61fF
C11822 io_in_3v3[7] vdda1 0.61fF
C11823 io_in[7] vdda1 0.61fF
C11824 io_out[7] vdda1 0.61fF
C11825 io_oeb[7] vdda1 0.61fF
C11826 io_oeb[19] vdda1 0.61fF
C11827 io_out[19] vdda1 0.61fF
C11828 io_in[19] vdda1 0.61fF
C11829 io_in_3v3[19] vdda1 0.61fF
C11830 gpio_noesd[12] vdda1 0.61fF
C11831 gpio_analog[12] vdda1 0.61fF
C11832 gpio_analog[1] vdda1 0.61fF
C11833 gpio_noesd[1] vdda1 0.61fF
C11834 io_in_3v3[8] vdda1 0.61fF
C11835 io_in[8] vdda1 0.61fF
C11836 io_out[8] vdda1 0.61fF
C11837 io_oeb[8] vdda1 0.61fF
C11838 io_oeb[18] vdda1 0.61fF
C11839 io_out[18] vdda1 0.61fF
C11840 io_in[18] vdda1 0.61fF
C11841 io_in_3v3[18] vdda1 0.61fF
C11842 gpio_noesd[11] vdda1 0.61fF
C11843 gpio_analog[11] vdda1 0.61fF
C11844 gpio_analog[2] vdda1 0.61fF
C11845 gpio_noesd[2] vdda1 0.61fF
C11846 io_in_3v3[9] vdda1 0.61fF
C11847 io_in[9] vdda1 0.61fF
C11848 io_out[9] vdda1 0.61fF
C11849 io_oeb[9] vdda1 0.61fF
C11850 io_oeb[17] vdda1 0.61fF
C11851 io_out[17] vdda1 0.61fF
C11852 io_in[17] vdda1 0.61fF
C11853 io_in_3v3[17] vdda1 0.61fF
C11854 gpio_noesd[10] vdda1 0.61fF
C11855 gpio_analog[10] vdda1 0.61fF
C11856 gpio_analog[3] vdda1 0.61fF
C11857 gpio_noesd[3] vdda1 0.61fF
C11858 io_in_3v3[10] vdda1 0.61fF
C11859 io_in[10] vdda1 0.61fF
C11860 io_out[10] vdda1 0.61fF
C11861 io_oeb[10] vdda1 0.61fF
C11862 io_oeb[16] vdda1 0.61fF
C11863 io_out[16] vdda1 0.61fF
C11864 io_in[16] vdda1 0.61fF
C11865 io_in_3v3[16] vdda1 0.61fF
C11866 gpio_noesd[9] vdda1 0.61fF
C11867 gpio_analog[9] vdda1 0.61fF
C11868 gpio_analog[4] vdda1 0.61fF
C11869 gpio_noesd[4] vdda1 0.61fF
C11870 io_in_3v3[11] vdda1 0.61fF
C11871 io_in[11] vdda1 0.61fF
C11872 io_out[11] vdda1 0.61fF
C11873 io_oeb[11] vdda1 0.61fF
C11874 io_oeb[15] vdda1 0.61fF
C11875 io_out[15] vdda1 0.61fF
C11876 io_in[15] vdda1 0.61fF
C11877 io_in_3v3[15] vdda1 0.61fF
C11878 gpio_noesd[8] vdda1 0.61fF
C11879 gpio_analog[8] vdda1 0.61fF
C11880 gpio_analog[5] vdda1 0.61fF
C11881 gpio_noesd[5] vdda1 0.61fF
C11882 io_in_3v3[12] vdda1 0.61fF
C11883 io_in[12] vdda1 0.61fF
C11884 io_out[12] vdda1 0.61fF
C11885 io_oeb[12] vdda1 0.61fF
C11886 io_oeb[14] vdda1 0.61fF
C11887 io_out[14] vdda1 0.61fF
C11888 io_in[14] vdda1 0.61fF
C11889 io_in_3v3[14] vdda1 0.61fF
C11890 gpio_noesd[7] vdda1 0.61fF
C11891 gpio_analog[7] vdda1 0.61fF
C11892 vssa2 vdda1 13.04fF
C11893 gpio_analog[6] vdda1 0.61fF
C11894 gpio_noesd[6] vdda1 0.61fF
C11895 io_in_3v3[13] vdda1 0.61fF
C11896 io_in[13] vdda1 0.61fF
C11897 io_out[13] vdda1 0.61fF
C11898 io_oeb[13] vdda1 0.61fF
C11899 vccd1 vdda1 13.04fF
C11900 vccd2 vdda1 13.04fF
C11901 io_analog[0] vdda1 7.42fF
C11902 io_analog[10] vdda1 6.83fF
C11903 io_analog[1] vdda1 10.18fF
C11904 io_analog[2] vdda1 7.88fF
C11905 io_analog[3] vdda1 6.86fF
C11906 io_clamp_high[0] vdda1 3.58fF
C11907 io_clamp_low[0] vdda1 3.58fF
C11908 io_clamp_high[1] vdda1 3.58fF
C11909 io_clamp_low[1] vdda1 3.58fF
C11910 io_clamp_high[2] vdda1 3.58fF
C11911 io_clamp_low[2] vdda1 3.58fF
C11912 io_analog[7] vdda1 6.83fF
C11913 io_analog[8] vdda1 6.83fF
C11914 io_analog[9] vdda1 6.83fF
C11915 user_irq[2] vdda1 0.63fF
C11916 user_irq[1] vdda1 0.63fF
C11917 user_irq[0] vdda1 0.63fF
C11918 user_clock2 vdda1 0.63fF
C11919 la_oenb[127] vdda1 0.63fF
C11920 la_data_out[127] vdda1 0.63fF
C11921 la_data_in[127] vdda1 0.63fF
C11922 la_oenb[126] vdda1 0.63fF
C11923 la_data_out[126] vdda1 0.63fF
C11924 la_data_in[126] vdda1 0.63fF
C11925 la_oenb[125] vdda1 0.63fF
C11926 la_data_out[125] vdda1 0.63fF
C11927 la_data_in[125] vdda1 0.63fF
C11928 la_oenb[124] vdda1 0.63fF
C11929 la_data_out[124] vdda1 0.63fF
C11930 la_data_in[124] vdda1 0.63fF
C11931 la_oenb[123] vdda1 0.63fF
C11932 la_data_out[123] vdda1 0.63fF
C11933 la_data_in[123] vdda1 0.63fF
C11934 la_oenb[122] vdda1 0.63fF
C11935 la_data_out[122] vdda1 0.63fF
C11936 la_data_in[122] vdda1 0.63fF
C11937 la_oenb[121] vdda1 0.63fF
C11938 la_data_out[121] vdda1 0.63fF
C11939 la_data_in[121] vdda1 0.63fF
C11940 la_oenb[120] vdda1 0.63fF
C11941 la_data_out[120] vdda1 0.63fF
C11942 la_data_in[120] vdda1 0.63fF
C11943 la_oenb[119] vdda1 0.63fF
C11944 la_data_out[119] vdda1 0.63fF
C11945 la_data_in[119] vdda1 0.63fF
C11946 la_oenb[118] vdda1 0.63fF
C11947 la_data_out[118] vdda1 0.63fF
C11948 la_data_in[118] vdda1 0.63fF
C11949 la_oenb[117] vdda1 0.63fF
C11950 la_data_out[117] vdda1 0.63fF
C11951 la_data_in[117] vdda1 0.63fF
C11952 la_oenb[116] vdda1 0.63fF
C11953 la_data_out[116] vdda1 0.63fF
C11954 la_data_in[116] vdda1 0.63fF
C11955 la_oenb[115] vdda1 0.63fF
C11956 la_data_out[115] vdda1 0.63fF
C11957 la_data_in[115] vdda1 0.63fF
C11958 la_oenb[114] vdda1 0.63fF
C11959 la_data_out[114] vdda1 0.63fF
C11960 la_data_in[114] vdda1 0.63fF
C11961 la_oenb[113] vdda1 0.63fF
C11962 la_data_out[113] vdda1 0.63fF
C11963 la_data_in[113] vdda1 0.63fF
C11964 la_oenb[112] vdda1 0.63fF
C11965 la_data_out[112] vdda1 0.63fF
C11966 la_data_in[112] vdda1 0.63fF
C11967 la_oenb[111] vdda1 0.63fF
C11968 la_data_out[111] vdda1 0.63fF
C11969 la_data_in[111] vdda1 0.63fF
C11970 la_oenb[110] vdda1 0.63fF
C11971 la_data_out[110] vdda1 0.63fF
C11972 la_data_in[110] vdda1 0.63fF
C11973 la_oenb[109] vdda1 0.63fF
C11974 la_data_out[109] vdda1 0.63fF
C11975 la_data_in[109] vdda1 0.63fF
C11976 la_oenb[108] vdda1 0.63fF
C11977 la_data_out[108] vdda1 0.63fF
C11978 la_data_in[108] vdda1 0.63fF
C11979 la_oenb[107] vdda1 0.63fF
C11980 la_data_out[107] vdda1 0.63fF
C11981 la_data_in[107] vdda1 0.63fF
C11982 la_oenb[106] vdda1 0.63fF
C11983 la_data_out[106] vdda1 0.63fF
C11984 la_data_in[106] vdda1 0.63fF
C11985 la_oenb[105] vdda1 0.63fF
C11986 la_data_out[105] vdda1 0.63fF
C11987 la_data_in[105] vdda1 0.63fF
C11988 la_oenb[104] vdda1 0.63fF
C11989 la_data_out[104] vdda1 0.63fF
C11990 la_data_in[104] vdda1 0.63fF
C11991 la_oenb[103] vdda1 0.63fF
C11992 la_data_out[103] vdda1 0.63fF
C11993 la_data_in[103] vdda1 0.63fF
C11994 la_oenb[102] vdda1 0.63fF
C11995 la_data_out[102] vdda1 0.63fF
C11996 la_data_in[102] vdda1 0.63fF
C11997 la_oenb[101] vdda1 0.63fF
C11998 la_data_out[101] vdda1 0.63fF
C11999 la_data_in[101] vdda1 0.63fF
C12000 la_oenb[100] vdda1 0.63fF
C12001 la_data_out[100] vdda1 0.63fF
C12002 la_data_in[100] vdda1 0.63fF
C12003 la_oenb[99] vdda1 0.63fF
C12004 la_data_out[99] vdda1 0.63fF
C12005 la_data_in[99] vdda1 0.63fF
C12006 la_oenb[98] vdda1 0.63fF
C12007 la_data_out[98] vdda1 0.63fF
C12008 la_data_in[98] vdda1 0.63fF
C12009 la_oenb[97] vdda1 0.63fF
C12010 la_data_out[97] vdda1 0.63fF
C12011 la_data_in[97] vdda1 0.63fF
C12012 la_oenb[96] vdda1 0.63fF
C12013 la_data_out[96] vdda1 0.63fF
C12014 la_data_in[96] vdda1 0.63fF
C12015 la_oenb[95] vdda1 0.63fF
C12016 la_data_out[95] vdda1 0.63fF
C12017 la_data_in[95] vdda1 0.63fF
C12018 la_oenb[94] vdda1 0.63fF
C12019 la_data_out[94] vdda1 0.63fF
C12020 la_data_in[94] vdda1 0.63fF
C12021 la_oenb[93] vdda1 0.63fF
C12022 la_data_out[93] vdda1 0.63fF
C12023 la_data_in[93] vdda1 0.63fF
C12024 la_oenb[92] vdda1 0.63fF
C12025 la_data_out[92] vdda1 0.63fF
C12026 la_data_in[92] vdda1 0.63fF
C12027 la_oenb[91] vdda1 0.63fF
C12028 la_data_out[91] vdda1 0.63fF
C12029 la_data_in[91] vdda1 0.63fF
C12030 la_oenb[90] vdda1 0.63fF
C12031 la_data_out[90] vdda1 0.63fF
C12032 la_data_in[90] vdda1 0.63fF
C12033 la_oenb[89] vdda1 0.63fF
C12034 la_data_out[89] vdda1 0.63fF
C12035 la_data_in[89] vdda1 0.63fF
C12036 la_oenb[88] vdda1 0.63fF
C12037 la_data_out[88] vdda1 0.63fF
C12038 la_data_in[88] vdda1 0.63fF
C12039 la_oenb[87] vdda1 0.63fF
C12040 la_data_out[87] vdda1 0.63fF
C12041 la_data_in[87] vdda1 0.63fF
C12042 la_oenb[86] vdda1 0.63fF
C12043 la_data_out[86] vdda1 0.63fF
C12044 la_data_in[86] vdda1 0.63fF
C12045 la_oenb[85] vdda1 0.63fF
C12046 la_data_out[85] vdda1 0.63fF
C12047 la_data_in[85] vdda1 0.63fF
C12048 la_oenb[84] vdda1 0.63fF
C12049 la_data_out[84] vdda1 0.63fF
C12050 la_data_in[84] vdda1 0.63fF
C12051 la_oenb[83] vdda1 0.63fF
C12052 la_data_out[83] vdda1 0.63fF
C12053 la_data_in[83] vdda1 0.63fF
C12054 la_oenb[82] vdda1 0.63fF
C12055 la_data_out[82] vdda1 0.63fF
C12056 la_data_in[82] vdda1 0.63fF
C12057 la_oenb[81] vdda1 0.63fF
C12058 la_data_out[81] vdda1 0.63fF
C12059 la_data_in[81] vdda1 0.63fF
C12060 la_oenb[80] vdda1 0.63fF
C12061 la_data_out[80] vdda1 0.63fF
C12062 la_data_in[80] vdda1 0.63fF
C12063 la_oenb[79] vdda1 0.63fF
C12064 la_data_out[79] vdda1 0.63fF
C12065 la_data_in[79] vdda1 0.63fF
C12066 la_oenb[78] vdda1 0.63fF
C12067 la_data_out[78] vdda1 0.63fF
C12068 la_data_in[78] vdda1 0.63fF
C12069 la_oenb[77] vdda1 0.63fF
C12070 la_data_out[77] vdda1 0.63fF
C12071 la_data_in[77] vdda1 0.63fF
C12072 la_oenb[76] vdda1 0.63fF
C12073 la_data_out[76] vdda1 0.63fF
C12074 la_data_in[76] vdda1 0.63fF
C12075 la_oenb[75] vdda1 0.63fF
C12076 la_data_out[75] vdda1 0.63fF
C12077 la_data_in[75] vdda1 0.63fF
C12078 la_oenb[74] vdda1 0.63fF
C12079 la_data_out[74] vdda1 0.63fF
C12080 la_data_in[74] vdda1 0.63fF
C12081 la_oenb[73] vdda1 0.63fF
C12082 la_data_out[73] vdda1 0.63fF
C12083 la_data_in[73] vdda1 0.63fF
C12084 la_oenb[72] vdda1 0.63fF
C12085 la_data_out[72] vdda1 0.63fF
C12086 la_data_in[72] vdda1 0.63fF
C12087 la_oenb[71] vdda1 0.63fF
C12088 la_data_out[71] vdda1 0.63fF
C12089 la_data_in[71] vdda1 0.63fF
C12090 la_oenb[70] vdda1 0.63fF
C12091 la_data_out[70] vdda1 0.63fF
C12092 la_data_in[70] vdda1 0.63fF
C12093 la_oenb[69] vdda1 0.63fF
C12094 la_data_out[69] vdda1 0.63fF
C12095 la_data_in[69] vdda1 0.63fF
C12096 la_oenb[68] vdda1 0.63fF
C12097 la_data_out[68] vdda1 0.63fF
C12098 la_data_in[68] vdda1 0.63fF
C12099 la_oenb[67] vdda1 0.63fF
C12100 la_data_out[67] vdda1 0.63fF
C12101 la_data_in[67] vdda1 0.63fF
C12102 la_oenb[66] vdda1 0.63fF
C12103 la_data_out[66] vdda1 0.63fF
C12104 la_data_in[66] vdda1 0.63fF
C12105 la_oenb[65] vdda1 0.63fF
C12106 la_data_out[65] vdda1 0.63fF
C12107 la_data_in[65] vdda1 0.63fF
C12108 la_oenb[64] vdda1 0.63fF
C12109 la_data_out[64] vdda1 0.63fF
C12110 la_data_in[64] vdda1 0.63fF
C12111 la_oenb[63] vdda1 0.63fF
C12112 la_data_out[63] vdda1 0.63fF
C12113 la_data_in[63] vdda1 0.63fF
C12114 la_oenb[62] vdda1 0.63fF
C12115 la_data_out[62] vdda1 0.63fF
C12116 la_data_in[62] vdda1 0.63fF
C12117 la_oenb[61] vdda1 0.63fF
C12118 la_data_out[61] vdda1 0.63fF
C12119 la_data_in[61] vdda1 0.63fF
C12120 la_oenb[60] vdda1 0.63fF
C12121 la_data_out[60] vdda1 0.63fF
C12122 la_data_in[60] vdda1 0.63fF
C12123 la_oenb[59] vdda1 0.63fF
C12124 la_data_out[59] vdda1 0.63fF
C12125 la_data_in[59] vdda1 0.63fF
C12126 la_oenb[58] vdda1 0.63fF
C12127 la_data_out[58] vdda1 0.63fF
C12128 la_data_in[58] vdda1 0.63fF
C12129 la_oenb[57] vdda1 0.63fF
C12130 la_data_out[57] vdda1 0.63fF
C12131 la_data_in[57] vdda1 0.63fF
C12132 la_oenb[56] vdda1 0.63fF
C12133 la_data_out[56] vdda1 0.63fF
C12134 la_data_in[56] vdda1 0.63fF
C12135 la_oenb[55] vdda1 0.63fF
C12136 la_data_out[55] vdda1 0.63fF
C12137 la_data_in[55] vdda1 0.63fF
C12138 la_oenb[54] vdda1 0.63fF
C12139 la_data_out[54] vdda1 0.63fF
C12140 la_data_in[54] vdda1 0.63fF
C12141 la_oenb[53] vdda1 0.63fF
C12142 la_data_out[53] vdda1 0.63fF
C12143 la_data_in[53] vdda1 0.63fF
C12144 la_oenb[52] vdda1 0.63fF
C12145 la_data_out[52] vdda1 0.63fF
C12146 la_data_in[52] vdda1 0.63fF
C12147 la_oenb[51] vdda1 0.63fF
C12148 la_data_out[51] vdda1 0.63fF
C12149 la_data_in[51] vdda1 0.63fF
C12150 la_oenb[50] vdda1 0.63fF
C12151 la_data_out[50] vdda1 0.63fF
C12152 la_data_in[50] vdda1 0.63fF
C12153 la_oenb[49] vdda1 0.63fF
C12154 la_data_out[49] vdda1 0.63fF
C12155 la_data_in[49] vdda1 0.63fF
C12156 la_oenb[48] vdda1 0.63fF
C12157 la_data_out[48] vdda1 0.63fF
C12158 la_data_in[48] vdda1 0.63fF
C12159 la_oenb[47] vdda1 0.63fF
C12160 la_data_out[47] vdda1 0.63fF
C12161 la_data_in[47] vdda1 0.63fF
C12162 la_oenb[46] vdda1 0.63fF
C12163 la_data_out[46] vdda1 0.63fF
C12164 la_data_in[46] vdda1 0.63fF
C12165 la_oenb[45] vdda1 0.63fF
C12166 la_data_out[45] vdda1 0.63fF
C12167 la_data_in[45] vdda1 0.63fF
C12168 la_oenb[44] vdda1 0.63fF
C12169 la_data_out[44] vdda1 0.63fF
C12170 la_data_in[44] vdda1 0.63fF
C12171 la_oenb[43] vdda1 0.63fF
C12172 la_data_out[43] vdda1 0.63fF
C12173 la_data_in[43] vdda1 0.63fF
C12174 la_oenb[42] vdda1 0.63fF
C12175 la_data_out[42] vdda1 0.63fF
C12176 la_data_in[42] vdda1 0.63fF
C12177 la_oenb[41] vdda1 0.63fF
C12178 la_data_out[41] vdda1 0.63fF
C12179 la_data_in[41] vdda1 0.63fF
C12180 la_oenb[40] vdda1 0.63fF
C12181 la_data_out[40] vdda1 0.63fF
C12182 la_data_in[40] vdda1 0.63fF
C12183 la_oenb[39] vdda1 0.63fF
C12184 la_data_out[39] vdda1 0.63fF
C12185 la_data_in[39] vdda1 0.63fF
C12186 la_oenb[38] vdda1 0.63fF
C12187 la_data_out[38] vdda1 0.63fF
C12188 la_data_in[38] vdda1 0.63fF
C12189 la_oenb[37] vdda1 0.63fF
C12190 la_data_out[37] vdda1 0.63fF
C12191 la_data_in[37] vdda1 0.63fF
C12192 la_oenb[36] vdda1 0.63fF
C12193 la_data_out[36] vdda1 0.63fF
C12194 la_data_in[36] vdda1 0.63fF
C12195 la_oenb[35] vdda1 0.63fF
C12196 la_data_out[35] vdda1 0.63fF
C12197 la_data_in[35] vdda1 0.63fF
C12198 la_oenb[34] vdda1 0.63fF
C12199 la_data_out[34] vdda1 0.63fF
C12200 la_data_in[34] vdda1 0.63fF
C12201 la_oenb[33] vdda1 0.63fF
C12202 la_data_out[33] vdda1 0.63fF
C12203 la_data_in[33] vdda1 0.63fF
C12204 la_oenb[32] vdda1 0.63fF
C12205 la_data_out[32] vdda1 0.63fF
C12206 la_data_in[32] vdda1 0.63fF
C12207 la_oenb[31] vdda1 0.63fF
C12208 la_data_out[31] vdda1 0.63fF
C12209 la_data_in[31] vdda1 0.63fF
C12210 la_oenb[30] vdda1 0.63fF
C12211 la_data_out[30] vdda1 0.63fF
C12212 la_data_in[30] vdda1 0.63fF
C12213 la_oenb[29] vdda1 0.63fF
C12214 la_data_out[29] vdda1 0.63fF
C12215 la_data_in[29] vdda1 0.63fF
C12216 la_oenb[28] vdda1 0.63fF
C12217 la_data_out[28] vdda1 0.63fF
C12218 la_data_in[28] vdda1 0.63fF
C12219 la_oenb[27] vdda1 0.63fF
C12220 la_data_out[27] vdda1 0.63fF
C12221 la_data_in[27] vdda1 0.63fF
C12222 la_oenb[26] vdda1 0.63fF
C12223 la_data_out[26] vdda1 0.63fF
C12224 la_data_in[26] vdda1 0.63fF
C12225 la_oenb[25] vdda1 0.63fF
C12226 la_data_out[25] vdda1 0.63fF
C12227 la_data_in[25] vdda1 0.63fF
C12228 la_oenb[24] vdda1 0.63fF
C12229 la_data_out[24] vdda1 0.63fF
C12230 la_data_in[24] vdda1 0.63fF
C12231 la_oenb[23] vdda1 0.63fF
C12232 la_data_out[23] vdda1 0.63fF
C12233 la_data_in[23] vdda1 0.63fF
C12234 la_oenb[22] vdda1 0.63fF
C12235 la_data_out[22] vdda1 0.63fF
C12236 la_data_in[22] vdda1 0.63fF
C12237 la_oenb[21] vdda1 0.63fF
C12238 la_data_out[21] vdda1 0.63fF
C12239 la_data_in[21] vdda1 0.63fF
C12240 la_oenb[20] vdda1 0.63fF
C12241 la_data_out[20] vdda1 0.63fF
C12242 la_data_in[20] vdda1 0.63fF
C12243 la_oenb[19] vdda1 0.63fF
C12244 la_data_out[19] vdda1 0.63fF
C12245 la_data_in[19] vdda1 0.63fF
C12246 la_oenb[18] vdda1 0.63fF
C12247 la_data_out[18] vdda1 0.63fF
C12248 la_data_in[18] vdda1 0.63fF
C12249 la_oenb[17] vdda1 0.63fF
C12250 la_data_out[17] vdda1 0.63fF
C12251 la_data_in[17] vdda1 0.63fF
C12252 la_oenb[16] vdda1 0.63fF
C12253 la_data_out[16] vdda1 0.63fF
C12254 la_data_in[16] vdda1 0.63fF
C12255 la_oenb[15] vdda1 0.63fF
C12256 la_data_out[15] vdda1 0.63fF
C12257 la_data_in[15] vdda1 0.63fF
C12258 la_oenb[14] vdda1 0.63fF
C12259 la_data_out[14] vdda1 0.63fF
C12260 la_data_in[14] vdda1 0.63fF
C12261 la_oenb[13] vdda1 0.63fF
C12262 la_data_out[13] vdda1 0.63fF
C12263 la_data_in[13] vdda1 0.63fF
C12264 la_oenb[12] vdda1 0.63fF
C12265 la_data_out[12] vdda1 0.63fF
C12266 la_data_in[12] vdda1 0.63fF
C12267 la_oenb[11] vdda1 0.63fF
C12268 la_data_out[11] vdda1 0.63fF
C12269 la_data_in[11] vdda1 0.63fF
C12270 la_oenb[10] vdda1 0.63fF
C12271 la_data_out[10] vdda1 0.63fF
C12272 la_data_in[10] vdda1 0.63fF
C12273 la_oenb[9] vdda1 0.63fF
C12274 la_data_out[9] vdda1 0.63fF
C12275 la_data_in[9] vdda1 0.63fF
C12276 la_oenb[8] vdda1 0.63fF
C12277 la_data_out[8] vdda1 0.63fF
C12278 la_data_in[8] vdda1 0.63fF
C12279 la_oenb[7] vdda1 0.63fF
C12280 la_data_out[7] vdda1 0.63fF
C12281 la_data_in[7] vdda1 0.63fF
C12282 la_oenb[6] vdda1 0.63fF
C12283 la_data_out[6] vdda1 0.63fF
C12284 la_data_in[6] vdda1 0.63fF
C12285 la_oenb[5] vdda1 0.63fF
C12286 la_data_out[5] vdda1 0.63fF
C12287 la_data_in[5] vdda1 0.63fF
C12288 la_oenb[4] vdda1 0.63fF
C12289 la_data_out[4] vdda1 0.63fF
C12290 la_data_in[4] vdda1 0.63fF
C12291 la_oenb[3] vdda1 0.63fF
C12292 la_data_out[3] vdda1 0.63fF
C12293 la_data_in[3] vdda1 0.63fF
C12294 la_oenb[2] vdda1 0.63fF
C12295 la_data_out[2] vdda1 0.63fF
C12296 la_data_in[2] vdda1 0.63fF
C12297 la_oenb[1] vdda1 0.63fF
C12298 la_data_out[1] vdda1 0.63fF
C12299 la_data_in[1] vdda1 0.63fF
C12300 la_oenb[0] vdda1 0.63fF
C12301 la_data_out[0] vdda1 0.63fF
C12302 la_data_in[0] vdda1 0.63fF
C12303 wbs_dat_o[31] vdda1 0.63fF
C12304 wbs_dat_i[31] vdda1 0.63fF
C12305 wbs_adr_i[31] vdda1 0.63fF
C12306 wbs_dat_o[30] vdda1 0.63fF
C12307 wbs_dat_i[30] vdda1 0.63fF
C12308 wbs_adr_i[30] vdda1 0.63fF
C12309 wbs_dat_o[29] vdda1 0.63fF
C12310 wbs_dat_i[29] vdda1 0.63fF
C12311 wbs_adr_i[29] vdda1 0.63fF
C12312 wbs_dat_o[28] vdda1 0.63fF
C12313 wbs_dat_i[28] vdda1 0.63fF
C12314 wbs_adr_i[28] vdda1 0.63fF
C12315 wbs_dat_o[27] vdda1 0.63fF
C12316 wbs_dat_i[27] vdda1 0.63fF
C12317 wbs_adr_i[27] vdda1 0.63fF
C12318 wbs_dat_o[26] vdda1 0.63fF
C12319 wbs_dat_i[26] vdda1 0.63fF
C12320 wbs_adr_i[26] vdda1 0.63fF
C12321 wbs_dat_o[25] vdda1 0.63fF
C12322 wbs_dat_i[25] vdda1 0.63fF
C12323 wbs_adr_i[25] vdda1 0.63fF
C12324 wbs_dat_o[24] vdda1 0.63fF
C12325 wbs_dat_i[24] vdda1 0.63fF
C12326 wbs_adr_i[24] vdda1 0.63fF
C12327 wbs_dat_o[23] vdda1 0.63fF
C12328 wbs_dat_i[23] vdda1 0.63fF
C12329 wbs_adr_i[23] vdda1 0.63fF
C12330 wbs_dat_o[22] vdda1 0.63fF
C12331 wbs_dat_i[22] vdda1 0.63fF
C12332 wbs_adr_i[22] vdda1 0.63fF
C12333 wbs_dat_o[21] vdda1 0.63fF
C12334 wbs_dat_i[21] vdda1 0.63fF
C12335 wbs_adr_i[21] vdda1 0.63fF
C12336 wbs_dat_o[20] vdda1 0.63fF
C12337 wbs_dat_i[20] vdda1 0.63fF
C12338 wbs_adr_i[20] vdda1 0.63fF
C12339 wbs_dat_o[19] vdda1 0.63fF
C12340 wbs_dat_i[19] vdda1 0.63fF
C12341 wbs_adr_i[19] vdda1 0.63fF
C12342 wbs_dat_o[18] vdda1 0.63fF
C12343 wbs_dat_i[18] vdda1 0.63fF
C12344 wbs_adr_i[18] vdda1 0.63fF
C12345 wbs_dat_o[17] vdda1 0.63fF
C12346 wbs_dat_i[17] vdda1 0.63fF
C12347 wbs_adr_i[17] vdda1 0.63fF
C12348 wbs_dat_o[16] vdda1 0.63fF
C12349 wbs_dat_i[16] vdda1 0.63fF
C12350 wbs_adr_i[16] vdda1 0.63fF
C12351 wbs_dat_o[15] vdda1 0.63fF
C12352 wbs_dat_i[15] vdda1 0.63fF
C12353 wbs_adr_i[15] vdda1 0.63fF
C12354 wbs_dat_o[14] vdda1 0.63fF
C12355 wbs_dat_i[14] vdda1 0.63fF
C12356 wbs_adr_i[14] vdda1 0.63fF
C12357 wbs_dat_o[13] vdda1 0.63fF
C12358 wbs_dat_i[13] vdda1 0.63fF
C12359 wbs_adr_i[13] vdda1 0.63fF
C12360 wbs_dat_o[12] vdda1 0.63fF
C12361 wbs_dat_i[12] vdda1 0.63fF
C12362 wbs_adr_i[12] vdda1 0.63fF
C12363 wbs_dat_o[11] vdda1 0.63fF
C12364 wbs_dat_i[11] vdda1 0.63fF
C12365 wbs_adr_i[11] vdda1 0.63fF
C12366 wbs_dat_o[10] vdda1 0.63fF
C12367 wbs_dat_i[10] vdda1 0.63fF
C12368 wbs_adr_i[10] vdda1 0.63fF
C12369 wbs_dat_o[9] vdda1 0.63fF
C12370 wbs_dat_i[9] vdda1 0.63fF
C12371 wbs_adr_i[9] vdda1 0.63fF
C12372 wbs_dat_o[8] vdda1 0.63fF
C12373 wbs_dat_i[8] vdda1 0.63fF
C12374 wbs_adr_i[8] vdda1 0.63fF
C12375 wbs_dat_o[7] vdda1 0.63fF
C12376 wbs_dat_i[7] vdda1 0.63fF
C12377 wbs_adr_i[7] vdda1 0.63fF
C12378 wbs_dat_o[6] vdda1 0.63fF
C12379 wbs_dat_i[6] vdda1 0.63fF
C12380 wbs_adr_i[6] vdda1 0.63fF
C12381 wbs_dat_o[5] vdda1 0.63fF
C12382 wbs_dat_i[5] vdda1 0.63fF
C12383 wbs_adr_i[5] vdda1 0.63fF
C12384 wbs_dat_o[4] vdda1 0.63fF
C12385 wbs_dat_i[4] vdda1 0.63fF
C12386 wbs_adr_i[4] vdda1 0.63fF
C12387 wbs_sel_i[3] vdda1 0.63fF
C12388 wbs_dat_o[3] vdda1 0.63fF
C12389 wbs_dat_i[3] vdda1 0.63fF
C12390 wbs_adr_i[3] vdda1 0.63fF
C12391 wbs_sel_i[2] vdda1 0.63fF
C12392 wbs_dat_o[2] vdda1 0.63fF
C12393 wbs_dat_i[2] vdda1 0.63fF
C12394 wbs_adr_i[2] vdda1 0.63fF
C12395 wbs_sel_i[1] vdda1 0.63fF
C12396 wbs_dat_o[1] vdda1 0.63fF
C12397 wbs_dat_i[1] vdda1 0.63fF
C12398 wbs_adr_i[1] vdda1 0.63fF
C12399 wbs_sel_i[0] vdda1 0.63fF
C12400 wbs_dat_o[0] vdda1 0.63fF
C12401 wbs_dat_i[0] vdda1 0.63fF
C12402 wbs_adr_i[0] vdda1 0.63fF
C12403 wbs_we_i vdda1 0.63fF
C12404 wbs_stb_i vdda1 0.63fF
C12405 wbs_cyc_i vdda1 0.63fF
C12406 wbs_ack_o vdda1 0.63fF
C12407 wb_rst_i vdda1 0.63fF
C12408 wb_clk_i vdda1 0.63fF
C12409 pll_full_0/divider_0/and_0/Z1 vdda1 0.33fF
C12410 pll_full_0/divider_0/and_0/B vdda1 1.79fF
C12411 pll_full_0/divider_0/and_0/A vdda1 1.66fF
C12412 pll_full_0/divider_0/and_0/out1 vdda1 2.71fF
C12413 pll_full_0/divider_0/tspc_2/Z4 vdda1 0.42fF
C12414 pll_full_0/divbuf_0/IN vdda1 6.23fF
C12415 pll_full_0/divider_0/tspc_2/Z3 vdda1 2.00fF
C12416 pll_full_0/divider_0/tspc_2/Z2 vdda1 1.29fF
C12417 pll_full_0/divider_0/tspc_2/Z1 vdda1 0.99fF
C12418 pll_full_0/divider_0/nor_0/B vdda1 5.25fF
C12419 pll_full_0/divider_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C12420 pll_full_0/divider_0/tspc_1/Z4 vdda1 0.42fF
C12421 pll_full_0/divider_0/tspc_1/Q vdda1 2.79fF
C12422 pll_full_0/divider_0/tspc_1/Z3 vdda1 2.00fF
C12423 pll_full_0/divider_0/tspc_1/Z2 vdda1 1.29fF
C12424 pll_full_0/divider_0/tspc_1/Z1 vdda1 0.99fF
C12425 pll_full_0/divider_0/nor_1/B vdda1 5.95fF
C12426 pll_full_0/divider_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C12427 pll_full_0/divider_0/tspc_0/Z4 vdda1 0.42fF
C12428 pll_full_0/divider_0/tspc_0/Q vdda1 2.81fF
C12429 pll_full_0/divider_0/tspc_0/Z3 vdda1 2.00fF
C12430 pll_full_0/divider_0/tspc_0/Z2 vdda1 1.30fF
C12431 pll_full_0/divider_0/tspc_0/Z1 vdda1 0.99fF
C12432 pll_full_0/divider_0/nor_1/A vdda1 6.02fF
C12433 pll_full_0/divider_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C12434 pll_full_0/divider_0/clk vdda1 31.77fF
C12435 pll_full_0/divider_0/prescaler_0/Out vdda1 4.13fF
C12436 pll_full_0/divider_0/prescaler_0/nand_1/z1 vdda1 0.20fF
C12437 pll_full_0/divider_0/prescaler_0/tspc_2/D vdda1 2.59fF
C12438 pll_full_0/divider_0/prescaler_0/tspc_0/Q vdda1 3.30fF
C12439 pll_full_0/divider_0/prescaler_0/tspc_1/Q vdda1 2.78fF
C12440 pll_full_0/divider_0/prescaler_0/nand_0/z1 vdda1 0.20fF
C12441 pll_full_0/divider_0/prescaler_0/tspc_0/D vdda1 3.07fF
C12442 pll_full_0/divider_0/and_0/OUT vdda1 5.35fF
C12443 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vdda1 0.42fF
C12444 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vdda1 2.00fF
C12445 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vdda1 1.30fF
C12446 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C12447 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C12448 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 1.89fF **FLOATING
C12449 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vdda1 0.42fF
C12450 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vdda1 2.00fF
C12451 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vdda1 1.31fF
C12452 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C12453 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C12454 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vdda1 3.99fF **FLOATING
C12455 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vdda1 0.42fF
C12456 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vdda1 2.00fF
C12457 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vdda1 1.30fF
C12458 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C12459 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C12460 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 1.89fF **FLOATING
C12461 pll_full_0/divider_0/nor_1/Z1 vdda1 1.33fF
C12462 pll_full_0/divider_0/nor_0/Z1 vdda1 1.33fF
C12463 pll_full_0/divbuf_1/OUT vdda1 3.28fF
C12464 pll_full_0/divbuf_1/OUT5 vdda1 16.40fF
C12465 pll_full_0/divbuf_1/OUT4 vdda1 100.06fF
C12466 pll_full_0/divbuf_1/OUT3 vdda1 27.01fF
C12467 pll_full_0/divbuf_1/OUT2 vdda1 8.71fF
C12468 pll_full_0/divbuf_1/a_60990_n1540# vdda1 1.57fF **FLOATING
C12469 pll_full_0/divbuf_1/a_60510_n1540# vdda1 1.62fF **FLOATING
C12470 pll_full_0/divbuf_1/a_60030_n1540# vdda1 1.62fF **FLOATING
C12471 pll_full_0/divbuf_1/a_59550_n1540# vdda1 1.62fF **FLOATING
C12472 pll_full_0/divbuf_1/a_59070_n1540# vdda1 1.62fF **FLOATING
C12473 pll_full_0/divbuf_1/a_58590_n1540# vdda1 1.62fF **FLOATING
C12474 pll_full_0/divbuf_1/a_58110_n1540# vdda1 1.62fF **FLOATING
C12475 pll_full_0/divbuf_1/a_57630_n1540# vdda1 1.62fF **FLOATING
C12476 pll_full_0/divbuf_1/a_57150_n1540# vdda1 1.62fF **FLOATING
C12477 pll_full_0/divbuf_1/a_56670_n1540# vdda1 1.62fF **FLOATING
C12478 pll_full_0/divbuf_1/a_56190_n1540# vdda1 1.62fF **FLOATING
C12479 pll_full_0/divbuf_1/a_55710_n1540# vdda1 1.62fF **FLOATING
C12480 pll_full_0/divbuf_1/a_55230_n1540# vdda1 1.62fF **FLOATING
C12481 pll_full_0/divbuf_1/a_54750_n1540# vdda1 1.62fF **FLOATING
C12482 pll_full_0/divbuf_1/a_54270_n1540# vdda1 1.62fF **FLOATING
C12483 pll_full_0/divbuf_1/a_53790_n1540# vdda1 1.62fF **FLOATING
C12484 pll_full_0/divbuf_1/a_53310_n1540# vdda1 1.62fF **FLOATING
C12485 pll_full_0/divbuf_1/a_52830_n1540# vdda1 1.62fF **FLOATING
C12486 pll_full_0/divbuf_1/a_52350_n1540# vdda1 1.62fF **FLOATING
C12487 pll_full_0/divbuf_1/a_51870_n1540# vdda1 1.62fF **FLOATING
C12488 pll_full_0/divbuf_1/a_51390_n1540# vdda1 1.62fF **FLOATING
C12489 pll_full_0/divbuf_1/a_50910_n1540# vdda1 1.62fF **FLOATING
C12490 pll_full_0/divbuf_1/a_50430_n1540# vdda1 1.62fF **FLOATING
C12491 pll_full_0/divbuf_1/a_49950_n1540# vdda1 1.62fF **FLOATING
C12492 pll_full_0/divbuf_1/a_49470_n1540# vdda1 1.62fF **FLOATING
C12493 pll_full_0/divbuf_1/a_48990_n1540# vdda1 1.62fF **FLOATING
C12494 pll_full_0/divbuf_1/a_48510_n1540# vdda1 1.62fF **FLOATING
C12495 pll_full_0/divbuf_1/a_48030_n1540# vdda1 1.62fF **FLOATING
C12496 pll_full_0/divbuf_1/a_47550_n1540# vdda1 1.62fF **FLOATING
C12497 pll_full_0/divbuf_1/a_47070_n1540# vdda1 1.62fF **FLOATING
C12498 pll_full_0/divbuf_1/a_46590_n1540# vdda1 1.62fF **FLOATING
C12499 pll_full_0/divbuf_1/a_46110_n1540# vdda1 1.62fF **FLOATING
C12500 pll_full_0/divbuf_1/a_45630_n1540# vdda1 1.62fF **FLOATING
C12501 pll_full_0/divbuf_1/a_45150_n1540# vdda1 1.62fF **FLOATING
C12502 pll_full_0/divbuf_1/a_44670_n1540# vdda1 1.62fF **FLOATING
C12503 pll_full_0/divbuf_1/a_44190_n1540# vdda1 1.62fF **FLOATING
C12504 pll_full_0/divbuf_1/a_43710_n1540# vdda1 1.62fF **FLOATING
C12505 pll_full_0/divbuf_1/a_43230_n1540# vdda1 1.62fF **FLOATING
C12506 pll_full_0/divbuf_1/a_42750_n1540# vdda1 1.62fF **FLOATING
C12507 pll_full_0/divbuf_1/a_42270_n1540# vdda1 1.62fF **FLOATING
C12508 pll_full_0/divbuf_1/a_41790_n1540# vdda1 1.62fF **FLOATING
C12509 pll_full_0/divbuf_1/a_41310_n1540# vdda1 1.62fF **FLOATING
C12510 pll_full_0/divbuf_1/a_40830_n1540# vdda1 1.62fF **FLOATING
C12511 pll_full_0/divbuf_1/a_40350_n1540# vdda1 1.62fF **FLOATING
C12512 pll_full_0/divbuf_1/a_39870_n1540# vdda1 1.62fF **FLOATING
C12513 pll_full_0/divbuf_1/a_39390_n1540# vdda1 1.62fF **FLOATING
C12514 pll_full_0/divbuf_1/a_38910_n1540# vdda1 1.62fF **FLOATING
C12515 pll_full_0/divbuf_1/a_38430_n1540# vdda1 1.62fF **FLOATING
C12516 pll_full_0/divbuf_1/a_37950_n1540# vdda1 1.62fF **FLOATING
C12517 pll_full_0/divbuf_1/a_37470_n1540# vdda1 1.62fF **FLOATING
C12518 pll_full_0/divbuf_1/a_36990_n1540# vdda1 1.62fF **FLOATING
C12519 pll_full_0/divbuf_1/a_36510_n1540# vdda1 1.62fF **FLOATING
C12520 pll_full_0/divbuf_1/a_36030_n1540# vdda1 1.62fF **FLOATING
C12521 pll_full_0/divbuf_1/a_35550_n1540# vdda1 1.62fF **FLOATING
C12522 pll_full_0/divbuf_1/a_35070_n1540# vdda1 1.62fF **FLOATING
C12523 pll_full_0/divbuf_1/a_34590_n1540# vdda1 1.62fF **FLOATING
C12524 pll_full_0/divbuf_1/a_34110_n1540# vdda1 1.62fF **FLOATING
C12525 pll_full_0/divbuf_1/a_33630_n1540# vdda1 1.62fF **FLOATING
C12526 pll_full_0/divbuf_1/a_33150_n1540# vdda1 1.62fF **FLOATING
C12527 pll_full_0/divbuf_1/a_32670_n1540# vdda1 1.62fF **FLOATING
C12528 pll_full_0/divbuf_1/a_32190_n1540# vdda1 1.62fF **FLOATING
C12529 pll_full_0/divbuf_1/a_31710_n1540# vdda1 1.62fF **FLOATING
C12530 pll_full_0/divbuf_1/a_31230_n1540# vdda1 1.62fF **FLOATING
C12531 pll_full_0/divbuf_1/a_30750_n1540# vdda1 1.62fF **FLOATING
C12532 pll_full_0/divbuf_1/a_30270_n1540# vdda1 1.62fF **FLOATING
C12533 pll_full_0/divbuf_1/a_29790_n1540# vdda1 1.62fF **FLOATING
C12534 pll_full_0/divbuf_1/a_29310_n1540# vdda1 1.62fF **FLOATING
C12535 pll_full_0/divbuf_1/a_28830_n1540# vdda1 1.62fF **FLOATING
C12536 pll_full_0/divbuf_1/a_28350_n1540# vdda1 1.62fF **FLOATING
C12537 pll_full_0/divbuf_1/a_27870_n1540# vdda1 1.62fF **FLOATING
C12538 pll_full_0/divbuf_1/a_27390_n1540# vdda1 1.62fF **FLOATING
C12539 pll_full_0/divbuf_1/a_26910_n1540# vdda1 1.62fF **FLOATING
C12540 pll_full_0/divbuf_1/a_26430_n1540# vdda1 1.62fF **FLOATING
C12541 pll_full_0/divbuf_1/a_25950_n1540# vdda1 1.62fF **FLOATING
C12542 pll_full_0/divbuf_1/a_25470_n1540# vdda1 1.62fF **FLOATING
C12543 pll_full_0/divbuf_1/a_24990_n1540# vdda1 1.62fF **FLOATING
C12544 pll_full_0/divbuf_1/a_24510_n1540# vdda1 1.62fF **FLOATING
C12545 pll_full_0/divbuf_1/a_24030_n1540# vdda1 1.62fF **FLOATING
C12546 pll_full_0/divbuf_1/a_23550_n1540# vdda1 1.62fF **FLOATING
C12547 pll_full_0/divbuf_1/a_23070_n1540# vdda1 1.62fF **FLOATING
C12548 pll_full_0/divbuf_1/a_22590_n1540# vdda1 1.62fF **FLOATING
C12549 pll_full_0/divbuf_1/a_22110_n1540# vdda1 1.62fF **FLOATING
C12550 pll_full_0/divbuf_1/a_21630_n1540# vdda1 1.62fF **FLOATING
C12551 pll_full_0/divbuf_1/a_21150_n1540# vdda1 1.62fF **FLOATING
C12552 pll_full_0/divbuf_1/a_20670_n1540# vdda1 1.62fF **FLOATING
C12553 pll_full_0/divbuf_1/a_20190_n1540# vdda1 1.62fF **FLOATING
C12554 pll_full_0/divbuf_1/a_19710_n1540# vdda1 1.62fF **FLOATING
C12555 pll_full_0/divbuf_1/a_19230_n1540# vdda1 1.62fF **FLOATING
C12556 pll_full_0/divbuf_1/a_18750_n1540# vdda1 1.62fF **FLOATING
C12557 pll_full_0/divbuf_1/a_18270_n1540# vdda1 1.62fF **FLOATING
C12558 pll_full_0/divbuf_1/a_17790_n1540# vdda1 1.62fF **FLOATING
C12559 pll_full_0/divbuf_1/a_17310_n1540# vdda1 1.62fF **FLOATING
C12560 pll_full_0/divbuf_1/a_16830_n1540# vdda1 1.62fF **FLOATING
C12561 pll_full_0/divbuf_1/a_16350_n1540# vdda1 1.62fF **FLOATING
C12562 pll_full_0/divbuf_1/a_15870_n1540# vdda1 1.62fF **FLOATING
C12563 pll_full_0/divbuf_1/a_15390_n1540# vdda1 1.62fF **FLOATING
C12564 pll_full_0/divbuf_1/a_14910_n1540# vdda1 1.62fF **FLOATING
C12565 pll_full_0/divbuf_1/a_14430_n1540# vdda1 1.62fF **FLOATING
C12566 pll_full_0/divbuf_1/a_13950_n1540# vdda1 1.62fF **FLOATING
C12567 pll_full_0/divbuf_1/a_13470_n1540# vdda1 1.62fF **FLOATING
C12568 pll_full_0/divbuf_1/a_12990_n1540# vdda1 1.62fF **FLOATING
C12569 pll_full_0/divbuf_1/a_12510_n1540# vdda1 1.62fF **FLOATING
C12570 pll_full_0/divbuf_1/a_12030_n1540# vdda1 1.62fF **FLOATING
C12571 pll_full_0/divbuf_1/a_11550_n1540# vdda1 1.62fF **FLOATING
C12572 pll_full_0/divbuf_1/a_11070_n1540# vdda1 1.62fF **FLOATING
C12573 pll_full_0/divbuf_1/a_10590_n1540# vdda1 1.62fF **FLOATING
C12574 pll_full_0/divbuf_1/a_10110_n1540# vdda1 1.62fF **FLOATING
C12575 pll_full_0/divbuf_1/a_9630_n1540# vdda1 1.62fF **FLOATING
C12576 pll_full_0/divbuf_1/a_9150_n1540# vdda1 1.62fF **FLOATING
C12577 pll_full_0/divbuf_1/a_8670_n1540# vdda1 1.62fF **FLOATING
C12578 pll_full_0/divbuf_1/a_8190_n1540# vdda1 1.62fF **FLOATING
C12579 pll_full_0/divbuf_1/a_7710_n1540# vdda1 1.62fF **FLOATING
C12580 pll_full_0/divbuf_1/a_7230_n1540# vdda1 1.62fF **FLOATING
C12581 pll_full_0/divbuf_1/a_6750_n1540# vdda1 1.62fF **FLOATING
C12582 pll_full_0/divbuf_1/a_6270_n1540# vdda1 1.62fF **FLOATING
C12583 pll_full_0/divbuf_1/a_5790_n1540# vdda1 1.62fF **FLOATING
C12584 pll_full_0/divbuf_1/a_5310_n1540# vdda1 1.62fF **FLOATING
C12585 pll_full_0/divbuf_1/a_4830_n1540# vdda1 1.62fF **FLOATING
C12586 pll_full_0/divbuf_1/a_4350_n1540# vdda1 1.62fF **FLOATING
C12587 pll_full_0/divbuf_1/a_3870_n1540# vdda1 1.62fF **FLOATING
C12588 pll_full_0/divbuf_1/a_3390_n1540# vdda1 1.62fF **FLOATING
C12589 pll_full_0/divbuf_1/a_2910_n1540# vdda1 1.62fF **FLOATING
C12590 pll_full_0/divbuf_1/a_2430_n1540# vdda1 1.62fF **FLOATING
C12591 pll_full_0/divbuf_1/a_1950_n1540# vdda1 1.62fF **FLOATING
C12592 pll_full_0/divbuf_1/a_1470_n1540# vdda1 1.62fF **FLOATING
C12593 pll_full_0/divbuf_1/a_990_n1540# vdda1 1.62fF **FLOATING
C12594 pll_full_0/divbuf_1/a_510_n1540# vdda1 1.62fF **FLOATING
C12595 pll_full_0/divbuf_1/a_60990_n840# vdda1 1.06fF **FLOATING
C12596 pll_full_0/divbuf_1/a_60510_n840# vdda1 1.09fF **FLOATING
C12597 pll_full_0/divbuf_1/a_60030_n840# vdda1 1.09fF **FLOATING
C12598 pll_full_0/divbuf_1/a_59550_n840# vdda1 1.09fF **FLOATING
C12599 pll_full_0/divbuf_1/a_59070_n840# vdda1 1.09fF **FLOATING
C12600 pll_full_0/divbuf_1/a_58590_n840# vdda1 1.09fF **FLOATING
C12601 pll_full_0/divbuf_1/a_58110_n840# vdda1 1.09fF **FLOATING
C12602 pll_full_0/divbuf_1/a_57630_n840# vdda1 1.09fF **FLOATING
C12603 pll_full_0/divbuf_1/a_57150_n840# vdda1 1.09fF **FLOATING
C12604 pll_full_0/divbuf_1/a_56670_n840# vdda1 1.09fF **FLOATING
C12605 pll_full_0/divbuf_1/a_56190_n840# vdda1 1.09fF **FLOATING
C12606 pll_full_0/divbuf_1/a_55710_n840# vdda1 1.09fF **FLOATING
C12607 pll_full_0/divbuf_1/a_55230_n840# vdda1 1.09fF **FLOATING
C12608 pll_full_0/divbuf_1/a_54750_n840# vdda1 1.09fF **FLOATING
C12609 pll_full_0/divbuf_1/a_54270_n840# vdda1 1.09fF **FLOATING
C12610 pll_full_0/divbuf_1/a_53790_n840# vdda1 1.09fF **FLOATING
C12611 pll_full_0/divbuf_1/a_53310_n840# vdda1 1.09fF **FLOATING
C12612 pll_full_0/divbuf_1/a_52830_n840# vdda1 1.09fF **FLOATING
C12613 pll_full_0/divbuf_1/a_52350_n840# vdda1 1.09fF **FLOATING
C12614 pll_full_0/divbuf_1/a_51870_n840# vdda1 1.09fF **FLOATING
C12615 pll_full_0/divbuf_1/a_51390_n840# vdda1 1.09fF **FLOATING
C12616 pll_full_0/divbuf_1/a_50910_n840# vdda1 1.09fF **FLOATING
C12617 pll_full_0/divbuf_1/a_50430_n840# vdda1 1.09fF **FLOATING
C12618 pll_full_0/divbuf_1/a_49950_n840# vdda1 1.09fF **FLOATING
C12619 pll_full_0/divbuf_1/a_49470_n840# vdda1 1.09fF **FLOATING
C12620 pll_full_0/divbuf_1/a_48990_n840# vdda1 1.09fF **FLOATING
C12621 pll_full_0/divbuf_1/a_48510_n840# vdda1 1.09fF **FLOATING
C12622 pll_full_0/divbuf_1/a_48030_n840# vdda1 1.09fF **FLOATING
C12623 pll_full_0/divbuf_1/a_47550_n840# vdda1 1.09fF **FLOATING
C12624 pll_full_0/divbuf_1/a_47070_n840# vdda1 1.09fF **FLOATING
C12625 pll_full_0/divbuf_1/a_46590_n840# vdda1 1.09fF **FLOATING
C12626 pll_full_0/divbuf_1/a_46110_n840# vdda1 1.09fF **FLOATING
C12627 pll_full_0/divbuf_1/a_45630_n840# vdda1 1.09fF **FLOATING
C12628 pll_full_0/divbuf_1/a_45150_n840# vdda1 1.09fF **FLOATING
C12629 pll_full_0/divbuf_1/a_44670_n840# vdda1 1.09fF **FLOATING
C12630 pll_full_0/divbuf_1/a_44190_n840# vdda1 1.09fF **FLOATING
C12631 pll_full_0/divbuf_1/a_43710_n840# vdda1 1.09fF **FLOATING
C12632 pll_full_0/divbuf_1/a_43230_n840# vdda1 1.09fF **FLOATING
C12633 pll_full_0/divbuf_1/a_42750_n840# vdda1 1.08fF **FLOATING
C12634 pll_full_0/divbuf_1/a_42270_n840# vdda1 1.08fF **FLOATING
C12635 pll_full_0/divbuf_1/a_41790_n840# vdda1 1.10fF **FLOATING
C12636 pll_full_0/divbuf_1/a_41310_n840# vdda1 1.09fF **FLOATING
C12637 pll_full_0/divbuf_1/a_40830_n840# vdda1 1.09fF **FLOATING
C12638 pll_full_0/divbuf_1/a_40350_n840# vdda1 1.09fF **FLOATING
C12639 pll_full_0/divbuf_1/a_39870_n840# vdda1 1.09fF **FLOATING
C12640 pll_full_0/divbuf_1/a_39390_n840# vdda1 1.09fF **FLOATING
C12641 pll_full_0/divbuf_1/a_38910_n840# vdda1 1.09fF **FLOATING
C12642 pll_full_0/divbuf_1/a_38430_n840# vdda1 1.09fF **FLOATING
C12643 pll_full_0/divbuf_1/a_37950_n840# vdda1 1.09fF **FLOATING
C12644 pll_full_0/divbuf_1/a_37470_n840# vdda1 1.09fF **FLOATING
C12645 pll_full_0/divbuf_1/a_36990_n840# vdda1 1.09fF **FLOATING
C12646 pll_full_0/divbuf_1/a_36510_n840# vdda1 1.09fF **FLOATING
C12647 pll_full_0/divbuf_1/a_36030_n840# vdda1 1.09fF **FLOATING
C12648 pll_full_0/divbuf_1/a_35550_n840# vdda1 1.09fF **FLOATING
C12649 pll_full_0/divbuf_1/a_35070_n840# vdda1 1.09fF **FLOATING
C12650 pll_full_0/divbuf_1/a_34590_n840# vdda1 1.09fF **FLOATING
C12651 pll_full_0/divbuf_1/a_34110_n840# vdda1 1.09fF **FLOATING
C12652 pll_full_0/divbuf_1/a_33630_n840# vdda1 1.09fF **FLOATING
C12653 pll_full_0/divbuf_1/a_33150_n840# vdda1 1.09fF **FLOATING
C12654 pll_full_0/divbuf_1/a_32670_n840# vdda1 1.09fF **FLOATING
C12655 pll_full_0/divbuf_1/a_32190_n840# vdda1 1.09fF **FLOATING
C12656 pll_full_0/divbuf_1/a_31710_n840# vdda1 1.11fF **FLOATING
C12657 pll_full_0/divbuf_1/a_31230_n840# vdda1 1.13fF **FLOATING
C12658 pll_full_0/divbuf_1/a_30750_n840# vdda1 1.09fF **FLOATING
C12659 pll_full_0/divbuf_1/a_30270_n840# vdda1 1.09fF **FLOATING
C12660 pll_full_0/divbuf_1/a_29790_n840# vdda1 1.09fF **FLOATING
C12661 pll_full_0/divbuf_1/a_29310_n840# vdda1 1.09fF **FLOATING
C12662 pll_full_0/divbuf_1/a_28830_n840# vdda1 1.09fF **FLOATING
C12663 pll_full_0/divbuf_1/a_28350_n840# vdda1 1.09fF **FLOATING
C12664 pll_full_0/divbuf_1/a_27870_n840# vdda1 1.08fF **FLOATING
C12665 pll_full_0/divbuf_1/a_27390_n840# vdda1 1.11fF **FLOATING
C12666 pll_full_0/divbuf_1/a_26910_n840# vdda1 1.10fF **FLOATING
C12667 pll_full_0/divbuf_1/a_26430_n840# vdda1 1.10fF **FLOATING
C12668 pll_full_0/divbuf_1/a_25950_n840# vdda1 1.10fF **FLOATING
C12669 pll_full_0/divbuf_1/a_25470_n840# vdda1 1.10fF **FLOATING
C12670 pll_full_0/divbuf_1/a_24990_n840# vdda1 1.10fF **FLOATING
C12671 pll_full_0/divbuf_1/a_24510_n840# vdda1 1.10fF **FLOATING
C12672 pll_full_0/divbuf_1/a_24030_n840# vdda1 1.09fF **FLOATING
C12673 pll_full_0/divbuf_1/a_23550_n840# vdda1 1.11fF **FLOATING
C12674 pll_full_0/divbuf_1/a_23070_n840# vdda1 1.10fF **FLOATING
C12675 pll_full_0/divbuf_1/a_22590_n840# vdda1 1.10fF **FLOATING
C12676 pll_full_0/divbuf_1/a_22110_n840# vdda1 1.10fF **FLOATING
C12677 pll_full_0/divbuf_1/a_21630_n840# vdda1 1.10fF **FLOATING
C12678 pll_full_0/divbuf_1/a_21150_n840# vdda1 1.10fF **FLOATING
C12679 pll_full_0/divbuf_1/a_20670_n840# vdda1 1.10fF **FLOATING
C12680 pll_full_0/divbuf_1/a_20190_n840# vdda1 1.09fF **FLOATING
C12681 pll_full_0/divbuf_1/a_19710_n840# vdda1 1.09fF **FLOATING
C12682 pll_full_0/divbuf_1/a_19230_n840# vdda1 1.09fF **FLOATING
C12683 pll_full_0/divbuf_1/a_18750_n840# vdda1 1.09fF **FLOATING
C12684 pll_full_0/divbuf_1/a_18270_n840# vdda1 1.08fF **FLOATING
C12685 pll_full_0/divbuf_1/a_17790_n840# vdda1 1.08fF **FLOATING
C12686 pll_full_0/divbuf_1/a_17310_n840# vdda1 1.07fF **FLOATING
C12687 pll_full_0/divbuf_1/a_16830_n840# vdda1 1.07fF **FLOATING
C12688 pll_full_0/divbuf_1/a_16350_n840# vdda1 1.07fF **FLOATING
C12689 pll_full_0/divbuf_1/a_15870_n840# vdda1 1.07fF **FLOATING
C12690 pll_full_0/divbuf_1/a_15390_n840# vdda1 1.08fF **FLOATING
C12691 pll_full_0/divbuf_1/a_14910_n840# vdda1 1.07fF **FLOATING
C12692 pll_full_0/divbuf_1/a_14430_n840# vdda1 1.07fF **FLOATING
C12693 pll_full_0/divbuf_1/a_13950_n840# vdda1 1.07fF **FLOATING
C12694 pll_full_0/divbuf_1/a_13470_n840# vdda1 1.07fF **FLOATING
C12695 pll_full_0/divbuf_1/a_12990_n840# vdda1 1.10fF **FLOATING
C12696 pll_full_0/divbuf_1/a_12510_n840# vdda1 1.08fF **FLOATING
C12697 pll_full_0/divbuf_1/a_12030_n840# vdda1 1.07fF **FLOATING
C12698 pll_full_0/divbuf_1/a_11550_n840# vdda1 1.07fF **FLOATING
C12699 pll_full_0/divbuf_1/a_11070_n840# vdda1 1.08fF **FLOATING
C12700 pll_full_0/divbuf_1/a_10590_n840# vdda1 1.10fF **FLOATING
C12701 pll_full_0/divbuf_1/a_10110_n840# vdda1 1.10fF **FLOATING
C12702 pll_full_0/divbuf_1/a_9630_n840# vdda1 1.10fF **FLOATING
C12703 pll_full_0/divbuf_1/a_9150_n840# vdda1 1.10fF **FLOATING
C12704 pll_full_0/divbuf_1/a_8670_n840# vdda1 1.10fF **FLOATING
C12705 pll_full_0/divbuf_1/a_8190_n840# vdda1 1.12fF **FLOATING
C12706 pll_full_0/divbuf_1/a_7710_n840# vdda1 1.10fF **FLOATING
C12707 pll_full_0/divbuf_1/a_7230_n840# vdda1 1.09fF **FLOATING
C12708 pll_full_0/divbuf_1/a_6750_n840# vdda1 1.09fF **FLOATING
C12709 pll_full_0/divbuf_1/a_6270_n840# vdda1 1.09fF **FLOATING
C12710 pll_full_0/divbuf_1/a_5790_n840# vdda1 1.09fF **FLOATING
C12711 pll_full_0/divbuf_1/a_5310_n840# vdda1 1.09fF **FLOATING
C12712 pll_full_0/divbuf_1/a_4830_n840# vdda1 1.09fF **FLOATING
C12713 pll_full_0/divbuf_1/a_4350_n840# vdda1 1.09fF **FLOATING
C12714 pll_full_0/divbuf_1/a_3870_n840# vdda1 1.09fF **FLOATING
C12715 pll_full_0/divbuf_1/a_3390_n840# vdda1 1.09fF **FLOATING
C12716 pll_full_0/divbuf_1/a_2910_n840# vdda1 1.10fF **FLOATING
C12717 pll_full_0/divbuf_1/a_2430_n840# vdda1 1.10fF **FLOATING
C12718 pll_full_0/divbuf_1/a_1950_n840# vdda1 1.10fF **FLOATING
C12719 pll_full_0/divbuf_1/a_1470_n840# vdda1 1.10fF **FLOATING
C12720 pll_full_0/divbuf_1/a_990_n840# vdda1 1.08fF **FLOATING
C12721 pll_full_0/divbuf_1/a_510_n840# vdda1 1.07fF **FLOATING
C12722 pll_full_0/divbuf_1/a_60480_n1600# vdda1 1.48fF **FLOATING
C12723 pll_full_0/divbuf_1/a_60000_n1600# vdda1 1.48fF **FLOATING
C12724 pll_full_0/divbuf_1/a_59520_n1600# vdda1 1.48fF **FLOATING
C12725 pll_full_0/divbuf_1/a_59040_n1600# vdda1 1.48fF **FLOATING
C12726 pll_full_0/divbuf_1/a_58560_n1600# vdda1 1.48fF **FLOATING
C12727 pll_full_0/divbuf_1/a_58080_n1600# vdda1 1.48fF **FLOATING
C12728 pll_full_0/divbuf_1/a_57600_n1600# vdda1 1.48fF **FLOATING
C12729 pll_full_0/divbuf_1/a_57120_n1600# vdda1 1.48fF **FLOATING
C12730 pll_full_0/divbuf_1/a_56640_n1600# vdda1 1.48fF **FLOATING
C12731 pll_full_0/divbuf_1/a_56160_n1600# vdda1 1.48fF **FLOATING
C12732 pll_full_0/divbuf_1/a_55680_n1600# vdda1 1.48fF **FLOATING
C12733 pll_full_0/divbuf_1/a_55200_n1600# vdda1 1.48fF **FLOATING
C12734 pll_full_0/divbuf_1/a_54720_n1600# vdda1 1.48fF **FLOATING
C12735 pll_full_0/divbuf_1/a_54240_n1600# vdda1 1.48fF **FLOATING
C12736 pll_full_0/divbuf_1/a_53760_n1600# vdda1 1.48fF **FLOATING
C12737 pll_full_0/divbuf_1/a_53280_n1600# vdda1 1.48fF **FLOATING
C12738 pll_full_0/divbuf_1/a_52800_n1600# vdda1 1.48fF **FLOATING
C12739 pll_full_0/divbuf_1/a_52320_n1600# vdda1 1.48fF **FLOATING
C12740 pll_full_0/divbuf_1/a_51840_n1600# vdda1 1.48fF **FLOATING
C12741 pll_full_0/divbuf_1/a_51360_n1600# vdda1 1.48fF **FLOATING
C12742 pll_full_0/divbuf_1/a_50880_n1600# vdda1 1.48fF **FLOATING
C12743 pll_full_0/divbuf_1/a_50400_n1600# vdda1 1.48fF **FLOATING
C12744 pll_full_0/divbuf_1/a_49920_n1600# vdda1 1.48fF **FLOATING
C12745 pll_full_0/divbuf_1/a_49440_n1600# vdda1 1.48fF **FLOATING
C12746 pll_full_0/divbuf_1/a_48960_n1600# vdda1 1.48fF **FLOATING
C12747 pll_full_0/divbuf_1/a_48480_n1600# vdda1 1.48fF **FLOATING
C12748 pll_full_0/divbuf_1/a_48000_n1600# vdda1 1.48fF **FLOATING
C12749 pll_full_0/divbuf_1/a_47520_n1600# vdda1 1.48fF **FLOATING
C12750 pll_full_0/divbuf_1/a_47040_n1600# vdda1 1.48fF **FLOATING
C12751 pll_full_0/divbuf_1/a_46560_n1600# vdda1 1.48fF **FLOATING
C12752 pll_full_0/divbuf_1/a_46080_n1600# vdda1 1.48fF **FLOATING
C12753 pll_full_0/divbuf_1/a_45600_n1600# vdda1 1.48fF **FLOATING
C12754 pll_full_0/divbuf_1/a_45120_n1600# vdda1 1.48fF **FLOATING
C12755 pll_full_0/divbuf_1/a_44640_n1600# vdda1 1.48fF **FLOATING
C12756 pll_full_0/divbuf_1/a_44160_n1600# vdda1 1.48fF **FLOATING
C12757 pll_full_0/divbuf_1/a_43680_n1600# vdda1 1.48fF **FLOATING
C12758 pll_full_0/divbuf_1/a_43200_n1600# vdda1 1.48fF **FLOATING
C12759 pll_full_0/divbuf_1/a_42720_n1600# vdda1 1.48fF **FLOATING
C12760 pll_full_0/divbuf_1/a_42240_n1600# vdda1 1.48fF **FLOATING
C12761 pll_full_0/divbuf_1/a_41760_n1600# vdda1 1.48fF **FLOATING
C12762 pll_full_0/divbuf_1/a_41280_n1600# vdda1 1.48fF **FLOATING
C12763 pll_full_0/divbuf_1/a_40800_n1600# vdda1 1.48fF **FLOATING
C12764 pll_full_0/divbuf_1/a_40320_n1600# vdda1 1.48fF **FLOATING
C12765 pll_full_0/divbuf_1/a_39840_n1600# vdda1 1.48fF **FLOATING
C12766 pll_full_0/divbuf_1/a_39360_n1600# vdda1 1.48fF **FLOATING
C12767 pll_full_0/divbuf_1/a_38880_n1600# vdda1 1.48fF **FLOATING
C12768 pll_full_0/divbuf_1/a_38400_n1600# vdda1 1.48fF **FLOATING
C12769 pll_full_0/divbuf_1/a_37920_n1600# vdda1 1.48fF **FLOATING
C12770 pll_full_0/divbuf_1/a_37440_n1600# vdda1 1.48fF **FLOATING
C12771 pll_full_0/divbuf_1/a_36960_n1600# vdda1 1.48fF **FLOATING
C12772 pll_full_0/divbuf_1/a_36480_n1600# vdda1 1.48fF **FLOATING
C12773 pll_full_0/divbuf_1/a_36000_n1600# vdda1 1.48fF **FLOATING
C12774 pll_full_0/divbuf_1/a_35520_n1600# vdda1 1.48fF **FLOATING
C12775 pll_full_0/divbuf_1/a_35040_n1600# vdda1 1.48fF **FLOATING
C12776 pll_full_0/divbuf_1/a_34560_n1600# vdda1 1.48fF **FLOATING
C12777 pll_full_0/divbuf_1/a_34080_n1600# vdda1 1.48fF **FLOATING
C12778 pll_full_0/divbuf_1/a_33600_n1600# vdda1 1.48fF **FLOATING
C12779 pll_full_0/divbuf_1/a_33120_n1600# vdda1 1.48fF **FLOATING
C12780 pll_full_0/divbuf_1/a_32640_n1600# vdda1 1.48fF **FLOATING
C12781 pll_full_0/divbuf_1/a_32160_n1600# vdda1 1.48fF **FLOATING
C12782 pll_full_0/divbuf_1/a_31680_n1600# vdda1 1.48fF **FLOATING
C12783 pll_full_0/divbuf_1/a_31200_n1600# vdda1 1.48fF **FLOATING
C12784 pll_full_0/divbuf_1/a_30720_n1600# vdda1 1.48fF **FLOATING
C12785 pll_full_0/divbuf_1/a_30240_n1600# vdda1 1.48fF **FLOATING
C12786 pll_full_0/divbuf_1/a_29760_n1600# vdda1 1.48fF **FLOATING
C12787 pll_full_0/divbuf_1/a_29280_n1600# vdda1 1.48fF **FLOATING
C12788 pll_full_0/divbuf_1/a_28800_n1600# vdda1 1.48fF **FLOATING
C12789 pll_full_0/divbuf_1/a_28320_n1600# vdda1 1.48fF **FLOATING
C12790 pll_full_0/divbuf_1/a_27840_n1600# vdda1 1.48fF **FLOATING
C12791 pll_full_0/divbuf_1/a_27360_n1600# vdda1 1.48fF **FLOATING
C12792 pll_full_0/divbuf_1/a_26880_n1600# vdda1 1.48fF **FLOATING
C12793 pll_full_0/divbuf_1/a_26400_n1600# vdda1 1.48fF **FLOATING
C12794 pll_full_0/divbuf_1/a_25920_n1600# vdda1 1.48fF **FLOATING
C12795 pll_full_0/divbuf_1/a_25440_n1600# vdda1 1.48fF **FLOATING
C12796 pll_full_0/divbuf_1/a_24960_n1600# vdda1 1.48fF **FLOATING
C12797 pll_full_0/divbuf_1/a_24480_n1600# vdda1 1.48fF **FLOATING
C12798 pll_full_0/divbuf_1/a_24000_n1600# vdda1 1.48fF **FLOATING
C12799 pll_full_0/divbuf_1/a_23520_n1600# vdda1 1.48fF **FLOATING
C12800 pll_full_0/divbuf_1/a_23040_n1600# vdda1 1.48fF **FLOATING
C12801 pll_full_0/divbuf_1/a_22560_n1600# vdda1 1.48fF **FLOATING
C12802 pll_full_0/divbuf_1/a_22080_n1600# vdda1 1.48fF **FLOATING
C12803 pll_full_0/divbuf_1/a_21600_n1600# vdda1 1.48fF **FLOATING
C12804 pll_full_0/divbuf_1/a_21120_n1600# vdda1 1.48fF **FLOATING
C12805 pll_full_0/divbuf_1/a_20640_n1600# vdda1 1.48fF **FLOATING
C12806 pll_full_0/divbuf_1/a_20160_n1600# vdda1 1.48fF **FLOATING
C12807 pll_full_0/divbuf_1/a_19680_n1600# vdda1 1.48fF **FLOATING
C12808 pll_full_0/divbuf_1/a_19200_n1600# vdda1 1.48fF **FLOATING
C12809 pll_full_0/divbuf_1/a_18720_n1600# vdda1 1.48fF **FLOATING
C12810 pll_full_0/divbuf_1/a_18240_n1600# vdda1 1.48fF **FLOATING
C12811 pll_full_0/divbuf_1/a_17760_n1600# vdda1 1.48fF **FLOATING
C12812 pll_full_0/divbuf_1/a_17280_n1600# vdda1 1.48fF **FLOATING
C12813 pll_full_0/divbuf_1/a_16800_n1600# vdda1 1.48fF **FLOATING
C12814 pll_full_0/divbuf_1/a_16320_n1600# vdda1 1.48fF **FLOATING
C12815 pll_full_0/divbuf_1/a_15840_n1600# vdda1 1.48fF **FLOATING
C12816 pll_full_0/divbuf_1/a_15360_n1600# vdda1 1.48fF **FLOATING
C12817 pll_full_0/divbuf_1/a_14880_n1600# vdda1 1.48fF **FLOATING
C12818 pll_full_0/divbuf_1/a_14400_n1600# vdda1 1.48fF **FLOATING
C12819 pll_full_0/divbuf_1/a_13920_n1600# vdda1 1.48fF **FLOATING
C12820 pll_full_0/divbuf_1/a_13440_n1600# vdda1 1.48fF **FLOATING
C12821 pll_full_0/divbuf_1/a_12960_n1600# vdda1 1.48fF **FLOATING
C12822 pll_full_0/divbuf_1/a_12480_n1600# vdda1 1.48fF **FLOATING
C12823 pll_full_0/divbuf_1/a_12000_n1600# vdda1 1.48fF **FLOATING
C12824 pll_full_0/divbuf_1/a_11520_n1600# vdda1 1.48fF **FLOATING
C12825 pll_full_0/divbuf_1/a_11040_n1600# vdda1 1.48fF **FLOATING
C12826 pll_full_0/divbuf_1/a_10560_n1600# vdda1 1.48fF **FLOATING
C12827 pll_full_0/divbuf_1/a_10080_n1600# vdda1 1.48fF **FLOATING
C12828 pll_full_0/divbuf_1/a_9600_n1600# vdda1 1.48fF **FLOATING
C12829 pll_full_0/divbuf_1/a_9120_n1600# vdda1 1.48fF **FLOATING
C12830 pll_full_0/divbuf_1/a_8640_n1600# vdda1 1.48fF **FLOATING
C12831 pll_full_0/divbuf_1/a_8160_n1600# vdda1 1.48fF **FLOATING
C12832 pll_full_0/divbuf_1/a_7680_n1600# vdda1 1.48fF **FLOATING
C12833 pll_full_0/divbuf_1/a_7200_n1600# vdda1 1.48fF **FLOATING
C12834 pll_full_0/divbuf_1/a_6720_n1600# vdda1 1.48fF **FLOATING
C12835 pll_full_0/divbuf_1/a_6240_n1600# vdda1 1.48fF **FLOATING
C12836 pll_full_0/divbuf_1/a_5760_n1600# vdda1 1.48fF **FLOATING
C12837 pll_full_0/divbuf_1/a_5280_n1600# vdda1 1.48fF **FLOATING
C12838 pll_full_0/divbuf_1/a_4800_n1600# vdda1 1.48fF **FLOATING
C12839 pll_full_0/divbuf_1/a_4320_n1600# vdda1 1.48fF **FLOATING
C12840 pll_full_0/divbuf_1/a_3840_n1600# vdda1 1.48fF **FLOATING
C12841 pll_full_0/divbuf_1/a_3360_n1600# vdda1 1.48fF **FLOATING
C12842 pll_full_0/divbuf_1/a_2880_n1600# vdda1 1.48fF **FLOATING
C12843 pll_full_0/divbuf_1/a_2400_n1600# vdda1 1.48fF **FLOATING
C12844 pll_full_0/divbuf_1/a_1920_n1600# vdda1 1.48fF **FLOATING
C12845 pll_full_0/divbuf_1/a_1440_n1600# vdda1 1.48fF **FLOATING
C12846 pll_full_0/divbuf_1/a_960_n1600# vdda1 1.48fF **FLOATING
C12847 pll_full_0/divbuf_1/a_480_n1600# vdda1 1.48fF **FLOATING
C12848 pll_full_0/divbuf_1/a_0_n1600# vdda1 1.48fF **FLOATING
C12849 pll_full_0/divbuf_1/a_41382_n240# vdda1 0.90fF **FLOATING
C12850 pll_full_0/divbuf_1/a_40902_n240# vdda1 0.90fF **FLOATING
C12851 pll_full_0/divbuf_1/a_40412_n240# vdda1 0.90fF **FLOATING
C12852 pll_full_0/divbuf_1/a_39932_n240# vdda1 0.90fF **FLOATING
C12853 pll_full_0/divbuf_1/a_39442_n240# vdda1 0.90fF **FLOATING
C12854 pll_full_0/divbuf_1/a_38962_n240# vdda1 0.91fF **FLOATING
C12855 pll_full_0/divbuf_1/a_38472_n240# vdda1 0.90fF **FLOATING
C12856 pll_full_0/divbuf_1/a_37992_n240# vdda1 0.90fF **FLOATING
C12857 pll_full_0/divbuf_1/a_37502_n240# vdda1 0.90fF **FLOATING
C12858 pll_full_0/divbuf_1/a_37022_n240# vdda1 0.90fF **FLOATING
C12859 pll_full_0/divbuf_1/a_36532_n240# vdda1 0.90fF **FLOATING
C12860 pll_full_0/divbuf_1/a_36052_n240# vdda1 0.90fF **FLOATING
C12861 pll_full_0/divbuf_1/a_35562_n240# vdda1 0.90fF **FLOATING
C12862 pll_full_0/divbuf_1/a_35082_n240# vdda1 0.91fF **FLOATING
C12863 pll_full_0/divbuf_1/a_34592_n240# vdda1 0.90fF **FLOATING
C12864 pll_full_0/divbuf_1/a_34112_n240# vdda1 0.90fF **FLOATING
C12865 pll_full_0/divbuf_1/a_33622_n240# vdda1 0.90fF **FLOATING
C12866 pll_full_0/divbuf_1/a_33142_n240# vdda1 0.90fF **FLOATING
C12867 pll_full_0/divbuf_1/a_32652_n240# vdda1 0.90fF **FLOATING
C12868 pll_full_0/divbuf_1/a_32172_n240# vdda1 0.90fF **FLOATING
C12869 pll_full_0/divbuf_1/a_31682_n240# vdda1 0.89fF **FLOATING
C12870 pll_full_0/divbuf_1/a_31202_n240# vdda1 0.92fF **FLOATING
C12871 pll_full_0/divbuf_1/a_30712_n240# vdda1 0.90fF **FLOATING
C12872 pll_full_0/divbuf_1/a_30232_n240# vdda1 0.90fF **FLOATING
C12873 pll_full_0/divbuf_1/a_29742_n240# vdda1 0.90fF **FLOATING
C12874 pll_full_0/divbuf_1/a_29262_n240# vdda1 0.90fF **FLOATING
C12875 pll_full_0/divbuf_1/a_28772_n240# vdda1 0.90fF **FLOATING
C12876 pll_full_0/divbuf_1/a_28292_n240# vdda1 0.90fF **FLOATING
C12877 pll_full_0/divbuf_1/a_27802_n240# vdda1 0.89fF **FLOATING
C12878 pll_full_0/divbuf_1/a_27322_n240# vdda1 0.95fF **FLOATING
C12879 pll_full_0/divbuf_1/a_26832_n240# vdda1 0.91fF **FLOATING
C12880 pll_full_0/divbuf_1/a_26352_n240# vdda1 0.91fF **FLOATING
C12881 pll_full_0/divbuf_1/a_25862_n240# vdda1 0.91fF **FLOATING
C12882 pll_full_0/divbuf_1/a_25382_n240# vdda1 0.91fF **FLOATING
C12883 pll_full_0/divbuf_1/a_24892_n240# vdda1 0.91fF **FLOATING
C12884 pll_full_0/divbuf_1/a_24412_n240# vdda1 0.91fF **FLOATING
C12885 pll_full_0/divbuf_1/a_23922_n240# vdda1 0.92fF **FLOATING
C12886 pll_full_0/divbuf_1/a_23442_n240# vdda1 0.94fF **FLOATING
C12887 pll_full_0/divbuf_1/a_22952_n240# vdda1 0.91fF **FLOATING
C12888 pll_full_0/divbuf_1/a_22472_n240# vdda1 0.91fF **FLOATING
C12889 pll_full_0/divbuf_1/a_21982_n240# vdda1 0.91fF **FLOATING
C12890 pll_full_0/divbuf_1/a_21502_n240# vdda1 0.91fF **FLOATING
C12891 pll_full_0/divbuf_1/a_21012_n240# vdda1 0.91fF **FLOATING
C12892 pll_full_0/divbuf_1/a_20532_n240# vdda1 0.91fF **FLOATING
C12893 pll_full_0/divbuf_1/a_20042_n240# vdda1 0.90fF **FLOATING
C12894 pll_full_0/divbuf_1/a_19562_n240# vdda1 0.90fF **FLOATING
C12895 pll_full_0/divbuf_1/a_19072_n240# vdda1 0.90fF **FLOATING
C12896 pll_full_0/divbuf_1/a_18582_n240# vdda1 0.89fF **FLOATING
C12897 pll_full_0/divbuf_1/a_18092_n240# vdda1 0.89fF **FLOATING
C12898 pll_full_0/divbuf_1/a_17612_n240# vdda1 0.89fF **FLOATING
C12899 pll_full_0/divbuf_1/a_17122_n240# vdda1 0.88fF **FLOATING
C12900 pll_full_0/divbuf_1/a_16642_n240# vdda1 0.88fF **FLOATING
C12901 pll_full_0/divbuf_1/a_16152_n240# vdda1 0.88fF **FLOATING
C12902 pll_full_0/divbuf_1/a_15672_n240# vdda1 0.90fF **FLOATING
C12903 pll_full_0/divbuf_1/a_15182_n240# vdda1 0.88fF **FLOATING
C12904 pll_full_0/divbuf_1/a_14702_n240# vdda1 0.88fF **FLOATING
C12905 pll_full_0/divbuf_1/a_14222_n240# vdda1 0.88fF **FLOATING
C12906 pll_full_0/divbuf_1/a_13742_n240# vdda1 0.88fF **FLOATING
C12907 pll_full_0/divbuf_1/a_13252_n240# vdda1 0.88fF **FLOATING
C12908 pll_full_0/divbuf_1/a_12772_n240# vdda1 0.88fF **FLOATING
C12909 pll_full_0/divbuf_1/a_12282_n240# vdda1 0.88fF **FLOATING
C12910 pll_full_0/divbuf_1/a_11802_n240# vdda1 0.88fF **FLOATING
C12911 pll_full_0/divbuf_1/a_11312_n240# vdda1 0.89fF **FLOATING
C12912 pll_full_0/divbuf_1/a_10212_n240# vdda1 0.91fF **FLOATING
C12913 pll_full_0/divbuf_1/a_9732_n240# vdda1 0.91fF **FLOATING
C12914 pll_full_0/divbuf_1/a_9242_n240# vdda1 0.91fF **FLOATING
C12915 pll_full_0/divbuf_1/a_8762_n240# vdda1 0.91fF **FLOATING
C12916 pll_full_0/divbuf_1/a_8272_n240# vdda1 0.91fF **FLOATING
C12917 pll_full_0/divbuf_1/a_7792_n240# vdda1 0.92fF **FLOATING
C12918 pll_full_0/divbuf_1/a_7302_n240# vdda1 0.90fF **FLOATING
C12919 pll_full_0/divbuf_1/a_6822_n240# vdda1 0.90fF **FLOATING
C12920 pll_full_0/divbuf_1/a_6332_n240# vdda1 0.90fF **FLOATING
C12921 pll_full_0/divbuf_1/a_5852_n240# vdda1 0.90fF **FLOATING
C12922 pll_full_0/divbuf_1/a_5362_n240# vdda1 0.90fF **FLOATING
C12923 pll_full_0/divbuf_1/a_4882_n240# vdda1 0.90fF **FLOATING
C12924 pll_full_0/divbuf_1/a_4392_n240# vdda1 0.90fF **FLOATING
C12925 pll_full_0/divbuf_1/a_3912_n240# vdda1 0.90fF **FLOATING
C12926 pll_full_0/divbuf_1/a_3422_n240# vdda1 0.90fF **FLOATING
C12927 pll_full_0/divbuf_1/a_2322_n240# vdda1 0.91fF **FLOATING
C12928 pll_full_0/divbuf_1/a_1842_n240# vdda1 0.91fF **FLOATING
C12929 pll_full_0/divbuf_1/a_1352_n240# vdda1 0.91fF **FLOATING
C12930 pll_full_0/divbuf_1/a_41382_170# vdda1 1.07fF **FLOATING
C12931 pll_full_0/divbuf_1/a_40902_170# vdda1 1.09fF **FLOATING
C12932 pll_full_0/divbuf_1/a_40412_170# vdda1 1.09fF **FLOATING
C12933 pll_full_0/divbuf_1/a_39932_170# vdda1 1.09fF **FLOATING
C12934 pll_full_0/divbuf_1/a_39442_170# vdda1 1.09fF **FLOATING
C12935 pll_full_0/divbuf_1/a_38962_170# vdda1 1.07fF **FLOATING
C12936 pll_full_0/divbuf_1/a_38472_170# vdda1 1.09fF **FLOATING
C12937 pll_full_0/divbuf_1/a_37992_170# vdda1 1.09fF **FLOATING
C12938 pll_full_0/divbuf_1/a_37502_170# vdda1 1.09fF **FLOATING
C12939 pll_full_0/divbuf_1/a_37022_170# vdda1 1.09fF **FLOATING
C12940 pll_full_0/divbuf_1/a_36532_170# vdda1 1.09fF **FLOATING
C12941 pll_full_0/divbuf_1/a_36052_170# vdda1 1.09fF **FLOATING
C12942 pll_full_0/divbuf_1/a_35562_170# vdda1 1.09fF **FLOATING
C12943 pll_full_0/divbuf_1/a_35082_170# vdda1 1.09fF **FLOATING
C12944 pll_full_0/divbuf_1/a_34592_170# vdda1 1.07fF **FLOATING
C12945 pll_full_0/divbuf_1/a_34112_170# vdda1 1.09fF **FLOATING
C12946 pll_full_0/divbuf_1/a_33622_170# vdda1 1.09fF **FLOATING
C12947 pll_full_0/divbuf_1/a_33142_170# vdda1 1.09fF **FLOATING
C12948 pll_full_0/divbuf_1/a_32652_170# vdda1 1.09fF **FLOATING
C12949 pll_full_0/divbuf_1/a_32172_170# vdda1 1.09fF **FLOATING
C12950 pll_full_0/divbuf_1/a_31682_170# vdda1 1.09fF **FLOATING
C12951 pll_full_0/divbuf_1/a_31202_170# vdda1 1.09fF **FLOATING
C12952 pll_full_0/divbuf_1/a_30712_170# vdda1 1.09fF **FLOATING
C12953 pll_full_0/divbuf_1/a_30232_170# vdda1 1.07fF **FLOATING
C12954 pll_full_0/divbuf_1/a_29742_170# vdda1 1.09fF **FLOATING
C12955 pll_full_0/divbuf_1/a_29262_170# vdda1 1.09fF **FLOATING
C12956 pll_full_0/divbuf_1/a_28772_170# vdda1 1.09fF **FLOATING
C12957 pll_full_0/divbuf_1/a_28292_170# vdda1 1.09fF **FLOATING
C12958 pll_full_0/divbuf_1/a_27802_170# vdda1 1.09fF **FLOATING
C12959 pll_full_0/divbuf_1/a_27322_170# vdda1 1.09fF **FLOATING
C12960 pll_full_0/divbuf_1/a_26832_170# vdda1 1.09fF **FLOATING
C12961 pll_full_0/divbuf_1/a_26352_170# vdda1 1.09fF **FLOATING
C12962 pll_full_0/divbuf_1/a_25862_170# vdda1 1.07fF **FLOATING
C12963 pll_full_0/divbuf_1/a_25382_170# vdda1 1.09fF **FLOATING
C12964 pll_full_0/divbuf_1/a_24892_170# vdda1 1.09fF **FLOATING
C12965 pll_full_0/divbuf_1/a_24412_170# vdda1 1.09fF **FLOATING
C12966 pll_full_0/divbuf_1/a_23922_170# vdda1 1.09fF **FLOATING
C12967 pll_full_0/divbuf_1/a_23442_170# vdda1 1.09fF **FLOATING
C12968 pll_full_0/divbuf_1/a_22952_170# vdda1 1.09fF **FLOATING
C12969 pll_full_0/divbuf_1/a_22472_170# vdda1 1.07fF **FLOATING
C12970 pll_full_0/divbuf_1/a_21982_170# vdda1 1.09fF **FLOATING
C12971 pll_full_0/divbuf_1/a_21502_170# vdda1 1.09fF **FLOATING
C12972 pll_full_0/divbuf_1/a_21012_170# vdda1 1.09fF **FLOATING
C12973 pll_full_0/divbuf_1/a_20532_170# vdda1 1.09fF **FLOATING
C12974 pll_full_0/divbuf_1/a_20042_170# vdda1 1.09fF **FLOATING
C12975 pll_full_0/divbuf_1/a_19562_170# vdda1 1.09fF **FLOATING
C12976 pll_full_0/divbuf_1/a_19072_170# vdda1 1.09fF **FLOATING
C12977 pll_full_0/divbuf_1/a_18582_170# vdda1 1.07fF **FLOATING
C12978 pll_full_0/divbuf_1/a_18092_170# vdda1 1.09fF **FLOATING
C12979 pll_full_0/divbuf_1/a_17612_170# vdda1 1.09fF **FLOATING
C12980 pll_full_0/divbuf_1/a_17122_170# vdda1 1.09fF **FLOATING
C12981 pll_full_0/divbuf_1/a_16642_170# vdda1 1.09fF **FLOATING
C12982 pll_full_0/divbuf_1/a_16152_170# vdda1 1.09fF **FLOATING
C12983 pll_full_0/divbuf_1/a_15672_170# vdda1 1.09fF **FLOATING
C12984 pll_full_0/divbuf_1/a_15182_170# vdda1 1.09fF **FLOATING
C12985 pll_full_0/divbuf_1/a_14702_170# vdda1 1.10fF **FLOATING
C12986 pll_full_0/divbuf_1/a_14222_170# vdda1 1.10fF **FLOATING
C12987 pll_full_0/divbuf_1/a_13742_170# vdda1 1.09fF **FLOATING
C12988 pll_full_0/divbuf_1/a_13252_170# vdda1 1.09fF **FLOATING
C12989 pll_full_0/divbuf_1/a_12772_170# vdda1 1.07fF **FLOATING
C12990 pll_full_0/divbuf_1/a_12282_170# vdda1 1.09fF **FLOATING
C12991 pll_full_0/divbuf_1/a_11802_170# vdda1 1.09fF **FLOATING
C12992 pll_full_0/divbuf_1/a_11312_170# vdda1 1.10fF **FLOATING
C12993 pll_full_0/divbuf_1/a_10212_170# vdda1 1.09fF **FLOATING
C12994 pll_full_0/divbuf_1/a_9732_170# vdda1 1.09fF **FLOATING
C12995 pll_full_0/divbuf_1/a_9242_170# vdda1 1.09fF **FLOATING
C12996 pll_full_0/divbuf_1/a_8762_170# vdda1 1.09fF **FLOATING
C12997 pll_full_0/divbuf_1/a_8272_170# vdda1 1.07fF **FLOATING
C12998 pll_full_0/divbuf_1/a_7792_170# vdda1 1.09fF **FLOATING
C12999 pll_full_0/divbuf_1/a_7302_170# vdda1 1.09fF **FLOATING
C13000 pll_full_0/divbuf_1/a_6822_170# vdda1 1.09fF **FLOATING
C13001 pll_full_0/divbuf_1/a_6332_170# vdda1 1.09fF **FLOATING
C13002 pll_full_0/divbuf_1/a_5852_170# vdda1 1.09fF **FLOATING
C13003 pll_full_0/divbuf_1/a_5362_170# vdda1 1.09fF **FLOATING
C13004 pll_full_0/divbuf_1/a_4882_170# vdda1 1.09fF **FLOATING
C13005 pll_full_0/divbuf_1/a_4392_170# vdda1 1.07fF **FLOATING
C13006 pll_full_0/divbuf_1/a_3912_170# vdda1 1.09fF **FLOATING
C13007 pll_full_0/divbuf_1/a_3422_170# vdda1 1.10fF **FLOATING
C13008 pll_full_0/divbuf_1/a_2322_170# vdda1 1.09fF **FLOATING
C13009 pll_full_0/divbuf_1/a_1842_170# vdda1 1.09fF **FLOATING
C13010 pll_full_0/divbuf_1/a_1352_170# vdda1 1.10fF **FLOATING
C13011 pll_full_0/divbuf_1/a_492_n240# vdda1 2.46fF **FLOATING
C13012 pll_full_0/divbuf_0/OUT5 vdda1 16.40fF
C13013 pll_full_0/divbuf_0/OUT4 vdda1 100.06fF
C13014 pll_full_0/divbuf_0/OUT3 vdda1 27.01fF
C13015 pll_full_0/divbuf_0/OUT2 vdda1 8.71fF
C13016 pll_full_0/divbuf_0/a_60990_n1540# vdda1 1.57fF **FLOATING
C13017 pll_full_0/divbuf_0/a_60510_n1540# vdda1 1.62fF **FLOATING
C13018 pll_full_0/divbuf_0/a_60030_n1540# vdda1 1.62fF **FLOATING
C13019 pll_full_0/divbuf_0/a_59550_n1540# vdda1 1.62fF **FLOATING
C13020 pll_full_0/divbuf_0/a_59070_n1540# vdda1 1.62fF **FLOATING
C13021 pll_full_0/divbuf_0/a_58590_n1540# vdda1 1.62fF **FLOATING
C13022 pll_full_0/divbuf_0/a_58110_n1540# vdda1 1.62fF **FLOATING
C13023 pll_full_0/divbuf_0/a_57630_n1540# vdda1 1.62fF **FLOATING
C13024 pll_full_0/divbuf_0/a_57150_n1540# vdda1 1.62fF **FLOATING
C13025 pll_full_0/divbuf_0/a_56670_n1540# vdda1 1.62fF **FLOATING
C13026 pll_full_0/divbuf_0/a_56190_n1540# vdda1 1.62fF **FLOATING
C13027 pll_full_0/divbuf_0/a_55710_n1540# vdda1 1.62fF **FLOATING
C13028 pll_full_0/divbuf_0/a_55230_n1540# vdda1 1.62fF **FLOATING
C13029 pll_full_0/divbuf_0/a_54750_n1540# vdda1 1.62fF **FLOATING
C13030 pll_full_0/divbuf_0/a_54270_n1540# vdda1 1.62fF **FLOATING
C13031 pll_full_0/divbuf_0/a_53790_n1540# vdda1 1.62fF **FLOATING
C13032 pll_full_0/divbuf_0/a_53310_n1540# vdda1 1.62fF **FLOATING
C13033 pll_full_0/divbuf_0/a_52830_n1540# vdda1 1.62fF **FLOATING
C13034 pll_full_0/divbuf_0/a_52350_n1540# vdda1 1.62fF **FLOATING
C13035 pll_full_0/divbuf_0/a_51870_n1540# vdda1 1.62fF **FLOATING
C13036 pll_full_0/divbuf_0/a_51390_n1540# vdda1 1.62fF **FLOATING
C13037 pll_full_0/divbuf_0/a_50910_n1540# vdda1 1.62fF **FLOATING
C13038 pll_full_0/divbuf_0/a_50430_n1540# vdda1 1.62fF **FLOATING
C13039 pll_full_0/divbuf_0/a_49950_n1540# vdda1 1.62fF **FLOATING
C13040 pll_full_0/divbuf_0/a_49470_n1540# vdda1 1.62fF **FLOATING
C13041 pll_full_0/divbuf_0/a_48990_n1540# vdda1 1.62fF **FLOATING
C13042 pll_full_0/divbuf_0/a_48510_n1540# vdda1 1.62fF **FLOATING
C13043 pll_full_0/divbuf_0/a_48030_n1540# vdda1 1.62fF **FLOATING
C13044 pll_full_0/divbuf_0/a_47550_n1540# vdda1 1.62fF **FLOATING
C13045 pll_full_0/divbuf_0/a_47070_n1540# vdda1 1.62fF **FLOATING
C13046 pll_full_0/divbuf_0/a_46590_n1540# vdda1 1.62fF **FLOATING
C13047 pll_full_0/divbuf_0/a_46110_n1540# vdda1 1.62fF **FLOATING
C13048 pll_full_0/divbuf_0/a_45630_n1540# vdda1 1.62fF **FLOATING
C13049 pll_full_0/divbuf_0/a_45150_n1540# vdda1 1.62fF **FLOATING
C13050 pll_full_0/divbuf_0/a_44670_n1540# vdda1 1.62fF **FLOATING
C13051 pll_full_0/divbuf_0/a_44190_n1540# vdda1 1.62fF **FLOATING
C13052 pll_full_0/divbuf_0/a_43710_n1540# vdda1 1.62fF **FLOATING
C13053 pll_full_0/divbuf_0/a_43230_n1540# vdda1 1.62fF **FLOATING
C13054 pll_full_0/divbuf_0/a_42750_n1540# vdda1 1.62fF **FLOATING
C13055 pll_full_0/divbuf_0/a_42270_n1540# vdda1 1.62fF **FLOATING
C13056 pll_full_0/divbuf_0/a_41790_n1540# vdda1 1.62fF **FLOATING
C13057 pll_full_0/divbuf_0/a_41310_n1540# vdda1 1.62fF **FLOATING
C13058 pll_full_0/divbuf_0/a_40830_n1540# vdda1 1.62fF **FLOATING
C13059 pll_full_0/divbuf_0/a_40350_n1540# vdda1 1.62fF **FLOATING
C13060 pll_full_0/divbuf_0/a_39870_n1540# vdda1 1.62fF **FLOATING
C13061 pll_full_0/divbuf_0/a_39390_n1540# vdda1 1.62fF **FLOATING
C13062 pll_full_0/divbuf_0/a_38910_n1540# vdda1 1.62fF **FLOATING
C13063 pll_full_0/divbuf_0/a_38430_n1540# vdda1 1.62fF **FLOATING
C13064 pll_full_0/divbuf_0/a_37950_n1540# vdda1 1.62fF **FLOATING
C13065 pll_full_0/divbuf_0/a_37470_n1540# vdda1 1.62fF **FLOATING
C13066 pll_full_0/divbuf_0/a_36990_n1540# vdda1 1.62fF **FLOATING
C13067 pll_full_0/divbuf_0/a_36510_n1540# vdda1 1.62fF **FLOATING
C13068 pll_full_0/divbuf_0/a_36030_n1540# vdda1 1.62fF **FLOATING
C13069 pll_full_0/divbuf_0/a_35550_n1540# vdda1 1.62fF **FLOATING
C13070 pll_full_0/divbuf_0/a_35070_n1540# vdda1 1.62fF **FLOATING
C13071 pll_full_0/divbuf_0/a_34590_n1540# vdda1 1.62fF **FLOATING
C13072 pll_full_0/divbuf_0/a_34110_n1540# vdda1 1.62fF **FLOATING
C13073 pll_full_0/divbuf_0/a_33630_n1540# vdda1 1.62fF **FLOATING
C13074 pll_full_0/divbuf_0/a_33150_n1540# vdda1 1.62fF **FLOATING
C13075 pll_full_0/divbuf_0/a_32670_n1540# vdda1 1.62fF **FLOATING
C13076 pll_full_0/divbuf_0/a_32190_n1540# vdda1 1.62fF **FLOATING
C13077 pll_full_0/divbuf_0/a_31710_n1540# vdda1 1.62fF **FLOATING
C13078 pll_full_0/divbuf_0/a_31230_n1540# vdda1 1.62fF **FLOATING
C13079 pll_full_0/divbuf_0/a_30750_n1540# vdda1 1.62fF **FLOATING
C13080 pll_full_0/divbuf_0/a_30270_n1540# vdda1 1.62fF **FLOATING
C13081 pll_full_0/divbuf_0/a_29790_n1540# vdda1 1.62fF **FLOATING
C13082 pll_full_0/divbuf_0/a_29310_n1540# vdda1 1.62fF **FLOATING
C13083 pll_full_0/divbuf_0/a_28830_n1540# vdda1 1.62fF **FLOATING
C13084 pll_full_0/divbuf_0/a_28350_n1540# vdda1 1.62fF **FLOATING
C13085 pll_full_0/divbuf_0/a_27870_n1540# vdda1 1.62fF **FLOATING
C13086 pll_full_0/divbuf_0/a_27390_n1540# vdda1 1.62fF **FLOATING
C13087 pll_full_0/divbuf_0/a_26910_n1540# vdda1 1.62fF **FLOATING
C13088 pll_full_0/divbuf_0/a_26430_n1540# vdda1 1.62fF **FLOATING
C13089 pll_full_0/divbuf_0/a_25950_n1540# vdda1 1.62fF **FLOATING
C13090 pll_full_0/divbuf_0/a_25470_n1540# vdda1 1.62fF **FLOATING
C13091 pll_full_0/divbuf_0/a_24990_n1540# vdda1 1.62fF **FLOATING
C13092 pll_full_0/divbuf_0/a_24510_n1540# vdda1 1.62fF **FLOATING
C13093 pll_full_0/divbuf_0/a_24030_n1540# vdda1 1.62fF **FLOATING
C13094 pll_full_0/divbuf_0/a_23550_n1540# vdda1 1.62fF **FLOATING
C13095 pll_full_0/divbuf_0/a_23070_n1540# vdda1 1.62fF **FLOATING
C13096 pll_full_0/divbuf_0/a_22590_n1540# vdda1 1.62fF **FLOATING
C13097 pll_full_0/divbuf_0/a_22110_n1540# vdda1 1.62fF **FLOATING
C13098 pll_full_0/divbuf_0/a_21630_n1540# vdda1 1.62fF **FLOATING
C13099 pll_full_0/divbuf_0/a_21150_n1540# vdda1 1.62fF **FLOATING
C13100 pll_full_0/divbuf_0/a_20670_n1540# vdda1 1.62fF **FLOATING
C13101 pll_full_0/divbuf_0/a_20190_n1540# vdda1 1.62fF **FLOATING
C13102 pll_full_0/divbuf_0/a_19710_n1540# vdda1 1.62fF **FLOATING
C13103 pll_full_0/divbuf_0/a_19230_n1540# vdda1 1.62fF **FLOATING
C13104 pll_full_0/divbuf_0/a_18750_n1540# vdda1 1.62fF **FLOATING
C13105 pll_full_0/divbuf_0/a_18270_n1540# vdda1 1.62fF **FLOATING
C13106 pll_full_0/divbuf_0/a_17790_n1540# vdda1 1.62fF **FLOATING
C13107 pll_full_0/divbuf_0/a_17310_n1540# vdda1 1.62fF **FLOATING
C13108 pll_full_0/divbuf_0/a_16830_n1540# vdda1 1.62fF **FLOATING
C13109 pll_full_0/divbuf_0/a_16350_n1540# vdda1 1.62fF **FLOATING
C13110 pll_full_0/divbuf_0/a_15870_n1540# vdda1 1.62fF **FLOATING
C13111 pll_full_0/divbuf_0/a_15390_n1540# vdda1 1.62fF **FLOATING
C13112 pll_full_0/divbuf_0/a_14910_n1540# vdda1 1.62fF **FLOATING
C13113 pll_full_0/divbuf_0/a_14430_n1540# vdda1 1.62fF **FLOATING
C13114 pll_full_0/divbuf_0/a_13950_n1540# vdda1 1.62fF **FLOATING
C13115 pll_full_0/divbuf_0/a_13470_n1540# vdda1 1.62fF **FLOATING
C13116 pll_full_0/divbuf_0/a_12990_n1540# vdda1 1.62fF **FLOATING
C13117 pll_full_0/divbuf_0/a_12510_n1540# vdda1 1.62fF **FLOATING
C13118 pll_full_0/divbuf_0/a_12030_n1540# vdda1 1.62fF **FLOATING
C13119 pll_full_0/divbuf_0/a_11550_n1540# vdda1 1.62fF **FLOATING
C13120 pll_full_0/divbuf_0/a_11070_n1540# vdda1 1.62fF **FLOATING
C13121 pll_full_0/divbuf_0/a_10590_n1540# vdda1 1.62fF **FLOATING
C13122 pll_full_0/divbuf_0/a_10110_n1540# vdda1 1.62fF **FLOATING
C13123 pll_full_0/divbuf_0/a_9630_n1540# vdda1 1.62fF **FLOATING
C13124 pll_full_0/divbuf_0/a_9150_n1540# vdda1 1.62fF **FLOATING
C13125 pll_full_0/divbuf_0/a_8670_n1540# vdda1 1.62fF **FLOATING
C13126 pll_full_0/divbuf_0/a_8190_n1540# vdda1 1.62fF **FLOATING
C13127 pll_full_0/divbuf_0/a_7710_n1540# vdda1 1.62fF **FLOATING
C13128 pll_full_0/divbuf_0/a_7230_n1540# vdda1 1.62fF **FLOATING
C13129 pll_full_0/divbuf_0/a_6750_n1540# vdda1 1.62fF **FLOATING
C13130 pll_full_0/divbuf_0/a_6270_n1540# vdda1 1.62fF **FLOATING
C13131 pll_full_0/divbuf_0/a_5790_n1540# vdda1 1.62fF **FLOATING
C13132 pll_full_0/divbuf_0/a_5310_n1540# vdda1 1.62fF **FLOATING
C13133 pll_full_0/divbuf_0/a_4830_n1540# vdda1 1.62fF **FLOATING
C13134 pll_full_0/divbuf_0/a_4350_n1540# vdda1 1.62fF **FLOATING
C13135 pll_full_0/divbuf_0/a_3870_n1540# vdda1 1.62fF **FLOATING
C13136 pll_full_0/divbuf_0/a_3390_n1540# vdda1 1.62fF **FLOATING
C13137 pll_full_0/divbuf_0/a_2910_n1540# vdda1 1.62fF **FLOATING
C13138 pll_full_0/divbuf_0/a_2430_n1540# vdda1 1.62fF **FLOATING
C13139 pll_full_0/divbuf_0/a_1950_n1540# vdda1 1.62fF **FLOATING
C13140 pll_full_0/divbuf_0/a_1470_n1540# vdda1 1.62fF **FLOATING
C13141 pll_full_0/divbuf_0/a_990_n1540# vdda1 1.62fF **FLOATING
C13142 pll_full_0/divbuf_0/a_510_n1540# vdda1 1.62fF **FLOATING
C13143 pll_full_0/divbuf_0/a_60990_n840# vdda1 1.06fF **FLOATING
C13144 pll_full_0/divbuf_0/a_60510_n840# vdda1 1.09fF **FLOATING
C13145 pll_full_0/divbuf_0/a_60030_n840# vdda1 1.09fF **FLOATING
C13146 pll_full_0/divbuf_0/a_59550_n840# vdda1 1.09fF **FLOATING
C13147 pll_full_0/divbuf_0/a_59070_n840# vdda1 1.09fF **FLOATING
C13148 pll_full_0/divbuf_0/a_58590_n840# vdda1 1.09fF **FLOATING
C13149 pll_full_0/divbuf_0/a_58110_n840# vdda1 1.09fF **FLOATING
C13150 pll_full_0/divbuf_0/a_57630_n840# vdda1 1.09fF **FLOATING
C13151 pll_full_0/divbuf_0/a_57150_n840# vdda1 1.09fF **FLOATING
C13152 pll_full_0/divbuf_0/a_56670_n840# vdda1 1.09fF **FLOATING
C13153 pll_full_0/divbuf_0/a_56190_n840# vdda1 1.09fF **FLOATING
C13154 pll_full_0/divbuf_0/a_55710_n840# vdda1 1.09fF **FLOATING
C13155 pll_full_0/divbuf_0/a_55230_n840# vdda1 1.09fF **FLOATING
C13156 pll_full_0/divbuf_0/a_54750_n840# vdda1 1.09fF **FLOATING
C13157 pll_full_0/divbuf_0/a_54270_n840# vdda1 1.09fF **FLOATING
C13158 pll_full_0/divbuf_0/a_53790_n840# vdda1 1.09fF **FLOATING
C13159 pll_full_0/divbuf_0/a_53310_n840# vdda1 1.09fF **FLOATING
C13160 pll_full_0/divbuf_0/a_52830_n840# vdda1 1.09fF **FLOATING
C13161 pll_full_0/divbuf_0/a_52350_n840# vdda1 1.09fF **FLOATING
C13162 pll_full_0/divbuf_0/a_51870_n840# vdda1 1.09fF **FLOATING
C13163 pll_full_0/divbuf_0/a_51390_n840# vdda1 1.09fF **FLOATING
C13164 pll_full_0/divbuf_0/a_50910_n840# vdda1 1.09fF **FLOATING
C13165 pll_full_0/divbuf_0/a_50430_n840# vdda1 1.09fF **FLOATING
C13166 pll_full_0/divbuf_0/a_49950_n840# vdda1 1.09fF **FLOATING
C13167 pll_full_0/divbuf_0/a_49470_n840# vdda1 1.09fF **FLOATING
C13168 pll_full_0/divbuf_0/a_48990_n840# vdda1 1.09fF **FLOATING
C13169 pll_full_0/divbuf_0/a_48510_n840# vdda1 1.09fF **FLOATING
C13170 pll_full_0/divbuf_0/a_48030_n840# vdda1 1.09fF **FLOATING
C13171 pll_full_0/divbuf_0/a_47550_n840# vdda1 1.09fF **FLOATING
C13172 pll_full_0/divbuf_0/a_47070_n840# vdda1 1.09fF **FLOATING
C13173 pll_full_0/divbuf_0/a_46590_n840# vdda1 1.09fF **FLOATING
C13174 pll_full_0/divbuf_0/a_46110_n840# vdda1 1.09fF **FLOATING
C13175 pll_full_0/divbuf_0/a_45630_n840# vdda1 1.09fF **FLOATING
C13176 pll_full_0/divbuf_0/a_45150_n840# vdda1 1.09fF **FLOATING
C13177 pll_full_0/divbuf_0/a_44670_n840# vdda1 1.09fF **FLOATING
C13178 pll_full_0/divbuf_0/a_44190_n840# vdda1 1.09fF **FLOATING
C13179 pll_full_0/divbuf_0/a_43710_n840# vdda1 1.09fF **FLOATING
C13180 pll_full_0/divbuf_0/a_43230_n840# vdda1 1.09fF **FLOATING
C13181 pll_full_0/divbuf_0/a_42750_n840# vdda1 1.08fF **FLOATING
C13182 pll_full_0/divbuf_0/a_42270_n840# vdda1 1.08fF **FLOATING
C13183 pll_full_0/divbuf_0/a_41790_n840# vdda1 1.10fF **FLOATING
C13184 pll_full_0/divbuf_0/a_41310_n840# vdda1 1.09fF **FLOATING
C13185 pll_full_0/divbuf_0/a_40830_n840# vdda1 1.09fF **FLOATING
C13186 pll_full_0/divbuf_0/a_40350_n840# vdda1 1.09fF **FLOATING
C13187 pll_full_0/divbuf_0/a_39870_n840# vdda1 1.09fF **FLOATING
C13188 pll_full_0/divbuf_0/a_39390_n840# vdda1 1.09fF **FLOATING
C13189 pll_full_0/divbuf_0/a_38910_n840# vdda1 1.09fF **FLOATING
C13190 pll_full_0/divbuf_0/a_38430_n840# vdda1 1.09fF **FLOATING
C13191 pll_full_0/divbuf_0/a_37950_n840# vdda1 1.09fF **FLOATING
C13192 pll_full_0/divbuf_0/a_37470_n840# vdda1 1.09fF **FLOATING
C13193 pll_full_0/divbuf_0/a_36990_n840# vdda1 1.09fF **FLOATING
C13194 pll_full_0/divbuf_0/a_36510_n840# vdda1 1.09fF **FLOATING
C13195 pll_full_0/divbuf_0/a_36030_n840# vdda1 1.09fF **FLOATING
C13196 pll_full_0/divbuf_0/a_35550_n840# vdda1 1.09fF **FLOATING
C13197 pll_full_0/divbuf_0/a_35070_n840# vdda1 1.09fF **FLOATING
C13198 pll_full_0/divbuf_0/a_34590_n840# vdda1 1.09fF **FLOATING
C13199 pll_full_0/divbuf_0/a_34110_n840# vdda1 1.09fF **FLOATING
C13200 pll_full_0/divbuf_0/a_33630_n840# vdda1 1.09fF **FLOATING
C13201 pll_full_0/divbuf_0/a_33150_n840# vdda1 1.09fF **FLOATING
C13202 pll_full_0/divbuf_0/a_32670_n840# vdda1 1.09fF **FLOATING
C13203 pll_full_0/divbuf_0/a_32190_n840# vdda1 1.09fF **FLOATING
C13204 pll_full_0/divbuf_0/a_31710_n840# vdda1 1.11fF **FLOATING
C13205 pll_full_0/divbuf_0/a_31230_n840# vdda1 1.13fF **FLOATING
C13206 pll_full_0/divbuf_0/a_30750_n840# vdda1 1.09fF **FLOATING
C13207 pll_full_0/divbuf_0/a_30270_n840# vdda1 1.09fF **FLOATING
C13208 pll_full_0/divbuf_0/a_29790_n840# vdda1 1.09fF **FLOATING
C13209 pll_full_0/divbuf_0/a_29310_n840# vdda1 1.09fF **FLOATING
C13210 pll_full_0/divbuf_0/a_28830_n840# vdda1 1.09fF **FLOATING
C13211 pll_full_0/divbuf_0/a_28350_n840# vdda1 1.09fF **FLOATING
C13212 pll_full_0/divbuf_0/a_27870_n840# vdda1 1.08fF **FLOATING
C13213 pll_full_0/divbuf_0/a_27390_n840# vdda1 1.11fF **FLOATING
C13214 pll_full_0/divbuf_0/a_26910_n840# vdda1 1.10fF **FLOATING
C13215 pll_full_0/divbuf_0/a_26430_n840# vdda1 1.10fF **FLOATING
C13216 pll_full_0/divbuf_0/a_25950_n840# vdda1 1.10fF **FLOATING
C13217 pll_full_0/divbuf_0/a_25470_n840# vdda1 1.10fF **FLOATING
C13218 pll_full_0/divbuf_0/a_24990_n840# vdda1 1.10fF **FLOATING
C13219 pll_full_0/divbuf_0/a_24510_n840# vdda1 1.10fF **FLOATING
C13220 pll_full_0/divbuf_0/a_24030_n840# vdda1 1.09fF **FLOATING
C13221 pll_full_0/divbuf_0/a_23550_n840# vdda1 1.11fF **FLOATING
C13222 pll_full_0/divbuf_0/a_23070_n840# vdda1 1.10fF **FLOATING
C13223 pll_full_0/divbuf_0/a_22590_n840# vdda1 1.10fF **FLOATING
C13224 pll_full_0/divbuf_0/a_22110_n840# vdda1 1.10fF **FLOATING
C13225 pll_full_0/divbuf_0/a_21630_n840# vdda1 1.10fF **FLOATING
C13226 pll_full_0/divbuf_0/a_21150_n840# vdda1 1.10fF **FLOATING
C13227 pll_full_0/divbuf_0/a_20670_n840# vdda1 1.10fF **FLOATING
C13228 pll_full_0/divbuf_0/a_20190_n840# vdda1 1.09fF **FLOATING
C13229 pll_full_0/divbuf_0/a_19710_n840# vdda1 1.09fF **FLOATING
C13230 pll_full_0/divbuf_0/a_19230_n840# vdda1 1.09fF **FLOATING
C13231 pll_full_0/divbuf_0/a_18750_n840# vdda1 1.09fF **FLOATING
C13232 pll_full_0/divbuf_0/a_18270_n840# vdda1 1.08fF **FLOATING
C13233 pll_full_0/divbuf_0/a_17790_n840# vdda1 1.08fF **FLOATING
C13234 pll_full_0/divbuf_0/a_17310_n840# vdda1 1.07fF **FLOATING
C13235 pll_full_0/divbuf_0/a_16830_n840# vdda1 1.07fF **FLOATING
C13236 pll_full_0/divbuf_0/a_16350_n840# vdda1 1.07fF **FLOATING
C13237 pll_full_0/divbuf_0/a_15870_n840# vdda1 1.07fF **FLOATING
C13238 pll_full_0/divbuf_0/a_15390_n840# vdda1 1.08fF **FLOATING
C13239 pll_full_0/divbuf_0/a_14910_n840# vdda1 1.07fF **FLOATING
C13240 pll_full_0/divbuf_0/a_14430_n840# vdda1 1.07fF **FLOATING
C13241 pll_full_0/divbuf_0/a_13950_n840# vdda1 1.07fF **FLOATING
C13242 pll_full_0/divbuf_0/a_13470_n840# vdda1 1.07fF **FLOATING
C13243 pll_full_0/divbuf_0/a_12990_n840# vdda1 1.10fF **FLOATING
C13244 pll_full_0/divbuf_0/a_12510_n840# vdda1 1.08fF **FLOATING
C13245 pll_full_0/divbuf_0/a_12030_n840# vdda1 1.07fF **FLOATING
C13246 pll_full_0/divbuf_0/a_11550_n840# vdda1 1.07fF **FLOATING
C13247 pll_full_0/divbuf_0/a_11070_n840# vdda1 1.08fF **FLOATING
C13248 pll_full_0/divbuf_0/a_10590_n840# vdda1 1.10fF **FLOATING
C13249 pll_full_0/divbuf_0/a_10110_n840# vdda1 1.10fF **FLOATING
C13250 pll_full_0/divbuf_0/a_9630_n840# vdda1 1.10fF **FLOATING
C13251 pll_full_0/divbuf_0/a_9150_n840# vdda1 1.10fF **FLOATING
C13252 pll_full_0/divbuf_0/a_8670_n840# vdda1 1.10fF **FLOATING
C13253 pll_full_0/divbuf_0/a_8190_n840# vdda1 1.12fF **FLOATING
C13254 pll_full_0/divbuf_0/a_7710_n840# vdda1 1.10fF **FLOATING
C13255 pll_full_0/divbuf_0/a_7230_n840# vdda1 1.09fF **FLOATING
C13256 pll_full_0/divbuf_0/a_6750_n840# vdda1 1.09fF **FLOATING
C13257 pll_full_0/divbuf_0/a_6270_n840# vdda1 1.09fF **FLOATING
C13258 pll_full_0/divbuf_0/a_5790_n840# vdda1 1.09fF **FLOATING
C13259 pll_full_0/divbuf_0/a_5310_n840# vdda1 1.09fF **FLOATING
C13260 pll_full_0/divbuf_0/a_4830_n840# vdda1 1.09fF **FLOATING
C13261 pll_full_0/divbuf_0/a_4350_n840# vdda1 1.09fF **FLOATING
C13262 pll_full_0/divbuf_0/a_3870_n840# vdda1 1.09fF **FLOATING
C13263 pll_full_0/divbuf_0/a_3390_n840# vdda1 1.09fF **FLOATING
C13264 pll_full_0/divbuf_0/a_2910_n840# vdda1 1.10fF **FLOATING
C13265 pll_full_0/divbuf_0/a_2430_n840# vdda1 1.10fF **FLOATING
C13266 pll_full_0/divbuf_0/a_1950_n840# vdda1 1.10fF **FLOATING
C13267 pll_full_0/divbuf_0/a_1470_n840# vdda1 1.10fF **FLOATING
C13268 pll_full_0/divbuf_0/a_990_n840# vdda1 1.08fF **FLOATING
C13269 pll_full_0/divbuf_0/a_510_n840# vdda1 1.07fF **FLOATING
C13270 pll_full_0/divbuf_0/a_60480_n1600# vdda1 1.48fF **FLOATING
C13271 pll_full_0/divbuf_0/a_60000_n1600# vdda1 1.48fF **FLOATING
C13272 pll_full_0/divbuf_0/a_59520_n1600# vdda1 1.48fF **FLOATING
C13273 pll_full_0/divbuf_0/a_59040_n1600# vdda1 1.48fF **FLOATING
C13274 pll_full_0/divbuf_0/a_58560_n1600# vdda1 1.48fF **FLOATING
C13275 pll_full_0/divbuf_0/a_58080_n1600# vdda1 1.48fF **FLOATING
C13276 pll_full_0/divbuf_0/a_57600_n1600# vdda1 1.48fF **FLOATING
C13277 pll_full_0/divbuf_0/a_57120_n1600# vdda1 1.48fF **FLOATING
C13278 pll_full_0/divbuf_0/a_56640_n1600# vdda1 1.48fF **FLOATING
C13279 pll_full_0/divbuf_0/a_56160_n1600# vdda1 1.48fF **FLOATING
C13280 pll_full_0/divbuf_0/a_55680_n1600# vdda1 1.48fF **FLOATING
C13281 pll_full_0/divbuf_0/a_55200_n1600# vdda1 1.48fF **FLOATING
C13282 pll_full_0/divbuf_0/a_54720_n1600# vdda1 1.48fF **FLOATING
C13283 pll_full_0/divbuf_0/a_54240_n1600# vdda1 1.48fF **FLOATING
C13284 pll_full_0/divbuf_0/a_53760_n1600# vdda1 1.48fF **FLOATING
C13285 pll_full_0/divbuf_0/a_53280_n1600# vdda1 1.48fF **FLOATING
C13286 pll_full_0/divbuf_0/a_52800_n1600# vdda1 1.48fF **FLOATING
C13287 pll_full_0/divbuf_0/a_52320_n1600# vdda1 1.48fF **FLOATING
C13288 pll_full_0/divbuf_0/a_51840_n1600# vdda1 1.48fF **FLOATING
C13289 pll_full_0/divbuf_0/a_51360_n1600# vdda1 1.48fF **FLOATING
C13290 pll_full_0/divbuf_0/a_50880_n1600# vdda1 1.48fF **FLOATING
C13291 pll_full_0/divbuf_0/a_50400_n1600# vdda1 1.48fF **FLOATING
C13292 pll_full_0/divbuf_0/a_49920_n1600# vdda1 1.48fF **FLOATING
C13293 pll_full_0/divbuf_0/a_49440_n1600# vdda1 1.48fF **FLOATING
C13294 pll_full_0/divbuf_0/a_48960_n1600# vdda1 1.48fF **FLOATING
C13295 pll_full_0/divbuf_0/a_48480_n1600# vdda1 1.48fF **FLOATING
C13296 pll_full_0/divbuf_0/a_48000_n1600# vdda1 1.48fF **FLOATING
C13297 pll_full_0/divbuf_0/a_47520_n1600# vdda1 1.48fF **FLOATING
C13298 pll_full_0/divbuf_0/a_47040_n1600# vdda1 1.48fF **FLOATING
C13299 pll_full_0/divbuf_0/a_46560_n1600# vdda1 1.48fF **FLOATING
C13300 pll_full_0/divbuf_0/a_46080_n1600# vdda1 1.48fF **FLOATING
C13301 pll_full_0/divbuf_0/a_45600_n1600# vdda1 1.48fF **FLOATING
C13302 pll_full_0/divbuf_0/a_45120_n1600# vdda1 1.48fF **FLOATING
C13303 pll_full_0/divbuf_0/a_44640_n1600# vdda1 1.48fF **FLOATING
C13304 pll_full_0/divbuf_0/a_44160_n1600# vdda1 1.48fF **FLOATING
C13305 pll_full_0/divbuf_0/a_43680_n1600# vdda1 1.48fF **FLOATING
C13306 pll_full_0/divbuf_0/a_43200_n1600# vdda1 1.48fF **FLOATING
C13307 pll_full_0/divbuf_0/a_42720_n1600# vdda1 1.48fF **FLOATING
C13308 pll_full_0/divbuf_0/a_42240_n1600# vdda1 1.48fF **FLOATING
C13309 pll_full_0/divbuf_0/a_41760_n1600# vdda1 1.48fF **FLOATING
C13310 pll_full_0/divbuf_0/a_41280_n1600# vdda1 1.48fF **FLOATING
C13311 pll_full_0/divbuf_0/a_40800_n1600# vdda1 1.48fF **FLOATING
C13312 pll_full_0/divbuf_0/a_40320_n1600# vdda1 1.48fF **FLOATING
C13313 pll_full_0/divbuf_0/a_39840_n1600# vdda1 1.48fF **FLOATING
C13314 pll_full_0/divbuf_0/a_39360_n1600# vdda1 1.48fF **FLOATING
C13315 pll_full_0/divbuf_0/a_38880_n1600# vdda1 1.48fF **FLOATING
C13316 pll_full_0/divbuf_0/a_38400_n1600# vdda1 1.48fF **FLOATING
C13317 pll_full_0/divbuf_0/a_37920_n1600# vdda1 1.48fF **FLOATING
C13318 pll_full_0/divbuf_0/a_37440_n1600# vdda1 1.48fF **FLOATING
C13319 pll_full_0/divbuf_0/a_36960_n1600# vdda1 1.48fF **FLOATING
C13320 pll_full_0/divbuf_0/a_36480_n1600# vdda1 1.48fF **FLOATING
C13321 pll_full_0/divbuf_0/a_36000_n1600# vdda1 1.48fF **FLOATING
C13322 pll_full_0/divbuf_0/a_35520_n1600# vdda1 1.48fF **FLOATING
C13323 pll_full_0/divbuf_0/a_35040_n1600# vdda1 1.48fF **FLOATING
C13324 pll_full_0/divbuf_0/a_34560_n1600# vdda1 1.48fF **FLOATING
C13325 pll_full_0/divbuf_0/a_34080_n1600# vdda1 1.48fF **FLOATING
C13326 pll_full_0/divbuf_0/a_33600_n1600# vdda1 1.48fF **FLOATING
C13327 pll_full_0/divbuf_0/a_33120_n1600# vdda1 1.48fF **FLOATING
C13328 pll_full_0/divbuf_0/a_32640_n1600# vdda1 1.48fF **FLOATING
C13329 pll_full_0/divbuf_0/a_32160_n1600# vdda1 1.48fF **FLOATING
C13330 pll_full_0/divbuf_0/a_31680_n1600# vdda1 1.48fF **FLOATING
C13331 pll_full_0/divbuf_0/a_31200_n1600# vdda1 1.48fF **FLOATING
C13332 pll_full_0/divbuf_0/a_30720_n1600# vdda1 1.48fF **FLOATING
C13333 pll_full_0/divbuf_0/a_30240_n1600# vdda1 1.48fF **FLOATING
C13334 pll_full_0/divbuf_0/a_29760_n1600# vdda1 1.48fF **FLOATING
C13335 pll_full_0/divbuf_0/a_29280_n1600# vdda1 1.48fF **FLOATING
C13336 pll_full_0/divbuf_0/a_28800_n1600# vdda1 1.48fF **FLOATING
C13337 pll_full_0/divbuf_0/a_28320_n1600# vdda1 1.48fF **FLOATING
C13338 pll_full_0/divbuf_0/a_27840_n1600# vdda1 1.48fF **FLOATING
C13339 pll_full_0/divbuf_0/a_27360_n1600# vdda1 1.48fF **FLOATING
C13340 pll_full_0/divbuf_0/a_26880_n1600# vdda1 1.48fF **FLOATING
C13341 pll_full_0/divbuf_0/a_26400_n1600# vdda1 1.48fF **FLOATING
C13342 pll_full_0/divbuf_0/a_25920_n1600# vdda1 1.48fF **FLOATING
C13343 pll_full_0/divbuf_0/a_25440_n1600# vdda1 1.48fF **FLOATING
C13344 pll_full_0/divbuf_0/a_24960_n1600# vdda1 1.48fF **FLOATING
C13345 pll_full_0/divbuf_0/a_24480_n1600# vdda1 1.48fF **FLOATING
C13346 pll_full_0/divbuf_0/a_24000_n1600# vdda1 1.48fF **FLOATING
C13347 pll_full_0/divbuf_0/a_23520_n1600# vdda1 1.48fF **FLOATING
C13348 pll_full_0/divbuf_0/a_23040_n1600# vdda1 1.48fF **FLOATING
C13349 pll_full_0/divbuf_0/a_22560_n1600# vdda1 1.48fF **FLOATING
C13350 pll_full_0/divbuf_0/a_22080_n1600# vdda1 1.48fF **FLOATING
C13351 pll_full_0/divbuf_0/a_21600_n1600# vdda1 1.48fF **FLOATING
C13352 pll_full_0/divbuf_0/a_21120_n1600# vdda1 1.48fF **FLOATING
C13353 pll_full_0/divbuf_0/a_20640_n1600# vdda1 1.48fF **FLOATING
C13354 pll_full_0/divbuf_0/a_20160_n1600# vdda1 1.48fF **FLOATING
C13355 pll_full_0/divbuf_0/a_19680_n1600# vdda1 1.48fF **FLOATING
C13356 pll_full_0/divbuf_0/a_19200_n1600# vdda1 1.48fF **FLOATING
C13357 pll_full_0/divbuf_0/a_18720_n1600# vdda1 1.48fF **FLOATING
C13358 pll_full_0/divbuf_0/a_18240_n1600# vdda1 1.48fF **FLOATING
C13359 pll_full_0/divbuf_0/a_17760_n1600# vdda1 1.48fF **FLOATING
C13360 pll_full_0/divbuf_0/a_17280_n1600# vdda1 1.48fF **FLOATING
C13361 pll_full_0/divbuf_0/a_16800_n1600# vdda1 1.48fF **FLOATING
C13362 pll_full_0/divbuf_0/a_16320_n1600# vdda1 1.48fF **FLOATING
C13363 pll_full_0/divbuf_0/a_15840_n1600# vdda1 1.48fF **FLOATING
C13364 pll_full_0/divbuf_0/a_15360_n1600# vdda1 1.48fF **FLOATING
C13365 pll_full_0/divbuf_0/a_14880_n1600# vdda1 1.48fF **FLOATING
C13366 pll_full_0/divbuf_0/a_14400_n1600# vdda1 1.48fF **FLOATING
C13367 pll_full_0/divbuf_0/a_13920_n1600# vdda1 1.48fF **FLOATING
C13368 pll_full_0/divbuf_0/a_13440_n1600# vdda1 1.48fF **FLOATING
C13369 pll_full_0/divbuf_0/a_12960_n1600# vdda1 1.48fF **FLOATING
C13370 pll_full_0/divbuf_0/a_12480_n1600# vdda1 1.48fF **FLOATING
C13371 pll_full_0/divbuf_0/a_12000_n1600# vdda1 1.48fF **FLOATING
C13372 pll_full_0/divbuf_0/a_11520_n1600# vdda1 1.48fF **FLOATING
C13373 pll_full_0/divbuf_0/a_11040_n1600# vdda1 1.48fF **FLOATING
C13374 pll_full_0/divbuf_0/a_10560_n1600# vdda1 1.48fF **FLOATING
C13375 pll_full_0/divbuf_0/a_10080_n1600# vdda1 1.48fF **FLOATING
C13376 pll_full_0/divbuf_0/a_9600_n1600# vdda1 1.48fF **FLOATING
C13377 pll_full_0/divbuf_0/a_9120_n1600# vdda1 1.48fF **FLOATING
C13378 pll_full_0/divbuf_0/a_8640_n1600# vdda1 1.48fF **FLOATING
C13379 pll_full_0/divbuf_0/a_8160_n1600# vdda1 1.48fF **FLOATING
C13380 pll_full_0/divbuf_0/a_7680_n1600# vdda1 1.48fF **FLOATING
C13381 pll_full_0/divbuf_0/a_7200_n1600# vdda1 1.48fF **FLOATING
C13382 pll_full_0/divbuf_0/a_6720_n1600# vdda1 1.48fF **FLOATING
C13383 pll_full_0/divbuf_0/a_6240_n1600# vdda1 1.48fF **FLOATING
C13384 pll_full_0/divbuf_0/a_5760_n1600# vdda1 1.48fF **FLOATING
C13385 pll_full_0/divbuf_0/a_5280_n1600# vdda1 1.48fF **FLOATING
C13386 pll_full_0/divbuf_0/a_4800_n1600# vdda1 1.48fF **FLOATING
C13387 pll_full_0/divbuf_0/a_4320_n1600# vdda1 1.48fF **FLOATING
C13388 pll_full_0/divbuf_0/a_3840_n1600# vdda1 1.48fF **FLOATING
C13389 pll_full_0/divbuf_0/a_3360_n1600# vdda1 1.48fF **FLOATING
C13390 pll_full_0/divbuf_0/a_2880_n1600# vdda1 1.48fF **FLOATING
C13391 pll_full_0/divbuf_0/a_2400_n1600# vdda1 1.48fF **FLOATING
C13392 pll_full_0/divbuf_0/a_1920_n1600# vdda1 1.48fF **FLOATING
C13393 pll_full_0/divbuf_0/a_1440_n1600# vdda1 1.48fF **FLOATING
C13394 pll_full_0/divbuf_0/a_960_n1600# vdda1 1.48fF **FLOATING
C13395 pll_full_0/divbuf_0/a_480_n1600# vdda1 1.48fF **FLOATING
C13396 pll_full_0/divbuf_0/a_0_n1600# vdda1 1.48fF **FLOATING
C13397 pll_full_0/divbuf_0/a_41382_n240# vdda1 0.90fF **FLOATING
C13398 pll_full_0/divbuf_0/a_40902_n240# vdda1 0.90fF **FLOATING
C13399 pll_full_0/divbuf_0/a_40412_n240# vdda1 0.90fF **FLOATING
C13400 pll_full_0/divbuf_0/a_39932_n240# vdda1 0.90fF **FLOATING
C13401 pll_full_0/divbuf_0/a_39442_n240# vdda1 0.90fF **FLOATING
C13402 pll_full_0/divbuf_0/a_38962_n240# vdda1 0.91fF **FLOATING
C13403 pll_full_0/divbuf_0/a_38472_n240# vdda1 0.90fF **FLOATING
C13404 pll_full_0/divbuf_0/a_37992_n240# vdda1 0.90fF **FLOATING
C13405 pll_full_0/divbuf_0/a_37502_n240# vdda1 0.90fF **FLOATING
C13406 pll_full_0/divbuf_0/a_37022_n240# vdda1 0.90fF **FLOATING
C13407 pll_full_0/divbuf_0/a_36532_n240# vdda1 0.90fF **FLOATING
C13408 pll_full_0/divbuf_0/a_36052_n240# vdda1 0.90fF **FLOATING
C13409 pll_full_0/divbuf_0/a_35562_n240# vdda1 0.90fF **FLOATING
C13410 pll_full_0/divbuf_0/a_35082_n240# vdda1 0.91fF **FLOATING
C13411 pll_full_0/divbuf_0/a_34592_n240# vdda1 0.90fF **FLOATING
C13412 pll_full_0/divbuf_0/a_34112_n240# vdda1 0.90fF **FLOATING
C13413 pll_full_0/divbuf_0/a_33622_n240# vdda1 0.90fF **FLOATING
C13414 pll_full_0/divbuf_0/a_33142_n240# vdda1 0.90fF **FLOATING
C13415 pll_full_0/divbuf_0/a_32652_n240# vdda1 0.90fF **FLOATING
C13416 pll_full_0/divbuf_0/a_32172_n240# vdda1 0.90fF **FLOATING
C13417 pll_full_0/divbuf_0/a_31682_n240# vdda1 0.89fF **FLOATING
C13418 pll_full_0/divbuf_0/a_31202_n240# vdda1 0.92fF **FLOATING
C13419 pll_full_0/divbuf_0/a_30712_n240# vdda1 0.90fF **FLOATING
C13420 pll_full_0/divbuf_0/a_30232_n240# vdda1 0.90fF **FLOATING
C13421 pll_full_0/divbuf_0/a_29742_n240# vdda1 0.90fF **FLOATING
C13422 pll_full_0/divbuf_0/a_29262_n240# vdda1 0.90fF **FLOATING
C13423 pll_full_0/divbuf_0/a_28772_n240# vdda1 0.90fF **FLOATING
C13424 pll_full_0/divbuf_0/a_28292_n240# vdda1 0.90fF **FLOATING
C13425 pll_full_0/divbuf_0/a_27802_n240# vdda1 0.89fF **FLOATING
C13426 pll_full_0/divbuf_0/a_27322_n240# vdda1 0.95fF **FLOATING
C13427 pll_full_0/divbuf_0/a_26832_n240# vdda1 0.91fF **FLOATING
C13428 pll_full_0/divbuf_0/a_26352_n240# vdda1 0.91fF **FLOATING
C13429 pll_full_0/divbuf_0/a_25862_n240# vdda1 0.91fF **FLOATING
C13430 pll_full_0/divbuf_0/a_25382_n240# vdda1 0.91fF **FLOATING
C13431 pll_full_0/divbuf_0/a_24892_n240# vdda1 0.91fF **FLOATING
C13432 pll_full_0/divbuf_0/a_24412_n240# vdda1 0.91fF **FLOATING
C13433 pll_full_0/divbuf_0/a_23922_n240# vdda1 0.92fF **FLOATING
C13434 pll_full_0/divbuf_0/a_23442_n240# vdda1 0.94fF **FLOATING
C13435 pll_full_0/divbuf_0/a_22952_n240# vdda1 0.91fF **FLOATING
C13436 pll_full_0/divbuf_0/a_22472_n240# vdda1 0.91fF **FLOATING
C13437 pll_full_0/divbuf_0/a_21982_n240# vdda1 0.91fF **FLOATING
C13438 pll_full_0/divbuf_0/a_21502_n240# vdda1 0.91fF **FLOATING
C13439 pll_full_0/divbuf_0/a_21012_n240# vdda1 0.91fF **FLOATING
C13440 pll_full_0/divbuf_0/a_20532_n240# vdda1 0.91fF **FLOATING
C13441 pll_full_0/divbuf_0/a_20042_n240# vdda1 0.90fF **FLOATING
C13442 pll_full_0/divbuf_0/a_19562_n240# vdda1 0.90fF **FLOATING
C13443 pll_full_0/divbuf_0/a_19072_n240# vdda1 0.90fF **FLOATING
C13444 pll_full_0/divbuf_0/a_18582_n240# vdda1 0.89fF **FLOATING
C13445 pll_full_0/divbuf_0/a_18092_n240# vdda1 0.89fF **FLOATING
C13446 pll_full_0/divbuf_0/a_17612_n240# vdda1 0.89fF **FLOATING
C13447 pll_full_0/divbuf_0/a_17122_n240# vdda1 0.88fF **FLOATING
C13448 pll_full_0/divbuf_0/a_16642_n240# vdda1 0.88fF **FLOATING
C13449 pll_full_0/divbuf_0/a_16152_n240# vdda1 0.88fF **FLOATING
C13450 pll_full_0/divbuf_0/a_15672_n240# vdda1 0.90fF **FLOATING
C13451 pll_full_0/divbuf_0/a_15182_n240# vdda1 0.88fF **FLOATING
C13452 pll_full_0/divbuf_0/a_14702_n240# vdda1 0.88fF **FLOATING
C13453 pll_full_0/divbuf_0/a_14222_n240# vdda1 0.88fF **FLOATING
C13454 pll_full_0/divbuf_0/a_13742_n240# vdda1 0.88fF **FLOATING
C13455 pll_full_0/divbuf_0/a_13252_n240# vdda1 0.88fF **FLOATING
C13456 pll_full_0/divbuf_0/a_12772_n240# vdda1 0.88fF **FLOATING
C13457 pll_full_0/divbuf_0/a_12282_n240# vdda1 0.88fF **FLOATING
C13458 pll_full_0/divbuf_0/a_11802_n240# vdda1 0.88fF **FLOATING
C13459 pll_full_0/divbuf_0/a_11312_n240# vdda1 0.89fF **FLOATING
C13460 pll_full_0/divbuf_0/a_10212_n240# vdda1 0.91fF **FLOATING
C13461 pll_full_0/divbuf_0/a_9732_n240# vdda1 0.91fF **FLOATING
C13462 pll_full_0/divbuf_0/a_9242_n240# vdda1 0.91fF **FLOATING
C13463 pll_full_0/divbuf_0/a_8762_n240# vdda1 0.91fF **FLOATING
C13464 pll_full_0/divbuf_0/a_8272_n240# vdda1 0.91fF **FLOATING
C13465 pll_full_0/divbuf_0/a_7792_n240# vdda1 0.92fF **FLOATING
C13466 pll_full_0/divbuf_0/a_7302_n240# vdda1 0.90fF **FLOATING
C13467 pll_full_0/divbuf_0/a_6822_n240# vdda1 0.90fF **FLOATING
C13468 pll_full_0/divbuf_0/a_6332_n240# vdda1 0.90fF **FLOATING
C13469 pll_full_0/divbuf_0/a_5852_n240# vdda1 0.90fF **FLOATING
C13470 pll_full_0/divbuf_0/a_5362_n240# vdda1 0.90fF **FLOATING
C13471 pll_full_0/divbuf_0/a_4882_n240# vdda1 0.90fF **FLOATING
C13472 pll_full_0/divbuf_0/a_4392_n240# vdda1 0.90fF **FLOATING
C13473 pll_full_0/divbuf_0/a_3912_n240# vdda1 0.90fF **FLOATING
C13474 pll_full_0/divbuf_0/a_3422_n240# vdda1 0.90fF **FLOATING
C13475 pll_full_0/divbuf_0/a_2322_n240# vdda1 0.91fF **FLOATING
C13476 pll_full_0/divbuf_0/a_1842_n240# vdda1 0.91fF **FLOATING
C13477 pll_full_0/divbuf_0/a_1352_n240# vdda1 0.91fF **FLOATING
C13478 pll_full_0/divbuf_0/a_41382_170# vdda1 1.07fF **FLOATING
C13479 pll_full_0/divbuf_0/a_40902_170# vdda1 1.09fF **FLOATING
C13480 pll_full_0/divbuf_0/a_40412_170# vdda1 1.09fF **FLOATING
C13481 pll_full_0/divbuf_0/a_39932_170# vdda1 1.09fF **FLOATING
C13482 pll_full_0/divbuf_0/a_39442_170# vdda1 1.09fF **FLOATING
C13483 pll_full_0/divbuf_0/a_38962_170# vdda1 1.07fF **FLOATING
C13484 pll_full_0/divbuf_0/a_38472_170# vdda1 1.09fF **FLOATING
C13485 pll_full_0/divbuf_0/a_37992_170# vdda1 1.09fF **FLOATING
C13486 pll_full_0/divbuf_0/a_37502_170# vdda1 1.09fF **FLOATING
C13487 pll_full_0/divbuf_0/a_37022_170# vdda1 1.09fF **FLOATING
C13488 pll_full_0/divbuf_0/a_36532_170# vdda1 1.09fF **FLOATING
C13489 pll_full_0/divbuf_0/a_36052_170# vdda1 1.09fF **FLOATING
C13490 pll_full_0/divbuf_0/a_35562_170# vdda1 1.09fF **FLOATING
C13491 pll_full_0/divbuf_0/a_35082_170# vdda1 1.09fF **FLOATING
C13492 pll_full_0/divbuf_0/a_34592_170# vdda1 1.07fF **FLOATING
C13493 pll_full_0/divbuf_0/a_34112_170# vdda1 1.09fF **FLOATING
C13494 pll_full_0/divbuf_0/a_33622_170# vdda1 1.09fF **FLOATING
C13495 pll_full_0/divbuf_0/a_33142_170# vdda1 1.09fF **FLOATING
C13496 pll_full_0/divbuf_0/a_32652_170# vdda1 1.09fF **FLOATING
C13497 pll_full_0/divbuf_0/a_32172_170# vdda1 1.09fF **FLOATING
C13498 pll_full_0/divbuf_0/a_31682_170# vdda1 1.09fF **FLOATING
C13499 pll_full_0/divbuf_0/a_31202_170# vdda1 1.09fF **FLOATING
C13500 pll_full_0/divbuf_0/a_30712_170# vdda1 1.09fF **FLOATING
C13501 pll_full_0/divbuf_0/a_30232_170# vdda1 1.07fF **FLOATING
C13502 pll_full_0/divbuf_0/a_29742_170# vdda1 1.09fF **FLOATING
C13503 pll_full_0/divbuf_0/a_29262_170# vdda1 1.09fF **FLOATING
C13504 pll_full_0/divbuf_0/a_28772_170# vdda1 1.09fF **FLOATING
C13505 pll_full_0/divbuf_0/a_28292_170# vdda1 1.09fF **FLOATING
C13506 pll_full_0/divbuf_0/a_27802_170# vdda1 1.09fF **FLOATING
C13507 pll_full_0/divbuf_0/a_27322_170# vdda1 1.09fF **FLOATING
C13508 pll_full_0/divbuf_0/a_26832_170# vdda1 1.09fF **FLOATING
C13509 pll_full_0/divbuf_0/a_26352_170# vdda1 1.09fF **FLOATING
C13510 pll_full_0/divbuf_0/a_25862_170# vdda1 1.07fF **FLOATING
C13511 pll_full_0/divbuf_0/a_25382_170# vdda1 1.09fF **FLOATING
C13512 pll_full_0/divbuf_0/a_24892_170# vdda1 1.09fF **FLOATING
C13513 pll_full_0/divbuf_0/a_24412_170# vdda1 1.09fF **FLOATING
C13514 pll_full_0/divbuf_0/a_23922_170# vdda1 1.09fF **FLOATING
C13515 pll_full_0/divbuf_0/a_23442_170# vdda1 1.09fF **FLOATING
C13516 pll_full_0/divbuf_0/a_22952_170# vdda1 1.09fF **FLOATING
C13517 pll_full_0/divbuf_0/a_22472_170# vdda1 1.07fF **FLOATING
C13518 pll_full_0/divbuf_0/a_21982_170# vdda1 1.09fF **FLOATING
C13519 pll_full_0/divbuf_0/a_21502_170# vdda1 1.09fF **FLOATING
C13520 pll_full_0/divbuf_0/a_21012_170# vdda1 1.09fF **FLOATING
C13521 pll_full_0/divbuf_0/a_20532_170# vdda1 1.09fF **FLOATING
C13522 pll_full_0/divbuf_0/a_20042_170# vdda1 1.09fF **FLOATING
C13523 pll_full_0/divbuf_0/a_19562_170# vdda1 1.09fF **FLOATING
C13524 pll_full_0/divbuf_0/a_19072_170# vdda1 1.09fF **FLOATING
C13525 pll_full_0/divbuf_0/a_18582_170# vdda1 1.07fF **FLOATING
C13526 pll_full_0/divbuf_0/a_18092_170# vdda1 1.09fF **FLOATING
C13527 pll_full_0/divbuf_0/a_17612_170# vdda1 1.09fF **FLOATING
C13528 pll_full_0/divbuf_0/a_17122_170# vdda1 1.09fF **FLOATING
C13529 pll_full_0/divbuf_0/a_16642_170# vdda1 1.09fF **FLOATING
C13530 pll_full_0/divbuf_0/a_16152_170# vdda1 1.09fF **FLOATING
C13531 pll_full_0/divbuf_0/a_15672_170# vdda1 1.09fF **FLOATING
C13532 pll_full_0/divbuf_0/a_15182_170# vdda1 1.09fF **FLOATING
C13533 pll_full_0/divbuf_0/a_14702_170# vdda1 1.10fF **FLOATING
C13534 pll_full_0/divbuf_0/a_14222_170# vdda1 1.10fF **FLOATING
C13535 pll_full_0/divbuf_0/a_13742_170# vdda1 1.09fF **FLOATING
C13536 pll_full_0/divbuf_0/a_13252_170# vdda1 1.09fF **FLOATING
C13537 pll_full_0/divbuf_0/a_12772_170# vdda1 1.07fF **FLOATING
C13538 pll_full_0/divbuf_0/a_12282_170# vdda1 1.09fF **FLOATING
C13539 pll_full_0/divbuf_0/a_11802_170# vdda1 1.09fF **FLOATING
C13540 pll_full_0/divbuf_0/a_11312_170# vdda1 1.10fF **FLOATING
C13541 pll_full_0/divbuf_0/a_10212_170# vdda1 1.09fF **FLOATING
C13542 pll_full_0/divbuf_0/a_9732_170# vdda1 1.09fF **FLOATING
C13543 pll_full_0/divbuf_0/a_9242_170# vdda1 1.09fF **FLOATING
C13544 pll_full_0/divbuf_0/a_8762_170# vdda1 1.09fF **FLOATING
C13545 pll_full_0/divbuf_0/a_8272_170# vdda1 1.07fF **FLOATING
C13546 pll_full_0/divbuf_0/a_7792_170# vdda1 1.09fF **FLOATING
C13547 pll_full_0/divbuf_0/a_7302_170# vdda1 1.09fF **FLOATING
C13548 pll_full_0/divbuf_0/a_6822_170# vdda1 1.09fF **FLOATING
C13549 pll_full_0/divbuf_0/a_6332_170# vdda1 1.09fF **FLOATING
C13550 pll_full_0/divbuf_0/a_5852_170# vdda1 1.09fF **FLOATING
C13551 pll_full_0/divbuf_0/a_5362_170# vdda1 1.09fF **FLOATING
C13552 pll_full_0/divbuf_0/a_4882_170# vdda1 1.09fF **FLOATING
C13553 pll_full_0/divbuf_0/a_4392_170# vdda1 1.07fF **FLOATING
C13554 pll_full_0/divbuf_0/a_3912_170# vdda1 1.09fF **FLOATING
C13555 pll_full_0/divbuf_0/a_3422_170# vdda1 1.10fF **FLOATING
C13556 pll_full_0/divbuf_0/a_2322_170# vdda1 1.09fF **FLOATING
C13557 pll_full_0/divbuf_0/a_1842_170# vdda1 1.09fF **FLOATING
C13558 pll_full_0/divbuf_0/a_1352_170# vdda1 1.10fF **FLOATING
C13559 pll_full_0/divbuf_0/a_492_n240# vdda1 2.46fF **FLOATING
C13560 pll_full_0/ro_complete_0/cbank_2/v vdda1 17.88fF
C13561 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C13562 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C13563 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C13564 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C13565 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C13566 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C13567 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C13568 pll_full_0/ro_complete_0/a0 vdda1 7.88fF
C13569 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C13570 pll_full_0/ro_complete_0/a1 vdda1 5.39fF
C13571 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C13572 pll_full_0/ro_complete_0/a3 vdda1 6.85fF
C13573 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C13574 pll_full_0/ro_complete_0/a2 vdda1 5.48fF
C13575 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C13576 pll_full_0/ro_complete_0/a4 vdda1 5.36fF
C13577 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C13578 pll_full_0/ro_complete_0/a5 vdda1 5.19fF
C13579 pll_full_0/ro_complete_0/cbank_0/v vdda1 15.02fF
C13580 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C13581 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C13582 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C13583 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C13584 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C13585 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C13586 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vdda1 0.27fF
C13587 pll_full_0/filter_0/a_4216_n5230# vdda1 419.25fF **FLOATING
C13588 pll_full_0/filter_0/a_4216_n2998# vdda1 1.39fF **FLOATING
C13589 pll_full_0/cp_0/down vdda1 1.54fF
C13590 pll_full_0/cp_0/upbar vdda1 1.79fF
C13591 pll_full_0/cp_0/a_7110_n2840# vdda1 0.17fF **FLOATING
C13592 pll_full_0/cp_0/a_3060_n2840# vdda1 1.71fF **FLOATING
C13593 pll_full_0/cp_0/a_7110_0# vdda1 0.17fF **FLOATING
C13594 pll_full_0/cp_0/a_6370_0# vdda1 0.40fF **FLOATING
C13595 pll_full_0/cp_0/a_3060_0# vdda1 2.49fF **FLOATING
C13596 pll_full_0/cp_0/a_1710_0# vdda1 7.47fF **FLOATING
C13597 pll_full_0/pd_0/and_pd_0/Z1 vdda1 0.39fF
C13598 pll_full_0/pd_0/and_pd_0/Out1 vdda1 2.22fF
C13599 pll_full_0/pd_0/tspc_r_1/z5 vdda1 1.10fF
C13600 pll_full_0/pd_0/tspc_r_1/Z4 vdda1 1.07fF
C13601 pll_full_0/pd_0/tspc_r_1/Qbar vdda1 0.88fF
C13602 pll_full_0/pd_0/tspc_r_1/Z2 vdda1 1.22fF
C13603 pll_full_0/pd_0/tspc_r_1/Z1 vdda1 0.67fF
C13604 pll_full_0/pd_0/UP vdda1 6.61fF
C13605 pll_full_0/pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C13606 pll_full_0/pd_0/tspc_r_1/Z3 vdda1 2.12fF
C13607 pll_full_0/pd_0/REF vdda1 6.44fF
C13608 pll_full_0/pd_0/tspc_r_0/z5 vdda1 1.10fF
C13609 pll_full_0/pd_0/tspc_r_0/Z4 vdda1 1.07fF
C13610 pll_full_0/pd_0/R vdda1 3.05fF
C13611 pll_full_0/pd_0/tspc_r_0/Qbar vdda1 0.79fF
C13612 pll_full_0/pd_0/tspc_r_0/Z2 vdda1 1.22fF
C13613 pll_full_0/pd_0/tspc_r_0/Z1 vdda1 0.67fF
C13614 pll_full_0/pd_0/DOWN vdda1 7.24fF
C13615 pll_full_0/pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C13616 pll_full_0/pd_0/tspc_r_0/Z3 vdda1 2.12fF
C13617 pll_full_0/pd_0/DIV vdda1 11.32fF
C13618 divbuf_3/OUT vdda1 3.28fF
C13619 divbuf_3/OUT5 vdda1 16.40fF
C13620 divbuf_3/OUT4 vdda1 100.06fF
C13621 divbuf_3/OUT3 vdda1 27.01fF
C13622 divbuf_3/OUT2 vdda1 8.71fF
C13623 divbuf_3/IN vdda1 0.89fF
C13624 divbuf_3/a_60990_n1540# vdda1 1.57fF **FLOATING
C13625 divbuf_3/a_60510_n1540# vdda1 1.62fF **FLOATING
C13626 divbuf_3/a_60030_n1540# vdda1 1.62fF **FLOATING
C13627 divbuf_3/a_59550_n1540# vdda1 1.62fF **FLOATING
C13628 divbuf_3/a_59070_n1540# vdda1 1.62fF **FLOATING
C13629 divbuf_3/a_58590_n1540# vdda1 1.62fF **FLOATING
C13630 divbuf_3/a_58110_n1540# vdda1 1.62fF **FLOATING
C13631 divbuf_3/a_57630_n1540# vdda1 1.62fF **FLOATING
C13632 divbuf_3/a_57150_n1540# vdda1 1.62fF **FLOATING
C13633 divbuf_3/a_56670_n1540# vdda1 1.62fF **FLOATING
C13634 divbuf_3/a_56190_n1540# vdda1 1.62fF **FLOATING
C13635 divbuf_3/a_55710_n1540# vdda1 1.62fF **FLOATING
C13636 divbuf_3/a_55230_n1540# vdda1 1.62fF **FLOATING
C13637 divbuf_3/a_54750_n1540# vdda1 1.62fF **FLOATING
C13638 divbuf_3/a_54270_n1540# vdda1 1.62fF **FLOATING
C13639 divbuf_3/a_53790_n1540# vdda1 1.62fF **FLOATING
C13640 divbuf_3/a_53310_n1540# vdda1 1.62fF **FLOATING
C13641 divbuf_3/a_52830_n1540# vdda1 1.62fF **FLOATING
C13642 divbuf_3/a_52350_n1540# vdda1 1.62fF **FLOATING
C13643 divbuf_3/a_51870_n1540# vdda1 1.62fF **FLOATING
C13644 divbuf_3/a_51390_n1540# vdda1 1.62fF **FLOATING
C13645 divbuf_3/a_50910_n1540# vdda1 1.62fF **FLOATING
C13646 divbuf_3/a_50430_n1540# vdda1 1.62fF **FLOATING
C13647 divbuf_3/a_49950_n1540# vdda1 1.62fF **FLOATING
C13648 divbuf_3/a_49470_n1540# vdda1 1.62fF **FLOATING
C13649 divbuf_3/a_48990_n1540# vdda1 1.62fF **FLOATING
C13650 divbuf_3/a_48510_n1540# vdda1 1.62fF **FLOATING
C13651 divbuf_3/a_48030_n1540# vdda1 1.62fF **FLOATING
C13652 divbuf_3/a_47550_n1540# vdda1 1.62fF **FLOATING
C13653 divbuf_3/a_47070_n1540# vdda1 1.62fF **FLOATING
C13654 divbuf_3/a_46590_n1540# vdda1 1.62fF **FLOATING
C13655 divbuf_3/a_46110_n1540# vdda1 1.62fF **FLOATING
C13656 divbuf_3/a_45630_n1540# vdda1 1.62fF **FLOATING
C13657 divbuf_3/a_45150_n1540# vdda1 1.62fF **FLOATING
C13658 divbuf_3/a_44670_n1540# vdda1 1.62fF **FLOATING
C13659 divbuf_3/a_44190_n1540# vdda1 1.62fF **FLOATING
C13660 divbuf_3/a_43710_n1540# vdda1 1.62fF **FLOATING
C13661 divbuf_3/a_43230_n1540# vdda1 1.62fF **FLOATING
C13662 divbuf_3/a_42750_n1540# vdda1 1.62fF **FLOATING
C13663 divbuf_3/a_42270_n1540# vdda1 1.62fF **FLOATING
C13664 divbuf_3/a_41790_n1540# vdda1 1.62fF **FLOATING
C13665 divbuf_3/a_41310_n1540# vdda1 1.62fF **FLOATING
C13666 divbuf_3/a_40830_n1540# vdda1 1.62fF **FLOATING
C13667 divbuf_3/a_40350_n1540# vdda1 1.62fF **FLOATING
C13668 divbuf_3/a_39870_n1540# vdda1 1.62fF **FLOATING
C13669 divbuf_3/a_39390_n1540# vdda1 1.62fF **FLOATING
C13670 divbuf_3/a_38910_n1540# vdda1 1.62fF **FLOATING
C13671 divbuf_3/a_38430_n1540# vdda1 1.62fF **FLOATING
C13672 divbuf_3/a_37950_n1540# vdda1 1.62fF **FLOATING
C13673 divbuf_3/a_37470_n1540# vdda1 1.62fF **FLOATING
C13674 divbuf_3/a_36990_n1540# vdda1 1.62fF **FLOATING
C13675 divbuf_3/a_36510_n1540# vdda1 1.62fF **FLOATING
C13676 divbuf_3/a_36030_n1540# vdda1 1.62fF **FLOATING
C13677 divbuf_3/a_35550_n1540# vdda1 1.62fF **FLOATING
C13678 divbuf_3/a_35070_n1540# vdda1 1.62fF **FLOATING
C13679 divbuf_3/a_34590_n1540# vdda1 1.62fF **FLOATING
C13680 divbuf_3/a_34110_n1540# vdda1 1.62fF **FLOATING
C13681 divbuf_3/a_33630_n1540# vdda1 1.62fF **FLOATING
C13682 divbuf_3/a_33150_n1540# vdda1 1.62fF **FLOATING
C13683 divbuf_3/a_32670_n1540# vdda1 1.62fF **FLOATING
C13684 divbuf_3/a_32190_n1540# vdda1 1.62fF **FLOATING
C13685 divbuf_3/a_31710_n1540# vdda1 1.62fF **FLOATING
C13686 divbuf_3/a_31230_n1540# vdda1 1.62fF **FLOATING
C13687 divbuf_3/a_30750_n1540# vdda1 1.62fF **FLOATING
C13688 divbuf_3/a_30270_n1540# vdda1 1.62fF **FLOATING
C13689 divbuf_3/a_29790_n1540# vdda1 1.62fF **FLOATING
C13690 divbuf_3/a_29310_n1540# vdda1 1.62fF **FLOATING
C13691 divbuf_3/a_28830_n1540# vdda1 1.62fF **FLOATING
C13692 divbuf_3/a_28350_n1540# vdda1 1.62fF **FLOATING
C13693 divbuf_3/a_27870_n1540# vdda1 1.62fF **FLOATING
C13694 divbuf_3/a_27390_n1540# vdda1 1.62fF **FLOATING
C13695 divbuf_3/a_26910_n1540# vdda1 1.62fF **FLOATING
C13696 divbuf_3/a_26430_n1540# vdda1 1.62fF **FLOATING
C13697 divbuf_3/a_25950_n1540# vdda1 1.62fF **FLOATING
C13698 divbuf_3/a_25470_n1540# vdda1 1.62fF **FLOATING
C13699 divbuf_3/a_24990_n1540# vdda1 1.62fF **FLOATING
C13700 divbuf_3/a_24510_n1540# vdda1 1.62fF **FLOATING
C13701 divbuf_3/a_24030_n1540# vdda1 1.62fF **FLOATING
C13702 divbuf_3/a_23550_n1540# vdda1 1.62fF **FLOATING
C13703 divbuf_3/a_23070_n1540# vdda1 1.62fF **FLOATING
C13704 divbuf_3/a_22590_n1540# vdda1 1.62fF **FLOATING
C13705 divbuf_3/a_22110_n1540# vdda1 1.62fF **FLOATING
C13706 divbuf_3/a_21630_n1540# vdda1 1.62fF **FLOATING
C13707 divbuf_3/a_21150_n1540# vdda1 1.62fF **FLOATING
C13708 divbuf_3/a_20670_n1540# vdda1 1.62fF **FLOATING
C13709 divbuf_3/a_20190_n1540# vdda1 1.62fF **FLOATING
C13710 divbuf_3/a_19710_n1540# vdda1 1.62fF **FLOATING
C13711 divbuf_3/a_19230_n1540# vdda1 1.62fF **FLOATING
C13712 divbuf_3/a_18750_n1540# vdda1 1.62fF **FLOATING
C13713 divbuf_3/a_18270_n1540# vdda1 1.62fF **FLOATING
C13714 divbuf_3/a_17790_n1540# vdda1 1.62fF **FLOATING
C13715 divbuf_3/a_17310_n1540# vdda1 1.62fF **FLOATING
C13716 divbuf_3/a_16830_n1540# vdda1 1.62fF **FLOATING
C13717 divbuf_3/a_16350_n1540# vdda1 1.62fF **FLOATING
C13718 divbuf_3/a_15870_n1540# vdda1 1.62fF **FLOATING
C13719 divbuf_3/a_15390_n1540# vdda1 1.62fF **FLOATING
C13720 divbuf_3/a_14910_n1540# vdda1 1.62fF **FLOATING
C13721 divbuf_3/a_14430_n1540# vdda1 1.62fF **FLOATING
C13722 divbuf_3/a_13950_n1540# vdda1 1.62fF **FLOATING
C13723 divbuf_3/a_13470_n1540# vdda1 1.62fF **FLOATING
C13724 divbuf_3/a_12990_n1540# vdda1 1.62fF **FLOATING
C13725 divbuf_3/a_12510_n1540# vdda1 1.62fF **FLOATING
C13726 divbuf_3/a_12030_n1540# vdda1 1.62fF **FLOATING
C13727 divbuf_3/a_11550_n1540# vdda1 1.62fF **FLOATING
C13728 divbuf_3/a_11070_n1540# vdda1 1.62fF **FLOATING
C13729 divbuf_3/a_10590_n1540# vdda1 1.62fF **FLOATING
C13730 divbuf_3/a_10110_n1540# vdda1 1.62fF **FLOATING
C13731 divbuf_3/a_9630_n1540# vdda1 1.62fF **FLOATING
C13732 divbuf_3/a_9150_n1540# vdda1 1.62fF **FLOATING
C13733 divbuf_3/a_8670_n1540# vdda1 1.62fF **FLOATING
C13734 divbuf_3/a_8190_n1540# vdda1 1.62fF **FLOATING
C13735 divbuf_3/a_7710_n1540# vdda1 1.62fF **FLOATING
C13736 divbuf_3/a_7230_n1540# vdda1 1.62fF **FLOATING
C13737 divbuf_3/a_6750_n1540# vdda1 1.62fF **FLOATING
C13738 divbuf_3/a_6270_n1540# vdda1 1.62fF **FLOATING
C13739 divbuf_3/a_5790_n1540# vdda1 1.62fF **FLOATING
C13740 divbuf_3/a_5310_n1540# vdda1 1.62fF **FLOATING
C13741 divbuf_3/a_4830_n1540# vdda1 1.62fF **FLOATING
C13742 divbuf_3/a_4350_n1540# vdda1 1.62fF **FLOATING
C13743 divbuf_3/a_3870_n1540# vdda1 1.62fF **FLOATING
C13744 divbuf_3/a_3390_n1540# vdda1 1.62fF **FLOATING
C13745 divbuf_3/a_2910_n1540# vdda1 1.62fF **FLOATING
C13746 divbuf_3/a_2430_n1540# vdda1 1.62fF **FLOATING
C13747 divbuf_3/a_1950_n1540# vdda1 1.62fF **FLOATING
C13748 divbuf_3/a_1470_n1540# vdda1 1.62fF **FLOATING
C13749 divbuf_3/a_990_n1540# vdda1 1.62fF **FLOATING
C13750 divbuf_3/a_510_n1540# vdda1 1.62fF **FLOATING
C13751 divbuf_3/a_60990_n840# vdda1 1.06fF **FLOATING
C13752 divbuf_3/a_60510_n840# vdda1 1.09fF **FLOATING
C13753 divbuf_3/a_60030_n840# vdda1 1.09fF **FLOATING
C13754 divbuf_3/a_59550_n840# vdda1 1.09fF **FLOATING
C13755 divbuf_3/a_59070_n840# vdda1 1.09fF **FLOATING
C13756 divbuf_3/a_58590_n840# vdda1 1.09fF **FLOATING
C13757 divbuf_3/a_58110_n840# vdda1 1.09fF **FLOATING
C13758 divbuf_3/a_57630_n840# vdda1 1.09fF **FLOATING
C13759 divbuf_3/a_57150_n840# vdda1 1.09fF **FLOATING
C13760 divbuf_3/a_56670_n840# vdda1 1.09fF **FLOATING
C13761 divbuf_3/a_56190_n840# vdda1 1.09fF **FLOATING
C13762 divbuf_3/a_55710_n840# vdda1 1.09fF **FLOATING
C13763 divbuf_3/a_55230_n840# vdda1 1.09fF **FLOATING
C13764 divbuf_3/a_54750_n840# vdda1 1.09fF **FLOATING
C13765 divbuf_3/a_54270_n840# vdda1 1.09fF **FLOATING
C13766 divbuf_3/a_53790_n840# vdda1 1.09fF **FLOATING
C13767 divbuf_3/a_53310_n840# vdda1 1.09fF **FLOATING
C13768 divbuf_3/a_52830_n840# vdda1 1.09fF **FLOATING
C13769 divbuf_3/a_52350_n840# vdda1 1.09fF **FLOATING
C13770 divbuf_3/a_51870_n840# vdda1 1.09fF **FLOATING
C13771 divbuf_3/a_51390_n840# vdda1 1.09fF **FLOATING
C13772 divbuf_3/a_50910_n840# vdda1 1.09fF **FLOATING
C13773 divbuf_3/a_50430_n840# vdda1 1.09fF **FLOATING
C13774 divbuf_3/a_49950_n840# vdda1 1.09fF **FLOATING
C13775 divbuf_3/a_49470_n840# vdda1 1.09fF **FLOATING
C13776 divbuf_3/a_48990_n840# vdda1 1.09fF **FLOATING
C13777 divbuf_3/a_48510_n840# vdda1 1.09fF **FLOATING
C13778 divbuf_3/a_48030_n840# vdda1 1.09fF **FLOATING
C13779 divbuf_3/a_47550_n840# vdda1 1.09fF **FLOATING
C13780 divbuf_3/a_47070_n840# vdda1 1.09fF **FLOATING
C13781 divbuf_3/a_46590_n840# vdda1 1.09fF **FLOATING
C13782 divbuf_3/a_46110_n840# vdda1 1.09fF **FLOATING
C13783 divbuf_3/a_45630_n840# vdda1 1.09fF **FLOATING
C13784 divbuf_3/a_45150_n840# vdda1 1.09fF **FLOATING
C13785 divbuf_3/a_44670_n840# vdda1 1.09fF **FLOATING
C13786 divbuf_3/a_44190_n840# vdda1 1.09fF **FLOATING
C13787 divbuf_3/a_43710_n840# vdda1 1.09fF **FLOATING
C13788 divbuf_3/a_43230_n840# vdda1 1.09fF **FLOATING
C13789 divbuf_3/a_42750_n840# vdda1 1.08fF **FLOATING
C13790 divbuf_3/a_42270_n840# vdda1 1.08fF **FLOATING
C13791 divbuf_3/a_41790_n840# vdda1 1.10fF **FLOATING
C13792 divbuf_3/a_41310_n840# vdda1 1.09fF **FLOATING
C13793 divbuf_3/a_40830_n840# vdda1 1.09fF **FLOATING
C13794 divbuf_3/a_40350_n840# vdda1 1.09fF **FLOATING
C13795 divbuf_3/a_39870_n840# vdda1 1.09fF **FLOATING
C13796 divbuf_3/a_39390_n840# vdda1 1.09fF **FLOATING
C13797 divbuf_3/a_38910_n840# vdda1 1.09fF **FLOATING
C13798 divbuf_3/a_38430_n840# vdda1 1.09fF **FLOATING
C13799 divbuf_3/a_37950_n840# vdda1 1.09fF **FLOATING
C13800 divbuf_3/a_37470_n840# vdda1 1.09fF **FLOATING
C13801 divbuf_3/a_36990_n840# vdda1 1.09fF **FLOATING
C13802 divbuf_3/a_36510_n840# vdda1 1.09fF **FLOATING
C13803 divbuf_3/a_36030_n840# vdda1 1.09fF **FLOATING
C13804 divbuf_3/a_35550_n840# vdda1 1.09fF **FLOATING
C13805 divbuf_3/a_35070_n840# vdda1 1.09fF **FLOATING
C13806 divbuf_3/a_34590_n840# vdda1 1.09fF **FLOATING
C13807 divbuf_3/a_34110_n840# vdda1 1.09fF **FLOATING
C13808 divbuf_3/a_33630_n840# vdda1 1.09fF **FLOATING
C13809 divbuf_3/a_33150_n840# vdda1 1.09fF **FLOATING
C13810 divbuf_3/a_32670_n840# vdda1 1.09fF **FLOATING
C13811 divbuf_3/a_32190_n840# vdda1 1.09fF **FLOATING
C13812 divbuf_3/a_31710_n840# vdda1 1.11fF **FLOATING
C13813 divbuf_3/a_31230_n840# vdda1 1.13fF **FLOATING
C13814 divbuf_3/a_30750_n840# vdda1 1.09fF **FLOATING
C13815 divbuf_3/a_30270_n840# vdda1 1.09fF **FLOATING
C13816 divbuf_3/a_29790_n840# vdda1 1.09fF **FLOATING
C13817 divbuf_3/a_29310_n840# vdda1 1.09fF **FLOATING
C13818 divbuf_3/a_28830_n840# vdda1 1.09fF **FLOATING
C13819 divbuf_3/a_28350_n840# vdda1 1.09fF **FLOATING
C13820 divbuf_3/a_27870_n840# vdda1 1.08fF **FLOATING
C13821 divbuf_3/a_27390_n840# vdda1 1.11fF **FLOATING
C13822 divbuf_3/a_26910_n840# vdda1 1.10fF **FLOATING
C13823 divbuf_3/a_26430_n840# vdda1 1.10fF **FLOATING
C13824 divbuf_3/a_25950_n840# vdda1 1.10fF **FLOATING
C13825 divbuf_3/a_25470_n840# vdda1 1.10fF **FLOATING
C13826 divbuf_3/a_24990_n840# vdda1 1.10fF **FLOATING
C13827 divbuf_3/a_24510_n840# vdda1 1.10fF **FLOATING
C13828 divbuf_3/a_24030_n840# vdda1 1.09fF **FLOATING
C13829 divbuf_3/a_23550_n840# vdda1 1.11fF **FLOATING
C13830 divbuf_3/a_23070_n840# vdda1 1.10fF **FLOATING
C13831 divbuf_3/a_22590_n840# vdda1 1.10fF **FLOATING
C13832 divbuf_3/a_22110_n840# vdda1 1.10fF **FLOATING
C13833 divbuf_3/a_21630_n840# vdda1 1.10fF **FLOATING
C13834 divbuf_3/a_21150_n840# vdda1 1.10fF **FLOATING
C13835 divbuf_3/a_20670_n840# vdda1 1.10fF **FLOATING
C13836 divbuf_3/a_20190_n840# vdda1 1.09fF **FLOATING
C13837 divbuf_3/a_19710_n840# vdda1 1.09fF **FLOATING
C13838 divbuf_3/a_19230_n840# vdda1 1.09fF **FLOATING
C13839 divbuf_3/a_18750_n840# vdda1 1.09fF **FLOATING
C13840 divbuf_3/a_18270_n840# vdda1 1.08fF **FLOATING
C13841 divbuf_3/a_17790_n840# vdda1 1.08fF **FLOATING
C13842 divbuf_3/a_17310_n840# vdda1 1.07fF **FLOATING
C13843 divbuf_3/a_16830_n840# vdda1 1.07fF **FLOATING
C13844 divbuf_3/a_16350_n840# vdda1 1.07fF **FLOATING
C13845 divbuf_3/a_15870_n840# vdda1 1.07fF **FLOATING
C13846 divbuf_3/a_15390_n840# vdda1 1.08fF **FLOATING
C13847 divbuf_3/a_14910_n840# vdda1 1.07fF **FLOATING
C13848 divbuf_3/a_14430_n840# vdda1 1.07fF **FLOATING
C13849 divbuf_3/a_13950_n840# vdda1 1.07fF **FLOATING
C13850 divbuf_3/a_13470_n840# vdda1 1.07fF **FLOATING
C13851 divbuf_3/a_12990_n840# vdda1 1.10fF **FLOATING
C13852 divbuf_3/a_12510_n840# vdda1 1.08fF **FLOATING
C13853 divbuf_3/a_12030_n840# vdda1 1.07fF **FLOATING
C13854 divbuf_3/a_11550_n840# vdda1 1.07fF **FLOATING
C13855 divbuf_3/a_11070_n840# vdda1 1.08fF **FLOATING
C13856 divbuf_3/a_10590_n840# vdda1 1.10fF **FLOATING
C13857 divbuf_3/a_10110_n840# vdda1 1.10fF **FLOATING
C13858 divbuf_3/a_9630_n840# vdda1 1.10fF **FLOATING
C13859 divbuf_3/a_9150_n840# vdda1 1.10fF **FLOATING
C13860 divbuf_3/a_8670_n840# vdda1 1.10fF **FLOATING
C13861 divbuf_3/a_8190_n840# vdda1 1.12fF **FLOATING
C13862 divbuf_3/a_7710_n840# vdda1 1.10fF **FLOATING
C13863 divbuf_3/a_7230_n840# vdda1 1.09fF **FLOATING
C13864 divbuf_3/a_6750_n840# vdda1 1.09fF **FLOATING
C13865 divbuf_3/a_6270_n840# vdda1 1.09fF **FLOATING
C13866 divbuf_3/a_5790_n840# vdda1 1.09fF **FLOATING
C13867 divbuf_3/a_5310_n840# vdda1 1.09fF **FLOATING
C13868 divbuf_3/a_4830_n840# vdda1 1.09fF **FLOATING
C13869 divbuf_3/a_4350_n840# vdda1 1.09fF **FLOATING
C13870 divbuf_3/a_3870_n840# vdda1 1.09fF **FLOATING
C13871 divbuf_3/a_3390_n840# vdda1 1.09fF **FLOATING
C13872 divbuf_3/a_2910_n840# vdda1 1.10fF **FLOATING
C13873 divbuf_3/a_2430_n840# vdda1 1.10fF **FLOATING
C13874 divbuf_3/a_1950_n840# vdda1 1.10fF **FLOATING
C13875 divbuf_3/a_1470_n840# vdda1 1.10fF **FLOATING
C13876 divbuf_3/a_990_n840# vdda1 1.08fF **FLOATING
C13877 divbuf_3/a_510_n840# vdda1 1.07fF **FLOATING
C13878 divbuf_3/a_60480_n1600# vdda1 1.48fF **FLOATING
C13879 divbuf_3/a_60000_n1600# vdda1 1.48fF **FLOATING
C13880 divbuf_3/a_59520_n1600# vdda1 1.48fF **FLOATING
C13881 divbuf_3/a_59040_n1600# vdda1 1.48fF **FLOATING
C13882 divbuf_3/a_58560_n1600# vdda1 1.48fF **FLOATING
C13883 divbuf_3/a_58080_n1600# vdda1 1.48fF **FLOATING
C13884 divbuf_3/a_57600_n1600# vdda1 1.48fF **FLOATING
C13885 divbuf_3/a_57120_n1600# vdda1 1.48fF **FLOATING
C13886 divbuf_3/a_56640_n1600# vdda1 1.48fF **FLOATING
C13887 divbuf_3/a_56160_n1600# vdda1 1.48fF **FLOATING
C13888 divbuf_3/a_55680_n1600# vdda1 1.48fF **FLOATING
C13889 divbuf_3/a_55200_n1600# vdda1 1.48fF **FLOATING
C13890 divbuf_3/a_54720_n1600# vdda1 1.48fF **FLOATING
C13891 divbuf_3/a_54240_n1600# vdda1 1.48fF **FLOATING
C13892 divbuf_3/a_53760_n1600# vdda1 1.48fF **FLOATING
C13893 divbuf_3/a_53280_n1600# vdda1 1.48fF **FLOATING
C13894 divbuf_3/a_52800_n1600# vdda1 1.48fF **FLOATING
C13895 divbuf_3/a_52320_n1600# vdda1 1.48fF **FLOATING
C13896 divbuf_3/a_51840_n1600# vdda1 1.48fF **FLOATING
C13897 divbuf_3/a_51360_n1600# vdda1 1.48fF **FLOATING
C13898 divbuf_3/a_50880_n1600# vdda1 1.48fF **FLOATING
C13899 divbuf_3/a_50400_n1600# vdda1 1.48fF **FLOATING
C13900 divbuf_3/a_49920_n1600# vdda1 1.48fF **FLOATING
C13901 divbuf_3/a_49440_n1600# vdda1 1.48fF **FLOATING
C13902 divbuf_3/a_48960_n1600# vdda1 1.48fF **FLOATING
C13903 divbuf_3/a_48480_n1600# vdda1 1.48fF **FLOATING
C13904 divbuf_3/a_48000_n1600# vdda1 1.48fF **FLOATING
C13905 divbuf_3/a_47520_n1600# vdda1 1.48fF **FLOATING
C13906 divbuf_3/a_47040_n1600# vdda1 1.48fF **FLOATING
C13907 divbuf_3/a_46560_n1600# vdda1 1.48fF **FLOATING
C13908 divbuf_3/a_46080_n1600# vdda1 1.48fF **FLOATING
C13909 divbuf_3/a_45600_n1600# vdda1 1.48fF **FLOATING
C13910 divbuf_3/a_45120_n1600# vdda1 1.48fF **FLOATING
C13911 divbuf_3/a_44640_n1600# vdda1 1.48fF **FLOATING
C13912 divbuf_3/a_44160_n1600# vdda1 1.48fF **FLOATING
C13913 divbuf_3/a_43680_n1600# vdda1 1.48fF **FLOATING
C13914 divbuf_3/a_43200_n1600# vdda1 1.48fF **FLOATING
C13915 divbuf_3/a_42720_n1600# vdda1 1.48fF **FLOATING
C13916 divbuf_3/a_42240_n1600# vdda1 1.48fF **FLOATING
C13917 divbuf_3/a_41760_n1600# vdda1 1.48fF **FLOATING
C13918 divbuf_3/a_41280_n1600# vdda1 1.48fF **FLOATING
C13919 divbuf_3/a_40800_n1600# vdda1 1.48fF **FLOATING
C13920 divbuf_3/a_40320_n1600# vdda1 1.48fF **FLOATING
C13921 divbuf_3/a_39840_n1600# vdda1 1.48fF **FLOATING
C13922 divbuf_3/a_39360_n1600# vdda1 1.48fF **FLOATING
C13923 divbuf_3/a_38880_n1600# vdda1 1.48fF **FLOATING
C13924 divbuf_3/a_38400_n1600# vdda1 1.48fF **FLOATING
C13925 divbuf_3/a_37920_n1600# vdda1 1.48fF **FLOATING
C13926 divbuf_3/a_37440_n1600# vdda1 1.48fF **FLOATING
C13927 divbuf_3/a_36960_n1600# vdda1 1.48fF **FLOATING
C13928 divbuf_3/a_36480_n1600# vdda1 1.48fF **FLOATING
C13929 divbuf_3/a_36000_n1600# vdda1 1.48fF **FLOATING
C13930 divbuf_3/a_35520_n1600# vdda1 1.48fF **FLOATING
C13931 divbuf_3/a_35040_n1600# vdda1 1.48fF **FLOATING
C13932 divbuf_3/a_34560_n1600# vdda1 1.48fF **FLOATING
C13933 divbuf_3/a_34080_n1600# vdda1 1.48fF **FLOATING
C13934 divbuf_3/a_33600_n1600# vdda1 1.48fF **FLOATING
C13935 divbuf_3/a_33120_n1600# vdda1 1.48fF **FLOATING
C13936 divbuf_3/a_32640_n1600# vdda1 1.48fF **FLOATING
C13937 divbuf_3/a_32160_n1600# vdda1 1.48fF **FLOATING
C13938 divbuf_3/a_31680_n1600# vdda1 1.48fF **FLOATING
C13939 divbuf_3/a_31200_n1600# vdda1 1.48fF **FLOATING
C13940 divbuf_3/a_30720_n1600# vdda1 1.48fF **FLOATING
C13941 divbuf_3/a_30240_n1600# vdda1 1.48fF **FLOATING
C13942 divbuf_3/a_29760_n1600# vdda1 1.48fF **FLOATING
C13943 divbuf_3/a_29280_n1600# vdda1 1.48fF **FLOATING
C13944 divbuf_3/a_28800_n1600# vdda1 1.48fF **FLOATING
C13945 divbuf_3/a_28320_n1600# vdda1 1.48fF **FLOATING
C13946 divbuf_3/a_27840_n1600# vdda1 1.48fF **FLOATING
C13947 divbuf_3/a_27360_n1600# vdda1 1.48fF **FLOATING
C13948 divbuf_3/a_26880_n1600# vdda1 1.48fF **FLOATING
C13949 divbuf_3/a_26400_n1600# vdda1 1.48fF **FLOATING
C13950 divbuf_3/a_25920_n1600# vdda1 1.48fF **FLOATING
C13951 divbuf_3/a_25440_n1600# vdda1 1.48fF **FLOATING
C13952 divbuf_3/a_24960_n1600# vdda1 1.48fF **FLOATING
C13953 divbuf_3/a_24480_n1600# vdda1 1.48fF **FLOATING
C13954 divbuf_3/a_24000_n1600# vdda1 1.48fF **FLOATING
C13955 divbuf_3/a_23520_n1600# vdda1 1.48fF **FLOATING
C13956 divbuf_3/a_23040_n1600# vdda1 1.48fF **FLOATING
C13957 divbuf_3/a_22560_n1600# vdda1 1.48fF **FLOATING
C13958 divbuf_3/a_22080_n1600# vdda1 1.48fF **FLOATING
C13959 divbuf_3/a_21600_n1600# vdda1 1.48fF **FLOATING
C13960 divbuf_3/a_21120_n1600# vdda1 1.48fF **FLOATING
C13961 divbuf_3/a_20640_n1600# vdda1 1.48fF **FLOATING
C13962 divbuf_3/a_20160_n1600# vdda1 1.48fF **FLOATING
C13963 divbuf_3/a_19680_n1600# vdda1 1.48fF **FLOATING
C13964 divbuf_3/a_19200_n1600# vdda1 1.48fF **FLOATING
C13965 divbuf_3/a_18720_n1600# vdda1 1.48fF **FLOATING
C13966 divbuf_3/a_18240_n1600# vdda1 1.48fF **FLOATING
C13967 divbuf_3/a_17760_n1600# vdda1 1.48fF **FLOATING
C13968 divbuf_3/a_17280_n1600# vdda1 1.48fF **FLOATING
C13969 divbuf_3/a_16800_n1600# vdda1 1.48fF **FLOATING
C13970 divbuf_3/a_16320_n1600# vdda1 1.48fF **FLOATING
C13971 divbuf_3/a_15840_n1600# vdda1 1.48fF **FLOATING
C13972 divbuf_3/a_15360_n1600# vdda1 1.48fF **FLOATING
C13973 divbuf_3/a_14880_n1600# vdda1 1.48fF **FLOATING
C13974 divbuf_3/a_14400_n1600# vdda1 1.48fF **FLOATING
C13975 divbuf_3/a_13920_n1600# vdda1 1.48fF **FLOATING
C13976 divbuf_3/a_13440_n1600# vdda1 1.48fF **FLOATING
C13977 divbuf_3/a_12960_n1600# vdda1 1.48fF **FLOATING
C13978 divbuf_3/a_12480_n1600# vdda1 1.48fF **FLOATING
C13979 divbuf_3/a_12000_n1600# vdda1 1.48fF **FLOATING
C13980 divbuf_3/a_11520_n1600# vdda1 1.48fF **FLOATING
C13981 divbuf_3/a_11040_n1600# vdda1 1.48fF **FLOATING
C13982 divbuf_3/a_10560_n1600# vdda1 1.48fF **FLOATING
C13983 divbuf_3/a_10080_n1600# vdda1 1.48fF **FLOATING
C13984 divbuf_3/a_9600_n1600# vdda1 1.48fF **FLOATING
C13985 divbuf_3/a_9120_n1600# vdda1 1.48fF **FLOATING
C13986 divbuf_3/a_8640_n1600# vdda1 1.48fF **FLOATING
C13987 divbuf_3/a_8160_n1600# vdda1 1.48fF **FLOATING
C13988 divbuf_3/a_7680_n1600# vdda1 1.48fF **FLOATING
C13989 divbuf_3/a_7200_n1600# vdda1 1.48fF **FLOATING
C13990 divbuf_3/a_6720_n1600# vdda1 1.48fF **FLOATING
C13991 divbuf_3/a_6240_n1600# vdda1 1.48fF **FLOATING
C13992 divbuf_3/a_5760_n1600# vdda1 1.48fF **FLOATING
C13993 divbuf_3/a_5280_n1600# vdda1 1.48fF **FLOATING
C13994 divbuf_3/a_4800_n1600# vdda1 1.48fF **FLOATING
C13995 divbuf_3/a_4320_n1600# vdda1 1.48fF **FLOATING
C13996 divbuf_3/a_3840_n1600# vdda1 1.48fF **FLOATING
C13997 divbuf_3/a_3360_n1600# vdda1 1.48fF **FLOATING
C13998 divbuf_3/a_2880_n1600# vdda1 1.48fF **FLOATING
C13999 divbuf_3/a_2400_n1600# vdda1 1.48fF **FLOATING
C14000 divbuf_3/a_1920_n1600# vdda1 1.48fF **FLOATING
C14001 divbuf_3/a_1440_n1600# vdda1 1.48fF **FLOATING
C14002 divbuf_3/a_960_n1600# vdda1 1.48fF **FLOATING
C14003 divbuf_3/a_480_n1600# vdda1 1.48fF **FLOATING
C14004 divbuf_3/a_0_n1600# vdda1 1.48fF **FLOATING
C14005 divbuf_3/a_41382_n240# vdda1 0.90fF **FLOATING
C14006 divbuf_3/a_40902_n240# vdda1 0.90fF **FLOATING
C14007 divbuf_3/a_40412_n240# vdda1 0.90fF **FLOATING
C14008 divbuf_3/a_39932_n240# vdda1 0.90fF **FLOATING
C14009 divbuf_3/a_39442_n240# vdda1 0.90fF **FLOATING
C14010 divbuf_3/a_38962_n240# vdda1 0.91fF **FLOATING
C14011 divbuf_3/a_38472_n240# vdda1 0.90fF **FLOATING
C14012 divbuf_3/a_37992_n240# vdda1 0.90fF **FLOATING
C14013 divbuf_3/a_37502_n240# vdda1 0.90fF **FLOATING
C14014 divbuf_3/a_37022_n240# vdda1 0.90fF **FLOATING
C14015 divbuf_3/a_36532_n240# vdda1 0.90fF **FLOATING
C14016 divbuf_3/a_36052_n240# vdda1 0.90fF **FLOATING
C14017 divbuf_3/a_35562_n240# vdda1 0.90fF **FLOATING
C14018 divbuf_3/a_35082_n240# vdda1 0.91fF **FLOATING
C14019 divbuf_3/a_34592_n240# vdda1 0.90fF **FLOATING
C14020 divbuf_3/a_34112_n240# vdda1 0.90fF **FLOATING
C14021 divbuf_3/a_33622_n240# vdda1 0.90fF **FLOATING
C14022 divbuf_3/a_33142_n240# vdda1 0.90fF **FLOATING
C14023 divbuf_3/a_32652_n240# vdda1 0.90fF **FLOATING
C14024 divbuf_3/a_32172_n240# vdda1 0.90fF **FLOATING
C14025 divbuf_3/a_31682_n240# vdda1 0.89fF **FLOATING
C14026 divbuf_3/a_31202_n240# vdda1 0.92fF **FLOATING
C14027 divbuf_3/a_30712_n240# vdda1 0.90fF **FLOATING
C14028 divbuf_3/a_30232_n240# vdda1 0.90fF **FLOATING
C14029 divbuf_3/a_29742_n240# vdda1 0.90fF **FLOATING
C14030 divbuf_3/a_29262_n240# vdda1 0.90fF **FLOATING
C14031 divbuf_3/a_28772_n240# vdda1 0.90fF **FLOATING
C14032 divbuf_3/a_28292_n240# vdda1 0.90fF **FLOATING
C14033 divbuf_3/a_27802_n240# vdda1 0.89fF **FLOATING
C14034 divbuf_3/a_27322_n240# vdda1 0.95fF **FLOATING
C14035 divbuf_3/a_26832_n240# vdda1 0.91fF **FLOATING
C14036 divbuf_3/a_26352_n240# vdda1 0.91fF **FLOATING
C14037 divbuf_3/a_25862_n240# vdda1 0.91fF **FLOATING
C14038 divbuf_3/a_25382_n240# vdda1 0.91fF **FLOATING
C14039 divbuf_3/a_24892_n240# vdda1 0.91fF **FLOATING
C14040 divbuf_3/a_24412_n240# vdda1 0.91fF **FLOATING
C14041 divbuf_3/a_23922_n240# vdda1 0.92fF **FLOATING
C14042 divbuf_3/a_23442_n240# vdda1 0.94fF **FLOATING
C14043 divbuf_3/a_22952_n240# vdda1 0.91fF **FLOATING
C14044 divbuf_3/a_22472_n240# vdda1 0.91fF **FLOATING
C14045 divbuf_3/a_21982_n240# vdda1 0.91fF **FLOATING
C14046 divbuf_3/a_21502_n240# vdda1 0.91fF **FLOATING
C14047 divbuf_3/a_21012_n240# vdda1 0.91fF **FLOATING
C14048 divbuf_3/a_20532_n240# vdda1 0.91fF **FLOATING
C14049 divbuf_3/a_20042_n240# vdda1 0.90fF **FLOATING
C14050 divbuf_3/a_19562_n240# vdda1 0.90fF **FLOATING
C14051 divbuf_3/a_19072_n240# vdda1 0.90fF **FLOATING
C14052 divbuf_3/a_18582_n240# vdda1 0.89fF **FLOATING
C14053 divbuf_3/a_18092_n240# vdda1 0.89fF **FLOATING
C14054 divbuf_3/a_17612_n240# vdda1 0.89fF **FLOATING
C14055 divbuf_3/a_17122_n240# vdda1 0.88fF **FLOATING
C14056 divbuf_3/a_16642_n240# vdda1 0.88fF **FLOATING
C14057 divbuf_3/a_16152_n240# vdda1 0.88fF **FLOATING
C14058 divbuf_3/a_15672_n240# vdda1 0.90fF **FLOATING
C14059 divbuf_3/a_15182_n240# vdda1 0.88fF **FLOATING
C14060 divbuf_3/a_14702_n240# vdda1 0.88fF **FLOATING
C14061 divbuf_3/a_14222_n240# vdda1 0.88fF **FLOATING
C14062 divbuf_3/a_13742_n240# vdda1 0.88fF **FLOATING
C14063 divbuf_3/a_13252_n240# vdda1 0.88fF **FLOATING
C14064 divbuf_3/a_12772_n240# vdda1 0.88fF **FLOATING
C14065 divbuf_3/a_12282_n240# vdda1 0.88fF **FLOATING
C14066 divbuf_3/a_11802_n240# vdda1 0.88fF **FLOATING
C14067 divbuf_3/a_11312_n240# vdda1 0.89fF **FLOATING
C14068 divbuf_3/a_10212_n240# vdda1 0.91fF **FLOATING
C14069 divbuf_3/a_9732_n240# vdda1 0.91fF **FLOATING
C14070 divbuf_3/a_9242_n240# vdda1 0.91fF **FLOATING
C14071 divbuf_3/a_8762_n240# vdda1 0.91fF **FLOATING
C14072 divbuf_3/a_8272_n240# vdda1 0.91fF **FLOATING
C14073 divbuf_3/a_7792_n240# vdda1 0.92fF **FLOATING
C14074 divbuf_3/a_7302_n240# vdda1 0.90fF **FLOATING
C14075 divbuf_3/a_6822_n240# vdda1 0.90fF **FLOATING
C14076 divbuf_3/a_6332_n240# vdda1 0.90fF **FLOATING
C14077 divbuf_3/a_5852_n240# vdda1 0.90fF **FLOATING
C14078 divbuf_3/a_5362_n240# vdda1 0.90fF **FLOATING
C14079 divbuf_3/a_4882_n240# vdda1 0.90fF **FLOATING
C14080 divbuf_3/a_4392_n240# vdda1 0.90fF **FLOATING
C14081 divbuf_3/a_3912_n240# vdda1 0.90fF **FLOATING
C14082 divbuf_3/a_3422_n240# vdda1 0.90fF **FLOATING
C14083 divbuf_3/a_2322_n240# vdda1 0.91fF **FLOATING
C14084 divbuf_3/a_1842_n240# vdda1 0.91fF **FLOATING
C14085 divbuf_3/a_1352_n240# vdda1 0.91fF **FLOATING
C14086 divbuf_3/a_41382_170# vdda1 1.07fF **FLOATING
C14087 divbuf_3/a_40902_170# vdda1 1.09fF **FLOATING
C14088 divbuf_3/a_40412_170# vdda1 1.09fF **FLOATING
C14089 divbuf_3/a_39932_170# vdda1 1.09fF **FLOATING
C14090 divbuf_3/a_39442_170# vdda1 1.09fF **FLOATING
C14091 divbuf_3/a_38962_170# vdda1 1.07fF **FLOATING
C14092 divbuf_3/a_38472_170# vdda1 1.09fF **FLOATING
C14093 divbuf_3/a_37992_170# vdda1 1.09fF **FLOATING
C14094 divbuf_3/a_37502_170# vdda1 1.09fF **FLOATING
C14095 divbuf_3/a_37022_170# vdda1 1.09fF **FLOATING
C14096 divbuf_3/a_36532_170# vdda1 1.09fF **FLOATING
C14097 divbuf_3/a_36052_170# vdda1 1.09fF **FLOATING
C14098 divbuf_3/a_35562_170# vdda1 1.09fF **FLOATING
C14099 divbuf_3/a_35082_170# vdda1 1.09fF **FLOATING
C14100 divbuf_3/a_34592_170# vdda1 1.07fF **FLOATING
C14101 divbuf_3/a_34112_170# vdda1 1.09fF **FLOATING
C14102 divbuf_3/a_33622_170# vdda1 1.09fF **FLOATING
C14103 divbuf_3/a_33142_170# vdda1 1.09fF **FLOATING
C14104 divbuf_3/a_32652_170# vdda1 1.09fF **FLOATING
C14105 divbuf_3/a_32172_170# vdda1 1.09fF **FLOATING
C14106 divbuf_3/a_31682_170# vdda1 1.09fF **FLOATING
C14107 divbuf_3/a_31202_170# vdda1 1.09fF **FLOATING
C14108 divbuf_3/a_30712_170# vdda1 1.09fF **FLOATING
C14109 divbuf_3/a_30232_170# vdda1 1.07fF **FLOATING
C14110 divbuf_3/a_29742_170# vdda1 1.09fF **FLOATING
C14111 divbuf_3/a_29262_170# vdda1 1.09fF **FLOATING
C14112 divbuf_3/a_28772_170# vdda1 1.09fF **FLOATING
C14113 divbuf_3/a_28292_170# vdda1 1.09fF **FLOATING
C14114 divbuf_3/a_27802_170# vdda1 1.09fF **FLOATING
C14115 divbuf_3/a_27322_170# vdda1 1.09fF **FLOATING
C14116 divbuf_3/a_26832_170# vdda1 1.09fF **FLOATING
C14117 divbuf_3/a_26352_170# vdda1 1.09fF **FLOATING
C14118 divbuf_3/a_25862_170# vdda1 1.07fF **FLOATING
C14119 divbuf_3/a_25382_170# vdda1 1.09fF **FLOATING
C14120 divbuf_3/a_24892_170# vdda1 1.09fF **FLOATING
C14121 divbuf_3/a_24412_170# vdda1 1.09fF **FLOATING
C14122 divbuf_3/a_23922_170# vdda1 1.09fF **FLOATING
C14123 divbuf_3/a_23442_170# vdda1 1.09fF **FLOATING
C14124 divbuf_3/a_22952_170# vdda1 1.09fF **FLOATING
C14125 divbuf_3/a_22472_170# vdda1 1.07fF **FLOATING
C14126 divbuf_3/a_21982_170# vdda1 1.09fF **FLOATING
C14127 divbuf_3/a_21502_170# vdda1 1.09fF **FLOATING
C14128 divbuf_3/a_21012_170# vdda1 1.09fF **FLOATING
C14129 divbuf_3/a_20532_170# vdda1 1.09fF **FLOATING
C14130 divbuf_3/a_20042_170# vdda1 1.09fF **FLOATING
C14131 divbuf_3/a_19562_170# vdda1 1.09fF **FLOATING
C14132 divbuf_3/a_19072_170# vdda1 1.09fF **FLOATING
C14133 divbuf_3/a_18582_170# vdda1 1.07fF **FLOATING
C14134 divbuf_3/a_18092_170# vdda1 1.09fF **FLOATING
C14135 divbuf_3/a_17612_170# vdda1 1.09fF **FLOATING
C14136 divbuf_3/a_17122_170# vdda1 1.09fF **FLOATING
C14137 divbuf_3/a_16642_170# vdda1 1.09fF **FLOATING
C14138 divbuf_3/a_16152_170# vdda1 1.09fF **FLOATING
C14139 divbuf_3/a_15672_170# vdda1 1.09fF **FLOATING
C14140 divbuf_3/a_15182_170# vdda1 1.09fF **FLOATING
C14141 divbuf_3/a_14702_170# vdda1 1.10fF **FLOATING
C14142 divbuf_3/a_14222_170# vdda1 1.10fF **FLOATING
C14143 divbuf_3/a_13742_170# vdda1 1.09fF **FLOATING
C14144 divbuf_3/a_13252_170# vdda1 1.09fF **FLOATING
C14145 divbuf_3/a_12772_170# vdda1 1.07fF **FLOATING
C14146 divbuf_3/a_12282_170# vdda1 1.09fF **FLOATING
C14147 divbuf_3/a_11802_170# vdda1 1.09fF **FLOATING
C14148 divbuf_3/a_11312_170# vdda1 1.10fF **FLOATING
C14149 divbuf_3/a_10212_170# vdda1 1.09fF **FLOATING
C14150 divbuf_3/a_9732_170# vdda1 1.09fF **FLOATING
C14151 divbuf_3/a_9242_170# vdda1 1.09fF **FLOATING
C14152 divbuf_3/a_8762_170# vdda1 1.09fF **FLOATING
C14153 divbuf_3/a_8272_170# vdda1 1.07fF **FLOATING
C14154 divbuf_3/a_7792_170# vdda1 1.09fF **FLOATING
C14155 divbuf_3/a_7302_170# vdda1 1.09fF **FLOATING
C14156 divbuf_3/a_6822_170# vdda1 1.09fF **FLOATING
C14157 divbuf_3/a_6332_170# vdda1 1.09fF **FLOATING
C14158 divbuf_3/a_5852_170# vdda1 1.09fF **FLOATING
C14159 divbuf_3/a_5362_170# vdda1 1.09fF **FLOATING
C14160 divbuf_3/a_4882_170# vdda1 1.09fF **FLOATING
C14161 divbuf_3/a_4392_170# vdda1 1.07fF **FLOATING
C14162 divbuf_3/a_3912_170# vdda1 1.09fF **FLOATING
C14163 divbuf_3/a_3422_170# vdda1 1.10fF **FLOATING
C14164 divbuf_3/a_2322_170# vdda1 1.09fF **FLOATING
C14165 divbuf_3/a_1842_170# vdda1 1.09fF **FLOATING
C14166 divbuf_3/a_1352_170# vdda1 1.10fF **FLOATING
C14167 divbuf_3/a_492_n240# vdda1 2.46fF **FLOATING
C14168 divbuf_2/OUT vdda1 3.28fF
C14169 divbuf_2/OUT5 vdda1 16.40fF
C14170 divbuf_2/OUT4 vdda1 100.06fF
C14171 divbuf_2/OUT3 vdda1 27.01fF
C14172 divbuf_2/OUT2 vdda1 8.71fF
C14173 divbuf_2/IN vdda1 0.89fF
C14174 divbuf_2/a_60990_n1540# vdda1 1.57fF **FLOATING
C14175 divbuf_2/a_60510_n1540# vdda1 1.62fF **FLOATING
C14176 divbuf_2/a_60030_n1540# vdda1 1.62fF **FLOATING
C14177 divbuf_2/a_59550_n1540# vdda1 1.62fF **FLOATING
C14178 divbuf_2/a_59070_n1540# vdda1 1.62fF **FLOATING
C14179 divbuf_2/a_58590_n1540# vdda1 1.62fF **FLOATING
C14180 divbuf_2/a_58110_n1540# vdda1 1.62fF **FLOATING
C14181 divbuf_2/a_57630_n1540# vdda1 1.62fF **FLOATING
C14182 divbuf_2/a_57150_n1540# vdda1 1.62fF **FLOATING
C14183 divbuf_2/a_56670_n1540# vdda1 1.62fF **FLOATING
C14184 divbuf_2/a_56190_n1540# vdda1 1.62fF **FLOATING
C14185 divbuf_2/a_55710_n1540# vdda1 1.62fF **FLOATING
C14186 divbuf_2/a_55230_n1540# vdda1 1.62fF **FLOATING
C14187 divbuf_2/a_54750_n1540# vdda1 1.62fF **FLOATING
C14188 divbuf_2/a_54270_n1540# vdda1 1.62fF **FLOATING
C14189 divbuf_2/a_53790_n1540# vdda1 1.62fF **FLOATING
C14190 divbuf_2/a_53310_n1540# vdda1 1.62fF **FLOATING
C14191 divbuf_2/a_52830_n1540# vdda1 1.62fF **FLOATING
C14192 divbuf_2/a_52350_n1540# vdda1 1.62fF **FLOATING
C14193 divbuf_2/a_51870_n1540# vdda1 1.62fF **FLOATING
C14194 divbuf_2/a_51390_n1540# vdda1 1.62fF **FLOATING
C14195 divbuf_2/a_50910_n1540# vdda1 1.62fF **FLOATING
C14196 divbuf_2/a_50430_n1540# vdda1 1.62fF **FLOATING
C14197 divbuf_2/a_49950_n1540# vdda1 1.62fF **FLOATING
C14198 divbuf_2/a_49470_n1540# vdda1 1.62fF **FLOATING
C14199 divbuf_2/a_48990_n1540# vdda1 1.62fF **FLOATING
C14200 divbuf_2/a_48510_n1540# vdda1 1.62fF **FLOATING
C14201 divbuf_2/a_48030_n1540# vdda1 1.62fF **FLOATING
C14202 divbuf_2/a_47550_n1540# vdda1 1.62fF **FLOATING
C14203 divbuf_2/a_47070_n1540# vdda1 1.62fF **FLOATING
C14204 divbuf_2/a_46590_n1540# vdda1 1.62fF **FLOATING
C14205 divbuf_2/a_46110_n1540# vdda1 1.62fF **FLOATING
C14206 divbuf_2/a_45630_n1540# vdda1 1.62fF **FLOATING
C14207 divbuf_2/a_45150_n1540# vdda1 1.62fF **FLOATING
C14208 divbuf_2/a_44670_n1540# vdda1 1.62fF **FLOATING
C14209 divbuf_2/a_44190_n1540# vdda1 1.62fF **FLOATING
C14210 divbuf_2/a_43710_n1540# vdda1 1.62fF **FLOATING
C14211 divbuf_2/a_43230_n1540# vdda1 1.62fF **FLOATING
C14212 divbuf_2/a_42750_n1540# vdda1 1.62fF **FLOATING
C14213 divbuf_2/a_42270_n1540# vdda1 1.62fF **FLOATING
C14214 divbuf_2/a_41790_n1540# vdda1 1.62fF **FLOATING
C14215 divbuf_2/a_41310_n1540# vdda1 1.62fF **FLOATING
C14216 divbuf_2/a_40830_n1540# vdda1 1.62fF **FLOATING
C14217 divbuf_2/a_40350_n1540# vdda1 1.62fF **FLOATING
C14218 divbuf_2/a_39870_n1540# vdda1 1.62fF **FLOATING
C14219 divbuf_2/a_39390_n1540# vdda1 1.62fF **FLOATING
C14220 divbuf_2/a_38910_n1540# vdda1 1.62fF **FLOATING
C14221 divbuf_2/a_38430_n1540# vdda1 1.62fF **FLOATING
C14222 divbuf_2/a_37950_n1540# vdda1 1.62fF **FLOATING
C14223 divbuf_2/a_37470_n1540# vdda1 1.62fF **FLOATING
C14224 divbuf_2/a_36990_n1540# vdda1 1.62fF **FLOATING
C14225 divbuf_2/a_36510_n1540# vdda1 1.62fF **FLOATING
C14226 divbuf_2/a_36030_n1540# vdda1 1.62fF **FLOATING
C14227 divbuf_2/a_35550_n1540# vdda1 1.62fF **FLOATING
C14228 divbuf_2/a_35070_n1540# vdda1 1.62fF **FLOATING
C14229 divbuf_2/a_34590_n1540# vdda1 1.62fF **FLOATING
C14230 divbuf_2/a_34110_n1540# vdda1 1.62fF **FLOATING
C14231 divbuf_2/a_33630_n1540# vdda1 1.62fF **FLOATING
C14232 divbuf_2/a_33150_n1540# vdda1 1.62fF **FLOATING
C14233 divbuf_2/a_32670_n1540# vdda1 1.62fF **FLOATING
C14234 divbuf_2/a_32190_n1540# vdda1 1.62fF **FLOATING
C14235 divbuf_2/a_31710_n1540# vdda1 1.62fF **FLOATING
C14236 divbuf_2/a_31230_n1540# vdda1 1.62fF **FLOATING
C14237 divbuf_2/a_30750_n1540# vdda1 1.62fF **FLOATING
C14238 divbuf_2/a_30270_n1540# vdda1 1.62fF **FLOATING
C14239 divbuf_2/a_29790_n1540# vdda1 1.62fF **FLOATING
C14240 divbuf_2/a_29310_n1540# vdda1 1.62fF **FLOATING
C14241 divbuf_2/a_28830_n1540# vdda1 1.62fF **FLOATING
C14242 divbuf_2/a_28350_n1540# vdda1 1.62fF **FLOATING
C14243 divbuf_2/a_27870_n1540# vdda1 1.62fF **FLOATING
C14244 divbuf_2/a_27390_n1540# vdda1 1.62fF **FLOATING
C14245 divbuf_2/a_26910_n1540# vdda1 1.62fF **FLOATING
C14246 divbuf_2/a_26430_n1540# vdda1 1.62fF **FLOATING
C14247 divbuf_2/a_25950_n1540# vdda1 1.62fF **FLOATING
C14248 divbuf_2/a_25470_n1540# vdda1 1.62fF **FLOATING
C14249 divbuf_2/a_24990_n1540# vdda1 1.62fF **FLOATING
C14250 divbuf_2/a_24510_n1540# vdda1 1.62fF **FLOATING
C14251 divbuf_2/a_24030_n1540# vdda1 1.62fF **FLOATING
C14252 divbuf_2/a_23550_n1540# vdda1 1.62fF **FLOATING
C14253 divbuf_2/a_23070_n1540# vdda1 1.62fF **FLOATING
C14254 divbuf_2/a_22590_n1540# vdda1 1.62fF **FLOATING
C14255 divbuf_2/a_22110_n1540# vdda1 1.62fF **FLOATING
C14256 divbuf_2/a_21630_n1540# vdda1 1.62fF **FLOATING
C14257 divbuf_2/a_21150_n1540# vdda1 1.62fF **FLOATING
C14258 divbuf_2/a_20670_n1540# vdda1 1.62fF **FLOATING
C14259 divbuf_2/a_20190_n1540# vdda1 1.62fF **FLOATING
C14260 divbuf_2/a_19710_n1540# vdda1 1.62fF **FLOATING
C14261 divbuf_2/a_19230_n1540# vdda1 1.62fF **FLOATING
C14262 divbuf_2/a_18750_n1540# vdda1 1.62fF **FLOATING
C14263 divbuf_2/a_18270_n1540# vdda1 1.62fF **FLOATING
C14264 divbuf_2/a_17790_n1540# vdda1 1.62fF **FLOATING
C14265 divbuf_2/a_17310_n1540# vdda1 1.62fF **FLOATING
C14266 divbuf_2/a_16830_n1540# vdda1 1.62fF **FLOATING
C14267 divbuf_2/a_16350_n1540# vdda1 1.62fF **FLOATING
C14268 divbuf_2/a_15870_n1540# vdda1 1.62fF **FLOATING
C14269 divbuf_2/a_15390_n1540# vdda1 1.62fF **FLOATING
C14270 divbuf_2/a_14910_n1540# vdda1 1.62fF **FLOATING
C14271 divbuf_2/a_14430_n1540# vdda1 1.62fF **FLOATING
C14272 divbuf_2/a_13950_n1540# vdda1 1.62fF **FLOATING
C14273 divbuf_2/a_13470_n1540# vdda1 1.62fF **FLOATING
C14274 divbuf_2/a_12990_n1540# vdda1 1.62fF **FLOATING
C14275 divbuf_2/a_12510_n1540# vdda1 1.62fF **FLOATING
C14276 divbuf_2/a_12030_n1540# vdda1 1.62fF **FLOATING
C14277 divbuf_2/a_11550_n1540# vdda1 1.62fF **FLOATING
C14278 divbuf_2/a_11070_n1540# vdda1 1.62fF **FLOATING
C14279 divbuf_2/a_10590_n1540# vdda1 1.62fF **FLOATING
C14280 divbuf_2/a_10110_n1540# vdda1 1.62fF **FLOATING
C14281 divbuf_2/a_9630_n1540# vdda1 1.62fF **FLOATING
C14282 divbuf_2/a_9150_n1540# vdda1 1.62fF **FLOATING
C14283 divbuf_2/a_8670_n1540# vdda1 1.62fF **FLOATING
C14284 divbuf_2/a_8190_n1540# vdda1 1.62fF **FLOATING
C14285 divbuf_2/a_7710_n1540# vdda1 1.62fF **FLOATING
C14286 divbuf_2/a_7230_n1540# vdda1 1.62fF **FLOATING
C14287 divbuf_2/a_6750_n1540# vdda1 1.62fF **FLOATING
C14288 divbuf_2/a_6270_n1540# vdda1 1.62fF **FLOATING
C14289 divbuf_2/a_5790_n1540# vdda1 1.62fF **FLOATING
C14290 divbuf_2/a_5310_n1540# vdda1 1.62fF **FLOATING
C14291 divbuf_2/a_4830_n1540# vdda1 1.62fF **FLOATING
C14292 divbuf_2/a_4350_n1540# vdda1 1.62fF **FLOATING
C14293 divbuf_2/a_3870_n1540# vdda1 1.62fF **FLOATING
C14294 divbuf_2/a_3390_n1540# vdda1 1.62fF **FLOATING
C14295 divbuf_2/a_2910_n1540# vdda1 1.62fF **FLOATING
C14296 divbuf_2/a_2430_n1540# vdda1 1.62fF **FLOATING
C14297 divbuf_2/a_1950_n1540# vdda1 1.62fF **FLOATING
C14298 divbuf_2/a_1470_n1540# vdda1 1.62fF **FLOATING
C14299 divbuf_2/a_990_n1540# vdda1 1.62fF **FLOATING
C14300 divbuf_2/a_510_n1540# vdda1 1.62fF **FLOATING
C14301 divbuf_2/a_60990_n840# vdda1 1.06fF **FLOATING
C14302 divbuf_2/a_60510_n840# vdda1 1.09fF **FLOATING
C14303 divbuf_2/a_60030_n840# vdda1 1.09fF **FLOATING
C14304 divbuf_2/a_59550_n840# vdda1 1.09fF **FLOATING
C14305 divbuf_2/a_59070_n840# vdda1 1.09fF **FLOATING
C14306 divbuf_2/a_58590_n840# vdda1 1.09fF **FLOATING
C14307 divbuf_2/a_58110_n840# vdda1 1.09fF **FLOATING
C14308 divbuf_2/a_57630_n840# vdda1 1.09fF **FLOATING
C14309 divbuf_2/a_57150_n840# vdda1 1.09fF **FLOATING
C14310 divbuf_2/a_56670_n840# vdda1 1.09fF **FLOATING
C14311 divbuf_2/a_56190_n840# vdda1 1.09fF **FLOATING
C14312 divbuf_2/a_55710_n840# vdda1 1.09fF **FLOATING
C14313 divbuf_2/a_55230_n840# vdda1 1.09fF **FLOATING
C14314 divbuf_2/a_54750_n840# vdda1 1.09fF **FLOATING
C14315 divbuf_2/a_54270_n840# vdda1 1.09fF **FLOATING
C14316 divbuf_2/a_53790_n840# vdda1 1.09fF **FLOATING
C14317 divbuf_2/a_53310_n840# vdda1 1.09fF **FLOATING
C14318 divbuf_2/a_52830_n840# vdda1 1.09fF **FLOATING
C14319 divbuf_2/a_52350_n840# vdda1 1.09fF **FLOATING
C14320 divbuf_2/a_51870_n840# vdda1 1.09fF **FLOATING
C14321 divbuf_2/a_51390_n840# vdda1 1.09fF **FLOATING
C14322 divbuf_2/a_50910_n840# vdda1 1.09fF **FLOATING
C14323 divbuf_2/a_50430_n840# vdda1 1.09fF **FLOATING
C14324 divbuf_2/a_49950_n840# vdda1 1.09fF **FLOATING
C14325 divbuf_2/a_49470_n840# vdda1 1.09fF **FLOATING
C14326 divbuf_2/a_48990_n840# vdda1 1.09fF **FLOATING
C14327 divbuf_2/a_48510_n840# vdda1 1.09fF **FLOATING
C14328 divbuf_2/a_48030_n840# vdda1 1.09fF **FLOATING
C14329 divbuf_2/a_47550_n840# vdda1 1.09fF **FLOATING
C14330 divbuf_2/a_47070_n840# vdda1 1.09fF **FLOATING
C14331 divbuf_2/a_46590_n840# vdda1 1.09fF **FLOATING
C14332 divbuf_2/a_46110_n840# vdda1 1.09fF **FLOATING
C14333 divbuf_2/a_45630_n840# vdda1 1.09fF **FLOATING
C14334 divbuf_2/a_45150_n840# vdda1 1.09fF **FLOATING
C14335 divbuf_2/a_44670_n840# vdda1 1.09fF **FLOATING
C14336 divbuf_2/a_44190_n840# vdda1 1.09fF **FLOATING
C14337 divbuf_2/a_43710_n840# vdda1 1.09fF **FLOATING
C14338 divbuf_2/a_43230_n840# vdda1 1.09fF **FLOATING
C14339 divbuf_2/a_42750_n840# vdda1 1.08fF **FLOATING
C14340 divbuf_2/a_42270_n840# vdda1 1.08fF **FLOATING
C14341 divbuf_2/a_41790_n840# vdda1 1.10fF **FLOATING
C14342 divbuf_2/a_41310_n840# vdda1 1.09fF **FLOATING
C14343 divbuf_2/a_40830_n840# vdda1 1.09fF **FLOATING
C14344 divbuf_2/a_40350_n840# vdda1 1.09fF **FLOATING
C14345 divbuf_2/a_39870_n840# vdda1 1.09fF **FLOATING
C14346 divbuf_2/a_39390_n840# vdda1 1.09fF **FLOATING
C14347 divbuf_2/a_38910_n840# vdda1 1.09fF **FLOATING
C14348 divbuf_2/a_38430_n840# vdda1 1.09fF **FLOATING
C14349 divbuf_2/a_37950_n840# vdda1 1.09fF **FLOATING
C14350 divbuf_2/a_37470_n840# vdda1 1.09fF **FLOATING
C14351 divbuf_2/a_36990_n840# vdda1 1.09fF **FLOATING
C14352 divbuf_2/a_36510_n840# vdda1 1.09fF **FLOATING
C14353 divbuf_2/a_36030_n840# vdda1 1.09fF **FLOATING
C14354 divbuf_2/a_35550_n840# vdda1 1.09fF **FLOATING
C14355 divbuf_2/a_35070_n840# vdda1 1.09fF **FLOATING
C14356 divbuf_2/a_34590_n840# vdda1 1.09fF **FLOATING
C14357 divbuf_2/a_34110_n840# vdda1 1.09fF **FLOATING
C14358 divbuf_2/a_33630_n840# vdda1 1.09fF **FLOATING
C14359 divbuf_2/a_33150_n840# vdda1 1.09fF **FLOATING
C14360 divbuf_2/a_32670_n840# vdda1 1.09fF **FLOATING
C14361 divbuf_2/a_32190_n840# vdda1 1.09fF **FLOATING
C14362 divbuf_2/a_31710_n840# vdda1 1.11fF **FLOATING
C14363 divbuf_2/a_31230_n840# vdda1 1.13fF **FLOATING
C14364 divbuf_2/a_30750_n840# vdda1 1.09fF **FLOATING
C14365 divbuf_2/a_30270_n840# vdda1 1.09fF **FLOATING
C14366 divbuf_2/a_29790_n840# vdda1 1.09fF **FLOATING
C14367 divbuf_2/a_29310_n840# vdda1 1.09fF **FLOATING
C14368 divbuf_2/a_28830_n840# vdda1 1.09fF **FLOATING
C14369 divbuf_2/a_28350_n840# vdda1 1.09fF **FLOATING
C14370 divbuf_2/a_27870_n840# vdda1 1.08fF **FLOATING
C14371 divbuf_2/a_27390_n840# vdda1 1.11fF **FLOATING
C14372 divbuf_2/a_26910_n840# vdda1 1.10fF **FLOATING
C14373 divbuf_2/a_26430_n840# vdda1 1.10fF **FLOATING
C14374 divbuf_2/a_25950_n840# vdda1 1.10fF **FLOATING
C14375 divbuf_2/a_25470_n840# vdda1 1.10fF **FLOATING
C14376 divbuf_2/a_24990_n840# vdda1 1.10fF **FLOATING
C14377 divbuf_2/a_24510_n840# vdda1 1.10fF **FLOATING
C14378 divbuf_2/a_24030_n840# vdda1 1.09fF **FLOATING
C14379 divbuf_2/a_23550_n840# vdda1 1.11fF **FLOATING
C14380 divbuf_2/a_23070_n840# vdda1 1.10fF **FLOATING
C14381 divbuf_2/a_22590_n840# vdda1 1.10fF **FLOATING
C14382 divbuf_2/a_22110_n840# vdda1 1.10fF **FLOATING
C14383 divbuf_2/a_21630_n840# vdda1 1.10fF **FLOATING
C14384 divbuf_2/a_21150_n840# vdda1 1.10fF **FLOATING
C14385 divbuf_2/a_20670_n840# vdda1 1.10fF **FLOATING
C14386 divbuf_2/a_20190_n840# vdda1 1.09fF **FLOATING
C14387 divbuf_2/a_19710_n840# vdda1 1.09fF **FLOATING
C14388 divbuf_2/a_19230_n840# vdda1 1.09fF **FLOATING
C14389 divbuf_2/a_18750_n840# vdda1 1.09fF **FLOATING
C14390 divbuf_2/a_18270_n840# vdda1 1.08fF **FLOATING
C14391 divbuf_2/a_17790_n840# vdda1 1.08fF **FLOATING
C14392 divbuf_2/a_17310_n840# vdda1 1.07fF **FLOATING
C14393 divbuf_2/a_16830_n840# vdda1 1.07fF **FLOATING
C14394 divbuf_2/a_16350_n840# vdda1 1.07fF **FLOATING
C14395 divbuf_2/a_15870_n840# vdda1 1.07fF **FLOATING
C14396 divbuf_2/a_15390_n840# vdda1 1.08fF **FLOATING
C14397 divbuf_2/a_14910_n840# vdda1 1.07fF **FLOATING
C14398 divbuf_2/a_14430_n840# vdda1 1.07fF **FLOATING
C14399 divbuf_2/a_13950_n840# vdda1 1.07fF **FLOATING
C14400 divbuf_2/a_13470_n840# vdda1 1.07fF **FLOATING
C14401 divbuf_2/a_12990_n840# vdda1 1.10fF **FLOATING
C14402 divbuf_2/a_12510_n840# vdda1 1.08fF **FLOATING
C14403 divbuf_2/a_12030_n840# vdda1 1.07fF **FLOATING
C14404 divbuf_2/a_11550_n840# vdda1 1.07fF **FLOATING
C14405 divbuf_2/a_11070_n840# vdda1 1.08fF **FLOATING
C14406 divbuf_2/a_10590_n840# vdda1 1.10fF **FLOATING
C14407 divbuf_2/a_10110_n840# vdda1 1.10fF **FLOATING
C14408 divbuf_2/a_9630_n840# vdda1 1.10fF **FLOATING
C14409 divbuf_2/a_9150_n840# vdda1 1.10fF **FLOATING
C14410 divbuf_2/a_8670_n840# vdda1 1.10fF **FLOATING
C14411 divbuf_2/a_8190_n840# vdda1 1.12fF **FLOATING
C14412 divbuf_2/a_7710_n840# vdda1 1.10fF **FLOATING
C14413 divbuf_2/a_7230_n840# vdda1 1.09fF **FLOATING
C14414 divbuf_2/a_6750_n840# vdda1 1.09fF **FLOATING
C14415 divbuf_2/a_6270_n840# vdda1 1.09fF **FLOATING
C14416 divbuf_2/a_5790_n840# vdda1 1.09fF **FLOATING
C14417 divbuf_2/a_5310_n840# vdda1 1.09fF **FLOATING
C14418 divbuf_2/a_4830_n840# vdda1 1.09fF **FLOATING
C14419 divbuf_2/a_4350_n840# vdda1 1.09fF **FLOATING
C14420 divbuf_2/a_3870_n840# vdda1 1.09fF **FLOATING
C14421 divbuf_2/a_3390_n840# vdda1 1.09fF **FLOATING
C14422 divbuf_2/a_2910_n840# vdda1 1.10fF **FLOATING
C14423 divbuf_2/a_2430_n840# vdda1 1.10fF **FLOATING
C14424 divbuf_2/a_1950_n840# vdda1 1.10fF **FLOATING
C14425 divbuf_2/a_1470_n840# vdda1 1.10fF **FLOATING
C14426 divbuf_2/a_990_n840# vdda1 1.08fF **FLOATING
C14427 divbuf_2/a_510_n840# vdda1 1.07fF **FLOATING
C14428 divbuf_2/a_60480_n1600# vdda1 1.48fF **FLOATING
C14429 divbuf_2/a_60000_n1600# vdda1 1.48fF **FLOATING
C14430 divbuf_2/a_59520_n1600# vdda1 1.48fF **FLOATING
C14431 divbuf_2/a_59040_n1600# vdda1 1.48fF **FLOATING
C14432 divbuf_2/a_58560_n1600# vdda1 1.48fF **FLOATING
C14433 divbuf_2/a_58080_n1600# vdda1 1.48fF **FLOATING
C14434 divbuf_2/a_57600_n1600# vdda1 1.48fF **FLOATING
C14435 divbuf_2/a_57120_n1600# vdda1 1.48fF **FLOATING
C14436 divbuf_2/a_56640_n1600# vdda1 1.48fF **FLOATING
C14437 divbuf_2/a_56160_n1600# vdda1 1.48fF **FLOATING
C14438 divbuf_2/a_55680_n1600# vdda1 1.48fF **FLOATING
C14439 divbuf_2/a_55200_n1600# vdda1 1.48fF **FLOATING
C14440 divbuf_2/a_54720_n1600# vdda1 1.48fF **FLOATING
C14441 divbuf_2/a_54240_n1600# vdda1 1.48fF **FLOATING
C14442 divbuf_2/a_53760_n1600# vdda1 1.48fF **FLOATING
C14443 divbuf_2/a_53280_n1600# vdda1 1.48fF **FLOATING
C14444 divbuf_2/a_52800_n1600# vdda1 1.48fF **FLOATING
C14445 divbuf_2/a_52320_n1600# vdda1 1.48fF **FLOATING
C14446 divbuf_2/a_51840_n1600# vdda1 1.48fF **FLOATING
C14447 divbuf_2/a_51360_n1600# vdda1 1.48fF **FLOATING
C14448 divbuf_2/a_50880_n1600# vdda1 1.48fF **FLOATING
C14449 divbuf_2/a_50400_n1600# vdda1 1.48fF **FLOATING
C14450 divbuf_2/a_49920_n1600# vdda1 1.48fF **FLOATING
C14451 divbuf_2/a_49440_n1600# vdda1 1.48fF **FLOATING
C14452 divbuf_2/a_48960_n1600# vdda1 1.48fF **FLOATING
C14453 divbuf_2/a_48480_n1600# vdda1 1.48fF **FLOATING
C14454 divbuf_2/a_48000_n1600# vdda1 1.48fF **FLOATING
C14455 divbuf_2/a_47520_n1600# vdda1 1.48fF **FLOATING
C14456 divbuf_2/a_47040_n1600# vdda1 1.48fF **FLOATING
C14457 divbuf_2/a_46560_n1600# vdda1 1.48fF **FLOATING
C14458 divbuf_2/a_46080_n1600# vdda1 1.48fF **FLOATING
C14459 divbuf_2/a_45600_n1600# vdda1 1.48fF **FLOATING
C14460 divbuf_2/a_45120_n1600# vdda1 1.48fF **FLOATING
C14461 divbuf_2/a_44640_n1600# vdda1 1.48fF **FLOATING
C14462 divbuf_2/a_44160_n1600# vdda1 1.48fF **FLOATING
C14463 divbuf_2/a_43680_n1600# vdda1 1.48fF **FLOATING
C14464 divbuf_2/a_43200_n1600# vdda1 1.48fF **FLOATING
C14465 divbuf_2/a_42720_n1600# vdda1 1.48fF **FLOATING
C14466 divbuf_2/a_42240_n1600# vdda1 1.48fF **FLOATING
C14467 divbuf_2/a_41760_n1600# vdda1 1.48fF **FLOATING
C14468 divbuf_2/a_41280_n1600# vdda1 1.48fF **FLOATING
C14469 divbuf_2/a_40800_n1600# vdda1 1.48fF **FLOATING
C14470 divbuf_2/a_40320_n1600# vdda1 1.48fF **FLOATING
C14471 divbuf_2/a_39840_n1600# vdda1 1.48fF **FLOATING
C14472 divbuf_2/a_39360_n1600# vdda1 1.48fF **FLOATING
C14473 divbuf_2/a_38880_n1600# vdda1 1.48fF **FLOATING
C14474 divbuf_2/a_38400_n1600# vdda1 1.48fF **FLOATING
C14475 divbuf_2/a_37920_n1600# vdda1 1.48fF **FLOATING
C14476 divbuf_2/a_37440_n1600# vdda1 1.48fF **FLOATING
C14477 divbuf_2/a_36960_n1600# vdda1 1.48fF **FLOATING
C14478 divbuf_2/a_36480_n1600# vdda1 1.48fF **FLOATING
C14479 divbuf_2/a_36000_n1600# vdda1 1.48fF **FLOATING
C14480 divbuf_2/a_35520_n1600# vdda1 1.48fF **FLOATING
C14481 divbuf_2/a_35040_n1600# vdda1 1.48fF **FLOATING
C14482 divbuf_2/a_34560_n1600# vdda1 1.48fF **FLOATING
C14483 divbuf_2/a_34080_n1600# vdda1 1.48fF **FLOATING
C14484 divbuf_2/a_33600_n1600# vdda1 1.48fF **FLOATING
C14485 divbuf_2/a_33120_n1600# vdda1 1.48fF **FLOATING
C14486 divbuf_2/a_32640_n1600# vdda1 1.48fF **FLOATING
C14487 divbuf_2/a_32160_n1600# vdda1 1.48fF **FLOATING
C14488 divbuf_2/a_31680_n1600# vdda1 1.48fF **FLOATING
C14489 divbuf_2/a_31200_n1600# vdda1 1.48fF **FLOATING
C14490 divbuf_2/a_30720_n1600# vdda1 1.48fF **FLOATING
C14491 divbuf_2/a_30240_n1600# vdda1 1.48fF **FLOATING
C14492 divbuf_2/a_29760_n1600# vdda1 1.48fF **FLOATING
C14493 divbuf_2/a_29280_n1600# vdda1 1.48fF **FLOATING
C14494 divbuf_2/a_28800_n1600# vdda1 1.48fF **FLOATING
C14495 divbuf_2/a_28320_n1600# vdda1 1.48fF **FLOATING
C14496 divbuf_2/a_27840_n1600# vdda1 1.48fF **FLOATING
C14497 divbuf_2/a_27360_n1600# vdda1 1.48fF **FLOATING
C14498 divbuf_2/a_26880_n1600# vdda1 1.48fF **FLOATING
C14499 divbuf_2/a_26400_n1600# vdda1 1.48fF **FLOATING
C14500 divbuf_2/a_25920_n1600# vdda1 1.48fF **FLOATING
C14501 divbuf_2/a_25440_n1600# vdda1 1.48fF **FLOATING
C14502 divbuf_2/a_24960_n1600# vdda1 1.48fF **FLOATING
C14503 divbuf_2/a_24480_n1600# vdda1 1.48fF **FLOATING
C14504 divbuf_2/a_24000_n1600# vdda1 1.48fF **FLOATING
C14505 divbuf_2/a_23520_n1600# vdda1 1.48fF **FLOATING
C14506 divbuf_2/a_23040_n1600# vdda1 1.48fF **FLOATING
C14507 divbuf_2/a_22560_n1600# vdda1 1.48fF **FLOATING
C14508 divbuf_2/a_22080_n1600# vdda1 1.48fF **FLOATING
C14509 divbuf_2/a_21600_n1600# vdda1 1.48fF **FLOATING
C14510 divbuf_2/a_21120_n1600# vdda1 1.48fF **FLOATING
C14511 divbuf_2/a_20640_n1600# vdda1 1.48fF **FLOATING
C14512 divbuf_2/a_20160_n1600# vdda1 1.48fF **FLOATING
C14513 divbuf_2/a_19680_n1600# vdda1 1.48fF **FLOATING
C14514 divbuf_2/a_19200_n1600# vdda1 1.48fF **FLOATING
C14515 divbuf_2/a_18720_n1600# vdda1 1.48fF **FLOATING
C14516 divbuf_2/a_18240_n1600# vdda1 1.48fF **FLOATING
C14517 divbuf_2/a_17760_n1600# vdda1 1.48fF **FLOATING
C14518 divbuf_2/a_17280_n1600# vdda1 1.48fF **FLOATING
C14519 divbuf_2/a_16800_n1600# vdda1 1.48fF **FLOATING
C14520 divbuf_2/a_16320_n1600# vdda1 1.48fF **FLOATING
C14521 divbuf_2/a_15840_n1600# vdda1 1.48fF **FLOATING
C14522 divbuf_2/a_15360_n1600# vdda1 1.48fF **FLOATING
C14523 divbuf_2/a_14880_n1600# vdda1 1.48fF **FLOATING
C14524 divbuf_2/a_14400_n1600# vdda1 1.48fF **FLOATING
C14525 divbuf_2/a_13920_n1600# vdda1 1.48fF **FLOATING
C14526 divbuf_2/a_13440_n1600# vdda1 1.48fF **FLOATING
C14527 divbuf_2/a_12960_n1600# vdda1 1.48fF **FLOATING
C14528 divbuf_2/a_12480_n1600# vdda1 1.48fF **FLOATING
C14529 divbuf_2/a_12000_n1600# vdda1 1.48fF **FLOATING
C14530 divbuf_2/a_11520_n1600# vdda1 1.48fF **FLOATING
C14531 divbuf_2/a_11040_n1600# vdda1 1.48fF **FLOATING
C14532 divbuf_2/a_10560_n1600# vdda1 1.48fF **FLOATING
C14533 divbuf_2/a_10080_n1600# vdda1 1.48fF **FLOATING
C14534 divbuf_2/a_9600_n1600# vdda1 1.48fF **FLOATING
C14535 divbuf_2/a_9120_n1600# vdda1 1.48fF **FLOATING
C14536 divbuf_2/a_8640_n1600# vdda1 1.48fF **FLOATING
C14537 divbuf_2/a_8160_n1600# vdda1 1.48fF **FLOATING
C14538 divbuf_2/a_7680_n1600# vdda1 1.48fF **FLOATING
C14539 divbuf_2/a_7200_n1600# vdda1 1.48fF **FLOATING
C14540 divbuf_2/a_6720_n1600# vdda1 1.48fF **FLOATING
C14541 divbuf_2/a_6240_n1600# vdda1 1.48fF **FLOATING
C14542 divbuf_2/a_5760_n1600# vdda1 1.48fF **FLOATING
C14543 divbuf_2/a_5280_n1600# vdda1 1.48fF **FLOATING
C14544 divbuf_2/a_4800_n1600# vdda1 1.48fF **FLOATING
C14545 divbuf_2/a_4320_n1600# vdda1 1.48fF **FLOATING
C14546 divbuf_2/a_3840_n1600# vdda1 1.48fF **FLOATING
C14547 divbuf_2/a_3360_n1600# vdda1 1.48fF **FLOATING
C14548 divbuf_2/a_2880_n1600# vdda1 1.48fF **FLOATING
C14549 divbuf_2/a_2400_n1600# vdda1 1.48fF **FLOATING
C14550 divbuf_2/a_1920_n1600# vdda1 1.48fF **FLOATING
C14551 divbuf_2/a_1440_n1600# vdda1 1.48fF **FLOATING
C14552 divbuf_2/a_960_n1600# vdda1 1.48fF **FLOATING
C14553 divbuf_2/a_480_n1600# vdda1 1.48fF **FLOATING
C14554 divbuf_2/a_0_n1600# vdda1 1.48fF **FLOATING
C14555 divbuf_2/a_41382_n240# vdda1 0.90fF **FLOATING
C14556 divbuf_2/a_40902_n240# vdda1 0.90fF **FLOATING
C14557 divbuf_2/a_40412_n240# vdda1 0.90fF **FLOATING
C14558 divbuf_2/a_39932_n240# vdda1 0.90fF **FLOATING
C14559 divbuf_2/a_39442_n240# vdda1 0.90fF **FLOATING
C14560 divbuf_2/a_38962_n240# vdda1 0.91fF **FLOATING
C14561 divbuf_2/a_38472_n240# vdda1 0.90fF **FLOATING
C14562 divbuf_2/a_37992_n240# vdda1 0.90fF **FLOATING
C14563 divbuf_2/a_37502_n240# vdda1 0.90fF **FLOATING
C14564 divbuf_2/a_37022_n240# vdda1 0.90fF **FLOATING
C14565 divbuf_2/a_36532_n240# vdda1 0.90fF **FLOATING
C14566 divbuf_2/a_36052_n240# vdda1 0.90fF **FLOATING
C14567 divbuf_2/a_35562_n240# vdda1 0.90fF **FLOATING
C14568 divbuf_2/a_35082_n240# vdda1 0.91fF **FLOATING
C14569 divbuf_2/a_34592_n240# vdda1 0.90fF **FLOATING
C14570 divbuf_2/a_34112_n240# vdda1 0.90fF **FLOATING
C14571 divbuf_2/a_33622_n240# vdda1 0.90fF **FLOATING
C14572 divbuf_2/a_33142_n240# vdda1 0.90fF **FLOATING
C14573 divbuf_2/a_32652_n240# vdda1 0.90fF **FLOATING
C14574 divbuf_2/a_32172_n240# vdda1 0.90fF **FLOATING
C14575 divbuf_2/a_31682_n240# vdda1 0.89fF **FLOATING
C14576 divbuf_2/a_31202_n240# vdda1 0.92fF **FLOATING
C14577 divbuf_2/a_30712_n240# vdda1 0.90fF **FLOATING
C14578 divbuf_2/a_30232_n240# vdda1 0.90fF **FLOATING
C14579 divbuf_2/a_29742_n240# vdda1 0.90fF **FLOATING
C14580 divbuf_2/a_29262_n240# vdda1 0.90fF **FLOATING
C14581 divbuf_2/a_28772_n240# vdda1 0.90fF **FLOATING
C14582 divbuf_2/a_28292_n240# vdda1 0.90fF **FLOATING
C14583 divbuf_2/a_27802_n240# vdda1 0.89fF **FLOATING
C14584 divbuf_2/a_27322_n240# vdda1 0.95fF **FLOATING
C14585 divbuf_2/a_26832_n240# vdda1 0.91fF **FLOATING
C14586 divbuf_2/a_26352_n240# vdda1 0.91fF **FLOATING
C14587 divbuf_2/a_25862_n240# vdda1 0.91fF **FLOATING
C14588 divbuf_2/a_25382_n240# vdda1 0.91fF **FLOATING
C14589 divbuf_2/a_24892_n240# vdda1 0.91fF **FLOATING
C14590 divbuf_2/a_24412_n240# vdda1 0.91fF **FLOATING
C14591 divbuf_2/a_23922_n240# vdda1 0.92fF **FLOATING
C14592 divbuf_2/a_23442_n240# vdda1 0.94fF **FLOATING
C14593 divbuf_2/a_22952_n240# vdda1 0.91fF **FLOATING
C14594 divbuf_2/a_22472_n240# vdda1 0.91fF **FLOATING
C14595 divbuf_2/a_21982_n240# vdda1 0.91fF **FLOATING
C14596 divbuf_2/a_21502_n240# vdda1 0.91fF **FLOATING
C14597 divbuf_2/a_21012_n240# vdda1 0.91fF **FLOATING
C14598 divbuf_2/a_20532_n240# vdda1 0.91fF **FLOATING
C14599 divbuf_2/a_20042_n240# vdda1 0.90fF **FLOATING
C14600 divbuf_2/a_19562_n240# vdda1 0.90fF **FLOATING
C14601 divbuf_2/a_19072_n240# vdda1 0.90fF **FLOATING
C14602 divbuf_2/a_18582_n240# vdda1 0.89fF **FLOATING
C14603 divbuf_2/a_18092_n240# vdda1 0.89fF **FLOATING
C14604 divbuf_2/a_17612_n240# vdda1 0.89fF **FLOATING
C14605 divbuf_2/a_17122_n240# vdda1 0.88fF **FLOATING
C14606 divbuf_2/a_16642_n240# vdda1 0.88fF **FLOATING
C14607 divbuf_2/a_16152_n240# vdda1 0.88fF **FLOATING
C14608 divbuf_2/a_15672_n240# vdda1 0.90fF **FLOATING
C14609 divbuf_2/a_15182_n240# vdda1 0.88fF **FLOATING
C14610 divbuf_2/a_14702_n240# vdda1 0.88fF **FLOATING
C14611 divbuf_2/a_14222_n240# vdda1 0.88fF **FLOATING
C14612 divbuf_2/a_13742_n240# vdda1 0.88fF **FLOATING
C14613 divbuf_2/a_13252_n240# vdda1 0.88fF **FLOATING
C14614 divbuf_2/a_12772_n240# vdda1 0.88fF **FLOATING
C14615 divbuf_2/a_12282_n240# vdda1 0.88fF **FLOATING
C14616 divbuf_2/a_11802_n240# vdda1 0.88fF **FLOATING
C14617 divbuf_2/a_11312_n240# vdda1 0.89fF **FLOATING
C14618 divbuf_2/a_10212_n240# vdda1 0.91fF **FLOATING
C14619 divbuf_2/a_9732_n240# vdda1 0.91fF **FLOATING
C14620 divbuf_2/a_9242_n240# vdda1 0.91fF **FLOATING
C14621 divbuf_2/a_8762_n240# vdda1 0.91fF **FLOATING
C14622 divbuf_2/a_8272_n240# vdda1 0.91fF **FLOATING
C14623 divbuf_2/a_7792_n240# vdda1 0.92fF **FLOATING
C14624 divbuf_2/a_7302_n240# vdda1 0.90fF **FLOATING
C14625 divbuf_2/a_6822_n240# vdda1 0.90fF **FLOATING
C14626 divbuf_2/a_6332_n240# vdda1 0.90fF **FLOATING
C14627 divbuf_2/a_5852_n240# vdda1 0.90fF **FLOATING
C14628 divbuf_2/a_5362_n240# vdda1 0.90fF **FLOATING
C14629 divbuf_2/a_4882_n240# vdda1 0.90fF **FLOATING
C14630 divbuf_2/a_4392_n240# vdda1 0.90fF **FLOATING
C14631 divbuf_2/a_3912_n240# vdda1 0.90fF **FLOATING
C14632 divbuf_2/a_3422_n240# vdda1 0.90fF **FLOATING
C14633 divbuf_2/a_2322_n240# vdda1 0.91fF **FLOATING
C14634 divbuf_2/a_1842_n240# vdda1 0.91fF **FLOATING
C14635 divbuf_2/a_1352_n240# vdda1 0.91fF **FLOATING
C14636 divbuf_2/a_41382_170# vdda1 1.07fF **FLOATING
C14637 divbuf_2/a_40902_170# vdda1 1.09fF **FLOATING
C14638 divbuf_2/a_40412_170# vdda1 1.09fF **FLOATING
C14639 divbuf_2/a_39932_170# vdda1 1.09fF **FLOATING
C14640 divbuf_2/a_39442_170# vdda1 1.09fF **FLOATING
C14641 divbuf_2/a_38962_170# vdda1 1.07fF **FLOATING
C14642 divbuf_2/a_38472_170# vdda1 1.09fF **FLOATING
C14643 divbuf_2/a_37992_170# vdda1 1.09fF **FLOATING
C14644 divbuf_2/a_37502_170# vdda1 1.09fF **FLOATING
C14645 divbuf_2/a_37022_170# vdda1 1.09fF **FLOATING
C14646 divbuf_2/a_36532_170# vdda1 1.09fF **FLOATING
C14647 divbuf_2/a_36052_170# vdda1 1.09fF **FLOATING
C14648 divbuf_2/a_35562_170# vdda1 1.09fF **FLOATING
C14649 divbuf_2/a_35082_170# vdda1 1.09fF **FLOATING
C14650 divbuf_2/a_34592_170# vdda1 1.07fF **FLOATING
C14651 divbuf_2/a_34112_170# vdda1 1.09fF **FLOATING
C14652 divbuf_2/a_33622_170# vdda1 1.09fF **FLOATING
C14653 divbuf_2/a_33142_170# vdda1 1.09fF **FLOATING
C14654 divbuf_2/a_32652_170# vdda1 1.09fF **FLOATING
C14655 divbuf_2/a_32172_170# vdda1 1.09fF **FLOATING
C14656 divbuf_2/a_31682_170# vdda1 1.09fF **FLOATING
C14657 divbuf_2/a_31202_170# vdda1 1.09fF **FLOATING
C14658 divbuf_2/a_30712_170# vdda1 1.09fF **FLOATING
C14659 divbuf_2/a_30232_170# vdda1 1.07fF **FLOATING
C14660 divbuf_2/a_29742_170# vdda1 1.09fF **FLOATING
C14661 divbuf_2/a_29262_170# vdda1 1.09fF **FLOATING
C14662 divbuf_2/a_28772_170# vdda1 1.09fF **FLOATING
C14663 divbuf_2/a_28292_170# vdda1 1.09fF **FLOATING
C14664 divbuf_2/a_27802_170# vdda1 1.09fF **FLOATING
C14665 divbuf_2/a_27322_170# vdda1 1.09fF **FLOATING
C14666 divbuf_2/a_26832_170# vdda1 1.09fF **FLOATING
C14667 divbuf_2/a_26352_170# vdda1 1.09fF **FLOATING
C14668 divbuf_2/a_25862_170# vdda1 1.07fF **FLOATING
C14669 divbuf_2/a_25382_170# vdda1 1.09fF **FLOATING
C14670 divbuf_2/a_24892_170# vdda1 1.09fF **FLOATING
C14671 divbuf_2/a_24412_170# vdda1 1.09fF **FLOATING
C14672 divbuf_2/a_23922_170# vdda1 1.09fF **FLOATING
C14673 divbuf_2/a_23442_170# vdda1 1.09fF **FLOATING
C14674 divbuf_2/a_22952_170# vdda1 1.09fF **FLOATING
C14675 divbuf_2/a_22472_170# vdda1 1.07fF **FLOATING
C14676 divbuf_2/a_21982_170# vdda1 1.09fF **FLOATING
C14677 divbuf_2/a_21502_170# vdda1 1.09fF **FLOATING
C14678 divbuf_2/a_21012_170# vdda1 1.09fF **FLOATING
C14679 divbuf_2/a_20532_170# vdda1 1.09fF **FLOATING
C14680 divbuf_2/a_20042_170# vdda1 1.09fF **FLOATING
C14681 divbuf_2/a_19562_170# vdda1 1.09fF **FLOATING
C14682 divbuf_2/a_19072_170# vdda1 1.09fF **FLOATING
C14683 divbuf_2/a_18582_170# vdda1 1.07fF **FLOATING
C14684 divbuf_2/a_18092_170# vdda1 1.09fF **FLOATING
C14685 divbuf_2/a_17612_170# vdda1 1.09fF **FLOATING
C14686 divbuf_2/a_17122_170# vdda1 1.09fF **FLOATING
C14687 divbuf_2/a_16642_170# vdda1 1.09fF **FLOATING
C14688 divbuf_2/a_16152_170# vdda1 1.09fF **FLOATING
C14689 divbuf_2/a_15672_170# vdda1 1.09fF **FLOATING
C14690 divbuf_2/a_15182_170# vdda1 1.09fF **FLOATING
C14691 divbuf_2/a_14702_170# vdda1 1.10fF **FLOATING
C14692 divbuf_2/a_14222_170# vdda1 1.10fF **FLOATING
C14693 divbuf_2/a_13742_170# vdda1 1.09fF **FLOATING
C14694 divbuf_2/a_13252_170# vdda1 1.09fF **FLOATING
C14695 divbuf_2/a_12772_170# vdda1 1.07fF **FLOATING
C14696 divbuf_2/a_12282_170# vdda1 1.09fF **FLOATING
C14697 divbuf_2/a_11802_170# vdda1 1.09fF **FLOATING
C14698 divbuf_2/a_11312_170# vdda1 1.10fF **FLOATING
C14699 divbuf_2/a_10212_170# vdda1 1.09fF **FLOATING
C14700 divbuf_2/a_9732_170# vdda1 1.09fF **FLOATING
C14701 divbuf_2/a_9242_170# vdda1 1.09fF **FLOATING
C14702 divbuf_2/a_8762_170# vdda1 1.09fF **FLOATING
C14703 divbuf_2/a_8272_170# vdda1 1.07fF **FLOATING
C14704 divbuf_2/a_7792_170# vdda1 1.09fF **FLOATING
C14705 divbuf_2/a_7302_170# vdda1 1.09fF **FLOATING
C14706 divbuf_2/a_6822_170# vdda1 1.09fF **FLOATING
C14707 divbuf_2/a_6332_170# vdda1 1.09fF **FLOATING
C14708 divbuf_2/a_5852_170# vdda1 1.09fF **FLOATING
C14709 divbuf_2/a_5362_170# vdda1 1.09fF **FLOATING
C14710 divbuf_2/a_4882_170# vdda1 1.09fF **FLOATING
C14711 divbuf_2/a_4392_170# vdda1 1.07fF **FLOATING
C14712 divbuf_2/a_3912_170# vdda1 1.09fF **FLOATING
C14713 divbuf_2/a_3422_170# vdda1 1.10fF **FLOATING
C14714 divbuf_2/a_2322_170# vdda1 1.09fF **FLOATING
C14715 divbuf_2/a_1842_170# vdda1 1.09fF **FLOATING
C14716 divbuf_2/a_1352_170# vdda1 1.10fF **FLOATING
C14717 divbuf_2/a_492_n240# vdda1 2.46fF **FLOATING
C14718 divbuf_1/OUT vdda1 3.28fF
C14719 divbuf_1/OUT5 vdda1 16.40fF
C14720 divbuf_1/OUT4 vdda1 100.06fF
C14721 divbuf_1/OUT3 vdda1 27.01fF
C14722 divbuf_1/OUT2 vdda1 8.71fF
C14723 divbuf_1/IN vdda1 0.89fF
C14724 divbuf_1/a_60990_n1540# vdda1 1.57fF **FLOATING
C14725 divbuf_1/a_60510_n1540# vdda1 1.62fF **FLOATING
C14726 divbuf_1/a_60030_n1540# vdda1 1.62fF **FLOATING
C14727 divbuf_1/a_59550_n1540# vdda1 1.62fF **FLOATING
C14728 divbuf_1/a_59070_n1540# vdda1 1.62fF **FLOATING
C14729 divbuf_1/a_58590_n1540# vdda1 1.62fF **FLOATING
C14730 divbuf_1/a_58110_n1540# vdda1 1.62fF **FLOATING
C14731 divbuf_1/a_57630_n1540# vdda1 1.62fF **FLOATING
C14732 divbuf_1/a_57150_n1540# vdda1 1.62fF **FLOATING
C14733 divbuf_1/a_56670_n1540# vdda1 1.62fF **FLOATING
C14734 divbuf_1/a_56190_n1540# vdda1 1.62fF **FLOATING
C14735 divbuf_1/a_55710_n1540# vdda1 1.62fF **FLOATING
C14736 divbuf_1/a_55230_n1540# vdda1 1.62fF **FLOATING
C14737 divbuf_1/a_54750_n1540# vdda1 1.62fF **FLOATING
C14738 divbuf_1/a_54270_n1540# vdda1 1.62fF **FLOATING
C14739 divbuf_1/a_53790_n1540# vdda1 1.62fF **FLOATING
C14740 divbuf_1/a_53310_n1540# vdda1 1.62fF **FLOATING
C14741 divbuf_1/a_52830_n1540# vdda1 1.62fF **FLOATING
C14742 divbuf_1/a_52350_n1540# vdda1 1.62fF **FLOATING
C14743 divbuf_1/a_51870_n1540# vdda1 1.62fF **FLOATING
C14744 divbuf_1/a_51390_n1540# vdda1 1.62fF **FLOATING
C14745 divbuf_1/a_50910_n1540# vdda1 1.62fF **FLOATING
C14746 divbuf_1/a_50430_n1540# vdda1 1.62fF **FLOATING
C14747 divbuf_1/a_49950_n1540# vdda1 1.62fF **FLOATING
C14748 divbuf_1/a_49470_n1540# vdda1 1.62fF **FLOATING
C14749 divbuf_1/a_48990_n1540# vdda1 1.62fF **FLOATING
C14750 divbuf_1/a_48510_n1540# vdda1 1.62fF **FLOATING
C14751 divbuf_1/a_48030_n1540# vdda1 1.62fF **FLOATING
C14752 divbuf_1/a_47550_n1540# vdda1 1.62fF **FLOATING
C14753 divbuf_1/a_47070_n1540# vdda1 1.62fF **FLOATING
C14754 divbuf_1/a_46590_n1540# vdda1 1.62fF **FLOATING
C14755 divbuf_1/a_46110_n1540# vdda1 1.62fF **FLOATING
C14756 divbuf_1/a_45630_n1540# vdda1 1.62fF **FLOATING
C14757 divbuf_1/a_45150_n1540# vdda1 1.62fF **FLOATING
C14758 divbuf_1/a_44670_n1540# vdda1 1.62fF **FLOATING
C14759 divbuf_1/a_44190_n1540# vdda1 1.62fF **FLOATING
C14760 divbuf_1/a_43710_n1540# vdda1 1.62fF **FLOATING
C14761 divbuf_1/a_43230_n1540# vdda1 1.62fF **FLOATING
C14762 divbuf_1/a_42750_n1540# vdda1 1.62fF **FLOATING
C14763 divbuf_1/a_42270_n1540# vdda1 1.62fF **FLOATING
C14764 divbuf_1/a_41790_n1540# vdda1 1.62fF **FLOATING
C14765 divbuf_1/a_41310_n1540# vdda1 1.62fF **FLOATING
C14766 divbuf_1/a_40830_n1540# vdda1 1.62fF **FLOATING
C14767 divbuf_1/a_40350_n1540# vdda1 1.62fF **FLOATING
C14768 divbuf_1/a_39870_n1540# vdda1 1.62fF **FLOATING
C14769 divbuf_1/a_39390_n1540# vdda1 1.62fF **FLOATING
C14770 divbuf_1/a_38910_n1540# vdda1 1.62fF **FLOATING
C14771 divbuf_1/a_38430_n1540# vdda1 1.62fF **FLOATING
C14772 divbuf_1/a_37950_n1540# vdda1 1.62fF **FLOATING
C14773 divbuf_1/a_37470_n1540# vdda1 1.62fF **FLOATING
C14774 divbuf_1/a_36990_n1540# vdda1 1.62fF **FLOATING
C14775 divbuf_1/a_36510_n1540# vdda1 1.62fF **FLOATING
C14776 divbuf_1/a_36030_n1540# vdda1 1.62fF **FLOATING
C14777 divbuf_1/a_35550_n1540# vdda1 1.62fF **FLOATING
C14778 divbuf_1/a_35070_n1540# vdda1 1.62fF **FLOATING
C14779 divbuf_1/a_34590_n1540# vdda1 1.62fF **FLOATING
C14780 divbuf_1/a_34110_n1540# vdda1 1.62fF **FLOATING
C14781 divbuf_1/a_33630_n1540# vdda1 1.62fF **FLOATING
C14782 divbuf_1/a_33150_n1540# vdda1 1.62fF **FLOATING
C14783 divbuf_1/a_32670_n1540# vdda1 1.62fF **FLOATING
C14784 divbuf_1/a_32190_n1540# vdda1 1.62fF **FLOATING
C14785 divbuf_1/a_31710_n1540# vdda1 1.62fF **FLOATING
C14786 divbuf_1/a_31230_n1540# vdda1 1.62fF **FLOATING
C14787 divbuf_1/a_30750_n1540# vdda1 1.62fF **FLOATING
C14788 divbuf_1/a_30270_n1540# vdda1 1.62fF **FLOATING
C14789 divbuf_1/a_29790_n1540# vdda1 1.62fF **FLOATING
C14790 divbuf_1/a_29310_n1540# vdda1 1.62fF **FLOATING
C14791 divbuf_1/a_28830_n1540# vdda1 1.62fF **FLOATING
C14792 divbuf_1/a_28350_n1540# vdda1 1.62fF **FLOATING
C14793 divbuf_1/a_27870_n1540# vdda1 1.62fF **FLOATING
C14794 divbuf_1/a_27390_n1540# vdda1 1.62fF **FLOATING
C14795 divbuf_1/a_26910_n1540# vdda1 1.62fF **FLOATING
C14796 divbuf_1/a_26430_n1540# vdda1 1.62fF **FLOATING
C14797 divbuf_1/a_25950_n1540# vdda1 1.62fF **FLOATING
C14798 divbuf_1/a_25470_n1540# vdda1 1.62fF **FLOATING
C14799 divbuf_1/a_24990_n1540# vdda1 1.62fF **FLOATING
C14800 divbuf_1/a_24510_n1540# vdda1 1.62fF **FLOATING
C14801 divbuf_1/a_24030_n1540# vdda1 1.62fF **FLOATING
C14802 divbuf_1/a_23550_n1540# vdda1 1.62fF **FLOATING
C14803 divbuf_1/a_23070_n1540# vdda1 1.62fF **FLOATING
C14804 divbuf_1/a_22590_n1540# vdda1 1.62fF **FLOATING
C14805 divbuf_1/a_22110_n1540# vdda1 1.62fF **FLOATING
C14806 divbuf_1/a_21630_n1540# vdda1 1.62fF **FLOATING
C14807 divbuf_1/a_21150_n1540# vdda1 1.62fF **FLOATING
C14808 divbuf_1/a_20670_n1540# vdda1 1.62fF **FLOATING
C14809 divbuf_1/a_20190_n1540# vdda1 1.62fF **FLOATING
C14810 divbuf_1/a_19710_n1540# vdda1 1.62fF **FLOATING
C14811 divbuf_1/a_19230_n1540# vdda1 1.62fF **FLOATING
C14812 divbuf_1/a_18750_n1540# vdda1 1.62fF **FLOATING
C14813 divbuf_1/a_18270_n1540# vdda1 1.62fF **FLOATING
C14814 divbuf_1/a_17790_n1540# vdda1 1.62fF **FLOATING
C14815 divbuf_1/a_17310_n1540# vdda1 1.62fF **FLOATING
C14816 divbuf_1/a_16830_n1540# vdda1 1.62fF **FLOATING
C14817 divbuf_1/a_16350_n1540# vdda1 1.62fF **FLOATING
C14818 divbuf_1/a_15870_n1540# vdda1 1.62fF **FLOATING
C14819 divbuf_1/a_15390_n1540# vdda1 1.62fF **FLOATING
C14820 divbuf_1/a_14910_n1540# vdda1 1.62fF **FLOATING
C14821 divbuf_1/a_14430_n1540# vdda1 1.62fF **FLOATING
C14822 divbuf_1/a_13950_n1540# vdda1 1.62fF **FLOATING
C14823 divbuf_1/a_13470_n1540# vdda1 1.62fF **FLOATING
C14824 divbuf_1/a_12990_n1540# vdda1 1.62fF **FLOATING
C14825 divbuf_1/a_12510_n1540# vdda1 1.62fF **FLOATING
C14826 divbuf_1/a_12030_n1540# vdda1 1.62fF **FLOATING
C14827 divbuf_1/a_11550_n1540# vdda1 1.62fF **FLOATING
C14828 divbuf_1/a_11070_n1540# vdda1 1.62fF **FLOATING
C14829 divbuf_1/a_10590_n1540# vdda1 1.62fF **FLOATING
C14830 divbuf_1/a_10110_n1540# vdda1 1.62fF **FLOATING
C14831 divbuf_1/a_9630_n1540# vdda1 1.62fF **FLOATING
C14832 divbuf_1/a_9150_n1540# vdda1 1.62fF **FLOATING
C14833 divbuf_1/a_8670_n1540# vdda1 1.62fF **FLOATING
C14834 divbuf_1/a_8190_n1540# vdda1 1.62fF **FLOATING
C14835 divbuf_1/a_7710_n1540# vdda1 1.62fF **FLOATING
C14836 divbuf_1/a_7230_n1540# vdda1 1.62fF **FLOATING
C14837 divbuf_1/a_6750_n1540# vdda1 1.62fF **FLOATING
C14838 divbuf_1/a_6270_n1540# vdda1 1.62fF **FLOATING
C14839 divbuf_1/a_5790_n1540# vdda1 1.62fF **FLOATING
C14840 divbuf_1/a_5310_n1540# vdda1 1.62fF **FLOATING
C14841 divbuf_1/a_4830_n1540# vdda1 1.62fF **FLOATING
C14842 divbuf_1/a_4350_n1540# vdda1 1.62fF **FLOATING
C14843 divbuf_1/a_3870_n1540# vdda1 1.62fF **FLOATING
C14844 divbuf_1/a_3390_n1540# vdda1 1.62fF **FLOATING
C14845 divbuf_1/a_2910_n1540# vdda1 1.62fF **FLOATING
C14846 divbuf_1/a_2430_n1540# vdda1 1.62fF **FLOATING
C14847 divbuf_1/a_1950_n1540# vdda1 1.62fF **FLOATING
C14848 divbuf_1/a_1470_n1540# vdda1 1.62fF **FLOATING
C14849 divbuf_1/a_990_n1540# vdda1 1.62fF **FLOATING
C14850 divbuf_1/a_510_n1540# vdda1 1.62fF **FLOATING
C14851 divbuf_1/a_60990_n840# vdda1 1.06fF **FLOATING
C14852 divbuf_1/a_60510_n840# vdda1 1.09fF **FLOATING
C14853 divbuf_1/a_60030_n840# vdda1 1.09fF **FLOATING
C14854 divbuf_1/a_59550_n840# vdda1 1.09fF **FLOATING
C14855 divbuf_1/a_59070_n840# vdda1 1.09fF **FLOATING
C14856 divbuf_1/a_58590_n840# vdda1 1.09fF **FLOATING
C14857 divbuf_1/a_58110_n840# vdda1 1.09fF **FLOATING
C14858 divbuf_1/a_57630_n840# vdda1 1.09fF **FLOATING
C14859 divbuf_1/a_57150_n840# vdda1 1.09fF **FLOATING
C14860 divbuf_1/a_56670_n840# vdda1 1.09fF **FLOATING
C14861 divbuf_1/a_56190_n840# vdda1 1.09fF **FLOATING
C14862 divbuf_1/a_55710_n840# vdda1 1.09fF **FLOATING
C14863 divbuf_1/a_55230_n840# vdda1 1.09fF **FLOATING
C14864 divbuf_1/a_54750_n840# vdda1 1.09fF **FLOATING
C14865 divbuf_1/a_54270_n840# vdda1 1.09fF **FLOATING
C14866 divbuf_1/a_53790_n840# vdda1 1.09fF **FLOATING
C14867 divbuf_1/a_53310_n840# vdda1 1.09fF **FLOATING
C14868 divbuf_1/a_52830_n840# vdda1 1.09fF **FLOATING
C14869 divbuf_1/a_52350_n840# vdda1 1.09fF **FLOATING
C14870 divbuf_1/a_51870_n840# vdda1 1.09fF **FLOATING
C14871 divbuf_1/a_51390_n840# vdda1 1.09fF **FLOATING
C14872 divbuf_1/a_50910_n840# vdda1 1.09fF **FLOATING
C14873 divbuf_1/a_50430_n840# vdda1 1.09fF **FLOATING
C14874 divbuf_1/a_49950_n840# vdda1 1.09fF **FLOATING
C14875 divbuf_1/a_49470_n840# vdda1 1.09fF **FLOATING
C14876 divbuf_1/a_48990_n840# vdda1 1.09fF **FLOATING
C14877 divbuf_1/a_48510_n840# vdda1 1.09fF **FLOATING
C14878 divbuf_1/a_48030_n840# vdda1 1.09fF **FLOATING
C14879 divbuf_1/a_47550_n840# vdda1 1.09fF **FLOATING
C14880 divbuf_1/a_47070_n840# vdda1 1.09fF **FLOATING
C14881 divbuf_1/a_46590_n840# vdda1 1.09fF **FLOATING
C14882 divbuf_1/a_46110_n840# vdda1 1.09fF **FLOATING
C14883 divbuf_1/a_45630_n840# vdda1 1.09fF **FLOATING
C14884 divbuf_1/a_45150_n840# vdda1 1.09fF **FLOATING
C14885 divbuf_1/a_44670_n840# vdda1 1.09fF **FLOATING
C14886 divbuf_1/a_44190_n840# vdda1 1.09fF **FLOATING
C14887 divbuf_1/a_43710_n840# vdda1 1.09fF **FLOATING
C14888 divbuf_1/a_43230_n840# vdda1 1.09fF **FLOATING
C14889 divbuf_1/a_42750_n840# vdda1 1.08fF **FLOATING
C14890 divbuf_1/a_42270_n840# vdda1 1.08fF **FLOATING
C14891 divbuf_1/a_41790_n840# vdda1 1.10fF **FLOATING
C14892 divbuf_1/a_41310_n840# vdda1 1.09fF **FLOATING
C14893 divbuf_1/a_40830_n840# vdda1 1.09fF **FLOATING
C14894 divbuf_1/a_40350_n840# vdda1 1.09fF **FLOATING
C14895 divbuf_1/a_39870_n840# vdda1 1.09fF **FLOATING
C14896 divbuf_1/a_39390_n840# vdda1 1.09fF **FLOATING
C14897 divbuf_1/a_38910_n840# vdda1 1.09fF **FLOATING
C14898 divbuf_1/a_38430_n840# vdda1 1.09fF **FLOATING
C14899 divbuf_1/a_37950_n840# vdda1 1.09fF **FLOATING
C14900 divbuf_1/a_37470_n840# vdda1 1.09fF **FLOATING
C14901 divbuf_1/a_36990_n840# vdda1 1.09fF **FLOATING
C14902 divbuf_1/a_36510_n840# vdda1 1.09fF **FLOATING
C14903 divbuf_1/a_36030_n840# vdda1 1.09fF **FLOATING
C14904 divbuf_1/a_35550_n840# vdda1 1.09fF **FLOATING
C14905 divbuf_1/a_35070_n840# vdda1 1.09fF **FLOATING
C14906 divbuf_1/a_34590_n840# vdda1 1.09fF **FLOATING
C14907 divbuf_1/a_34110_n840# vdda1 1.09fF **FLOATING
C14908 divbuf_1/a_33630_n840# vdda1 1.09fF **FLOATING
C14909 divbuf_1/a_33150_n840# vdda1 1.09fF **FLOATING
C14910 divbuf_1/a_32670_n840# vdda1 1.09fF **FLOATING
C14911 divbuf_1/a_32190_n840# vdda1 1.09fF **FLOATING
C14912 divbuf_1/a_31710_n840# vdda1 1.11fF **FLOATING
C14913 divbuf_1/a_31230_n840# vdda1 1.13fF **FLOATING
C14914 divbuf_1/a_30750_n840# vdda1 1.09fF **FLOATING
C14915 divbuf_1/a_30270_n840# vdda1 1.09fF **FLOATING
C14916 divbuf_1/a_29790_n840# vdda1 1.09fF **FLOATING
C14917 divbuf_1/a_29310_n840# vdda1 1.09fF **FLOATING
C14918 divbuf_1/a_28830_n840# vdda1 1.09fF **FLOATING
C14919 divbuf_1/a_28350_n840# vdda1 1.09fF **FLOATING
C14920 divbuf_1/a_27870_n840# vdda1 1.08fF **FLOATING
C14921 divbuf_1/a_27390_n840# vdda1 1.11fF **FLOATING
C14922 divbuf_1/a_26910_n840# vdda1 1.10fF **FLOATING
C14923 divbuf_1/a_26430_n840# vdda1 1.10fF **FLOATING
C14924 divbuf_1/a_25950_n840# vdda1 1.10fF **FLOATING
C14925 divbuf_1/a_25470_n840# vdda1 1.10fF **FLOATING
C14926 divbuf_1/a_24990_n840# vdda1 1.10fF **FLOATING
C14927 divbuf_1/a_24510_n840# vdda1 1.10fF **FLOATING
C14928 divbuf_1/a_24030_n840# vdda1 1.09fF **FLOATING
C14929 divbuf_1/a_23550_n840# vdda1 1.11fF **FLOATING
C14930 divbuf_1/a_23070_n840# vdda1 1.10fF **FLOATING
C14931 divbuf_1/a_22590_n840# vdda1 1.10fF **FLOATING
C14932 divbuf_1/a_22110_n840# vdda1 1.10fF **FLOATING
C14933 divbuf_1/a_21630_n840# vdda1 1.10fF **FLOATING
C14934 divbuf_1/a_21150_n840# vdda1 1.10fF **FLOATING
C14935 divbuf_1/a_20670_n840# vdda1 1.10fF **FLOATING
C14936 divbuf_1/a_20190_n840# vdda1 1.09fF **FLOATING
C14937 divbuf_1/a_19710_n840# vdda1 1.09fF **FLOATING
C14938 divbuf_1/a_19230_n840# vdda1 1.09fF **FLOATING
C14939 divbuf_1/a_18750_n840# vdda1 1.09fF **FLOATING
C14940 divbuf_1/a_18270_n840# vdda1 1.08fF **FLOATING
C14941 divbuf_1/a_17790_n840# vdda1 1.08fF **FLOATING
C14942 divbuf_1/a_17310_n840# vdda1 1.07fF **FLOATING
C14943 divbuf_1/a_16830_n840# vdda1 1.07fF **FLOATING
C14944 divbuf_1/a_16350_n840# vdda1 1.07fF **FLOATING
C14945 divbuf_1/a_15870_n840# vdda1 1.07fF **FLOATING
C14946 divbuf_1/a_15390_n840# vdda1 1.08fF **FLOATING
C14947 divbuf_1/a_14910_n840# vdda1 1.07fF **FLOATING
C14948 divbuf_1/a_14430_n840# vdda1 1.07fF **FLOATING
C14949 divbuf_1/a_13950_n840# vdda1 1.07fF **FLOATING
C14950 divbuf_1/a_13470_n840# vdda1 1.07fF **FLOATING
C14951 divbuf_1/a_12990_n840# vdda1 1.10fF **FLOATING
C14952 divbuf_1/a_12510_n840# vdda1 1.08fF **FLOATING
C14953 divbuf_1/a_12030_n840# vdda1 1.07fF **FLOATING
C14954 divbuf_1/a_11550_n840# vdda1 1.07fF **FLOATING
C14955 divbuf_1/a_11070_n840# vdda1 1.08fF **FLOATING
C14956 divbuf_1/a_10590_n840# vdda1 1.10fF **FLOATING
C14957 divbuf_1/a_10110_n840# vdda1 1.10fF **FLOATING
C14958 divbuf_1/a_9630_n840# vdda1 1.10fF **FLOATING
C14959 divbuf_1/a_9150_n840# vdda1 1.10fF **FLOATING
C14960 divbuf_1/a_8670_n840# vdda1 1.10fF **FLOATING
C14961 divbuf_1/a_8190_n840# vdda1 1.12fF **FLOATING
C14962 divbuf_1/a_7710_n840# vdda1 1.10fF **FLOATING
C14963 divbuf_1/a_7230_n840# vdda1 1.09fF **FLOATING
C14964 divbuf_1/a_6750_n840# vdda1 1.09fF **FLOATING
C14965 divbuf_1/a_6270_n840# vdda1 1.09fF **FLOATING
C14966 divbuf_1/a_5790_n840# vdda1 1.09fF **FLOATING
C14967 divbuf_1/a_5310_n840# vdda1 1.09fF **FLOATING
C14968 divbuf_1/a_4830_n840# vdda1 1.09fF **FLOATING
C14969 divbuf_1/a_4350_n840# vdda1 1.09fF **FLOATING
C14970 divbuf_1/a_3870_n840# vdda1 1.09fF **FLOATING
C14971 divbuf_1/a_3390_n840# vdda1 1.09fF **FLOATING
C14972 divbuf_1/a_2910_n840# vdda1 1.10fF **FLOATING
C14973 divbuf_1/a_2430_n840# vdda1 1.10fF **FLOATING
C14974 divbuf_1/a_1950_n840# vdda1 1.10fF **FLOATING
C14975 divbuf_1/a_1470_n840# vdda1 1.10fF **FLOATING
C14976 divbuf_1/a_990_n840# vdda1 1.08fF **FLOATING
C14977 divbuf_1/a_510_n840# vdda1 1.07fF **FLOATING
C14978 divbuf_1/a_60480_n1600# vdda1 1.48fF **FLOATING
C14979 divbuf_1/a_60000_n1600# vdda1 1.48fF **FLOATING
C14980 divbuf_1/a_59520_n1600# vdda1 1.48fF **FLOATING
C14981 divbuf_1/a_59040_n1600# vdda1 1.48fF **FLOATING
C14982 divbuf_1/a_58560_n1600# vdda1 1.48fF **FLOATING
C14983 divbuf_1/a_58080_n1600# vdda1 1.48fF **FLOATING
C14984 divbuf_1/a_57600_n1600# vdda1 1.48fF **FLOATING
C14985 divbuf_1/a_57120_n1600# vdda1 1.48fF **FLOATING
C14986 divbuf_1/a_56640_n1600# vdda1 1.48fF **FLOATING
C14987 divbuf_1/a_56160_n1600# vdda1 1.48fF **FLOATING
C14988 divbuf_1/a_55680_n1600# vdda1 1.48fF **FLOATING
C14989 divbuf_1/a_55200_n1600# vdda1 1.48fF **FLOATING
C14990 divbuf_1/a_54720_n1600# vdda1 1.48fF **FLOATING
C14991 divbuf_1/a_54240_n1600# vdda1 1.48fF **FLOATING
C14992 divbuf_1/a_53760_n1600# vdda1 1.48fF **FLOATING
C14993 divbuf_1/a_53280_n1600# vdda1 1.48fF **FLOATING
C14994 divbuf_1/a_52800_n1600# vdda1 1.48fF **FLOATING
C14995 divbuf_1/a_52320_n1600# vdda1 1.48fF **FLOATING
C14996 divbuf_1/a_51840_n1600# vdda1 1.48fF **FLOATING
C14997 divbuf_1/a_51360_n1600# vdda1 1.48fF **FLOATING
C14998 divbuf_1/a_50880_n1600# vdda1 1.48fF **FLOATING
C14999 divbuf_1/a_50400_n1600# vdda1 1.48fF **FLOATING
C15000 divbuf_1/a_49920_n1600# vdda1 1.48fF **FLOATING
C15001 divbuf_1/a_49440_n1600# vdda1 1.48fF **FLOATING
C15002 divbuf_1/a_48960_n1600# vdda1 1.48fF **FLOATING
C15003 divbuf_1/a_48480_n1600# vdda1 1.48fF **FLOATING
C15004 divbuf_1/a_48000_n1600# vdda1 1.48fF **FLOATING
C15005 divbuf_1/a_47520_n1600# vdda1 1.48fF **FLOATING
C15006 divbuf_1/a_47040_n1600# vdda1 1.48fF **FLOATING
C15007 divbuf_1/a_46560_n1600# vdda1 1.48fF **FLOATING
C15008 divbuf_1/a_46080_n1600# vdda1 1.48fF **FLOATING
C15009 divbuf_1/a_45600_n1600# vdda1 1.48fF **FLOATING
C15010 divbuf_1/a_45120_n1600# vdda1 1.48fF **FLOATING
C15011 divbuf_1/a_44640_n1600# vdda1 1.48fF **FLOATING
C15012 divbuf_1/a_44160_n1600# vdda1 1.48fF **FLOATING
C15013 divbuf_1/a_43680_n1600# vdda1 1.48fF **FLOATING
C15014 divbuf_1/a_43200_n1600# vdda1 1.48fF **FLOATING
C15015 divbuf_1/a_42720_n1600# vdda1 1.48fF **FLOATING
C15016 divbuf_1/a_42240_n1600# vdda1 1.48fF **FLOATING
C15017 divbuf_1/a_41760_n1600# vdda1 1.48fF **FLOATING
C15018 divbuf_1/a_41280_n1600# vdda1 1.48fF **FLOATING
C15019 divbuf_1/a_40800_n1600# vdda1 1.48fF **FLOATING
C15020 divbuf_1/a_40320_n1600# vdda1 1.48fF **FLOATING
C15021 divbuf_1/a_39840_n1600# vdda1 1.48fF **FLOATING
C15022 divbuf_1/a_39360_n1600# vdda1 1.48fF **FLOATING
C15023 divbuf_1/a_38880_n1600# vdda1 1.48fF **FLOATING
C15024 divbuf_1/a_38400_n1600# vdda1 1.48fF **FLOATING
C15025 divbuf_1/a_37920_n1600# vdda1 1.48fF **FLOATING
C15026 divbuf_1/a_37440_n1600# vdda1 1.48fF **FLOATING
C15027 divbuf_1/a_36960_n1600# vdda1 1.48fF **FLOATING
C15028 divbuf_1/a_36480_n1600# vdda1 1.48fF **FLOATING
C15029 divbuf_1/a_36000_n1600# vdda1 1.48fF **FLOATING
C15030 divbuf_1/a_35520_n1600# vdda1 1.48fF **FLOATING
C15031 divbuf_1/a_35040_n1600# vdda1 1.48fF **FLOATING
C15032 divbuf_1/a_34560_n1600# vdda1 1.48fF **FLOATING
C15033 divbuf_1/a_34080_n1600# vdda1 1.48fF **FLOATING
C15034 divbuf_1/a_33600_n1600# vdda1 1.48fF **FLOATING
C15035 divbuf_1/a_33120_n1600# vdda1 1.48fF **FLOATING
C15036 divbuf_1/a_32640_n1600# vdda1 1.48fF **FLOATING
C15037 divbuf_1/a_32160_n1600# vdda1 1.48fF **FLOATING
C15038 divbuf_1/a_31680_n1600# vdda1 1.48fF **FLOATING
C15039 divbuf_1/a_31200_n1600# vdda1 1.48fF **FLOATING
C15040 divbuf_1/a_30720_n1600# vdda1 1.48fF **FLOATING
C15041 divbuf_1/a_30240_n1600# vdda1 1.48fF **FLOATING
C15042 divbuf_1/a_29760_n1600# vdda1 1.48fF **FLOATING
C15043 divbuf_1/a_29280_n1600# vdda1 1.48fF **FLOATING
C15044 divbuf_1/a_28800_n1600# vdda1 1.48fF **FLOATING
C15045 divbuf_1/a_28320_n1600# vdda1 1.48fF **FLOATING
C15046 divbuf_1/a_27840_n1600# vdda1 1.48fF **FLOATING
C15047 divbuf_1/a_27360_n1600# vdda1 1.48fF **FLOATING
C15048 divbuf_1/a_26880_n1600# vdda1 1.48fF **FLOATING
C15049 divbuf_1/a_26400_n1600# vdda1 1.48fF **FLOATING
C15050 divbuf_1/a_25920_n1600# vdda1 1.48fF **FLOATING
C15051 divbuf_1/a_25440_n1600# vdda1 1.48fF **FLOATING
C15052 divbuf_1/a_24960_n1600# vdda1 1.48fF **FLOATING
C15053 divbuf_1/a_24480_n1600# vdda1 1.48fF **FLOATING
C15054 divbuf_1/a_24000_n1600# vdda1 1.48fF **FLOATING
C15055 divbuf_1/a_23520_n1600# vdda1 1.48fF **FLOATING
C15056 divbuf_1/a_23040_n1600# vdda1 1.48fF **FLOATING
C15057 divbuf_1/a_22560_n1600# vdda1 1.48fF **FLOATING
C15058 divbuf_1/a_22080_n1600# vdda1 1.48fF **FLOATING
C15059 divbuf_1/a_21600_n1600# vdda1 1.48fF **FLOATING
C15060 divbuf_1/a_21120_n1600# vdda1 1.48fF **FLOATING
C15061 divbuf_1/a_20640_n1600# vdda1 1.48fF **FLOATING
C15062 divbuf_1/a_20160_n1600# vdda1 1.48fF **FLOATING
C15063 divbuf_1/a_19680_n1600# vdda1 1.48fF **FLOATING
C15064 divbuf_1/a_19200_n1600# vdda1 1.48fF **FLOATING
C15065 divbuf_1/a_18720_n1600# vdda1 1.48fF **FLOATING
C15066 divbuf_1/a_18240_n1600# vdda1 1.48fF **FLOATING
C15067 divbuf_1/a_17760_n1600# vdda1 1.48fF **FLOATING
C15068 divbuf_1/a_17280_n1600# vdda1 1.48fF **FLOATING
C15069 divbuf_1/a_16800_n1600# vdda1 1.48fF **FLOATING
C15070 divbuf_1/a_16320_n1600# vdda1 1.48fF **FLOATING
C15071 divbuf_1/a_15840_n1600# vdda1 1.48fF **FLOATING
C15072 divbuf_1/a_15360_n1600# vdda1 1.48fF **FLOATING
C15073 divbuf_1/a_14880_n1600# vdda1 1.48fF **FLOATING
C15074 divbuf_1/a_14400_n1600# vdda1 1.48fF **FLOATING
C15075 divbuf_1/a_13920_n1600# vdda1 1.48fF **FLOATING
C15076 divbuf_1/a_13440_n1600# vdda1 1.48fF **FLOATING
C15077 divbuf_1/a_12960_n1600# vdda1 1.48fF **FLOATING
C15078 divbuf_1/a_12480_n1600# vdda1 1.48fF **FLOATING
C15079 divbuf_1/a_12000_n1600# vdda1 1.48fF **FLOATING
C15080 divbuf_1/a_11520_n1600# vdda1 1.48fF **FLOATING
C15081 divbuf_1/a_11040_n1600# vdda1 1.48fF **FLOATING
C15082 divbuf_1/a_10560_n1600# vdda1 1.48fF **FLOATING
C15083 divbuf_1/a_10080_n1600# vdda1 1.48fF **FLOATING
C15084 divbuf_1/a_9600_n1600# vdda1 1.48fF **FLOATING
C15085 divbuf_1/a_9120_n1600# vdda1 1.48fF **FLOATING
C15086 divbuf_1/a_8640_n1600# vdda1 1.48fF **FLOATING
C15087 divbuf_1/a_8160_n1600# vdda1 1.48fF **FLOATING
C15088 divbuf_1/a_7680_n1600# vdda1 1.48fF **FLOATING
C15089 divbuf_1/a_7200_n1600# vdda1 1.48fF **FLOATING
C15090 divbuf_1/a_6720_n1600# vdda1 1.48fF **FLOATING
C15091 divbuf_1/a_6240_n1600# vdda1 1.48fF **FLOATING
C15092 divbuf_1/a_5760_n1600# vdda1 1.48fF **FLOATING
C15093 divbuf_1/a_5280_n1600# vdda1 1.48fF **FLOATING
C15094 divbuf_1/a_4800_n1600# vdda1 1.48fF **FLOATING
C15095 divbuf_1/a_4320_n1600# vdda1 1.48fF **FLOATING
C15096 divbuf_1/a_3840_n1600# vdda1 1.48fF **FLOATING
C15097 divbuf_1/a_3360_n1600# vdda1 1.48fF **FLOATING
C15098 divbuf_1/a_2880_n1600# vdda1 1.48fF **FLOATING
C15099 divbuf_1/a_2400_n1600# vdda1 1.48fF **FLOATING
C15100 divbuf_1/a_1920_n1600# vdda1 1.48fF **FLOATING
C15101 divbuf_1/a_1440_n1600# vdda1 1.48fF **FLOATING
C15102 divbuf_1/a_960_n1600# vdda1 1.48fF **FLOATING
C15103 divbuf_1/a_480_n1600# vdda1 1.48fF **FLOATING
C15104 divbuf_1/a_0_n1600# vdda1 1.48fF **FLOATING
C15105 divbuf_1/a_41382_n240# vdda1 0.90fF **FLOATING
C15106 divbuf_1/a_40902_n240# vdda1 0.90fF **FLOATING
C15107 divbuf_1/a_40412_n240# vdda1 0.90fF **FLOATING
C15108 divbuf_1/a_39932_n240# vdda1 0.90fF **FLOATING
C15109 divbuf_1/a_39442_n240# vdda1 0.90fF **FLOATING
C15110 divbuf_1/a_38962_n240# vdda1 0.91fF **FLOATING
C15111 divbuf_1/a_38472_n240# vdda1 0.90fF **FLOATING
C15112 divbuf_1/a_37992_n240# vdda1 0.90fF **FLOATING
C15113 divbuf_1/a_37502_n240# vdda1 0.90fF **FLOATING
C15114 divbuf_1/a_37022_n240# vdda1 0.90fF **FLOATING
C15115 divbuf_1/a_36532_n240# vdda1 0.90fF **FLOATING
C15116 divbuf_1/a_36052_n240# vdda1 0.90fF **FLOATING
C15117 divbuf_1/a_35562_n240# vdda1 0.90fF **FLOATING
C15118 divbuf_1/a_35082_n240# vdda1 0.91fF **FLOATING
C15119 divbuf_1/a_34592_n240# vdda1 0.90fF **FLOATING
C15120 divbuf_1/a_34112_n240# vdda1 0.90fF **FLOATING
C15121 divbuf_1/a_33622_n240# vdda1 0.90fF **FLOATING
C15122 divbuf_1/a_33142_n240# vdda1 0.90fF **FLOATING
C15123 divbuf_1/a_32652_n240# vdda1 0.90fF **FLOATING
C15124 divbuf_1/a_32172_n240# vdda1 0.90fF **FLOATING
C15125 divbuf_1/a_31682_n240# vdda1 0.89fF **FLOATING
C15126 divbuf_1/a_31202_n240# vdda1 0.92fF **FLOATING
C15127 divbuf_1/a_30712_n240# vdda1 0.90fF **FLOATING
C15128 divbuf_1/a_30232_n240# vdda1 0.90fF **FLOATING
C15129 divbuf_1/a_29742_n240# vdda1 0.90fF **FLOATING
C15130 divbuf_1/a_29262_n240# vdda1 0.90fF **FLOATING
C15131 divbuf_1/a_28772_n240# vdda1 0.90fF **FLOATING
C15132 divbuf_1/a_28292_n240# vdda1 0.90fF **FLOATING
C15133 divbuf_1/a_27802_n240# vdda1 0.89fF **FLOATING
C15134 divbuf_1/a_27322_n240# vdda1 0.95fF **FLOATING
C15135 divbuf_1/a_26832_n240# vdda1 0.91fF **FLOATING
C15136 divbuf_1/a_26352_n240# vdda1 0.91fF **FLOATING
C15137 divbuf_1/a_25862_n240# vdda1 0.91fF **FLOATING
C15138 divbuf_1/a_25382_n240# vdda1 0.91fF **FLOATING
C15139 divbuf_1/a_24892_n240# vdda1 0.91fF **FLOATING
C15140 divbuf_1/a_24412_n240# vdda1 0.91fF **FLOATING
C15141 divbuf_1/a_23922_n240# vdda1 0.92fF **FLOATING
C15142 divbuf_1/a_23442_n240# vdda1 0.94fF **FLOATING
C15143 divbuf_1/a_22952_n240# vdda1 0.91fF **FLOATING
C15144 divbuf_1/a_22472_n240# vdda1 0.91fF **FLOATING
C15145 divbuf_1/a_21982_n240# vdda1 0.91fF **FLOATING
C15146 divbuf_1/a_21502_n240# vdda1 0.91fF **FLOATING
C15147 divbuf_1/a_21012_n240# vdda1 0.91fF **FLOATING
C15148 divbuf_1/a_20532_n240# vdda1 0.91fF **FLOATING
C15149 divbuf_1/a_20042_n240# vdda1 0.90fF **FLOATING
C15150 divbuf_1/a_19562_n240# vdda1 0.90fF **FLOATING
C15151 divbuf_1/a_19072_n240# vdda1 0.90fF **FLOATING
C15152 divbuf_1/a_18582_n240# vdda1 0.89fF **FLOATING
C15153 divbuf_1/a_18092_n240# vdda1 0.89fF **FLOATING
C15154 divbuf_1/a_17612_n240# vdda1 0.89fF **FLOATING
C15155 divbuf_1/a_17122_n240# vdda1 0.88fF **FLOATING
C15156 divbuf_1/a_16642_n240# vdda1 0.88fF **FLOATING
C15157 divbuf_1/a_16152_n240# vdda1 0.88fF **FLOATING
C15158 divbuf_1/a_15672_n240# vdda1 0.90fF **FLOATING
C15159 divbuf_1/a_15182_n240# vdda1 0.88fF **FLOATING
C15160 divbuf_1/a_14702_n240# vdda1 0.88fF **FLOATING
C15161 divbuf_1/a_14222_n240# vdda1 0.88fF **FLOATING
C15162 divbuf_1/a_13742_n240# vdda1 0.88fF **FLOATING
C15163 divbuf_1/a_13252_n240# vdda1 0.88fF **FLOATING
C15164 divbuf_1/a_12772_n240# vdda1 0.88fF **FLOATING
C15165 divbuf_1/a_12282_n240# vdda1 0.88fF **FLOATING
C15166 divbuf_1/a_11802_n240# vdda1 0.88fF **FLOATING
C15167 divbuf_1/a_11312_n240# vdda1 0.89fF **FLOATING
C15168 divbuf_1/a_10212_n240# vdda1 0.91fF **FLOATING
C15169 divbuf_1/a_9732_n240# vdda1 0.91fF **FLOATING
C15170 divbuf_1/a_9242_n240# vdda1 0.91fF **FLOATING
C15171 divbuf_1/a_8762_n240# vdda1 0.91fF **FLOATING
C15172 divbuf_1/a_8272_n240# vdda1 0.91fF **FLOATING
C15173 divbuf_1/a_7792_n240# vdda1 0.92fF **FLOATING
C15174 divbuf_1/a_7302_n240# vdda1 0.90fF **FLOATING
C15175 divbuf_1/a_6822_n240# vdda1 0.90fF **FLOATING
C15176 divbuf_1/a_6332_n240# vdda1 0.90fF **FLOATING
C15177 divbuf_1/a_5852_n240# vdda1 0.90fF **FLOATING
C15178 divbuf_1/a_5362_n240# vdda1 0.90fF **FLOATING
C15179 divbuf_1/a_4882_n240# vdda1 0.90fF **FLOATING
C15180 divbuf_1/a_4392_n240# vdda1 0.90fF **FLOATING
C15181 divbuf_1/a_3912_n240# vdda1 0.90fF **FLOATING
C15182 divbuf_1/a_3422_n240# vdda1 0.90fF **FLOATING
C15183 divbuf_1/a_2322_n240# vdda1 0.91fF **FLOATING
C15184 divbuf_1/a_1842_n240# vdda1 0.91fF **FLOATING
C15185 divbuf_1/a_1352_n240# vdda1 0.91fF **FLOATING
C15186 divbuf_1/a_41382_170# vdda1 1.07fF **FLOATING
C15187 divbuf_1/a_40902_170# vdda1 1.09fF **FLOATING
C15188 divbuf_1/a_40412_170# vdda1 1.09fF **FLOATING
C15189 divbuf_1/a_39932_170# vdda1 1.09fF **FLOATING
C15190 divbuf_1/a_39442_170# vdda1 1.09fF **FLOATING
C15191 divbuf_1/a_38962_170# vdda1 1.07fF **FLOATING
C15192 divbuf_1/a_38472_170# vdda1 1.09fF **FLOATING
C15193 divbuf_1/a_37992_170# vdda1 1.09fF **FLOATING
C15194 divbuf_1/a_37502_170# vdda1 1.09fF **FLOATING
C15195 divbuf_1/a_37022_170# vdda1 1.09fF **FLOATING
C15196 divbuf_1/a_36532_170# vdda1 1.09fF **FLOATING
C15197 divbuf_1/a_36052_170# vdda1 1.09fF **FLOATING
C15198 divbuf_1/a_35562_170# vdda1 1.09fF **FLOATING
C15199 divbuf_1/a_35082_170# vdda1 1.09fF **FLOATING
C15200 divbuf_1/a_34592_170# vdda1 1.07fF **FLOATING
C15201 divbuf_1/a_34112_170# vdda1 1.09fF **FLOATING
C15202 divbuf_1/a_33622_170# vdda1 1.09fF **FLOATING
C15203 divbuf_1/a_33142_170# vdda1 1.09fF **FLOATING
C15204 divbuf_1/a_32652_170# vdda1 1.09fF **FLOATING
C15205 divbuf_1/a_32172_170# vdda1 1.09fF **FLOATING
C15206 divbuf_1/a_31682_170# vdda1 1.09fF **FLOATING
C15207 divbuf_1/a_31202_170# vdda1 1.09fF **FLOATING
C15208 divbuf_1/a_30712_170# vdda1 1.09fF **FLOATING
C15209 divbuf_1/a_30232_170# vdda1 1.07fF **FLOATING
C15210 divbuf_1/a_29742_170# vdda1 1.09fF **FLOATING
C15211 divbuf_1/a_29262_170# vdda1 1.09fF **FLOATING
C15212 divbuf_1/a_28772_170# vdda1 1.09fF **FLOATING
C15213 divbuf_1/a_28292_170# vdda1 1.09fF **FLOATING
C15214 divbuf_1/a_27802_170# vdda1 1.09fF **FLOATING
C15215 divbuf_1/a_27322_170# vdda1 1.09fF **FLOATING
C15216 divbuf_1/a_26832_170# vdda1 1.09fF **FLOATING
C15217 divbuf_1/a_26352_170# vdda1 1.09fF **FLOATING
C15218 divbuf_1/a_25862_170# vdda1 1.07fF **FLOATING
C15219 divbuf_1/a_25382_170# vdda1 1.09fF **FLOATING
C15220 divbuf_1/a_24892_170# vdda1 1.09fF **FLOATING
C15221 divbuf_1/a_24412_170# vdda1 1.09fF **FLOATING
C15222 divbuf_1/a_23922_170# vdda1 1.09fF **FLOATING
C15223 divbuf_1/a_23442_170# vdda1 1.09fF **FLOATING
C15224 divbuf_1/a_22952_170# vdda1 1.09fF **FLOATING
C15225 divbuf_1/a_22472_170# vdda1 1.07fF **FLOATING
C15226 divbuf_1/a_21982_170# vdda1 1.09fF **FLOATING
C15227 divbuf_1/a_21502_170# vdda1 1.09fF **FLOATING
C15228 divbuf_1/a_21012_170# vdda1 1.09fF **FLOATING
C15229 divbuf_1/a_20532_170# vdda1 1.09fF **FLOATING
C15230 divbuf_1/a_20042_170# vdda1 1.09fF **FLOATING
C15231 divbuf_1/a_19562_170# vdda1 1.09fF **FLOATING
C15232 divbuf_1/a_19072_170# vdda1 1.09fF **FLOATING
C15233 divbuf_1/a_18582_170# vdda1 1.07fF **FLOATING
C15234 divbuf_1/a_18092_170# vdda1 1.09fF **FLOATING
C15235 divbuf_1/a_17612_170# vdda1 1.09fF **FLOATING
C15236 divbuf_1/a_17122_170# vdda1 1.09fF **FLOATING
C15237 divbuf_1/a_16642_170# vdda1 1.09fF **FLOATING
C15238 divbuf_1/a_16152_170# vdda1 1.09fF **FLOATING
C15239 divbuf_1/a_15672_170# vdda1 1.09fF **FLOATING
C15240 divbuf_1/a_15182_170# vdda1 1.09fF **FLOATING
C15241 divbuf_1/a_14702_170# vdda1 1.10fF **FLOATING
C15242 divbuf_1/a_14222_170# vdda1 1.10fF **FLOATING
C15243 divbuf_1/a_13742_170# vdda1 1.09fF **FLOATING
C15244 divbuf_1/a_13252_170# vdda1 1.09fF **FLOATING
C15245 divbuf_1/a_12772_170# vdda1 1.07fF **FLOATING
C15246 divbuf_1/a_12282_170# vdda1 1.09fF **FLOATING
C15247 divbuf_1/a_11802_170# vdda1 1.09fF **FLOATING
C15248 divbuf_1/a_11312_170# vdda1 1.10fF **FLOATING
C15249 divbuf_1/a_10212_170# vdda1 1.09fF **FLOATING
C15250 divbuf_1/a_9732_170# vdda1 1.09fF **FLOATING
C15251 divbuf_1/a_9242_170# vdda1 1.09fF **FLOATING
C15252 divbuf_1/a_8762_170# vdda1 1.09fF **FLOATING
C15253 divbuf_1/a_8272_170# vdda1 1.07fF **FLOATING
C15254 divbuf_1/a_7792_170# vdda1 1.09fF **FLOATING
C15255 divbuf_1/a_7302_170# vdda1 1.09fF **FLOATING
C15256 divbuf_1/a_6822_170# vdda1 1.09fF **FLOATING
C15257 divbuf_1/a_6332_170# vdda1 1.09fF **FLOATING
C15258 divbuf_1/a_5852_170# vdda1 1.09fF **FLOATING
C15259 divbuf_1/a_5362_170# vdda1 1.09fF **FLOATING
C15260 divbuf_1/a_4882_170# vdda1 1.09fF **FLOATING
C15261 divbuf_1/a_4392_170# vdda1 1.07fF **FLOATING
C15262 divbuf_1/a_3912_170# vdda1 1.09fF **FLOATING
C15263 divbuf_1/a_3422_170# vdda1 1.10fF **FLOATING
C15264 divbuf_1/a_2322_170# vdda1 1.09fF **FLOATING
C15265 divbuf_1/a_1842_170# vdda1 1.09fF **FLOATING
C15266 divbuf_1/a_1352_170# vdda1 1.10fF **FLOATING
C15267 divbuf_1/a_492_n240# vdda1 2.46fF **FLOATING
C15268 pd_div_0/divider_0/and_0/Z1 vdda1 0.33fF
C15269 pd_div_0/divider_0/and_0/B vdda1 1.79fF
C15270 pd_div_0/divider_0/and_0/A vdda1 1.66fF
C15271 pd_div_0/divider_0/and_0/out1 vdda1 2.71fF
C15272 pd_div_0/divider_0/tspc_2/Z4 vdda1 0.42fF
C15273 pd_div_0/bufin vdda1 9.07fF
C15274 pd_div_0/divider_0/tspc_2/Z3 vdda1 2.00fF
C15275 pd_div_0/divider_0/tspc_2/Z2 vdda1 1.29fF
C15276 pd_div_0/divider_0/tspc_2/Z1 vdda1 0.99fF
C15277 pd_div_0/divider_0/nor_0/B vdda1 5.25fF
C15278 pd_div_0/divider_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C15279 pd_div_0/divider_0/tspc_1/Z4 vdda1 0.42fF
C15280 pd_div_0/divider_0/tspc_1/Q vdda1 2.79fF
C15281 pd_div_0/divider_0/tspc_1/Z3 vdda1 2.00fF
C15282 pd_div_0/divider_0/tspc_1/Z2 vdda1 1.29fF
C15283 pd_div_0/divider_0/tspc_1/Z1 vdda1 0.99fF
C15284 pd_div_0/divider_0/nor_1/B vdda1 5.95fF
C15285 pd_div_0/divider_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C15286 pd_div_0/divider_0/tspc_0/Z4 vdda1 0.42fF
C15287 pd_div_0/divider_0/tspc_0/Q vdda1 2.81fF
C15288 pd_div_0/divider_0/tspc_0/Z3 vdda1 2.00fF
C15289 pd_div_0/divider_0/tspc_0/Z2 vdda1 1.30fF
C15290 pd_div_0/divider_0/tspc_0/Z1 vdda1 0.99fF
C15291 pd_div_0/divider_0/nor_1/A vdda1 6.02fF
C15292 pd_div_0/divider_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C15293 pd_div_0/divider_0/clk vdda1 5.63fF
C15294 pd_div_0/divider_0/prescaler_0/Out vdda1 4.13fF
C15295 pd_div_0/divider_0/prescaler_0/nand_1/z1 vdda1 0.20fF
C15296 gnd vdda1 78.43fF
C15297 pd_div_0/divider_0/prescaler_0/tspc_2/D vdda1 2.59fF
C15298 pd_div_0/divider_0/prescaler_0/tspc_0/Q vdda1 3.30fF
C15299 pd_div_0/divider_0/prescaler_0/tspc_1/Q vdda1 2.78fF
C15300 pd_div_0/divider_0/prescaler_0/nand_0/z1 vdda1 0.20fF
C15301 pd_div_0/divider_0/prescaler_0/tspc_0/D vdda1 3.07fF
C15302 pd_div_0/divider_0/and_0/OUT vdda1 5.35fF
C15303 pd_div_0/divider_0/prescaler_0/tspc_2/Z4 vdda1 0.42fF
C15304 pd_div_0/divider_0/prescaler_0/tspc_2/Z3 vdda1 2.00fF
C15305 pd_div_0/divider_0/prescaler_0/tspc_2/Z2 vdda1 1.30fF
C15306 pd_div_0/divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C15307 pd_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C15308 pd_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 1.89fF **FLOATING
C15309 pd_div_0/divider_0/prescaler_0/tspc_1/Z4 vdda1 0.42fF
C15310 pd_div_0/divider_0/prescaler_0/tspc_1/Z3 vdda1 2.00fF
C15311 pd_div_0/divider_0/prescaler_0/tspc_1/Z2 vdda1 1.31fF
C15312 pd_div_0/divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C15313 pd_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C15314 pd_div_0/divider_0/prescaler_0/m1_2700_2190# vdda1 3.99fF **FLOATING
C15315 pd_div_0/divider_0/prescaler_0/tspc_0/Z4 vdda1 0.42fF
C15316 pd_div_0/divider_0/prescaler_0/tspc_0/Z3 vdda1 2.00fF
C15317 pd_div_0/divider_0/prescaler_0/tspc_0/Z2 vdda1 1.30fF
C15318 pd_div_0/divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C15319 pd_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C15320 pd_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 1.89fF **FLOATING
C15321 pd_div_0/divider_0/nor_1/Z1 vdda1 1.33fF
C15322 pd_div_0/divider_0/nor_0/Z1 vdda1 1.33fF
C15323 pd_div_0/divbuf_0/OUT5 vdda1 16.40fF
C15324 pd_div_0/divbuf_0/OUT4 vdda1 100.06fF
C15325 pd_div_0/divbuf_0/OUT3 vdda1 27.01fF
C15326 pd_div_0/divbuf_0/OUT2 vdda1 8.71fF
C15327 pd_div_0/divbuf_0/a_60990_n1540# vdda1 1.57fF **FLOATING
C15328 pd_div_0/divbuf_0/a_60510_n1540# vdda1 1.62fF **FLOATING
C15329 pd_div_0/divbuf_0/a_60030_n1540# vdda1 1.62fF **FLOATING
C15330 pd_div_0/divbuf_0/a_59550_n1540# vdda1 1.62fF **FLOATING
C15331 pd_div_0/divbuf_0/a_59070_n1540# vdda1 1.62fF **FLOATING
C15332 pd_div_0/divbuf_0/a_58590_n1540# vdda1 1.62fF **FLOATING
C15333 pd_div_0/divbuf_0/a_58110_n1540# vdda1 1.62fF **FLOATING
C15334 pd_div_0/divbuf_0/a_57630_n1540# vdda1 1.62fF **FLOATING
C15335 pd_div_0/divbuf_0/a_57150_n1540# vdda1 1.62fF **FLOATING
C15336 pd_div_0/divbuf_0/a_56670_n1540# vdda1 1.62fF **FLOATING
C15337 pd_div_0/divbuf_0/a_56190_n1540# vdda1 1.62fF **FLOATING
C15338 pd_div_0/divbuf_0/a_55710_n1540# vdda1 1.62fF **FLOATING
C15339 pd_div_0/divbuf_0/a_55230_n1540# vdda1 1.62fF **FLOATING
C15340 pd_div_0/divbuf_0/a_54750_n1540# vdda1 1.62fF **FLOATING
C15341 pd_div_0/divbuf_0/a_54270_n1540# vdda1 1.62fF **FLOATING
C15342 pd_div_0/divbuf_0/a_53790_n1540# vdda1 1.62fF **FLOATING
C15343 pd_div_0/divbuf_0/a_53310_n1540# vdda1 1.62fF **FLOATING
C15344 pd_div_0/divbuf_0/a_52830_n1540# vdda1 1.62fF **FLOATING
C15345 pd_div_0/divbuf_0/a_52350_n1540# vdda1 1.62fF **FLOATING
C15346 pd_div_0/divbuf_0/a_51870_n1540# vdda1 1.62fF **FLOATING
C15347 pd_div_0/divbuf_0/a_51390_n1540# vdda1 1.62fF **FLOATING
C15348 pd_div_0/divbuf_0/a_50910_n1540# vdda1 1.62fF **FLOATING
C15349 pd_div_0/divbuf_0/a_50430_n1540# vdda1 1.62fF **FLOATING
C15350 pd_div_0/divbuf_0/a_49950_n1540# vdda1 1.62fF **FLOATING
C15351 pd_div_0/divbuf_0/a_49470_n1540# vdda1 1.62fF **FLOATING
C15352 pd_div_0/divbuf_0/a_48990_n1540# vdda1 1.62fF **FLOATING
C15353 pd_div_0/divbuf_0/a_48510_n1540# vdda1 1.62fF **FLOATING
C15354 pd_div_0/divbuf_0/a_48030_n1540# vdda1 1.62fF **FLOATING
C15355 pd_div_0/divbuf_0/a_47550_n1540# vdda1 1.62fF **FLOATING
C15356 pd_div_0/divbuf_0/a_47070_n1540# vdda1 1.62fF **FLOATING
C15357 pd_div_0/divbuf_0/a_46590_n1540# vdda1 1.62fF **FLOATING
C15358 pd_div_0/divbuf_0/a_46110_n1540# vdda1 1.62fF **FLOATING
C15359 pd_div_0/divbuf_0/a_45630_n1540# vdda1 1.62fF **FLOATING
C15360 pd_div_0/divbuf_0/a_45150_n1540# vdda1 1.62fF **FLOATING
C15361 pd_div_0/divbuf_0/a_44670_n1540# vdda1 1.62fF **FLOATING
C15362 pd_div_0/divbuf_0/a_44190_n1540# vdda1 1.62fF **FLOATING
C15363 pd_div_0/divbuf_0/a_43710_n1540# vdda1 1.62fF **FLOATING
C15364 pd_div_0/divbuf_0/a_43230_n1540# vdda1 1.62fF **FLOATING
C15365 pd_div_0/divbuf_0/a_42750_n1540# vdda1 1.62fF **FLOATING
C15366 pd_div_0/divbuf_0/a_42270_n1540# vdda1 1.62fF **FLOATING
C15367 pd_div_0/divbuf_0/a_41790_n1540# vdda1 1.62fF **FLOATING
C15368 pd_div_0/divbuf_0/a_41310_n1540# vdda1 1.62fF **FLOATING
C15369 pd_div_0/divbuf_0/a_40830_n1540# vdda1 1.62fF **FLOATING
C15370 pd_div_0/divbuf_0/a_40350_n1540# vdda1 1.62fF **FLOATING
C15371 pd_div_0/divbuf_0/a_39870_n1540# vdda1 1.62fF **FLOATING
C15372 pd_div_0/divbuf_0/a_39390_n1540# vdda1 1.62fF **FLOATING
C15373 pd_div_0/divbuf_0/a_38910_n1540# vdda1 1.62fF **FLOATING
C15374 pd_div_0/divbuf_0/a_38430_n1540# vdda1 1.62fF **FLOATING
C15375 pd_div_0/divbuf_0/a_37950_n1540# vdda1 1.62fF **FLOATING
C15376 pd_div_0/divbuf_0/a_37470_n1540# vdda1 1.62fF **FLOATING
C15377 pd_div_0/divbuf_0/a_36990_n1540# vdda1 1.62fF **FLOATING
C15378 pd_div_0/divbuf_0/a_36510_n1540# vdda1 1.62fF **FLOATING
C15379 pd_div_0/divbuf_0/a_36030_n1540# vdda1 1.62fF **FLOATING
C15380 pd_div_0/divbuf_0/a_35550_n1540# vdda1 1.62fF **FLOATING
C15381 pd_div_0/divbuf_0/a_35070_n1540# vdda1 1.62fF **FLOATING
C15382 pd_div_0/divbuf_0/a_34590_n1540# vdda1 1.62fF **FLOATING
C15383 pd_div_0/divbuf_0/a_34110_n1540# vdda1 1.62fF **FLOATING
C15384 pd_div_0/divbuf_0/a_33630_n1540# vdda1 1.62fF **FLOATING
C15385 pd_div_0/divbuf_0/a_33150_n1540# vdda1 1.62fF **FLOATING
C15386 pd_div_0/divbuf_0/a_32670_n1540# vdda1 1.62fF **FLOATING
C15387 pd_div_0/divbuf_0/a_32190_n1540# vdda1 1.62fF **FLOATING
C15388 pd_div_0/divbuf_0/a_31710_n1540# vdda1 1.62fF **FLOATING
C15389 pd_div_0/divbuf_0/a_31230_n1540# vdda1 1.62fF **FLOATING
C15390 pd_div_0/divbuf_0/a_30750_n1540# vdda1 1.62fF **FLOATING
C15391 pd_div_0/divbuf_0/a_30270_n1540# vdda1 1.62fF **FLOATING
C15392 pd_div_0/divbuf_0/a_29790_n1540# vdda1 1.62fF **FLOATING
C15393 pd_div_0/divbuf_0/a_29310_n1540# vdda1 1.62fF **FLOATING
C15394 pd_div_0/divbuf_0/a_28830_n1540# vdda1 1.62fF **FLOATING
C15395 pd_div_0/divbuf_0/a_28350_n1540# vdda1 1.62fF **FLOATING
C15396 pd_div_0/divbuf_0/a_27870_n1540# vdda1 1.62fF **FLOATING
C15397 pd_div_0/divbuf_0/a_27390_n1540# vdda1 1.62fF **FLOATING
C15398 pd_div_0/divbuf_0/a_26910_n1540# vdda1 1.62fF **FLOATING
C15399 pd_div_0/divbuf_0/a_26430_n1540# vdda1 1.62fF **FLOATING
C15400 pd_div_0/divbuf_0/a_25950_n1540# vdda1 1.62fF **FLOATING
C15401 pd_div_0/divbuf_0/a_25470_n1540# vdda1 1.62fF **FLOATING
C15402 pd_div_0/divbuf_0/a_24990_n1540# vdda1 1.62fF **FLOATING
C15403 pd_div_0/divbuf_0/a_24510_n1540# vdda1 1.62fF **FLOATING
C15404 pd_div_0/divbuf_0/a_24030_n1540# vdda1 1.62fF **FLOATING
C15405 pd_div_0/divbuf_0/a_23550_n1540# vdda1 1.62fF **FLOATING
C15406 pd_div_0/divbuf_0/a_23070_n1540# vdda1 1.62fF **FLOATING
C15407 pd_div_0/divbuf_0/a_22590_n1540# vdda1 1.62fF **FLOATING
C15408 pd_div_0/divbuf_0/a_22110_n1540# vdda1 1.62fF **FLOATING
C15409 pd_div_0/divbuf_0/a_21630_n1540# vdda1 1.62fF **FLOATING
C15410 pd_div_0/divbuf_0/a_21150_n1540# vdda1 1.62fF **FLOATING
C15411 pd_div_0/divbuf_0/a_20670_n1540# vdda1 1.62fF **FLOATING
C15412 pd_div_0/divbuf_0/a_20190_n1540# vdda1 1.62fF **FLOATING
C15413 pd_div_0/divbuf_0/a_19710_n1540# vdda1 1.62fF **FLOATING
C15414 pd_div_0/divbuf_0/a_19230_n1540# vdda1 1.62fF **FLOATING
C15415 pd_div_0/divbuf_0/a_18750_n1540# vdda1 1.62fF **FLOATING
C15416 pd_div_0/divbuf_0/a_18270_n1540# vdda1 1.62fF **FLOATING
C15417 pd_div_0/divbuf_0/a_17790_n1540# vdda1 1.62fF **FLOATING
C15418 pd_div_0/divbuf_0/a_17310_n1540# vdda1 1.62fF **FLOATING
C15419 pd_div_0/divbuf_0/a_16830_n1540# vdda1 1.62fF **FLOATING
C15420 pd_div_0/divbuf_0/a_16350_n1540# vdda1 1.62fF **FLOATING
C15421 pd_div_0/divbuf_0/a_15870_n1540# vdda1 1.62fF **FLOATING
C15422 pd_div_0/divbuf_0/a_15390_n1540# vdda1 1.62fF **FLOATING
C15423 pd_div_0/divbuf_0/a_14910_n1540# vdda1 1.62fF **FLOATING
C15424 pd_div_0/divbuf_0/a_14430_n1540# vdda1 1.62fF **FLOATING
C15425 pd_div_0/divbuf_0/a_13950_n1540# vdda1 1.62fF **FLOATING
C15426 pd_div_0/divbuf_0/a_13470_n1540# vdda1 1.62fF **FLOATING
C15427 pd_div_0/divbuf_0/a_12990_n1540# vdda1 1.62fF **FLOATING
C15428 pd_div_0/divbuf_0/a_12510_n1540# vdda1 1.62fF **FLOATING
C15429 pd_div_0/divbuf_0/a_12030_n1540# vdda1 1.62fF **FLOATING
C15430 pd_div_0/divbuf_0/a_11550_n1540# vdda1 1.62fF **FLOATING
C15431 pd_div_0/divbuf_0/a_11070_n1540# vdda1 1.62fF **FLOATING
C15432 pd_div_0/divbuf_0/a_10590_n1540# vdda1 1.62fF **FLOATING
C15433 pd_div_0/divbuf_0/a_10110_n1540# vdda1 1.62fF **FLOATING
C15434 pd_div_0/divbuf_0/a_9630_n1540# vdda1 1.62fF **FLOATING
C15435 pd_div_0/divbuf_0/a_9150_n1540# vdda1 1.62fF **FLOATING
C15436 pd_div_0/divbuf_0/a_8670_n1540# vdda1 1.62fF **FLOATING
C15437 pd_div_0/divbuf_0/a_8190_n1540# vdda1 1.62fF **FLOATING
C15438 pd_div_0/divbuf_0/a_7710_n1540# vdda1 1.62fF **FLOATING
C15439 pd_div_0/divbuf_0/a_7230_n1540# vdda1 1.62fF **FLOATING
C15440 pd_div_0/divbuf_0/a_6750_n1540# vdda1 1.62fF **FLOATING
C15441 pd_div_0/divbuf_0/a_6270_n1540# vdda1 1.62fF **FLOATING
C15442 pd_div_0/divbuf_0/a_5790_n1540# vdda1 1.62fF **FLOATING
C15443 pd_div_0/divbuf_0/a_5310_n1540# vdda1 1.62fF **FLOATING
C15444 pd_div_0/divbuf_0/a_4830_n1540# vdda1 1.62fF **FLOATING
C15445 pd_div_0/divbuf_0/a_4350_n1540# vdda1 1.62fF **FLOATING
C15446 pd_div_0/divbuf_0/a_3870_n1540# vdda1 1.62fF **FLOATING
C15447 pd_div_0/divbuf_0/a_3390_n1540# vdda1 1.62fF **FLOATING
C15448 pd_div_0/divbuf_0/a_2910_n1540# vdda1 1.62fF **FLOATING
C15449 pd_div_0/divbuf_0/a_2430_n1540# vdda1 1.62fF **FLOATING
C15450 pd_div_0/divbuf_0/a_1950_n1540# vdda1 1.62fF **FLOATING
C15451 pd_div_0/divbuf_0/a_1470_n1540# vdda1 1.62fF **FLOATING
C15452 pd_div_0/divbuf_0/a_990_n1540# vdda1 1.62fF **FLOATING
C15453 pd_div_0/divbuf_0/a_510_n1540# vdda1 1.62fF **FLOATING
C15454 pd_div_0/divbuf_0/a_60990_n840# vdda1 1.06fF **FLOATING
C15455 pd_div_0/divbuf_0/a_60510_n840# vdda1 1.09fF **FLOATING
C15456 pd_div_0/divbuf_0/a_60030_n840# vdda1 1.09fF **FLOATING
C15457 pd_div_0/divbuf_0/a_59550_n840# vdda1 1.09fF **FLOATING
C15458 pd_div_0/divbuf_0/a_59070_n840# vdda1 1.09fF **FLOATING
C15459 pd_div_0/divbuf_0/a_58590_n840# vdda1 1.09fF **FLOATING
C15460 pd_div_0/divbuf_0/a_58110_n840# vdda1 1.09fF **FLOATING
C15461 pd_div_0/divbuf_0/a_57630_n840# vdda1 1.09fF **FLOATING
C15462 pd_div_0/divbuf_0/a_57150_n840# vdda1 1.09fF **FLOATING
C15463 pd_div_0/divbuf_0/a_56670_n840# vdda1 1.09fF **FLOATING
C15464 pd_div_0/divbuf_0/a_56190_n840# vdda1 1.09fF **FLOATING
C15465 pd_div_0/divbuf_0/a_55710_n840# vdda1 1.09fF **FLOATING
C15466 pd_div_0/divbuf_0/a_55230_n840# vdda1 1.09fF **FLOATING
C15467 pd_div_0/divbuf_0/a_54750_n840# vdda1 1.09fF **FLOATING
C15468 pd_div_0/divbuf_0/a_54270_n840# vdda1 1.09fF **FLOATING
C15469 pd_div_0/divbuf_0/a_53790_n840# vdda1 1.09fF **FLOATING
C15470 pd_div_0/divbuf_0/a_53310_n840# vdda1 1.09fF **FLOATING
C15471 pd_div_0/divbuf_0/a_52830_n840# vdda1 1.09fF **FLOATING
C15472 pd_div_0/divbuf_0/a_52350_n840# vdda1 1.09fF **FLOATING
C15473 pd_div_0/divbuf_0/a_51870_n840# vdda1 1.09fF **FLOATING
C15474 pd_div_0/divbuf_0/a_51390_n840# vdda1 1.09fF **FLOATING
C15475 pd_div_0/divbuf_0/a_50910_n840# vdda1 1.09fF **FLOATING
C15476 pd_div_0/divbuf_0/a_50430_n840# vdda1 1.09fF **FLOATING
C15477 pd_div_0/divbuf_0/a_49950_n840# vdda1 1.09fF **FLOATING
C15478 pd_div_0/divbuf_0/a_49470_n840# vdda1 1.09fF **FLOATING
C15479 pd_div_0/divbuf_0/a_48990_n840# vdda1 1.09fF **FLOATING
C15480 pd_div_0/divbuf_0/a_48510_n840# vdda1 1.09fF **FLOATING
C15481 pd_div_0/divbuf_0/a_48030_n840# vdda1 1.09fF **FLOATING
C15482 pd_div_0/divbuf_0/a_47550_n840# vdda1 1.09fF **FLOATING
C15483 pd_div_0/divbuf_0/a_47070_n840# vdda1 1.09fF **FLOATING
C15484 pd_div_0/divbuf_0/a_46590_n840# vdda1 1.09fF **FLOATING
C15485 pd_div_0/divbuf_0/a_46110_n840# vdda1 1.09fF **FLOATING
C15486 pd_div_0/divbuf_0/a_45630_n840# vdda1 1.09fF **FLOATING
C15487 pd_div_0/divbuf_0/a_45150_n840# vdda1 1.09fF **FLOATING
C15488 pd_div_0/divbuf_0/a_44670_n840# vdda1 1.09fF **FLOATING
C15489 pd_div_0/divbuf_0/a_44190_n840# vdda1 1.09fF **FLOATING
C15490 pd_div_0/divbuf_0/a_43710_n840# vdda1 1.09fF **FLOATING
C15491 pd_div_0/divbuf_0/a_43230_n840# vdda1 1.09fF **FLOATING
C15492 pd_div_0/divbuf_0/a_42750_n840# vdda1 1.08fF **FLOATING
C15493 pd_div_0/divbuf_0/a_42270_n840# vdda1 1.08fF **FLOATING
C15494 pd_div_0/divbuf_0/a_41790_n840# vdda1 1.10fF **FLOATING
C15495 pd_div_0/divbuf_0/a_41310_n840# vdda1 1.09fF **FLOATING
C15496 pd_div_0/divbuf_0/a_40830_n840# vdda1 1.09fF **FLOATING
C15497 pd_div_0/divbuf_0/a_40350_n840# vdda1 1.09fF **FLOATING
C15498 pd_div_0/divbuf_0/a_39870_n840# vdda1 1.09fF **FLOATING
C15499 pd_div_0/divbuf_0/a_39390_n840# vdda1 1.09fF **FLOATING
C15500 pd_div_0/divbuf_0/a_38910_n840# vdda1 1.09fF **FLOATING
C15501 pd_div_0/divbuf_0/a_38430_n840# vdda1 1.09fF **FLOATING
C15502 pd_div_0/divbuf_0/a_37950_n840# vdda1 1.09fF **FLOATING
C15503 pd_div_0/divbuf_0/a_37470_n840# vdda1 1.09fF **FLOATING
C15504 pd_div_0/divbuf_0/a_36990_n840# vdda1 1.09fF **FLOATING
C15505 pd_div_0/divbuf_0/a_36510_n840# vdda1 1.09fF **FLOATING
C15506 pd_div_0/divbuf_0/a_36030_n840# vdda1 1.09fF **FLOATING
C15507 pd_div_0/divbuf_0/a_35550_n840# vdda1 1.09fF **FLOATING
C15508 pd_div_0/divbuf_0/a_35070_n840# vdda1 1.09fF **FLOATING
C15509 pd_div_0/divbuf_0/a_34590_n840# vdda1 1.09fF **FLOATING
C15510 pd_div_0/divbuf_0/a_34110_n840# vdda1 1.09fF **FLOATING
C15511 pd_div_0/divbuf_0/a_33630_n840# vdda1 1.09fF **FLOATING
C15512 pd_div_0/divbuf_0/a_33150_n840# vdda1 1.09fF **FLOATING
C15513 pd_div_0/divbuf_0/a_32670_n840# vdda1 1.09fF **FLOATING
C15514 pd_div_0/divbuf_0/a_32190_n840# vdda1 1.09fF **FLOATING
C15515 pd_div_0/divbuf_0/a_31710_n840# vdda1 1.11fF **FLOATING
C15516 pd_div_0/divbuf_0/a_31230_n840# vdda1 1.13fF **FLOATING
C15517 pd_div_0/divbuf_0/a_30750_n840# vdda1 1.09fF **FLOATING
C15518 pd_div_0/divbuf_0/a_30270_n840# vdda1 1.09fF **FLOATING
C15519 pd_div_0/divbuf_0/a_29790_n840# vdda1 1.09fF **FLOATING
C15520 pd_div_0/divbuf_0/a_29310_n840# vdda1 1.09fF **FLOATING
C15521 pd_div_0/divbuf_0/a_28830_n840# vdda1 1.09fF **FLOATING
C15522 pd_div_0/divbuf_0/a_28350_n840# vdda1 1.09fF **FLOATING
C15523 pd_div_0/divbuf_0/a_27870_n840# vdda1 1.08fF **FLOATING
C15524 pd_div_0/divbuf_0/a_27390_n840# vdda1 1.11fF **FLOATING
C15525 pd_div_0/divbuf_0/a_26910_n840# vdda1 1.10fF **FLOATING
C15526 pd_div_0/divbuf_0/a_26430_n840# vdda1 1.10fF **FLOATING
C15527 pd_div_0/divbuf_0/a_25950_n840# vdda1 1.10fF **FLOATING
C15528 pd_div_0/divbuf_0/a_25470_n840# vdda1 1.10fF **FLOATING
C15529 pd_div_0/divbuf_0/a_24990_n840# vdda1 1.10fF **FLOATING
C15530 pd_div_0/divbuf_0/a_24510_n840# vdda1 1.10fF **FLOATING
C15531 pd_div_0/divbuf_0/a_24030_n840# vdda1 1.09fF **FLOATING
C15532 pd_div_0/divbuf_0/a_23550_n840# vdda1 1.11fF **FLOATING
C15533 pd_div_0/divbuf_0/a_23070_n840# vdda1 1.10fF **FLOATING
C15534 pd_div_0/divbuf_0/a_22590_n840# vdda1 1.10fF **FLOATING
C15535 pd_div_0/divbuf_0/a_22110_n840# vdda1 1.10fF **FLOATING
C15536 pd_div_0/divbuf_0/a_21630_n840# vdda1 1.10fF **FLOATING
C15537 pd_div_0/divbuf_0/a_21150_n840# vdda1 1.10fF **FLOATING
C15538 pd_div_0/divbuf_0/a_20670_n840# vdda1 1.10fF **FLOATING
C15539 pd_div_0/divbuf_0/a_20190_n840# vdda1 1.09fF **FLOATING
C15540 pd_div_0/divbuf_0/a_19710_n840# vdda1 1.09fF **FLOATING
C15541 pd_div_0/divbuf_0/a_19230_n840# vdda1 1.09fF **FLOATING
C15542 pd_div_0/divbuf_0/a_18750_n840# vdda1 1.09fF **FLOATING
C15543 pd_div_0/divbuf_0/a_18270_n840# vdda1 1.08fF **FLOATING
C15544 pd_div_0/divbuf_0/a_17790_n840# vdda1 1.08fF **FLOATING
C15545 pd_div_0/divbuf_0/a_17310_n840# vdda1 1.07fF **FLOATING
C15546 pd_div_0/divbuf_0/a_16830_n840# vdda1 1.07fF **FLOATING
C15547 pd_div_0/divbuf_0/a_16350_n840# vdda1 1.07fF **FLOATING
C15548 pd_div_0/divbuf_0/a_15870_n840# vdda1 1.07fF **FLOATING
C15549 pd_div_0/divbuf_0/a_15390_n840# vdda1 1.08fF **FLOATING
C15550 pd_div_0/divbuf_0/a_14910_n840# vdda1 1.07fF **FLOATING
C15551 pd_div_0/divbuf_0/a_14430_n840# vdda1 1.07fF **FLOATING
C15552 pd_div_0/divbuf_0/a_13950_n840# vdda1 1.07fF **FLOATING
C15553 pd_div_0/divbuf_0/a_13470_n840# vdda1 1.07fF **FLOATING
C15554 pd_div_0/divbuf_0/a_12990_n840# vdda1 1.10fF **FLOATING
C15555 pd_div_0/divbuf_0/a_12510_n840# vdda1 1.08fF **FLOATING
C15556 pd_div_0/divbuf_0/a_12030_n840# vdda1 1.07fF **FLOATING
C15557 pd_div_0/divbuf_0/a_11550_n840# vdda1 1.07fF **FLOATING
C15558 pd_div_0/divbuf_0/a_11070_n840# vdda1 1.08fF **FLOATING
C15559 pd_div_0/divbuf_0/a_10590_n840# vdda1 1.10fF **FLOATING
C15560 pd_div_0/divbuf_0/a_10110_n840# vdda1 1.10fF **FLOATING
C15561 pd_div_0/divbuf_0/a_9630_n840# vdda1 1.10fF **FLOATING
C15562 pd_div_0/divbuf_0/a_9150_n840# vdda1 1.10fF **FLOATING
C15563 pd_div_0/divbuf_0/a_8670_n840# vdda1 1.10fF **FLOATING
C15564 pd_div_0/divbuf_0/a_8190_n840# vdda1 1.12fF **FLOATING
C15565 pd_div_0/divbuf_0/a_7710_n840# vdda1 1.10fF **FLOATING
C15566 pd_div_0/divbuf_0/a_7230_n840# vdda1 1.09fF **FLOATING
C15567 pd_div_0/divbuf_0/a_6750_n840# vdda1 1.09fF **FLOATING
C15568 pd_div_0/divbuf_0/a_6270_n840# vdda1 1.09fF **FLOATING
C15569 pd_div_0/divbuf_0/a_5790_n840# vdda1 1.09fF **FLOATING
C15570 pd_div_0/divbuf_0/a_5310_n840# vdda1 1.09fF **FLOATING
C15571 pd_div_0/divbuf_0/a_4830_n840# vdda1 1.09fF **FLOATING
C15572 pd_div_0/divbuf_0/a_4350_n840# vdda1 1.09fF **FLOATING
C15573 pd_div_0/divbuf_0/a_3870_n840# vdda1 1.09fF **FLOATING
C15574 pd_div_0/divbuf_0/a_3390_n840# vdda1 1.09fF **FLOATING
C15575 pd_div_0/divbuf_0/a_2910_n840# vdda1 1.10fF **FLOATING
C15576 pd_div_0/divbuf_0/a_2430_n840# vdda1 1.10fF **FLOATING
C15577 pd_div_0/divbuf_0/a_1950_n840# vdda1 1.10fF **FLOATING
C15578 pd_div_0/divbuf_0/a_1470_n840# vdda1 1.10fF **FLOATING
C15579 pd_div_0/divbuf_0/a_990_n840# vdda1 1.08fF **FLOATING
C15580 pd_div_0/divbuf_0/a_510_n840# vdda1 1.07fF **FLOATING
C15581 pd_div_0/divbuf_0/a_60480_n1600# vdda1 1.48fF **FLOATING
C15582 pd_div_0/divbuf_0/a_60000_n1600# vdda1 1.48fF **FLOATING
C15583 pd_div_0/divbuf_0/a_59520_n1600# vdda1 1.48fF **FLOATING
C15584 pd_div_0/divbuf_0/a_59040_n1600# vdda1 1.48fF **FLOATING
C15585 pd_div_0/divbuf_0/a_58560_n1600# vdda1 1.48fF **FLOATING
C15586 pd_div_0/divbuf_0/a_58080_n1600# vdda1 1.48fF **FLOATING
C15587 pd_div_0/divbuf_0/a_57600_n1600# vdda1 1.48fF **FLOATING
C15588 pd_div_0/divbuf_0/a_57120_n1600# vdda1 1.48fF **FLOATING
C15589 pd_div_0/divbuf_0/a_56640_n1600# vdda1 1.48fF **FLOATING
C15590 pd_div_0/divbuf_0/a_56160_n1600# vdda1 1.48fF **FLOATING
C15591 pd_div_0/divbuf_0/a_55680_n1600# vdda1 1.48fF **FLOATING
C15592 pd_div_0/divbuf_0/a_55200_n1600# vdda1 1.48fF **FLOATING
C15593 pd_div_0/divbuf_0/a_54720_n1600# vdda1 1.48fF **FLOATING
C15594 pd_div_0/divbuf_0/a_54240_n1600# vdda1 1.48fF **FLOATING
C15595 pd_div_0/divbuf_0/a_53760_n1600# vdda1 1.48fF **FLOATING
C15596 pd_div_0/divbuf_0/a_53280_n1600# vdda1 1.48fF **FLOATING
C15597 pd_div_0/divbuf_0/a_52800_n1600# vdda1 1.48fF **FLOATING
C15598 pd_div_0/divbuf_0/a_52320_n1600# vdda1 1.48fF **FLOATING
C15599 pd_div_0/divbuf_0/a_51840_n1600# vdda1 1.48fF **FLOATING
C15600 pd_div_0/divbuf_0/a_51360_n1600# vdda1 1.48fF **FLOATING
C15601 pd_div_0/divbuf_0/a_50880_n1600# vdda1 1.48fF **FLOATING
C15602 pd_div_0/divbuf_0/a_50400_n1600# vdda1 1.48fF **FLOATING
C15603 pd_div_0/divbuf_0/a_49920_n1600# vdda1 1.48fF **FLOATING
C15604 pd_div_0/divbuf_0/a_49440_n1600# vdda1 1.48fF **FLOATING
C15605 pd_div_0/divbuf_0/a_48960_n1600# vdda1 1.48fF **FLOATING
C15606 pd_div_0/divbuf_0/a_48480_n1600# vdda1 1.48fF **FLOATING
C15607 pd_div_0/divbuf_0/a_48000_n1600# vdda1 1.48fF **FLOATING
C15608 pd_div_0/divbuf_0/a_47520_n1600# vdda1 1.48fF **FLOATING
C15609 pd_div_0/divbuf_0/a_47040_n1600# vdda1 1.48fF **FLOATING
C15610 pd_div_0/divbuf_0/a_46560_n1600# vdda1 1.48fF **FLOATING
C15611 pd_div_0/divbuf_0/a_46080_n1600# vdda1 1.48fF **FLOATING
C15612 pd_div_0/divbuf_0/a_45600_n1600# vdda1 1.48fF **FLOATING
C15613 pd_div_0/divbuf_0/a_45120_n1600# vdda1 1.48fF **FLOATING
C15614 pd_div_0/divbuf_0/a_44640_n1600# vdda1 1.48fF **FLOATING
C15615 pd_div_0/divbuf_0/a_44160_n1600# vdda1 1.48fF **FLOATING
C15616 pd_div_0/divbuf_0/a_43680_n1600# vdda1 1.48fF **FLOATING
C15617 pd_div_0/divbuf_0/a_43200_n1600# vdda1 1.48fF **FLOATING
C15618 pd_div_0/divbuf_0/a_42720_n1600# vdda1 1.48fF **FLOATING
C15619 pd_div_0/divbuf_0/a_42240_n1600# vdda1 1.48fF **FLOATING
C15620 pd_div_0/divbuf_0/a_41760_n1600# vdda1 1.48fF **FLOATING
C15621 pd_div_0/divbuf_0/a_41280_n1600# vdda1 1.48fF **FLOATING
C15622 pd_div_0/divbuf_0/a_40800_n1600# vdda1 1.48fF **FLOATING
C15623 pd_div_0/divbuf_0/a_40320_n1600# vdda1 1.48fF **FLOATING
C15624 pd_div_0/divbuf_0/a_39840_n1600# vdda1 1.48fF **FLOATING
C15625 pd_div_0/divbuf_0/a_39360_n1600# vdda1 1.48fF **FLOATING
C15626 pd_div_0/divbuf_0/a_38880_n1600# vdda1 1.48fF **FLOATING
C15627 pd_div_0/divbuf_0/a_38400_n1600# vdda1 1.48fF **FLOATING
C15628 pd_div_0/divbuf_0/a_37920_n1600# vdda1 1.48fF **FLOATING
C15629 pd_div_0/divbuf_0/a_37440_n1600# vdda1 1.48fF **FLOATING
C15630 pd_div_0/divbuf_0/a_36960_n1600# vdda1 1.48fF **FLOATING
C15631 pd_div_0/divbuf_0/a_36480_n1600# vdda1 1.48fF **FLOATING
C15632 pd_div_0/divbuf_0/a_36000_n1600# vdda1 1.48fF **FLOATING
C15633 pd_div_0/divbuf_0/a_35520_n1600# vdda1 1.48fF **FLOATING
C15634 pd_div_0/divbuf_0/a_35040_n1600# vdda1 1.48fF **FLOATING
C15635 pd_div_0/divbuf_0/a_34560_n1600# vdda1 1.48fF **FLOATING
C15636 pd_div_0/divbuf_0/a_34080_n1600# vdda1 1.48fF **FLOATING
C15637 pd_div_0/divbuf_0/a_33600_n1600# vdda1 1.48fF **FLOATING
C15638 pd_div_0/divbuf_0/a_33120_n1600# vdda1 1.48fF **FLOATING
C15639 pd_div_0/divbuf_0/a_32640_n1600# vdda1 1.48fF **FLOATING
C15640 pd_div_0/divbuf_0/a_32160_n1600# vdda1 1.48fF **FLOATING
C15641 pd_div_0/divbuf_0/a_31680_n1600# vdda1 1.48fF **FLOATING
C15642 pd_div_0/divbuf_0/a_31200_n1600# vdda1 1.48fF **FLOATING
C15643 pd_div_0/divbuf_0/a_30720_n1600# vdda1 1.48fF **FLOATING
C15644 pd_div_0/divbuf_0/a_30240_n1600# vdda1 1.48fF **FLOATING
C15645 pd_div_0/divbuf_0/a_29760_n1600# vdda1 1.48fF **FLOATING
C15646 pd_div_0/divbuf_0/a_29280_n1600# vdda1 1.48fF **FLOATING
C15647 pd_div_0/divbuf_0/a_28800_n1600# vdda1 1.48fF **FLOATING
C15648 pd_div_0/divbuf_0/a_28320_n1600# vdda1 1.48fF **FLOATING
C15649 pd_div_0/divbuf_0/a_27840_n1600# vdda1 1.48fF **FLOATING
C15650 pd_div_0/divbuf_0/a_27360_n1600# vdda1 1.48fF **FLOATING
C15651 pd_div_0/divbuf_0/a_26880_n1600# vdda1 1.48fF **FLOATING
C15652 pd_div_0/divbuf_0/a_26400_n1600# vdda1 1.48fF **FLOATING
C15653 pd_div_0/divbuf_0/a_25920_n1600# vdda1 1.48fF **FLOATING
C15654 pd_div_0/divbuf_0/a_25440_n1600# vdda1 1.48fF **FLOATING
C15655 pd_div_0/divbuf_0/a_24960_n1600# vdda1 1.48fF **FLOATING
C15656 pd_div_0/divbuf_0/a_24480_n1600# vdda1 1.48fF **FLOATING
C15657 pd_div_0/divbuf_0/a_24000_n1600# vdda1 1.48fF **FLOATING
C15658 pd_div_0/divbuf_0/a_23520_n1600# vdda1 1.48fF **FLOATING
C15659 pd_div_0/divbuf_0/a_23040_n1600# vdda1 1.48fF **FLOATING
C15660 pd_div_0/divbuf_0/a_22560_n1600# vdda1 1.48fF **FLOATING
C15661 pd_div_0/divbuf_0/a_22080_n1600# vdda1 1.48fF **FLOATING
C15662 pd_div_0/divbuf_0/a_21600_n1600# vdda1 1.48fF **FLOATING
C15663 pd_div_0/divbuf_0/a_21120_n1600# vdda1 1.48fF **FLOATING
C15664 pd_div_0/divbuf_0/a_20640_n1600# vdda1 1.48fF **FLOATING
C15665 pd_div_0/divbuf_0/a_20160_n1600# vdda1 1.48fF **FLOATING
C15666 pd_div_0/divbuf_0/a_19680_n1600# vdda1 1.48fF **FLOATING
C15667 pd_div_0/divbuf_0/a_19200_n1600# vdda1 1.48fF **FLOATING
C15668 pd_div_0/divbuf_0/a_18720_n1600# vdda1 1.48fF **FLOATING
C15669 pd_div_0/divbuf_0/a_18240_n1600# vdda1 1.48fF **FLOATING
C15670 pd_div_0/divbuf_0/a_17760_n1600# vdda1 1.48fF **FLOATING
C15671 pd_div_0/divbuf_0/a_17280_n1600# vdda1 1.48fF **FLOATING
C15672 pd_div_0/divbuf_0/a_16800_n1600# vdda1 1.48fF **FLOATING
C15673 pd_div_0/divbuf_0/a_16320_n1600# vdda1 1.48fF **FLOATING
C15674 pd_div_0/divbuf_0/a_15840_n1600# vdda1 1.48fF **FLOATING
C15675 pd_div_0/divbuf_0/a_15360_n1600# vdda1 1.48fF **FLOATING
C15676 pd_div_0/divbuf_0/a_14880_n1600# vdda1 1.48fF **FLOATING
C15677 pd_div_0/divbuf_0/a_14400_n1600# vdda1 1.48fF **FLOATING
C15678 pd_div_0/divbuf_0/a_13920_n1600# vdda1 1.48fF **FLOATING
C15679 pd_div_0/divbuf_0/a_13440_n1600# vdda1 1.48fF **FLOATING
C15680 pd_div_0/divbuf_0/a_12960_n1600# vdda1 1.48fF **FLOATING
C15681 pd_div_0/divbuf_0/a_12480_n1600# vdda1 1.48fF **FLOATING
C15682 pd_div_0/divbuf_0/a_12000_n1600# vdda1 1.48fF **FLOATING
C15683 pd_div_0/divbuf_0/a_11520_n1600# vdda1 1.48fF **FLOATING
C15684 pd_div_0/divbuf_0/a_11040_n1600# vdda1 1.48fF **FLOATING
C15685 pd_div_0/divbuf_0/a_10560_n1600# vdda1 1.48fF **FLOATING
C15686 pd_div_0/divbuf_0/a_10080_n1600# vdda1 1.48fF **FLOATING
C15687 pd_div_0/divbuf_0/a_9600_n1600# vdda1 1.48fF **FLOATING
C15688 pd_div_0/divbuf_0/a_9120_n1600# vdda1 1.48fF **FLOATING
C15689 pd_div_0/divbuf_0/a_8640_n1600# vdda1 1.48fF **FLOATING
C15690 pd_div_0/divbuf_0/a_8160_n1600# vdda1 1.48fF **FLOATING
C15691 pd_div_0/divbuf_0/a_7680_n1600# vdda1 1.48fF **FLOATING
C15692 pd_div_0/divbuf_0/a_7200_n1600# vdda1 1.48fF **FLOATING
C15693 pd_div_0/divbuf_0/a_6720_n1600# vdda1 1.48fF **FLOATING
C15694 pd_div_0/divbuf_0/a_6240_n1600# vdda1 1.48fF **FLOATING
C15695 pd_div_0/divbuf_0/a_5760_n1600# vdda1 1.48fF **FLOATING
C15696 pd_div_0/divbuf_0/a_5280_n1600# vdda1 1.48fF **FLOATING
C15697 pd_div_0/divbuf_0/a_4800_n1600# vdda1 1.48fF **FLOATING
C15698 pd_div_0/divbuf_0/a_4320_n1600# vdda1 1.48fF **FLOATING
C15699 pd_div_0/divbuf_0/a_3840_n1600# vdda1 1.48fF **FLOATING
C15700 pd_div_0/divbuf_0/a_3360_n1600# vdda1 1.48fF **FLOATING
C15701 pd_div_0/divbuf_0/a_2880_n1600# vdda1 1.48fF **FLOATING
C15702 pd_div_0/divbuf_0/a_2400_n1600# vdda1 1.48fF **FLOATING
C15703 pd_div_0/divbuf_0/a_1920_n1600# vdda1 1.48fF **FLOATING
C15704 pd_div_0/divbuf_0/a_1440_n1600# vdda1 1.48fF **FLOATING
C15705 pd_div_0/divbuf_0/a_960_n1600# vdda1 1.48fF **FLOATING
C15706 pd_div_0/divbuf_0/a_480_n1600# vdda1 1.48fF **FLOATING
C15707 pd_div_0/divbuf_0/a_0_n1600# vdda1 1.48fF **FLOATING
C15708 pd_div_0/divbuf_0/a_41382_n240# vdda1 0.90fF **FLOATING
C15709 pd_div_0/divbuf_0/a_40902_n240# vdda1 0.90fF **FLOATING
C15710 pd_div_0/divbuf_0/a_40412_n240# vdda1 0.90fF **FLOATING
C15711 pd_div_0/divbuf_0/a_39932_n240# vdda1 0.90fF **FLOATING
C15712 pd_div_0/divbuf_0/a_39442_n240# vdda1 0.90fF **FLOATING
C15713 pd_div_0/divbuf_0/a_38962_n240# vdda1 0.91fF **FLOATING
C15714 pd_div_0/divbuf_0/a_38472_n240# vdda1 0.90fF **FLOATING
C15715 pd_div_0/divbuf_0/a_37992_n240# vdda1 0.90fF **FLOATING
C15716 pd_div_0/divbuf_0/a_37502_n240# vdda1 0.90fF **FLOATING
C15717 pd_div_0/divbuf_0/a_37022_n240# vdda1 0.90fF **FLOATING
C15718 pd_div_0/divbuf_0/a_36532_n240# vdda1 0.90fF **FLOATING
C15719 pd_div_0/divbuf_0/a_36052_n240# vdda1 0.90fF **FLOATING
C15720 pd_div_0/divbuf_0/a_35562_n240# vdda1 0.90fF **FLOATING
C15721 pd_div_0/divbuf_0/a_35082_n240# vdda1 0.91fF **FLOATING
C15722 pd_div_0/divbuf_0/a_34592_n240# vdda1 0.90fF **FLOATING
C15723 pd_div_0/divbuf_0/a_34112_n240# vdda1 0.90fF **FLOATING
C15724 pd_div_0/divbuf_0/a_33622_n240# vdda1 0.90fF **FLOATING
C15725 pd_div_0/divbuf_0/a_33142_n240# vdda1 0.90fF **FLOATING
C15726 pd_div_0/divbuf_0/a_32652_n240# vdda1 0.90fF **FLOATING
C15727 pd_div_0/divbuf_0/a_32172_n240# vdda1 0.90fF **FLOATING
C15728 pd_div_0/divbuf_0/a_31682_n240# vdda1 0.89fF **FLOATING
C15729 pd_div_0/divbuf_0/a_31202_n240# vdda1 0.92fF **FLOATING
C15730 pd_div_0/divbuf_0/a_30712_n240# vdda1 0.90fF **FLOATING
C15731 pd_div_0/divbuf_0/a_30232_n240# vdda1 0.90fF **FLOATING
C15732 pd_div_0/divbuf_0/a_29742_n240# vdda1 0.90fF **FLOATING
C15733 pd_div_0/divbuf_0/a_29262_n240# vdda1 0.90fF **FLOATING
C15734 pd_div_0/divbuf_0/a_28772_n240# vdda1 0.90fF **FLOATING
C15735 pd_div_0/divbuf_0/a_28292_n240# vdda1 0.90fF **FLOATING
C15736 pd_div_0/divbuf_0/a_27802_n240# vdda1 0.89fF **FLOATING
C15737 pd_div_0/divbuf_0/a_27322_n240# vdda1 0.95fF **FLOATING
C15738 pd_div_0/divbuf_0/a_26832_n240# vdda1 0.91fF **FLOATING
C15739 pd_div_0/divbuf_0/a_26352_n240# vdda1 0.91fF **FLOATING
C15740 pd_div_0/divbuf_0/a_25862_n240# vdda1 0.91fF **FLOATING
C15741 pd_div_0/divbuf_0/a_25382_n240# vdda1 0.91fF **FLOATING
C15742 pd_div_0/divbuf_0/a_24892_n240# vdda1 0.91fF **FLOATING
C15743 pd_div_0/divbuf_0/a_24412_n240# vdda1 0.91fF **FLOATING
C15744 pd_div_0/divbuf_0/a_23922_n240# vdda1 0.92fF **FLOATING
C15745 pd_div_0/divbuf_0/a_23442_n240# vdda1 0.94fF **FLOATING
C15746 pd_div_0/divbuf_0/a_22952_n240# vdda1 0.91fF **FLOATING
C15747 pd_div_0/divbuf_0/a_22472_n240# vdda1 0.91fF **FLOATING
C15748 pd_div_0/divbuf_0/a_21982_n240# vdda1 0.91fF **FLOATING
C15749 pd_div_0/divbuf_0/a_21502_n240# vdda1 0.91fF **FLOATING
C15750 pd_div_0/divbuf_0/a_21012_n240# vdda1 0.91fF **FLOATING
C15751 pd_div_0/divbuf_0/a_20532_n240# vdda1 0.91fF **FLOATING
C15752 pd_div_0/divbuf_0/a_20042_n240# vdda1 0.90fF **FLOATING
C15753 pd_div_0/divbuf_0/a_19562_n240# vdda1 0.90fF **FLOATING
C15754 pd_div_0/divbuf_0/a_19072_n240# vdda1 0.90fF **FLOATING
C15755 pd_div_0/divbuf_0/a_18582_n240# vdda1 0.89fF **FLOATING
C15756 pd_div_0/divbuf_0/a_18092_n240# vdda1 0.89fF **FLOATING
C15757 pd_div_0/divbuf_0/a_17612_n240# vdda1 0.89fF **FLOATING
C15758 pd_div_0/divbuf_0/a_17122_n240# vdda1 0.88fF **FLOATING
C15759 pd_div_0/divbuf_0/a_16642_n240# vdda1 0.88fF **FLOATING
C15760 pd_div_0/divbuf_0/a_16152_n240# vdda1 0.88fF **FLOATING
C15761 pd_div_0/divbuf_0/a_15672_n240# vdda1 0.90fF **FLOATING
C15762 pd_div_0/divbuf_0/a_15182_n240# vdda1 0.88fF **FLOATING
C15763 pd_div_0/divbuf_0/a_14702_n240# vdda1 0.88fF **FLOATING
C15764 pd_div_0/divbuf_0/a_14222_n240# vdda1 0.88fF **FLOATING
C15765 pd_div_0/divbuf_0/a_13742_n240# vdda1 0.88fF **FLOATING
C15766 pd_div_0/divbuf_0/a_13252_n240# vdda1 0.88fF **FLOATING
C15767 pd_div_0/divbuf_0/a_12772_n240# vdda1 0.88fF **FLOATING
C15768 pd_div_0/divbuf_0/a_12282_n240# vdda1 0.88fF **FLOATING
C15769 pd_div_0/divbuf_0/a_11802_n240# vdda1 0.88fF **FLOATING
C15770 pd_div_0/divbuf_0/a_11312_n240# vdda1 0.89fF **FLOATING
C15771 pd_div_0/divbuf_0/a_10212_n240# vdda1 0.91fF **FLOATING
C15772 pd_div_0/divbuf_0/a_9732_n240# vdda1 0.91fF **FLOATING
C15773 pd_div_0/divbuf_0/a_9242_n240# vdda1 0.91fF **FLOATING
C15774 pd_div_0/divbuf_0/a_8762_n240# vdda1 0.91fF **FLOATING
C15775 pd_div_0/divbuf_0/a_8272_n240# vdda1 0.91fF **FLOATING
C15776 pd_div_0/divbuf_0/a_7792_n240# vdda1 0.92fF **FLOATING
C15777 pd_div_0/divbuf_0/a_7302_n240# vdda1 0.90fF **FLOATING
C15778 pd_div_0/divbuf_0/a_6822_n240# vdda1 0.90fF **FLOATING
C15779 pd_div_0/divbuf_0/a_6332_n240# vdda1 0.90fF **FLOATING
C15780 pd_div_0/divbuf_0/a_5852_n240# vdda1 0.90fF **FLOATING
C15781 pd_div_0/divbuf_0/a_5362_n240# vdda1 0.90fF **FLOATING
C15782 pd_div_0/divbuf_0/a_4882_n240# vdda1 0.90fF **FLOATING
C15783 pd_div_0/divbuf_0/a_4392_n240# vdda1 0.90fF **FLOATING
C15784 pd_div_0/divbuf_0/a_3912_n240# vdda1 0.90fF **FLOATING
C15785 pd_div_0/divbuf_0/a_3422_n240# vdda1 0.90fF **FLOATING
C15786 pd_div_0/divbuf_0/a_2322_n240# vdda1 0.91fF **FLOATING
C15787 pd_div_0/divbuf_0/a_1842_n240# vdda1 0.91fF **FLOATING
C15788 pd_div_0/divbuf_0/a_1352_n240# vdda1 0.91fF **FLOATING
C15789 pd_div_0/divbuf_0/a_41382_170# vdda1 1.07fF **FLOATING
C15790 pd_div_0/divbuf_0/a_40902_170# vdda1 1.09fF **FLOATING
C15791 pd_div_0/divbuf_0/a_40412_170# vdda1 1.09fF **FLOATING
C15792 pd_div_0/divbuf_0/a_39932_170# vdda1 1.09fF **FLOATING
C15793 pd_div_0/divbuf_0/a_39442_170# vdda1 1.09fF **FLOATING
C15794 pd_div_0/divbuf_0/a_38962_170# vdda1 1.07fF **FLOATING
C15795 pd_div_0/divbuf_0/a_38472_170# vdda1 1.09fF **FLOATING
C15796 pd_div_0/divbuf_0/a_37992_170# vdda1 1.09fF **FLOATING
C15797 pd_div_0/divbuf_0/a_37502_170# vdda1 1.09fF **FLOATING
C15798 pd_div_0/divbuf_0/a_37022_170# vdda1 1.09fF **FLOATING
C15799 pd_div_0/divbuf_0/a_36532_170# vdda1 1.09fF **FLOATING
C15800 pd_div_0/divbuf_0/a_36052_170# vdda1 1.09fF **FLOATING
C15801 pd_div_0/divbuf_0/a_35562_170# vdda1 1.09fF **FLOATING
C15802 pd_div_0/divbuf_0/a_35082_170# vdda1 1.09fF **FLOATING
C15803 pd_div_0/divbuf_0/a_34592_170# vdda1 1.07fF **FLOATING
C15804 pd_div_0/divbuf_0/a_34112_170# vdda1 1.09fF **FLOATING
C15805 pd_div_0/divbuf_0/a_33622_170# vdda1 1.09fF **FLOATING
C15806 pd_div_0/divbuf_0/a_33142_170# vdda1 1.09fF **FLOATING
C15807 pd_div_0/divbuf_0/a_32652_170# vdda1 1.09fF **FLOATING
C15808 pd_div_0/divbuf_0/a_32172_170# vdda1 1.09fF **FLOATING
C15809 pd_div_0/divbuf_0/a_31682_170# vdda1 1.09fF **FLOATING
C15810 pd_div_0/divbuf_0/a_31202_170# vdda1 1.09fF **FLOATING
C15811 pd_div_0/divbuf_0/a_30712_170# vdda1 1.09fF **FLOATING
C15812 pd_div_0/divbuf_0/a_30232_170# vdda1 1.07fF **FLOATING
C15813 pd_div_0/divbuf_0/a_29742_170# vdda1 1.09fF **FLOATING
C15814 pd_div_0/divbuf_0/a_29262_170# vdda1 1.09fF **FLOATING
C15815 pd_div_0/divbuf_0/a_28772_170# vdda1 1.09fF **FLOATING
C15816 pd_div_0/divbuf_0/a_28292_170# vdda1 1.09fF **FLOATING
C15817 pd_div_0/divbuf_0/a_27802_170# vdda1 1.09fF **FLOATING
C15818 pd_div_0/divbuf_0/a_27322_170# vdda1 1.09fF **FLOATING
C15819 pd_div_0/divbuf_0/a_26832_170# vdda1 1.09fF **FLOATING
C15820 pd_div_0/divbuf_0/a_26352_170# vdda1 1.09fF **FLOATING
C15821 pd_div_0/divbuf_0/a_25862_170# vdda1 1.07fF **FLOATING
C15822 pd_div_0/divbuf_0/a_25382_170# vdda1 1.09fF **FLOATING
C15823 pd_div_0/divbuf_0/a_24892_170# vdda1 1.09fF **FLOATING
C15824 pd_div_0/divbuf_0/a_24412_170# vdda1 1.09fF **FLOATING
C15825 pd_div_0/divbuf_0/a_23922_170# vdda1 1.09fF **FLOATING
C15826 pd_div_0/divbuf_0/a_23442_170# vdda1 1.09fF **FLOATING
C15827 pd_div_0/divbuf_0/a_22952_170# vdda1 1.09fF **FLOATING
C15828 pd_div_0/divbuf_0/a_22472_170# vdda1 1.07fF **FLOATING
C15829 pd_div_0/divbuf_0/a_21982_170# vdda1 1.09fF **FLOATING
C15830 pd_div_0/divbuf_0/a_21502_170# vdda1 1.09fF **FLOATING
C15831 pd_div_0/divbuf_0/a_21012_170# vdda1 1.09fF **FLOATING
C15832 pd_div_0/divbuf_0/a_20532_170# vdda1 1.09fF **FLOATING
C15833 pd_div_0/divbuf_0/a_20042_170# vdda1 1.09fF **FLOATING
C15834 pd_div_0/divbuf_0/a_19562_170# vdda1 1.09fF **FLOATING
C15835 pd_div_0/divbuf_0/a_19072_170# vdda1 1.09fF **FLOATING
C15836 pd_div_0/divbuf_0/a_18582_170# vdda1 1.07fF **FLOATING
C15837 pd_div_0/divbuf_0/a_18092_170# vdda1 1.09fF **FLOATING
C15838 pd_div_0/divbuf_0/a_17612_170# vdda1 1.09fF **FLOATING
C15839 pd_div_0/divbuf_0/a_17122_170# vdda1 1.09fF **FLOATING
C15840 pd_div_0/divbuf_0/a_16642_170# vdda1 1.09fF **FLOATING
C15841 pd_div_0/divbuf_0/a_16152_170# vdda1 1.09fF **FLOATING
C15842 pd_div_0/divbuf_0/a_15672_170# vdda1 1.09fF **FLOATING
C15843 pd_div_0/divbuf_0/a_15182_170# vdda1 1.09fF **FLOATING
C15844 pd_div_0/divbuf_0/a_14702_170# vdda1 1.10fF **FLOATING
C15845 pd_div_0/divbuf_0/a_14222_170# vdda1 1.10fF **FLOATING
C15846 pd_div_0/divbuf_0/a_13742_170# vdda1 1.09fF **FLOATING
C15847 pd_div_0/divbuf_0/a_13252_170# vdda1 1.09fF **FLOATING
C15848 pd_div_0/divbuf_0/a_12772_170# vdda1 1.07fF **FLOATING
C15849 pd_div_0/divbuf_0/a_12282_170# vdda1 1.09fF **FLOATING
C15850 pd_div_0/divbuf_0/a_11802_170# vdda1 1.09fF **FLOATING
C15851 pd_div_0/divbuf_0/a_11312_170# vdda1 1.10fF **FLOATING
C15852 pd_div_0/divbuf_0/a_10212_170# vdda1 1.09fF **FLOATING
C15853 pd_div_0/divbuf_0/a_9732_170# vdda1 1.09fF **FLOATING
C15854 pd_div_0/divbuf_0/a_9242_170# vdda1 1.09fF **FLOATING
C15855 pd_div_0/divbuf_0/a_8762_170# vdda1 1.09fF **FLOATING
C15856 pd_div_0/divbuf_0/a_8272_170# vdda1 1.07fF **FLOATING
C15857 pd_div_0/divbuf_0/a_7792_170# vdda1 1.09fF **FLOATING
C15858 pd_div_0/divbuf_0/a_7302_170# vdda1 1.09fF **FLOATING
C15859 pd_div_0/divbuf_0/a_6822_170# vdda1 1.09fF **FLOATING
C15860 pd_div_0/divbuf_0/a_6332_170# vdda1 1.09fF **FLOATING
C15861 pd_div_0/divbuf_0/a_5852_170# vdda1 1.09fF **FLOATING
C15862 pd_div_0/divbuf_0/a_5362_170# vdda1 1.09fF **FLOATING
C15863 pd_div_0/divbuf_0/a_4882_170# vdda1 1.09fF **FLOATING
C15864 pd_div_0/divbuf_0/a_4392_170# vdda1 1.07fF **FLOATING
C15865 pd_div_0/divbuf_0/a_3912_170# vdda1 1.09fF **FLOATING
C15866 pd_div_0/divbuf_0/a_3422_170# vdda1 1.10fF **FLOATING
C15867 pd_div_0/divbuf_0/a_2322_170# vdda1 1.09fF **FLOATING
C15868 pd_div_0/divbuf_0/a_1842_170# vdda1 1.09fF **FLOATING
C15869 pd_div_0/divbuf_0/a_1352_170# vdda1 1.10fF **FLOATING
C15870 pd_div_0/divbuf_0/a_492_n240# vdda1 2.46fF **FLOATING
C15871 pd_div_0/pd_0/and_pd_0/Z1 vdda1 0.39fF
C15872 pd_div_0/pd_0/and_pd_0/Out1 vdda1 2.22fF
C15873 pd_div_0/pd_0/tspc_r_1/z5 vdda1 1.10fF
C15874 pd_div_0/pd_0/tspc_r_1/Z4 vdda1 1.07fF
C15875 pd_div_0/pd_0/tspc_r_1/Qbar vdda1 0.88fF
C15876 pd_div_0/pd_0/tspc_r_1/Z2 vdda1 1.22fF
C15877 pd_div_0/pd_0/tspc_r_1/Z1 vdda1 0.67fF
C15878 pd_div_0/pd_0/UP vdda1 2.30fF
C15879 pd_div_0/pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C15880 pd_div_0/pd_0/tspc_r_1/Z3 vdda1 2.12fF
C15881 pd_div_0/pd_0/REF vdda1 1.86fF
C15882 pd_div_0/pd_0/tspc_r_0/z5 vdda1 1.10fF
C15883 pd_div_0/pd_0/tspc_r_0/Z4 vdda1 1.07fF
C15884 pd_div_0/pd_0/R vdda1 3.05fF
C15885 pd_div_0/pd_0/tspc_r_0/Qbar vdda1 0.79fF
C15886 pd_div_0/pd_0/tspc_r_0/Z2 vdda1 1.22fF
C15887 pd_div_0/pd_0/tspc_r_0/Z1 vdda1 0.67fF
C15888 pd_div_0/pd_0/DOWN vdda1 3.17fF
C15889 pd_div_0/pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C15890 pd_div_0/pd_0/tspc_r_0/Z3 vdda1 2.12fF
C15891 pd_div_0/div vdda1 8.07fF
C15892 divbuf_0/OUT vdda1 3.28fF
C15893 divbuf_0/OUT5 vdda1 16.40fF
C15894 divbuf_0/OUT4 vdda1 100.06fF
C15895 divbuf_0/OUT3 vdda1 27.01fF
C15896 divbuf_0/OUT2 vdda1 8.71fF
C15897 divbuf_0/IN vdda1 0.89fF
C15898 divbuf_0/a_60990_n1540# vdda1 1.57fF **FLOATING
C15899 divbuf_0/a_60510_n1540# vdda1 1.62fF **FLOATING
C15900 divbuf_0/a_60030_n1540# vdda1 1.62fF **FLOATING
C15901 divbuf_0/a_59550_n1540# vdda1 1.62fF **FLOATING
C15902 divbuf_0/a_59070_n1540# vdda1 1.62fF **FLOATING
C15903 divbuf_0/a_58590_n1540# vdda1 1.62fF **FLOATING
C15904 divbuf_0/a_58110_n1540# vdda1 1.62fF **FLOATING
C15905 divbuf_0/a_57630_n1540# vdda1 1.62fF **FLOATING
C15906 divbuf_0/a_57150_n1540# vdda1 1.62fF **FLOATING
C15907 divbuf_0/a_56670_n1540# vdda1 1.62fF **FLOATING
C15908 divbuf_0/a_56190_n1540# vdda1 1.62fF **FLOATING
C15909 divbuf_0/a_55710_n1540# vdda1 1.62fF **FLOATING
C15910 divbuf_0/a_55230_n1540# vdda1 1.62fF **FLOATING
C15911 divbuf_0/a_54750_n1540# vdda1 1.62fF **FLOATING
C15912 divbuf_0/a_54270_n1540# vdda1 1.62fF **FLOATING
C15913 divbuf_0/a_53790_n1540# vdda1 1.62fF **FLOATING
C15914 divbuf_0/a_53310_n1540# vdda1 1.62fF **FLOATING
C15915 divbuf_0/a_52830_n1540# vdda1 1.62fF **FLOATING
C15916 divbuf_0/a_52350_n1540# vdda1 1.62fF **FLOATING
C15917 divbuf_0/a_51870_n1540# vdda1 1.62fF **FLOATING
C15918 divbuf_0/a_51390_n1540# vdda1 1.62fF **FLOATING
C15919 divbuf_0/a_50910_n1540# vdda1 1.62fF **FLOATING
C15920 divbuf_0/a_50430_n1540# vdda1 1.62fF **FLOATING
C15921 divbuf_0/a_49950_n1540# vdda1 1.62fF **FLOATING
C15922 divbuf_0/a_49470_n1540# vdda1 1.62fF **FLOATING
C15923 divbuf_0/a_48990_n1540# vdda1 1.62fF **FLOATING
C15924 divbuf_0/a_48510_n1540# vdda1 1.62fF **FLOATING
C15925 divbuf_0/a_48030_n1540# vdda1 1.62fF **FLOATING
C15926 divbuf_0/a_47550_n1540# vdda1 1.62fF **FLOATING
C15927 divbuf_0/a_47070_n1540# vdda1 1.62fF **FLOATING
C15928 divbuf_0/a_46590_n1540# vdda1 1.62fF **FLOATING
C15929 divbuf_0/a_46110_n1540# vdda1 1.62fF **FLOATING
C15930 divbuf_0/a_45630_n1540# vdda1 1.62fF **FLOATING
C15931 divbuf_0/a_45150_n1540# vdda1 1.62fF **FLOATING
C15932 divbuf_0/a_44670_n1540# vdda1 1.62fF **FLOATING
C15933 divbuf_0/a_44190_n1540# vdda1 1.62fF **FLOATING
C15934 divbuf_0/a_43710_n1540# vdda1 1.62fF **FLOATING
C15935 divbuf_0/a_43230_n1540# vdda1 1.62fF **FLOATING
C15936 divbuf_0/a_42750_n1540# vdda1 1.62fF **FLOATING
C15937 divbuf_0/a_42270_n1540# vdda1 1.62fF **FLOATING
C15938 divbuf_0/a_41790_n1540# vdda1 1.62fF **FLOATING
C15939 divbuf_0/a_41310_n1540# vdda1 1.62fF **FLOATING
C15940 divbuf_0/a_40830_n1540# vdda1 1.62fF **FLOATING
C15941 divbuf_0/a_40350_n1540# vdda1 1.62fF **FLOATING
C15942 divbuf_0/a_39870_n1540# vdda1 1.62fF **FLOATING
C15943 divbuf_0/a_39390_n1540# vdda1 1.62fF **FLOATING
C15944 divbuf_0/a_38910_n1540# vdda1 1.62fF **FLOATING
C15945 divbuf_0/a_38430_n1540# vdda1 1.62fF **FLOATING
C15946 divbuf_0/a_37950_n1540# vdda1 1.62fF **FLOATING
C15947 divbuf_0/a_37470_n1540# vdda1 1.62fF **FLOATING
C15948 divbuf_0/a_36990_n1540# vdda1 1.62fF **FLOATING
C15949 divbuf_0/a_36510_n1540# vdda1 1.62fF **FLOATING
C15950 divbuf_0/a_36030_n1540# vdda1 1.62fF **FLOATING
C15951 divbuf_0/a_35550_n1540# vdda1 1.62fF **FLOATING
C15952 divbuf_0/a_35070_n1540# vdda1 1.62fF **FLOATING
C15953 divbuf_0/a_34590_n1540# vdda1 1.62fF **FLOATING
C15954 divbuf_0/a_34110_n1540# vdda1 1.62fF **FLOATING
C15955 divbuf_0/a_33630_n1540# vdda1 1.62fF **FLOATING
C15956 divbuf_0/a_33150_n1540# vdda1 1.62fF **FLOATING
C15957 divbuf_0/a_32670_n1540# vdda1 1.62fF **FLOATING
C15958 divbuf_0/a_32190_n1540# vdda1 1.62fF **FLOATING
C15959 divbuf_0/a_31710_n1540# vdda1 1.62fF **FLOATING
C15960 divbuf_0/a_31230_n1540# vdda1 1.62fF **FLOATING
C15961 divbuf_0/a_30750_n1540# vdda1 1.62fF **FLOATING
C15962 divbuf_0/a_30270_n1540# vdda1 1.62fF **FLOATING
C15963 divbuf_0/a_29790_n1540# vdda1 1.62fF **FLOATING
C15964 divbuf_0/a_29310_n1540# vdda1 1.62fF **FLOATING
C15965 divbuf_0/a_28830_n1540# vdda1 1.62fF **FLOATING
C15966 divbuf_0/a_28350_n1540# vdda1 1.62fF **FLOATING
C15967 divbuf_0/a_27870_n1540# vdda1 1.62fF **FLOATING
C15968 divbuf_0/a_27390_n1540# vdda1 1.62fF **FLOATING
C15969 divbuf_0/a_26910_n1540# vdda1 1.62fF **FLOATING
C15970 divbuf_0/a_26430_n1540# vdda1 1.62fF **FLOATING
C15971 divbuf_0/a_25950_n1540# vdda1 1.62fF **FLOATING
C15972 divbuf_0/a_25470_n1540# vdda1 1.62fF **FLOATING
C15973 divbuf_0/a_24990_n1540# vdda1 1.62fF **FLOATING
C15974 divbuf_0/a_24510_n1540# vdda1 1.62fF **FLOATING
C15975 divbuf_0/a_24030_n1540# vdda1 1.62fF **FLOATING
C15976 divbuf_0/a_23550_n1540# vdda1 1.62fF **FLOATING
C15977 divbuf_0/a_23070_n1540# vdda1 1.62fF **FLOATING
C15978 divbuf_0/a_22590_n1540# vdda1 1.62fF **FLOATING
C15979 divbuf_0/a_22110_n1540# vdda1 1.62fF **FLOATING
C15980 divbuf_0/a_21630_n1540# vdda1 1.62fF **FLOATING
C15981 divbuf_0/a_21150_n1540# vdda1 1.62fF **FLOATING
C15982 divbuf_0/a_20670_n1540# vdda1 1.62fF **FLOATING
C15983 divbuf_0/a_20190_n1540# vdda1 1.62fF **FLOATING
C15984 divbuf_0/a_19710_n1540# vdda1 1.62fF **FLOATING
C15985 divbuf_0/a_19230_n1540# vdda1 1.62fF **FLOATING
C15986 divbuf_0/a_18750_n1540# vdda1 1.62fF **FLOATING
C15987 divbuf_0/a_18270_n1540# vdda1 1.62fF **FLOATING
C15988 divbuf_0/a_17790_n1540# vdda1 1.62fF **FLOATING
C15989 divbuf_0/a_17310_n1540# vdda1 1.62fF **FLOATING
C15990 divbuf_0/a_16830_n1540# vdda1 1.62fF **FLOATING
C15991 divbuf_0/a_16350_n1540# vdda1 1.62fF **FLOATING
C15992 divbuf_0/a_15870_n1540# vdda1 1.62fF **FLOATING
C15993 divbuf_0/a_15390_n1540# vdda1 1.62fF **FLOATING
C15994 divbuf_0/a_14910_n1540# vdda1 1.62fF **FLOATING
C15995 divbuf_0/a_14430_n1540# vdda1 1.62fF **FLOATING
C15996 divbuf_0/a_13950_n1540# vdda1 1.62fF **FLOATING
C15997 divbuf_0/a_13470_n1540# vdda1 1.62fF **FLOATING
C15998 divbuf_0/a_12990_n1540# vdda1 1.62fF **FLOATING
C15999 divbuf_0/a_12510_n1540# vdda1 1.62fF **FLOATING
C16000 divbuf_0/a_12030_n1540# vdda1 1.62fF **FLOATING
C16001 divbuf_0/a_11550_n1540# vdda1 1.62fF **FLOATING
C16002 divbuf_0/a_11070_n1540# vdda1 1.62fF **FLOATING
C16003 divbuf_0/a_10590_n1540# vdda1 1.62fF **FLOATING
C16004 divbuf_0/a_10110_n1540# vdda1 1.62fF **FLOATING
C16005 divbuf_0/a_9630_n1540# vdda1 1.62fF **FLOATING
C16006 divbuf_0/a_9150_n1540# vdda1 1.62fF **FLOATING
C16007 divbuf_0/a_8670_n1540# vdda1 1.62fF **FLOATING
C16008 divbuf_0/a_8190_n1540# vdda1 1.62fF **FLOATING
C16009 divbuf_0/a_7710_n1540# vdda1 1.62fF **FLOATING
C16010 divbuf_0/a_7230_n1540# vdda1 1.62fF **FLOATING
C16011 divbuf_0/a_6750_n1540# vdda1 1.62fF **FLOATING
C16012 divbuf_0/a_6270_n1540# vdda1 1.62fF **FLOATING
C16013 divbuf_0/a_5790_n1540# vdda1 1.62fF **FLOATING
C16014 divbuf_0/a_5310_n1540# vdda1 1.62fF **FLOATING
C16015 divbuf_0/a_4830_n1540# vdda1 1.62fF **FLOATING
C16016 divbuf_0/a_4350_n1540# vdda1 1.62fF **FLOATING
C16017 divbuf_0/a_3870_n1540# vdda1 1.62fF **FLOATING
C16018 divbuf_0/a_3390_n1540# vdda1 1.62fF **FLOATING
C16019 divbuf_0/a_2910_n1540# vdda1 1.62fF **FLOATING
C16020 divbuf_0/a_2430_n1540# vdda1 1.62fF **FLOATING
C16021 divbuf_0/a_1950_n1540# vdda1 1.62fF **FLOATING
C16022 divbuf_0/a_1470_n1540# vdda1 1.62fF **FLOATING
C16023 divbuf_0/a_990_n1540# vdda1 1.62fF **FLOATING
C16024 divbuf_0/a_510_n1540# vdda1 1.62fF **FLOATING
C16025 divbuf_0/a_60990_n840# vdda1 1.06fF **FLOATING
C16026 divbuf_0/a_60510_n840# vdda1 1.09fF **FLOATING
C16027 divbuf_0/a_60030_n840# vdda1 1.09fF **FLOATING
C16028 divbuf_0/a_59550_n840# vdda1 1.09fF **FLOATING
C16029 divbuf_0/a_59070_n840# vdda1 1.09fF **FLOATING
C16030 divbuf_0/a_58590_n840# vdda1 1.09fF **FLOATING
C16031 divbuf_0/a_58110_n840# vdda1 1.09fF **FLOATING
C16032 divbuf_0/a_57630_n840# vdda1 1.09fF **FLOATING
C16033 divbuf_0/a_57150_n840# vdda1 1.09fF **FLOATING
C16034 divbuf_0/a_56670_n840# vdda1 1.09fF **FLOATING
C16035 divbuf_0/a_56190_n840# vdda1 1.09fF **FLOATING
C16036 divbuf_0/a_55710_n840# vdda1 1.09fF **FLOATING
C16037 divbuf_0/a_55230_n840# vdda1 1.09fF **FLOATING
C16038 divbuf_0/a_54750_n840# vdda1 1.09fF **FLOATING
C16039 divbuf_0/a_54270_n840# vdda1 1.09fF **FLOATING
C16040 divbuf_0/a_53790_n840# vdda1 1.09fF **FLOATING
C16041 divbuf_0/a_53310_n840# vdda1 1.09fF **FLOATING
C16042 divbuf_0/a_52830_n840# vdda1 1.09fF **FLOATING
C16043 divbuf_0/a_52350_n840# vdda1 1.09fF **FLOATING
C16044 divbuf_0/a_51870_n840# vdda1 1.09fF **FLOATING
C16045 divbuf_0/a_51390_n840# vdda1 1.09fF **FLOATING
C16046 divbuf_0/a_50910_n840# vdda1 1.09fF **FLOATING
C16047 divbuf_0/a_50430_n840# vdda1 1.09fF **FLOATING
C16048 divbuf_0/a_49950_n840# vdda1 1.09fF **FLOATING
C16049 divbuf_0/a_49470_n840# vdda1 1.09fF **FLOATING
C16050 divbuf_0/a_48990_n840# vdda1 1.09fF **FLOATING
C16051 divbuf_0/a_48510_n840# vdda1 1.09fF **FLOATING
C16052 divbuf_0/a_48030_n840# vdda1 1.09fF **FLOATING
C16053 divbuf_0/a_47550_n840# vdda1 1.09fF **FLOATING
C16054 divbuf_0/a_47070_n840# vdda1 1.09fF **FLOATING
C16055 divbuf_0/a_46590_n840# vdda1 1.09fF **FLOATING
C16056 divbuf_0/a_46110_n840# vdda1 1.09fF **FLOATING
C16057 divbuf_0/a_45630_n840# vdda1 1.09fF **FLOATING
C16058 divbuf_0/a_45150_n840# vdda1 1.09fF **FLOATING
C16059 divbuf_0/a_44670_n840# vdda1 1.09fF **FLOATING
C16060 divbuf_0/a_44190_n840# vdda1 1.09fF **FLOATING
C16061 divbuf_0/a_43710_n840# vdda1 1.09fF **FLOATING
C16062 divbuf_0/a_43230_n840# vdda1 1.09fF **FLOATING
C16063 divbuf_0/a_42750_n840# vdda1 1.08fF **FLOATING
C16064 divbuf_0/a_42270_n840# vdda1 1.08fF **FLOATING
C16065 divbuf_0/a_41790_n840# vdda1 1.10fF **FLOATING
C16066 divbuf_0/a_41310_n840# vdda1 1.09fF **FLOATING
C16067 divbuf_0/a_40830_n840# vdda1 1.09fF **FLOATING
C16068 divbuf_0/a_40350_n840# vdda1 1.09fF **FLOATING
C16069 divbuf_0/a_39870_n840# vdda1 1.09fF **FLOATING
C16070 divbuf_0/a_39390_n840# vdda1 1.09fF **FLOATING
C16071 divbuf_0/a_38910_n840# vdda1 1.09fF **FLOATING
C16072 divbuf_0/a_38430_n840# vdda1 1.09fF **FLOATING
C16073 divbuf_0/a_37950_n840# vdda1 1.09fF **FLOATING
C16074 divbuf_0/a_37470_n840# vdda1 1.09fF **FLOATING
C16075 divbuf_0/a_36990_n840# vdda1 1.09fF **FLOATING
C16076 divbuf_0/a_36510_n840# vdda1 1.09fF **FLOATING
C16077 divbuf_0/a_36030_n840# vdda1 1.09fF **FLOATING
C16078 divbuf_0/a_35550_n840# vdda1 1.09fF **FLOATING
C16079 divbuf_0/a_35070_n840# vdda1 1.09fF **FLOATING
C16080 divbuf_0/a_34590_n840# vdda1 1.09fF **FLOATING
C16081 divbuf_0/a_34110_n840# vdda1 1.09fF **FLOATING
C16082 divbuf_0/a_33630_n840# vdda1 1.09fF **FLOATING
C16083 divbuf_0/a_33150_n840# vdda1 1.09fF **FLOATING
C16084 divbuf_0/a_32670_n840# vdda1 1.09fF **FLOATING
C16085 divbuf_0/a_32190_n840# vdda1 1.09fF **FLOATING
C16086 divbuf_0/a_31710_n840# vdda1 1.11fF **FLOATING
C16087 divbuf_0/a_31230_n840# vdda1 1.13fF **FLOATING
C16088 divbuf_0/a_30750_n840# vdda1 1.09fF **FLOATING
C16089 divbuf_0/a_30270_n840# vdda1 1.09fF **FLOATING
C16090 divbuf_0/a_29790_n840# vdda1 1.09fF **FLOATING
C16091 divbuf_0/a_29310_n840# vdda1 1.09fF **FLOATING
C16092 divbuf_0/a_28830_n840# vdda1 1.09fF **FLOATING
C16093 divbuf_0/a_28350_n840# vdda1 1.09fF **FLOATING
C16094 divbuf_0/a_27870_n840# vdda1 1.08fF **FLOATING
C16095 divbuf_0/a_27390_n840# vdda1 1.11fF **FLOATING
C16096 divbuf_0/a_26910_n840# vdda1 1.10fF **FLOATING
C16097 divbuf_0/a_26430_n840# vdda1 1.10fF **FLOATING
C16098 divbuf_0/a_25950_n840# vdda1 1.10fF **FLOATING
C16099 divbuf_0/a_25470_n840# vdda1 1.10fF **FLOATING
C16100 divbuf_0/a_24990_n840# vdda1 1.10fF **FLOATING
C16101 divbuf_0/a_24510_n840# vdda1 1.10fF **FLOATING
C16102 divbuf_0/a_24030_n840# vdda1 1.09fF **FLOATING
C16103 divbuf_0/a_23550_n840# vdda1 1.11fF **FLOATING
C16104 divbuf_0/a_23070_n840# vdda1 1.10fF **FLOATING
C16105 divbuf_0/a_22590_n840# vdda1 1.10fF **FLOATING
C16106 divbuf_0/a_22110_n840# vdda1 1.10fF **FLOATING
C16107 divbuf_0/a_21630_n840# vdda1 1.10fF **FLOATING
C16108 divbuf_0/a_21150_n840# vdda1 1.10fF **FLOATING
C16109 divbuf_0/a_20670_n840# vdda1 1.10fF **FLOATING
C16110 divbuf_0/a_20190_n840# vdda1 1.09fF **FLOATING
C16111 divbuf_0/a_19710_n840# vdda1 1.09fF **FLOATING
C16112 divbuf_0/a_19230_n840# vdda1 1.09fF **FLOATING
C16113 divbuf_0/a_18750_n840# vdda1 1.09fF **FLOATING
C16114 divbuf_0/a_18270_n840# vdda1 1.08fF **FLOATING
C16115 divbuf_0/a_17790_n840# vdda1 1.08fF **FLOATING
C16116 divbuf_0/a_17310_n840# vdda1 1.07fF **FLOATING
C16117 divbuf_0/a_16830_n840# vdda1 1.07fF **FLOATING
C16118 divbuf_0/a_16350_n840# vdda1 1.07fF **FLOATING
C16119 divbuf_0/a_15870_n840# vdda1 1.07fF **FLOATING
C16120 divbuf_0/a_15390_n840# vdda1 1.08fF **FLOATING
C16121 divbuf_0/a_14910_n840# vdda1 1.07fF **FLOATING
C16122 divbuf_0/a_14430_n840# vdda1 1.07fF **FLOATING
C16123 divbuf_0/a_13950_n840# vdda1 1.07fF **FLOATING
C16124 divbuf_0/a_13470_n840# vdda1 1.07fF **FLOATING
C16125 divbuf_0/a_12990_n840# vdda1 1.10fF **FLOATING
C16126 divbuf_0/a_12510_n840# vdda1 1.08fF **FLOATING
C16127 divbuf_0/a_12030_n840# vdda1 1.07fF **FLOATING
C16128 divbuf_0/a_11550_n840# vdda1 1.07fF **FLOATING
C16129 divbuf_0/a_11070_n840# vdda1 1.08fF **FLOATING
C16130 divbuf_0/a_10590_n840# vdda1 1.10fF **FLOATING
C16131 divbuf_0/a_10110_n840# vdda1 1.10fF **FLOATING
C16132 divbuf_0/a_9630_n840# vdda1 1.10fF **FLOATING
C16133 divbuf_0/a_9150_n840# vdda1 1.10fF **FLOATING
C16134 divbuf_0/a_8670_n840# vdda1 1.10fF **FLOATING
C16135 divbuf_0/a_8190_n840# vdda1 1.12fF **FLOATING
C16136 divbuf_0/a_7710_n840# vdda1 1.10fF **FLOATING
C16137 divbuf_0/a_7230_n840# vdda1 1.09fF **FLOATING
C16138 divbuf_0/a_6750_n840# vdda1 1.09fF **FLOATING
C16139 divbuf_0/a_6270_n840# vdda1 1.09fF **FLOATING
C16140 divbuf_0/a_5790_n840# vdda1 1.09fF **FLOATING
C16141 divbuf_0/a_5310_n840# vdda1 1.09fF **FLOATING
C16142 divbuf_0/a_4830_n840# vdda1 1.09fF **FLOATING
C16143 divbuf_0/a_4350_n840# vdda1 1.09fF **FLOATING
C16144 divbuf_0/a_3870_n840# vdda1 1.09fF **FLOATING
C16145 divbuf_0/a_3390_n840# vdda1 1.09fF **FLOATING
C16146 divbuf_0/a_2910_n840# vdda1 1.10fF **FLOATING
C16147 divbuf_0/a_2430_n840# vdda1 1.10fF **FLOATING
C16148 divbuf_0/a_1950_n840# vdda1 1.10fF **FLOATING
C16149 divbuf_0/a_1470_n840# vdda1 1.10fF **FLOATING
C16150 divbuf_0/a_990_n840# vdda1 1.08fF **FLOATING
C16151 divbuf_0/a_510_n840# vdda1 1.07fF **FLOATING
C16152 divbuf_0/a_60480_n1600# vdda1 1.48fF **FLOATING
C16153 divbuf_0/a_60000_n1600# vdda1 1.48fF **FLOATING
C16154 divbuf_0/a_59520_n1600# vdda1 1.48fF **FLOATING
C16155 divbuf_0/a_59040_n1600# vdda1 1.48fF **FLOATING
C16156 divbuf_0/a_58560_n1600# vdda1 1.48fF **FLOATING
C16157 divbuf_0/a_58080_n1600# vdda1 1.48fF **FLOATING
C16158 divbuf_0/a_57600_n1600# vdda1 1.48fF **FLOATING
C16159 divbuf_0/a_57120_n1600# vdda1 1.48fF **FLOATING
C16160 divbuf_0/a_56640_n1600# vdda1 1.48fF **FLOATING
C16161 divbuf_0/a_56160_n1600# vdda1 1.48fF **FLOATING
C16162 divbuf_0/a_55680_n1600# vdda1 1.48fF **FLOATING
C16163 divbuf_0/a_55200_n1600# vdda1 1.48fF **FLOATING
C16164 divbuf_0/a_54720_n1600# vdda1 1.48fF **FLOATING
C16165 divbuf_0/a_54240_n1600# vdda1 1.48fF **FLOATING
C16166 divbuf_0/a_53760_n1600# vdda1 1.48fF **FLOATING
C16167 divbuf_0/a_53280_n1600# vdda1 1.48fF **FLOATING
C16168 divbuf_0/a_52800_n1600# vdda1 1.48fF **FLOATING
C16169 divbuf_0/a_52320_n1600# vdda1 1.48fF **FLOATING
C16170 divbuf_0/a_51840_n1600# vdda1 1.48fF **FLOATING
C16171 divbuf_0/a_51360_n1600# vdda1 1.48fF **FLOATING
C16172 divbuf_0/a_50880_n1600# vdda1 1.48fF **FLOATING
C16173 divbuf_0/a_50400_n1600# vdda1 1.48fF **FLOATING
C16174 divbuf_0/a_49920_n1600# vdda1 1.48fF **FLOATING
C16175 divbuf_0/a_49440_n1600# vdda1 1.48fF **FLOATING
C16176 divbuf_0/a_48960_n1600# vdda1 1.48fF **FLOATING
C16177 divbuf_0/a_48480_n1600# vdda1 1.48fF **FLOATING
C16178 divbuf_0/a_48000_n1600# vdda1 1.48fF **FLOATING
C16179 divbuf_0/a_47520_n1600# vdda1 1.48fF **FLOATING
C16180 divbuf_0/a_47040_n1600# vdda1 1.48fF **FLOATING
C16181 divbuf_0/a_46560_n1600# vdda1 1.48fF **FLOATING
C16182 divbuf_0/a_46080_n1600# vdda1 1.48fF **FLOATING
C16183 divbuf_0/a_45600_n1600# vdda1 1.48fF **FLOATING
C16184 divbuf_0/a_45120_n1600# vdda1 1.48fF **FLOATING
C16185 divbuf_0/a_44640_n1600# vdda1 1.48fF **FLOATING
C16186 divbuf_0/a_44160_n1600# vdda1 1.48fF **FLOATING
C16187 divbuf_0/a_43680_n1600# vdda1 1.48fF **FLOATING
C16188 divbuf_0/a_43200_n1600# vdda1 1.48fF **FLOATING
C16189 divbuf_0/a_42720_n1600# vdda1 1.48fF **FLOATING
C16190 divbuf_0/a_42240_n1600# vdda1 1.48fF **FLOATING
C16191 divbuf_0/a_41760_n1600# vdda1 1.48fF **FLOATING
C16192 divbuf_0/a_41280_n1600# vdda1 1.48fF **FLOATING
C16193 divbuf_0/a_40800_n1600# vdda1 1.48fF **FLOATING
C16194 divbuf_0/a_40320_n1600# vdda1 1.48fF **FLOATING
C16195 divbuf_0/a_39840_n1600# vdda1 1.48fF **FLOATING
C16196 divbuf_0/a_39360_n1600# vdda1 1.48fF **FLOATING
C16197 divbuf_0/a_38880_n1600# vdda1 1.48fF **FLOATING
C16198 divbuf_0/a_38400_n1600# vdda1 1.48fF **FLOATING
C16199 divbuf_0/a_37920_n1600# vdda1 1.48fF **FLOATING
C16200 divbuf_0/a_37440_n1600# vdda1 1.48fF **FLOATING
C16201 divbuf_0/a_36960_n1600# vdda1 1.48fF **FLOATING
C16202 divbuf_0/a_36480_n1600# vdda1 1.48fF **FLOATING
C16203 divbuf_0/a_36000_n1600# vdda1 1.48fF **FLOATING
C16204 divbuf_0/a_35520_n1600# vdda1 1.48fF **FLOATING
C16205 divbuf_0/a_35040_n1600# vdda1 1.48fF **FLOATING
C16206 divbuf_0/a_34560_n1600# vdda1 1.48fF **FLOATING
C16207 divbuf_0/a_34080_n1600# vdda1 1.48fF **FLOATING
C16208 divbuf_0/a_33600_n1600# vdda1 1.48fF **FLOATING
C16209 divbuf_0/a_33120_n1600# vdda1 1.48fF **FLOATING
C16210 divbuf_0/a_32640_n1600# vdda1 1.48fF **FLOATING
C16211 divbuf_0/a_32160_n1600# vdda1 1.48fF **FLOATING
C16212 divbuf_0/a_31680_n1600# vdda1 1.48fF **FLOATING
C16213 divbuf_0/a_31200_n1600# vdda1 1.48fF **FLOATING
C16214 divbuf_0/a_30720_n1600# vdda1 1.48fF **FLOATING
C16215 divbuf_0/a_30240_n1600# vdda1 1.48fF **FLOATING
C16216 divbuf_0/a_29760_n1600# vdda1 1.48fF **FLOATING
C16217 divbuf_0/a_29280_n1600# vdda1 1.48fF **FLOATING
C16218 divbuf_0/a_28800_n1600# vdda1 1.48fF **FLOATING
C16219 divbuf_0/a_28320_n1600# vdda1 1.48fF **FLOATING
C16220 divbuf_0/a_27840_n1600# vdda1 1.48fF **FLOATING
C16221 divbuf_0/a_27360_n1600# vdda1 1.48fF **FLOATING
C16222 divbuf_0/a_26880_n1600# vdda1 1.48fF **FLOATING
C16223 divbuf_0/a_26400_n1600# vdda1 1.48fF **FLOATING
C16224 divbuf_0/a_25920_n1600# vdda1 1.48fF **FLOATING
C16225 divbuf_0/a_25440_n1600# vdda1 1.48fF **FLOATING
C16226 divbuf_0/a_24960_n1600# vdda1 1.48fF **FLOATING
C16227 divbuf_0/a_24480_n1600# vdda1 1.48fF **FLOATING
C16228 divbuf_0/a_24000_n1600# vdda1 1.48fF **FLOATING
C16229 divbuf_0/a_23520_n1600# vdda1 1.48fF **FLOATING
C16230 divbuf_0/a_23040_n1600# vdda1 1.48fF **FLOATING
C16231 divbuf_0/a_22560_n1600# vdda1 1.48fF **FLOATING
C16232 divbuf_0/a_22080_n1600# vdda1 1.48fF **FLOATING
C16233 divbuf_0/a_21600_n1600# vdda1 1.48fF **FLOATING
C16234 divbuf_0/a_21120_n1600# vdda1 1.48fF **FLOATING
C16235 divbuf_0/a_20640_n1600# vdda1 1.48fF **FLOATING
C16236 divbuf_0/a_20160_n1600# vdda1 1.48fF **FLOATING
C16237 divbuf_0/a_19680_n1600# vdda1 1.48fF **FLOATING
C16238 divbuf_0/a_19200_n1600# vdda1 1.48fF **FLOATING
C16239 divbuf_0/a_18720_n1600# vdda1 1.48fF **FLOATING
C16240 divbuf_0/a_18240_n1600# vdda1 1.48fF **FLOATING
C16241 divbuf_0/a_17760_n1600# vdda1 1.48fF **FLOATING
C16242 divbuf_0/a_17280_n1600# vdda1 1.48fF **FLOATING
C16243 divbuf_0/a_16800_n1600# vdda1 1.48fF **FLOATING
C16244 divbuf_0/a_16320_n1600# vdda1 1.48fF **FLOATING
C16245 divbuf_0/a_15840_n1600# vdda1 1.48fF **FLOATING
C16246 divbuf_0/a_15360_n1600# vdda1 1.48fF **FLOATING
C16247 divbuf_0/a_14880_n1600# vdda1 1.48fF **FLOATING
C16248 divbuf_0/a_14400_n1600# vdda1 1.48fF **FLOATING
C16249 divbuf_0/a_13920_n1600# vdda1 1.48fF **FLOATING
C16250 divbuf_0/a_13440_n1600# vdda1 1.48fF **FLOATING
C16251 divbuf_0/a_12960_n1600# vdda1 1.48fF **FLOATING
C16252 divbuf_0/a_12480_n1600# vdda1 1.48fF **FLOATING
C16253 divbuf_0/a_12000_n1600# vdda1 1.48fF **FLOATING
C16254 divbuf_0/a_11520_n1600# vdda1 1.48fF **FLOATING
C16255 divbuf_0/a_11040_n1600# vdda1 1.48fF **FLOATING
C16256 divbuf_0/a_10560_n1600# vdda1 1.48fF **FLOATING
C16257 divbuf_0/a_10080_n1600# vdda1 1.48fF **FLOATING
C16258 divbuf_0/a_9600_n1600# vdda1 1.48fF **FLOATING
C16259 divbuf_0/a_9120_n1600# vdda1 1.48fF **FLOATING
C16260 divbuf_0/a_8640_n1600# vdda1 1.48fF **FLOATING
C16261 divbuf_0/a_8160_n1600# vdda1 1.48fF **FLOATING
C16262 divbuf_0/a_7680_n1600# vdda1 1.48fF **FLOATING
C16263 divbuf_0/a_7200_n1600# vdda1 1.48fF **FLOATING
C16264 divbuf_0/a_6720_n1600# vdda1 1.48fF **FLOATING
C16265 divbuf_0/a_6240_n1600# vdda1 1.48fF **FLOATING
C16266 divbuf_0/a_5760_n1600# vdda1 1.48fF **FLOATING
C16267 divbuf_0/a_5280_n1600# vdda1 1.48fF **FLOATING
C16268 divbuf_0/a_4800_n1600# vdda1 1.48fF **FLOATING
C16269 divbuf_0/a_4320_n1600# vdda1 1.48fF **FLOATING
C16270 divbuf_0/a_3840_n1600# vdda1 1.48fF **FLOATING
C16271 divbuf_0/a_3360_n1600# vdda1 1.48fF **FLOATING
C16272 divbuf_0/a_2880_n1600# vdda1 1.48fF **FLOATING
C16273 divbuf_0/a_2400_n1600# vdda1 1.48fF **FLOATING
C16274 divbuf_0/a_1920_n1600# vdda1 1.48fF **FLOATING
C16275 divbuf_0/a_1440_n1600# vdda1 1.48fF **FLOATING
C16276 divbuf_0/a_960_n1600# vdda1 1.48fF **FLOATING
C16277 divbuf_0/a_480_n1600# vdda1 1.48fF **FLOATING
C16278 divbuf_0/a_0_n1600# vdda1 1.48fF **FLOATING
C16279 divbuf_0/a_41382_n240# vdda1 0.90fF **FLOATING
C16280 divbuf_0/a_40902_n240# vdda1 0.90fF **FLOATING
C16281 divbuf_0/a_40412_n240# vdda1 0.90fF **FLOATING
C16282 divbuf_0/a_39932_n240# vdda1 0.90fF **FLOATING
C16283 divbuf_0/a_39442_n240# vdda1 0.90fF **FLOATING
C16284 divbuf_0/a_38962_n240# vdda1 0.91fF **FLOATING
C16285 divbuf_0/a_38472_n240# vdda1 0.90fF **FLOATING
C16286 divbuf_0/a_37992_n240# vdda1 0.90fF **FLOATING
C16287 divbuf_0/a_37502_n240# vdda1 0.90fF **FLOATING
C16288 divbuf_0/a_37022_n240# vdda1 0.90fF **FLOATING
C16289 divbuf_0/a_36532_n240# vdda1 0.90fF **FLOATING
C16290 divbuf_0/a_36052_n240# vdda1 0.90fF **FLOATING
C16291 divbuf_0/a_35562_n240# vdda1 0.90fF **FLOATING
C16292 divbuf_0/a_35082_n240# vdda1 0.91fF **FLOATING
C16293 divbuf_0/a_34592_n240# vdda1 0.90fF **FLOATING
C16294 divbuf_0/a_34112_n240# vdda1 0.90fF **FLOATING
C16295 divbuf_0/a_33622_n240# vdda1 0.90fF **FLOATING
C16296 divbuf_0/a_33142_n240# vdda1 0.90fF **FLOATING
C16297 divbuf_0/a_32652_n240# vdda1 0.90fF **FLOATING
C16298 divbuf_0/a_32172_n240# vdda1 0.90fF **FLOATING
C16299 divbuf_0/a_31682_n240# vdda1 0.89fF **FLOATING
C16300 divbuf_0/a_31202_n240# vdda1 0.92fF **FLOATING
C16301 divbuf_0/a_30712_n240# vdda1 0.90fF **FLOATING
C16302 divbuf_0/a_30232_n240# vdda1 0.90fF **FLOATING
C16303 divbuf_0/a_29742_n240# vdda1 0.90fF **FLOATING
C16304 divbuf_0/a_29262_n240# vdda1 0.90fF **FLOATING
C16305 divbuf_0/a_28772_n240# vdda1 0.90fF **FLOATING
C16306 divbuf_0/a_28292_n240# vdda1 0.90fF **FLOATING
C16307 divbuf_0/a_27802_n240# vdda1 0.89fF **FLOATING
C16308 divbuf_0/a_27322_n240# vdda1 0.95fF **FLOATING
C16309 divbuf_0/a_26832_n240# vdda1 0.91fF **FLOATING
C16310 divbuf_0/a_26352_n240# vdda1 0.91fF **FLOATING
C16311 divbuf_0/a_25862_n240# vdda1 0.91fF **FLOATING
C16312 divbuf_0/a_25382_n240# vdda1 0.91fF **FLOATING
C16313 divbuf_0/a_24892_n240# vdda1 0.91fF **FLOATING
C16314 divbuf_0/a_24412_n240# vdda1 0.91fF **FLOATING
C16315 divbuf_0/a_23922_n240# vdda1 0.92fF **FLOATING
C16316 divbuf_0/a_23442_n240# vdda1 0.94fF **FLOATING
C16317 divbuf_0/a_22952_n240# vdda1 0.91fF **FLOATING
C16318 divbuf_0/a_22472_n240# vdda1 0.91fF **FLOATING
C16319 divbuf_0/a_21982_n240# vdda1 0.91fF **FLOATING
C16320 divbuf_0/a_21502_n240# vdda1 0.91fF **FLOATING
C16321 divbuf_0/a_21012_n240# vdda1 0.91fF **FLOATING
C16322 divbuf_0/a_20532_n240# vdda1 0.91fF **FLOATING
C16323 divbuf_0/a_20042_n240# vdda1 0.90fF **FLOATING
C16324 divbuf_0/a_19562_n240# vdda1 0.90fF **FLOATING
C16325 divbuf_0/a_19072_n240# vdda1 0.90fF **FLOATING
C16326 divbuf_0/a_18582_n240# vdda1 0.89fF **FLOATING
C16327 divbuf_0/a_18092_n240# vdda1 0.89fF **FLOATING
C16328 divbuf_0/a_17612_n240# vdda1 0.89fF **FLOATING
C16329 divbuf_0/a_17122_n240# vdda1 0.88fF **FLOATING
C16330 divbuf_0/a_16642_n240# vdda1 0.88fF **FLOATING
C16331 divbuf_0/a_16152_n240# vdda1 0.88fF **FLOATING
C16332 divbuf_0/a_15672_n240# vdda1 0.90fF **FLOATING
C16333 divbuf_0/a_15182_n240# vdda1 0.88fF **FLOATING
C16334 divbuf_0/a_14702_n240# vdda1 0.88fF **FLOATING
C16335 divbuf_0/a_14222_n240# vdda1 0.88fF **FLOATING
C16336 divbuf_0/a_13742_n240# vdda1 0.88fF **FLOATING
C16337 divbuf_0/a_13252_n240# vdda1 0.88fF **FLOATING
C16338 divbuf_0/a_12772_n240# vdda1 0.88fF **FLOATING
C16339 divbuf_0/a_12282_n240# vdda1 0.88fF **FLOATING
C16340 divbuf_0/a_11802_n240# vdda1 0.88fF **FLOATING
C16341 divbuf_0/a_11312_n240# vdda1 0.89fF **FLOATING
C16342 divbuf_0/a_10212_n240# vdda1 0.91fF **FLOATING
C16343 divbuf_0/a_9732_n240# vdda1 0.91fF **FLOATING
C16344 divbuf_0/a_9242_n240# vdda1 0.91fF **FLOATING
C16345 divbuf_0/a_8762_n240# vdda1 0.91fF **FLOATING
C16346 divbuf_0/a_8272_n240# vdda1 0.91fF **FLOATING
C16347 divbuf_0/a_7792_n240# vdda1 0.92fF **FLOATING
C16348 divbuf_0/a_7302_n240# vdda1 0.90fF **FLOATING
C16349 divbuf_0/a_6822_n240# vdda1 0.90fF **FLOATING
C16350 divbuf_0/a_6332_n240# vdda1 0.90fF **FLOATING
C16351 divbuf_0/a_5852_n240# vdda1 0.90fF **FLOATING
C16352 divbuf_0/a_5362_n240# vdda1 0.90fF **FLOATING
C16353 divbuf_0/a_4882_n240# vdda1 0.90fF **FLOATING
C16354 divbuf_0/a_4392_n240# vdda1 0.90fF **FLOATING
C16355 divbuf_0/a_3912_n240# vdda1 0.90fF **FLOATING
C16356 divbuf_0/a_3422_n240# vdda1 0.90fF **FLOATING
C16357 divbuf_0/a_2322_n240# vdda1 0.91fF **FLOATING
C16358 divbuf_0/a_1842_n240# vdda1 0.91fF **FLOATING
C16359 divbuf_0/a_1352_n240# vdda1 0.91fF **FLOATING
C16360 divbuf_0/a_41382_170# vdda1 1.07fF **FLOATING
C16361 divbuf_0/a_40902_170# vdda1 1.09fF **FLOATING
C16362 divbuf_0/a_40412_170# vdda1 1.09fF **FLOATING
C16363 divbuf_0/a_39932_170# vdda1 1.09fF **FLOATING
C16364 divbuf_0/a_39442_170# vdda1 1.09fF **FLOATING
C16365 divbuf_0/a_38962_170# vdda1 1.07fF **FLOATING
C16366 divbuf_0/a_38472_170# vdda1 1.09fF **FLOATING
C16367 divbuf_0/a_37992_170# vdda1 1.09fF **FLOATING
C16368 divbuf_0/a_37502_170# vdda1 1.09fF **FLOATING
C16369 divbuf_0/a_37022_170# vdda1 1.09fF **FLOATING
C16370 divbuf_0/a_36532_170# vdda1 1.09fF **FLOATING
C16371 divbuf_0/a_36052_170# vdda1 1.09fF **FLOATING
C16372 divbuf_0/a_35562_170# vdda1 1.09fF **FLOATING
C16373 divbuf_0/a_35082_170# vdda1 1.09fF **FLOATING
C16374 divbuf_0/a_34592_170# vdda1 1.07fF **FLOATING
C16375 divbuf_0/a_34112_170# vdda1 1.09fF **FLOATING
C16376 divbuf_0/a_33622_170# vdda1 1.09fF **FLOATING
C16377 divbuf_0/a_33142_170# vdda1 1.09fF **FLOATING
C16378 divbuf_0/a_32652_170# vdda1 1.09fF **FLOATING
C16379 divbuf_0/a_32172_170# vdda1 1.09fF **FLOATING
C16380 divbuf_0/a_31682_170# vdda1 1.09fF **FLOATING
C16381 divbuf_0/a_31202_170# vdda1 1.09fF **FLOATING
C16382 divbuf_0/a_30712_170# vdda1 1.09fF **FLOATING
C16383 divbuf_0/a_30232_170# vdda1 1.07fF **FLOATING
C16384 divbuf_0/a_29742_170# vdda1 1.09fF **FLOATING
C16385 divbuf_0/a_29262_170# vdda1 1.09fF **FLOATING
C16386 divbuf_0/a_28772_170# vdda1 1.09fF **FLOATING
C16387 divbuf_0/a_28292_170# vdda1 1.09fF **FLOATING
C16388 divbuf_0/a_27802_170# vdda1 1.09fF **FLOATING
C16389 divbuf_0/a_27322_170# vdda1 1.09fF **FLOATING
C16390 divbuf_0/a_26832_170# vdda1 1.09fF **FLOATING
C16391 divbuf_0/a_26352_170# vdda1 1.09fF **FLOATING
C16392 divbuf_0/a_25862_170# vdda1 1.07fF **FLOATING
C16393 divbuf_0/a_25382_170# vdda1 1.09fF **FLOATING
C16394 divbuf_0/a_24892_170# vdda1 1.09fF **FLOATING
C16395 divbuf_0/a_24412_170# vdda1 1.09fF **FLOATING
C16396 divbuf_0/a_23922_170# vdda1 1.09fF **FLOATING
C16397 divbuf_0/a_23442_170# vdda1 1.09fF **FLOATING
C16398 divbuf_0/a_22952_170# vdda1 1.09fF **FLOATING
C16399 divbuf_0/a_22472_170# vdda1 1.07fF **FLOATING
C16400 divbuf_0/a_21982_170# vdda1 1.09fF **FLOATING
C16401 divbuf_0/a_21502_170# vdda1 1.09fF **FLOATING
C16402 divbuf_0/a_21012_170# vdda1 1.09fF **FLOATING
C16403 divbuf_0/a_20532_170# vdda1 1.09fF **FLOATING
C16404 divbuf_0/a_20042_170# vdda1 1.09fF **FLOATING
C16405 divbuf_0/a_19562_170# vdda1 1.09fF **FLOATING
C16406 divbuf_0/a_19072_170# vdda1 1.09fF **FLOATING
C16407 divbuf_0/a_18582_170# vdda1 1.07fF **FLOATING
C16408 divbuf_0/a_18092_170# vdda1 1.09fF **FLOATING
C16409 divbuf_0/a_17612_170# vdda1 1.09fF **FLOATING
C16410 divbuf_0/a_17122_170# vdda1 1.09fF **FLOATING
C16411 divbuf_0/a_16642_170# vdda1 1.09fF **FLOATING
C16412 divbuf_0/a_16152_170# vdda1 1.09fF **FLOATING
C16413 divbuf_0/a_15672_170# vdda1 1.09fF **FLOATING
C16414 divbuf_0/a_15182_170# vdda1 1.09fF **FLOATING
C16415 divbuf_0/a_14702_170# vdda1 1.10fF **FLOATING
C16416 divbuf_0/a_14222_170# vdda1 1.10fF **FLOATING
C16417 divbuf_0/a_13742_170# vdda1 1.09fF **FLOATING
C16418 divbuf_0/a_13252_170# vdda1 1.09fF **FLOATING
C16419 divbuf_0/a_12772_170# vdda1 1.07fF **FLOATING
C16420 divbuf_0/a_12282_170# vdda1 1.09fF **FLOATING
C16421 divbuf_0/a_11802_170# vdda1 1.09fF **FLOATING
C16422 divbuf_0/a_11312_170# vdda1 1.10fF **FLOATING
C16423 divbuf_0/a_10212_170# vdda1 1.09fF **FLOATING
C16424 divbuf_0/a_9732_170# vdda1 1.09fF **FLOATING
C16425 divbuf_0/a_9242_170# vdda1 1.09fF **FLOATING
C16426 divbuf_0/a_8762_170# vdda1 1.09fF **FLOATING
C16427 divbuf_0/a_8272_170# vdda1 1.07fF **FLOATING
C16428 divbuf_0/a_7792_170# vdda1 1.09fF **FLOATING
C16429 divbuf_0/a_7302_170# vdda1 1.09fF **FLOATING
C16430 divbuf_0/a_6822_170# vdda1 1.09fF **FLOATING
C16431 divbuf_0/a_6332_170# vdda1 1.09fF **FLOATING
C16432 divbuf_0/a_5852_170# vdda1 1.09fF **FLOATING
C16433 divbuf_0/a_5362_170# vdda1 1.09fF **FLOATING
C16434 divbuf_0/a_4882_170# vdda1 1.09fF **FLOATING
C16435 divbuf_0/a_4392_170# vdda1 1.07fF **FLOATING
C16436 divbuf_0/a_3912_170# vdda1 1.09fF **FLOATING
C16437 divbuf_0/a_3422_170# vdda1 1.10fF **FLOATING
C16438 divbuf_0/a_2322_170# vdda1 1.09fF **FLOATING
C16439 divbuf_0/a_1842_170# vdda1 1.09fF **FLOATING
C16440 divbuf_0/a_1352_170# vdda1 1.10fF **FLOATING
C16441 divbuf_0/a_492_n240# vdda1 2.46fF **FLOATING
C16442 ro_complete_0/cbank_2/v vdda1 17.84fF
C16443 ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C16444 ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C16445 ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C16446 ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C16447 ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C16448 ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C16449 ro_complete_0/cbank_1/v vdda1 16.34fF
C16450 ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C16451 ro_complete_0/a0 vdda1 7.88fF
C16452 ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C16453 ro_complete_0/a1 vdda1 5.39fF
C16454 ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C16455 ro_complete_0/a3 vdda1 6.85fF
C16456 ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C16457 ro_complete_0/a2 vdda1 5.48fF
C16458 ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C16459 ro_complete_0/a4 vdda1 5.36fF
C16460 ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C16461 ro_complete_0/a5 vdda1 5.19fF
C16462 ro_complete_0/cbank_0/v vdda1 14.98fF
C16463 ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C16464 ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C16465 ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C16466 ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C16467 ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C16468 ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C16469 ro_complete_0/ro_var_extend_0/vcont vdda1 0.27fF
C16470 ro_div_0/divider_0/and_0/Z1 vdda1 0.33fF
C16471 ro_div_0/divider_0/and_0/B vdda1 1.79fF
C16472 ro_div_0/divider_0/and_0/A vdda1 1.66fF
C16473 ro_div_0/divider_0/and_0/out1 vdda1 2.71fF
C16474 ro_div_0/divider_0/tspc_2/Z4 vdda1 0.42fF
C16475 ro_div_0/divbuf_0/IN vdda1 9.25fF
C16476 ro_div_0/divider_0/tspc_2/Z3 vdda1 2.00fF
C16477 ro_div_0/divider_0/tspc_2/Z2 vdda1 1.29fF
C16478 ro_div_0/divider_0/tspc_2/Z1 vdda1 0.99fF
C16479 ro_div_0/divider_0/nor_0/B vdda1 5.25fF
C16480 ro_div_0/divider_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C16481 ro_div_0/divider_0/tspc_1/Z4 vdda1 0.42fF
C16482 ro_div_0/divider_0/tspc_1/Q vdda1 2.79fF
C16483 ro_div_0/divider_0/tspc_1/Z3 vdda1 2.00fF
C16484 ro_div_0/divider_0/tspc_1/Z2 vdda1 1.29fF
C16485 ro_div_0/divider_0/tspc_1/Z1 vdda1 0.99fF
C16486 ro_div_0/divider_0/nor_1/B vdda1 5.95fF
C16487 ro_div_0/divider_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C16488 ro_div_0/divider_0/tspc_0/Z4 vdda1 0.42fF
C16489 ro_div_0/divider_0/tspc_0/Q vdda1 2.81fF
C16490 ro_div_0/divider_0/tspc_0/Z3 vdda1 2.00fF
C16491 ro_div_0/divider_0/tspc_0/Z2 vdda1 1.30fF
C16492 ro_div_0/divider_0/tspc_0/Z1 vdda1 0.99fF
C16493 ro_div_0/divider_0/nor_1/A vdda1 6.02fF
C16494 ro_div_0/divider_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C16495 ro_div_0/divider_0/clk vdda1 23.35fF
C16496 ro_div_0/divider_0/prescaler_0/Out vdda1 4.13fF
C16497 ro_div_0/divider_0/prescaler_0/nand_1/z1 vdda1 0.20fF
C16498 ro_div_0/divider_0/prescaler_0/tspc_2/D vdda1 2.59fF
C16499 ro_div_0/divider_0/prescaler_0/tspc_0/Q vdda1 3.30fF
C16500 ro_div_0/divider_0/prescaler_0/tspc_1/Q vdda1 2.78fF
C16501 ro_div_0/divider_0/prescaler_0/nand_0/z1 vdda1 0.20fF
C16502 ro_div_0/divider_0/prescaler_0/tspc_0/D vdda1 3.07fF
C16503 ro_div_0/divider_0/and_0/OUT vdda1 5.35fF
C16504 ro_div_0/divider_0/prescaler_0/tspc_2/Z4 vdda1 0.42fF
C16505 ro_div_0/divider_0/prescaler_0/tspc_2/Z3 vdda1 2.00fF
C16506 ro_div_0/divider_0/prescaler_0/tspc_2/Z2 vdda1 1.30fF
C16507 ro_div_0/divider_0/prescaler_0/tspc_2/Z1 vdda1 0.99fF
C16508 ro_div_0/divider_0/prescaler_0/tspc_2/a_630_n680# vdda1 0.53fF **FLOATING
C16509 ro_div_0/divider_0/prescaler_0/tspc_2/a_740_n680# vdda1 1.89fF **FLOATING
C16510 ro_div_0/divider_0/prescaler_0/tspc_1/Z4 vdda1 0.42fF
C16511 ro_div_0/divider_0/prescaler_0/tspc_1/Z3 vdda1 2.00fF
C16512 ro_div_0/divider_0/prescaler_0/tspc_1/Z2 vdda1 1.31fF
C16513 ro_div_0/divider_0/prescaler_0/tspc_1/Z1 vdda1 0.99fF
C16514 ro_div_0/divider_0/prescaler_0/tspc_1/a_630_n680# vdda1 0.53fF **FLOATING
C16515 ro_div_0/divider_0/prescaler_0/m1_2700_2190# vdda1 3.99fF **FLOATING
C16516 ro_div_0/divider_0/prescaler_0/tspc_0/Z4 vdda1 0.42fF
C16517 ro_div_0/divider_0/prescaler_0/tspc_0/Z3 vdda1 2.00fF
C16518 ro_div_0/divider_0/prescaler_0/tspc_0/Z2 vdda1 1.30fF
C16519 ro_div_0/divider_0/prescaler_0/tspc_0/Z1 vdda1 0.99fF
C16520 ro_div_0/divider_0/prescaler_0/tspc_0/a_630_n680# vdda1 0.53fF **FLOATING
C16521 ro_div_0/divider_0/prescaler_0/tspc_0/a_740_n680# vdda1 1.89fF **FLOATING
C16522 ro_div_0/divider_0/nor_1/Z1 vdda1 1.33fF
C16523 ro_div_0/divider_0/nor_0/Z1 vdda1 1.33fF
C16524 ro_div_0/divbuf_0/OUT vdda1 3.35fF
C16525 ro_div_0/divbuf_0/OUT5 vdda1 16.40fF
C16526 ro_div_0/divbuf_0/OUT4 vdda1 100.06fF
C16527 ro_div_0/divbuf_0/OUT3 vdda1 27.01fF
C16528 ro_div_0/divbuf_0/OUT2 vdda1 8.71fF
C16529 ro_div_0/divbuf_0/a_60990_n1540# vdda1 1.57fF **FLOATING
C16530 ro_div_0/divbuf_0/a_60510_n1540# vdda1 1.62fF **FLOATING
C16531 ro_div_0/divbuf_0/a_60030_n1540# vdda1 1.62fF **FLOATING
C16532 ro_div_0/divbuf_0/a_59550_n1540# vdda1 1.62fF **FLOATING
C16533 ro_div_0/divbuf_0/a_59070_n1540# vdda1 1.62fF **FLOATING
C16534 ro_div_0/divbuf_0/a_58590_n1540# vdda1 1.62fF **FLOATING
C16535 ro_div_0/divbuf_0/a_58110_n1540# vdda1 1.62fF **FLOATING
C16536 ro_div_0/divbuf_0/a_57630_n1540# vdda1 1.62fF **FLOATING
C16537 ro_div_0/divbuf_0/a_57150_n1540# vdda1 1.62fF **FLOATING
C16538 ro_div_0/divbuf_0/a_56670_n1540# vdda1 1.62fF **FLOATING
C16539 ro_div_0/divbuf_0/a_56190_n1540# vdda1 1.62fF **FLOATING
C16540 ro_div_0/divbuf_0/a_55710_n1540# vdda1 1.62fF **FLOATING
C16541 ro_div_0/divbuf_0/a_55230_n1540# vdda1 1.62fF **FLOATING
C16542 ro_div_0/divbuf_0/a_54750_n1540# vdda1 1.62fF **FLOATING
C16543 ro_div_0/divbuf_0/a_54270_n1540# vdda1 1.62fF **FLOATING
C16544 ro_div_0/divbuf_0/a_53790_n1540# vdda1 1.62fF **FLOATING
C16545 ro_div_0/divbuf_0/a_53310_n1540# vdda1 1.62fF **FLOATING
C16546 ro_div_0/divbuf_0/a_52830_n1540# vdda1 1.62fF **FLOATING
C16547 ro_div_0/divbuf_0/a_52350_n1540# vdda1 1.62fF **FLOATING
C16548 ro_div_0/divbuf_0/a_51870_n1540# vdda1 1.62fF **FLOATING
C16549 ro_div_0/divbuf_0/a_51390_n1540# vdda1 1.62fF **FLOATING
C16550 ro_div_0/divbuf_0/a_50910_n1540# vdda1 1.62fF **FLOATING
C16551 ro_div_0/divbuf_0/a_50430_n1540# vdda1 1.62fF **FLOATING
C16552 ro_div_0/divbuf_0/a_49950_n1540# vdda1 1.62fF **FLOATING
C16553 ro_div_0/divbuf_0/a_49470_n1540# vdda1 1.62fF **FLOATING
C16554 ro_div_0/divbuf_0/a_48990_n1540# vdda1 1.62fF **FLOATING
C16555 ro_div_0/divbuf_0/a_48510_n1540# vdda1 1.62fF **FLOATING
C16556 ro_div_0/divbuf_0/a_48030_n1540# vdda1 1.62fF **FLOATING
C16557 ro_div_0/divbuf_0/a_47550_n1540# vdda1 1.62fF **FLOATING
C16558 ro_div_0/divbuf_0/a_47070_n1540# vdda1 1.62fF **FLOATING
C16559 ro_div_0/divbuf_0/a_46590_n1540# vdda1 1.62fF **FLOATING
C16560 ro_div_0/divbuf_0/a_46110_n1540# vdda1 1.62fF **FLOATING
C16561 ro_div_0/divbuf_0/a_45630_n1540# vdda1 1.62fF **FLOATING
C16562 ro_div_0/divbuf_0/a_45150_n1540# vdda1 1.62fF **FLOATING
C16563 ro_div_0/divbuf_0/a_44670_n1540# vdda1 1.62fF **FLOATING
C16564 ro_div_0/divbuf_0/a_44190_n1540# vdda1 1.62fF **FLOATING
C16565 ro_div_0/divbuf_0/a_43710_n1540# vdda1 1.62fF **FLOATING
C16566 ro_div_0/divbuf_0/a_43230_n1540# vdda1 1.62fF **FLOATING
C16567 ro_div_0/divbuf_0/a_42750_n1540# vdda1 1.62fF **FLOATING
C16568 ro_div_0/divbuf_0/a_42270_n1540# vdda1 1.62fF **FLOATING
C16569 ro_div_0/divbuf_0/a_41790_n1540# vdda1 1.62fF **FLOATING
C16570 ro_div_0/divbuf_0/a_41310_n1540# vdda1 1.62fF **FLOATING
C16571 ro_div_0/divbuf_0/a_40830_n1540# vdda1 1.62fF **FLOATING
C16572 ro_div_0/divbuf_0/a_40350_n1540# vdda1 1.62fF **FLOATING
C16573 ro_div_0/divbuf_0/a_39870_n1540# vdda1 1.62fF **FLOATING
C16574 ro_div_0/divbuf_0/a_39390_n1540# vdda1 1.62fF **FLOATING
C16575 ro_div_0/divbuf_0/a_38910_n1540# vdda1 1.62fF **FLOATING
C16576 ro_div_0/divbuf_0/a_38430_n1540# vdda1 1.62fF **FLOATING
C16577 ro_div_0/divbuf_0/a_37950_n1540# vdda1 1.62fF **FLOATING
C16578 ro_div_0/divbuf_0/a_37470_n1540# vdda1 1.62fF **FLOATING
C16579 ro_div_0/divbuf_0/a_36990_n1540# vdda1 1.62fF **FLOATING
C16580 ro_div_0/divbuf_0/a_36510_n1540# vdda1 1.62fF **FLOATING
C16581 ro_div_0/divbuf_0/a_36030_n1540# vdda1 1.62fF **FLOATING
C16582 ro_div_0/divbuf_0/a_35550_n1540# vdda1 1.62fF **FLOATING
C16583 ro_div_0/divbuf_0/a_35070_n1540# vdda1 1.62fF **FLOATING
C16584 ro_div_0/divbuf_0/a_34590_n1540# vdda1 1.62fF **FLOATING
C16585 ro_div_0/divbuf_0/a_34110_n1540# vdda1 1.62fF **FLOATING
C16586 ro_div_0/divbuf_0/a_33630_n1540# vdda1 1.62fF **FLOATING
C16587 ro_div_0/divbuf_0/a_33150_n1540# vdda1 1.62fF **FLOATING
C16588 ro_div_0/divbuf_0/a_32670_n1540# vdda1 1.62fF **FLOATING
C16589 ro_div_0/divbuf_0/a_32190_n1540# vdda1 1.62fF **FLOATING
C16590 ro_div_0/divbuf_0/a_31710_n1540# vdda1 1.62fF **FLOATING
C16591 ro_div_0/divbuf_0/a_31230_n1540# vdda1 1.62fF **FLOATING
C16592 ro_div_0/divbuf_0/a_30750_n1540# vdda1 1.62fF **FLOATING
C16593 ro_div_0/divbuf_0/a_30270_n1540# vdda1 1.62fF **FLOATING
C16594 ro_div_0/divbuf_0/a_29790_n1540# vdda1 1.62fF **FLOATING
C16595 ro_div_0/divbuf_0/a_29310_n1540# vdda1 1.62fF **FLOATING
C16596 ro_div_0/divbuf_0/a_28830_n1540# vdda1 1.62fF **FLOATING
C16597 ro_div_0/divbuf_0/a_28350_n1540# vdda1 1.62fF **FLOATING
C16598 ro_div_0/divbuf_0/a_27870_n1540# vdda1 1.62fF **FLOATING
C16599 ro_div_0/divbuf_0/a_27390_n1540# vdda1 1.62fF **FLOATING
C16600 ro_div_0/divbuf_0/a_26910_n1540# vdda1 1.62fF **FLOATING
C16601 ro_div_0/divbuf_0/a_26430_n1540# vdda1 1.62fF **FLOATING
C16602 ro_div_0/divbuf_0/a_25950_n1540# vdda1 1.62fF **FLOATING
C16603 ro_div_0/divbuf_0/a_25470_n1540# vdda1 1.62fF **FLOATING
C16604 ro_div_0/divbuf_0/a_24990_n1540# vdda1 1.62fF **FLOATING
C16605 ro_div_0/divbuf_0/a_24510_n1540# vdda1 1.62fF **FLOATING
C16606 ro_div_0/divbuf_0/a_24030_n1540# vdda1 1.62fF **FLOATING
C16607 ro_div_0/divbuf_0/a_23550_n1540# vdda1 1.62fF **FLOATING
C16608 ro_div_0/divbuf_0/a_23070_n1540# vdda1 1.62fF **FLOATING
C16609 ro_div_0/divbuf_0/a_22590_n1540# vdda1 1.62fF **FLOATING
C16610 ro_div_0/divbuf_0/a_22110_n1540# vdda1 1.62fF **FLOATING
C16611 ro_div_0/divbuf_0/a_21630_n1540# vdda1 1.62fF **FLOATING
C16612 ro_div_0/divbuf_0/a_21150_n1540# vdda1 1.62fF **FLOATING
C16613 ro_div_0/divbuf_0/a_20670_n1540# vdda1 1.62fF **FLOATING
C16614 ro_div_0/divbuf_0/a_20190_n1540# vdda1 1.62fF **FLOATING
C16615 ro_div_0/divbuf_0/a_19710_n1540# vdda1 1.62fF **FLOATING
C16616 ro_div_0/divbuf_0/a_19230_n1540# vdda1 1.62fF **FLOATING
C16617 ro_div_0/divbuf_0/a_18750_n1540# vdda1 1.62fF **FLOATING
C16618 ro_div_0/divbuf_0/a_18270_n1540# vdda1 1.62fF **FLOATING
C16619 ro_div_0/divbuf_0/a_17790_n1540# vdda1 1.62fF **FLOATING
C16620 ro_div_0/divbuf_0/a_17310_n1540# vdda1 1.62fF **FLOATING
C16621 ro_div_0/divbuf_0/a_16830_n1540# vdda1 1.62fF **FLOATING
C16622 ro_div_0/divbuf_0/a_16350_n1540# vdda1 1.62fF **FLOATING
C16623 ro_div_0/divbuf_0/a_15870_n1540# vdda1 1.62fF **FLOATING
C16624 ro_div_0/divbuf_0/a_15390_n1540# vdda1 1.62fF **FLOATING
C16625 ro_div_0/divbuf_0/a_14910_n1540# vdda1 1.62fF **FLOATING
C16626 ro_div_0/divbuf_0/a_14430_n1540# vdda1 1.62fF **FLOATING
C16627 ro_div_0/divbuf_0/a_13950_n1540# vdda1 1.62fF **FLOATING
C16628 ro_div_0/divbuf_0/a_13470_n1540# vdda1 1.62fF **FLOATING
C16629 ro_div_0/divbuf_0/a_12990_n1540# vdda1 1.62fF **FLOATING
C16630 ro_div_0/divbuf_0/a_12510_n1540# vdda1 1.62fF **FLOATING
C16631 ro_div_0/divbuf_0/a_12030_n1540# vdda1 1.62fF **FLOATING
C16632 ro_div_0/divbuf_0/a_11550_n1540# vdda1 1.62fF **FLOATING
C16633 ro_div_0/divbuf_0/a_11070_n1540# vdda1 1.62fF **FLOATING
C16634 ro_div_0/divbuf_0/a_10590_n1540# vdda1 1.62fF **FLOATING
C16635 ro_div_0/divbuf_0/a_10110_n1540# vdda1 1.62fF **FLOATING
C16636 ro_div_0/divbuf_0/a_9630_n1540# vdda1 1.62fF **FLOATING
C16637 ro_div_0/divbuf_0/a_9150_n1540# vdda1 1.62fF **FLOATING
C16638 ro_div_0/divbuf_0/a_8670_n1540# vdda1 1.62fF **FLOATING
C16639 ro_div_0/divbuf_0/a_8190_n1540# vdda1 1.62fF **FLOATING
C16640 ro_div_0/divbuf_0/a_7710_n1540# vdda1 1.62fF **FLOATING
C16641 ro_div_0/divbuf_0/a_7230_n1540# vdda1 1.62fF **FLOATING
C16642 ro_div_0/divbuf_0/a_6750_n1540# vdda1 1.62fF **FLOATING
C16643 ro_div_0/divbuf_0/a_6270_n1540# vdda1 1.62fF **FLOATING
C16644 ro_div_0/divbuf_0/a_5790_n1540# vdda1 1.62fF **FLOATING
C16645 ro_div_0/divbuf_0/a_5310_n1540# vdda1 1.62fF **FLOATING
C16646 ro_div_0/divbuf_0/a_4830_n1540# vdda1 1.62fF **FLOATING
C16647 ro_div_0/divbuf_0/a_4350_n1540# vdda1 1.62fF **FLOATING
C16648 ro_div_0/divbuf_0/a_3870_n1540# vdda1 1.62fF **FLOATING
C16649 ro_div_0/divbuf_0/a_3390_n1540# vdda1 1.62fF **FLOATING
C16650 ro_div_0/divbuf_0/a_2910_n1540# vdda1 1.62fF **FLOATING
C16651 ro_div_0/divbuf_0/a_2430_n1540# vdda1 1.62fF **FLOATING
C16652 ro_div_0/divbuf_0/a_1950_n1540# vdda1 1.62fF **FLOATING
C16653 ro_div_0/divbuf_0/a_1470_n1540# vdda1 1.62fF **FLOATING
C16654 ro_div_0/divbuf_0/a_990_n1540# vdda1 1.62fF **FLOATING
C16655 ro_div_0/divbuf_0/a_510_n1540# vdda1 1.62fF **FLOATING
C16656 ro_div_0/divbuf_0/a_60990_n840# vdda1 1.06fF **FLOATING
C16657 ro_div_0/divbuf_0/a_60510_n840# vdda1 1.09fF **FLOATING
C16658 ro_div_0/divbuf_0/a_60030_n840# vdda1 1.09fF **FLOATING
C16659 ro_div_0/divbuf_0/a_59550_n840# vdda1 1.09fF **FLOATING
C16660 ro_div_0/divbuf_0/a_59070_n840# vdda1 1.09fF **FLOATING
C16661 ro_div_0/divbuf_0/a_58590_n840# vdda1 1.09fF **FLOATING
C16662 ro_div_0/divbuf_0/a_58110_n840# vdda1 1.09fF **FLOATING
C16663 ro_div_0/divbuf_0/a_57630_n840# vdda1 1.09fF **FLOATING
C16664 ro_div_0/divbuf_0/a_57150_n840# vdda1 1.09fF **FLOATING
C16665 ro_div_0/divbuf_0/a_56670_n840# vdda1 1.09fF **FLOATING
C16666 ro_div_0/divbuf_0/a_56190_n840# vdda1 1.09fF **FLOATING
C16667 ro_div_0/divbuf_0/a_55710_n840# vdda1 1.09fF **FLOATING
C16668 ro_div_0/divbuf_0/a_55230_n840# vdda1 1.09fF **FLOATING
C16669 ro_div_0/divbuf_0/a_54750_n840# vdda1 1.09fF **FLOATING
C16670 ro_div_0/divbuf_0/a_54270_n840# vdda1 1.09fF **FLOATING
C16671 ro_div_0/divbuf_0/a_53790_n840# vdda1 1.09fF **FLOATING
C16672 ro_div_0/divbuf_0/a_53310_n840# vdda1 1.09fF **FLOATING
C16673 ro_div_0/divbuf_0/a_52830_n840# vdda1 1.09fF **FLOATING
C16674 ro_div_0/divbuf_0/a_52350_n840# vdda1 1.09fF **FLOATING
C16675 ro_div_0/divbuf_0/a_51870_n840# vdda1 1.09fF **FLOATING
C16676 ro_div_0/divbuf_0/a_51390_n840# vdda1 1.09fF **FLOATING
C16677 ro_div_0/divbuf_0/a_50910_n840# vdda1 1.09fF **FLOATING
C16678 ro_div_0/divbuf_0/a_50430_n840# vdda1 1.09fF **FLOATING
C16679 ro_div_0/divbuf_0/a_49950_n840# vdda1 1.09fF **FLOATING
C16680 ro_div_0/divbuf_0/a_49470_n840# vdda1 1.09fF **FLOATING
C16681 ro_div_0/divbuf_0/a_48990_n840# vdda1 1.09fF **FLOATING
C16682 ro_div_0/divbuf_0/a_48510_n840# vdda1 1.09fF **FLOATING
C16683 ro_div_0/divbuf_0/a_48030_n840# vdda1 1.09fF **FLOATING
C16684 ro_div_0/divbuf_0/a_47550_n840# vdda1 1.09fF **FLOATING
C16685 ro_div_0/divbuf_0/a_47070_n840# vdda1 1.09fF **FLOATING
C16686 ro_div_0/divbuf_0/a_46590_n840# vdda1 1.09fF **FLOATING
C16687 ro_div_0/divbuf_0/a_46110_n840# vdda1 1.09fF **FLOATING
C16688 ro_div_0/divbuf_0/a_45630_n840# vdda1 1.09fF **FLOATING
C16689 ro_div_0/divbuf_0/a_45150_n840# vdda1 1.09fF **FLOATING
C16690 ro_div_0/divbuf_0/a_44670_n840# vdda1 1.09fF **FLOATING
C16691 ro_div_0/divbuf_0/a_44190_n840# vdda1 1.09fF **FLOATING
C16692 ro_div_0/divbuf_0/a_43710_n840# vdda1 1.09fF **FLOATING
C16693 ro_div_0/divbuf_0/a_43230_n840# vdda1 1.09fF **FLOATING
C16694 ro_div_0/divbuf_0/a_42750_n840# vdda1 1.08fF **FLOATING
C16695 ro_div_0/divbuf_0/a_42270_n840# vdda1 1.08fF **FLOATING
C16696 ro_div_0/divbuf_0/a_41790_n840# vdda1 1.10fF **FLOATING
C16697 ro_div_0/divbuf_0/a_41310_n840# vdda1 1.09fF **FLOATING
C16698 ro_div_0/divbuf_0/a_40830_n840# vdda1 1.09fF **FLOATING
C16699 ro_div_0/divbuf_0/a_40350_n840# vdda1 1.09fF **FLOATING
C16700 ro_div_0/divbuf_0/a_39870_n840# vdda1 1.09fF **FLOATING
C16701 ro_div_0/divbuf_0/a_39390_n840# vdda1 1.09fF **FLOATING
C16702 ro_div_0/divbuf_0/a_38910_n840# vdda1 1.09fF **FLOATING
C16703 ro_div_0/divbuf_0/a_38430_n840# vdda1 1.09fF **FLOATING
C16704 ro_div_0/divbuf_0/a_37950_n840# vdda1 1.09fF **FLOATING
C16705 ro_div_0/divbuf_0/a_37470_n840# vdda1 1.09fF **FLOATING
C16706 ro_div_0/divbuf_0/a_36990_n840# vdda1 1.09fF **FLOATING
C16707 ro_div_0/divbuf_0/a_36510_n840# vdda1 1.09fF **FLOATING
C16708 ro_div_0/divbuf_0/a_36030_n840# vdda1 1.09fF **FLOATING
C16709 ro_div_0/divbuf_0/a_35550_n840# vdda1 1.09fF **FLOATING
C16710 ro_div_0/divbuf_0/a_35070_n840# vdda1 1.09fF **FLOATING
C16711 ro_div_0/divbuf_0/a_34590_n840# vdda1 1.09fF **FLOATING
C16712 ro_div_0/divbuf_0/a_34110_n840# vdda1 1.09fF **FLOATING
C16713 ro_div_0/divbuf_0/a_33630_n840# vdda1 1.09fF **FLOATING
C16714 ro_div_0/divbuf_0/a_33150_n840# vdda1 1.09fF **FLOATING
C16715 ro_div_0/divbuf_0/a_32670_n840# vdda1 1.09fF **FLOATING
C16716 ro_div_0/divbuf_0/a_32190_n840# vdda1 1.09fF **FLOATING
C16717 ro_div_0/divbuf_0/a_31710_n840# vdda1 1.11fF **FLOATING
C16718 ro_div_0/divbuf_0/a_31230_n840# vdda1 1.13fF **FLOATING
C16719 ro_div_0/divbuf_0/a_30750_n840# vdda1 1.09fF **FLOATING
C16720 ro_div_0/divbuf_0/a_30270_n840# vdda1 1.09fF **FLOATING
C16721 ro_div_0/divbuf_0/a_29790_n840# vdda1 1.09fF **FLOATING
C16722 ro_div_0/divbuf_0/a_29310_n840# vdda1 1.09fF **FLOATING
C16723 ro_div_0/divbuf_0/a_28830_n840# vdda1 1.09fF **FLOATING
C16724 ro_div_0/divbuf_0/a_28350_n840# vdda1 1.09fF **FLOATING
C16725 ro_div_0/divbuf_0/a_27870_n840# vdda1 1.08fF **FLOATING
C16726 ro_div_0/divbuf_0/a_27390_n840# vdda1 1.11fF **FLOATING
C16727 ro_div_0/divbuf_0/a_26910_n840# vdda1 1.10fF **FLOATING
C16728 ro_div_0/divbuf_0/a_26430_n840# vdda1 1.10fF **FLOATING
C16729 ro_div_0/divbuf_0/a_25950_n840# vdda1 1.10fF **FLOATING
C16730 ro_div_0/divbuf_0/a_25470_n840# vdda1 1.10fF **FLOATING
C16731 ro_div_0/divbuf_0/a_24990_n840# vdda1 1.10fF **FLOATING
C16732 ro_div_0/divbuf_0/a_24510_n840# vdda1 1.10fF **FLOATING
C16733 ro_div_0/divbuf_0/a_24030_n840# vdda1 1.09fF **FLOATING
C16734 ro_div_0/divbuf_0/a_23550_n840# vdda1 1.11fF **FLOATING
C16735 ro_div_0/divbuf_0/a_23070_n840# vdda1 1.10fF **FLOATING
C16736 ro_div_0/divbuf_0/a_22590_n840# vdda1 1.10fF **FLOATING
C16737 ro_div_0/divbuf_0/a_22110_n840# vdda1 1.10fF **FLOATING
C16738 ro_div_0/divbuf_0/a_21630_n840# vdda1 1.10fF **FLOATING
C16739 ro_div_0/divbuf_0/a_21150_n840# vdda1 1.10fF **FLOATING
C16740 ro_div_0/divbuf_0/a_20670_n840# vdda1 1.10fF **FLOATING
C16741 ro_div_0/divbuf_0/a_20190_n840# vdda1 1.09fF **FLOATING
C16742 ro_div_0/divbuf_0/a_19710_n840# vdda1 1.09fF **FLOATING
C16743 ro_div_0/divbuf_0/a_19230_n840# vdda1 1.09fF **FLOATING
C16744 ro_div_0/divbuf_0/a_18750_n840# vdda1 1.09fF **FLOATING
C16745 ro_div_0/divbuf_0/a_18270_n840# vdda1 1.08fF **FLOATING
C16746 ro_div_0/divbuf_0/a_17790_n840# vdda1 1.08fF **FLOATING
C16747 ro_div_0/divbuf_0/a_17310_n840# vdda1 1.07fF **FLOATING
C16748 ro_div_0/divbuf_0/a_16830_n840# vdda1 1.07fF **FLOATING
C16749 ro_div_0/divbuf_0/a_16350_n840# vdda1 1.07fF **FLOATING
C16750 ro_div_0/divbuf_0/a_15870_n840# vdda1 1.07fF **FLOATING
C16751 ro_div_0/divbuf_0/a_15390_n840# vdda1 1.08fF **FLOATING
C16752 ro_div_0/divbuf_0/a_14910_n840# vdda1 1.07fF **FLOATING
C16753 ro_div_0/divbuf_0/a_14430_n840# vdda1 1.07fF **FLOATING
C16754 ro_div_0/divbuf_0/a_13950_n840# vdda1 1.07fF **FLOATING
C16755 ro_div_0/divbuf_0/a_13470_n840# vdda1 1.07fF **FLOATING
C16756 ro_div_0/divbuf_0/a_12990_n840# vdda1 1.10fF **FLOATING
C16757 ro_div_0/divbuf_0/a_12510_n840# vdda1 1.08fF **FLOATING
C16758 ro_div_0/divbuf_0/a_12030_n840# vdda1 1.07fF **FLOATING
C16759 ro_div_0/divbuf_0/a_11550_n840# vdda1 1.07fF **FLOATING
C16760 ro_div_0/divbuf_0/a_11070_n840# vdda1 1.08fF **FLOATING
C16761 ro_div_0/divbuf_0/a_10590_n840# vdda1 1.10fF **FLOATING
C16762 ro_div_0/divbuf_0/a_10110_n840# vdda1 1.10fF **FLOATING
C16763 ro_div_0/divbuf_0/a_9630_n840# vdda1 1.10fF **FLOATING
C16764 ro_div_0/divbuf_0/a_9150_n840# vdda1 1.10fF **FLOATING
C16765 ro_div_0/divbuf_0/a_8670_n840# vdda1 1.10fF **FLOATING
C16766 ro_div_0/divbuf_0/a_8190_n840# vdda1 1.12fF **FLOATING
C16767 ro_div_0/divbuf_0/a_7710_n840# vdda1 1.10fF **FLOATING
C16768 ro_div_0/divbuf_0/a_7230_n840# vdda1 1.09fF **FLOATING
C16769 ro_div_0/divbuf_0/a_6750_n840# vdda1 1.09fF **FLOATING
C16770 ro_div_0/divbuf_0/a_6270_n840# vdda1 1.09fF **FLOATING
C16771 ro_div_0/divbuf_0/a_5790_n840# vdda1 1.09fF **FLOATING
C16772 ro_div_0/divbuf_0/a_5310_n840# vdda1 1.09fF **FLOATING
C16773 ro_div_0/divbuf_0/a_4830_n840# vdda1 1.09fF **FLOATING
C16774 ro_div_0/divbuf_0/a_4350_n840# vdda1 1.09fF **FLOATING
C16775 ro_div_0/divbuf_0/a_3870_n840# vdda1 1.09fF **FLOATING
C16776 ro_div_0/divbuf_0/a_3390_n840# vdda1 1.09fF **FLOATING
C16777 ro_div_0/divbuf_0/a_2910_n840# vdda1 1.10fF **FLOATING
C16778 ro_div_0/divbuf_0/a_2430_n840# vdda1 1.10fF **FLOATING
C16779 ro_div_0/divbuf_0/a_1950_n840# vdda1 1.10fF **FLOATING
C16780 ro_div_0/divbuf_0/a_1470_n840# vdda1 1.10fF **FLOATING
C16781 ro_div_0/divbuf_0/a_990_n840# vdda1 1.08fF **FLOATING
C16782 ro_div_0/divbuf_0/a_510_n840# vdda1 1.07fF **FLOATING
C16783 ro_div_0/divbuf_0/a_60480_n1600# vdda1 1.48fF **FLOATING
C16784 ro_div_0/divbuf_0/a_60000_n1600# vdda1 1.48fF **FLOATING
C16785 ro_div_0/divbuf_0/a_59520_n1600# vdda1 1.48fF **FLOATING
C16786 ro_div_0/divbuf_0/a_59040_n1600# vdda1 1.48fF **FLOATING
C16787 ro_div_0/divbuf_0/a_58560_n1600# vdda1 1.48fF **FLOATING
C16788 ro_div_0/divbuf_0/a_58080_n1600# vdda1 1.48fF **FLOATING
C16789 ro_div_0/divbuf_0/a_57600_n1600# vdda1 1.48fF **FLOATING
C16790 ro_div_0/divbuf_0/a_57120_n1600# vdda1 1.48fF **FLOATING
C16791 ro_div_0/divbuf_0/a_56640_n1600# vdda1 1.48fF **FLOATING
C16792 ro_div_0/divbuf_0/a_56160_n1600# vdda1 1.48fF **FLOATING
C16793 ro_div_0/divbuf_0/a_55680_n1600# vdda1 1.48fF **FLOATING
C16794 ro_div_0/divbuf_0/a_55200_n1600# vdda1 1.48fF **FLOATING
C16795 ro_div_0/divbuf_0/a_54720_n1600# vdda1 1.48fF **FLOATING
C16796 ro_div_0/divbuf_0/a_54240_n1600# vdda1 1.48fF **FLOATING
C16797 ro_div_0/divbuf_0/a_53760_n1600# vdda1 1.48fF **FLOATING
C16798 ro_div_0/divbuf_0/a_53280_n1600# vdda1 1.48fF **FLOATING
C16799 ro_div_0/divbuf_0/a_52800_n1600# vdda1 1.48fF **FLOATING
C16800 ro_div_0/divbuf_0/a_52320_n1600# vdda1 1.48fF **FLOATING
C16801 ro_div_0/divbuf_0/a_51840_n1600# vdda1 1.48fF **FLOATING
C16802 ro_div_0/divbuf_0/a_51360_n1600# vdda1 1.48fF **FLOATING
C16803 ro_div_0/divbuf_0/a_50880_n1600# vdda1 1.48fF **FLOATING
C16804 ro_div_0/divbuf_0/a_50400_n1600# vdda1 1.48fF **FLOATING
C16805 ro_div_0/divbuf_0/a_49920_n1600# vdda1 1.48fF **FLOATING
C16806 ro_div_0/divbuf_0/a_49440_n1600# vdda1 1.48fF **FLOATING
C16807 ro_div_0/divbuf_0/a_48960_n1600# vdda1 1.48fF **FLOATING
C16808 ro_div_0/divbuf_0/a_48480_n1600# vdda1 1.48fF **FLOATING
C16809 ro_div_0/divbuf_0/a_48000_n1600# vdda1 1.48fF **FLOATING
C16810 ro_div_0/divbuf_0/a_47520_n1600# vdda1 1.48fF **FLOATING
C16811 ro_div_0/divbuf_0/a_47040_n1600# vdda1 1.48fF **FLOATING
C16812 ro_div_0/divbuf_0/a_46560_n1600# vdda1 1.48fF **FLOATING
C16813 ro_div_0/divbuf_0/a_46080_n1600# vdda1 1.48fF **FLOATING
C16814 ro_div_0/divbuf_0/a_45600_n1600# vdda1 1.48fF **FLOATING
C16815 ro_div_0/divbuf_0/a_45120_n1600# vdda1 1.48fF **FLOATING
C16816 ro_div_0/divbuf_0/a_44640_n1600# vdda1 1.48fF **FLOATING
C16817 ro_div_0/divbuf_0/a_44160_n1600# vdda1 1.48fF **FLOATING
C16818 ro_div_0/divbuf_0/a_43680_n1600# vdda1 1.48fF **FLOATING
C16819 ro_div_0/divbuf_0/a_43200_n1600# vdda1 1.48fF **FLOATING
C16820 ro_div_0/divbuf_0/a_42720_n1600# vdda1 1.48fF **FLOATING
C16821 ro_div_0/divbuf_0/a_42240_n1600# vdda1 1.48fF **FLOATING
C16822 ro_div_0/divbuf_0/a_41760_n1600# vdda1 1.48fF **FLOATING
C16823 ro_div_0/divbuf_0/a_41280_n1600# vdda1 1.48fF **FLOATING
C16824 ro_div_0/divbuf_0/a_40800_n1600# vdda1 1.48fF **FLOATING
C16825 ro_div_0/divbuf_0/a_40320_n1600# vdda1 1.48fF **FLOATING
C16826 ro_div_0/divbuf_0/a_39840_n1600# vdda1 1.48fF **FLOATING
C16827 ro_div_0/divbuf_0/a_39360_n1600# vdda1 1.48fF **FLOATING
C16828 ro_div_0/divbuf_0/a_38880_n1600# vdda1 1.48fF **FLOATING
C16829 ro_div_0/divbuf_0/a_38400_n1600# vdda1 1.48fF **FLOATING
C16830 ro_div_0/divbuf_0/a_37920_n1600# vdda1 1.48fF **FLOATING
C16831 ro_div_0/divbuf_0/a_37440_n1600# vdda1 1.48fF **FLOATING
C16832 ro_div_0/divbuf_0/a_36960_n1600# vdda1 1.48fF **FLOATING
C16833 ro_div_0/divbuf_0/a_36480_n1600# vdda1 1.48fF **FLOATING
C16834 ro_div_0/divbuf_0/a_36000_n1600# vdda1 1.48fF **FLOATING
C16835 ro_div_0/divbuf_0/a_35520_n1600# vdda1 1.48fF **FLOATING
C16836 ro_div_0/divbuf_0/a_35040_n1600# vdda1 1.48fF **FLOATING
C16837 ro_div_0/divbuf_0/a_34560_n1600# vdda1 1.48fF **FLOATING
C16838 ro_div_0/divbuf_0/a_34080_n1600# vdda1 1.48fF **FLOATING
C16839 ro_div_0/divbuf_0/a_33600_n1600# vdda1 1.48fF **FLOATING
C16840 ro_div_0/divbuf_0/a_33120_n1600# vdda1 1.48fF **FLOATING
C16841 ro_div_0/divbuf_0/a_32640_n1600# vdda1 1.48fF **FLOATING
C16842 ro_div_0/divbuf_0/a_32160_n1600# vdda1 1.48fF **FLOATING
C16843 ro_div_0/divbuf_0/a_31680_n1600# vdda1 1.48fF **FLOATING
C16844 ro_div_0/divbuf_0/a_31200_n1600# vdda1 1.48fF **FLOATING
C16845 ro_div_0/divbuf_0/a_30720_n1600# vdda1 1.48fF **FLOATING
C16846 ro_div_0/divbuf_0/a_30240_n1600# vdda1 1.48fF **FLOATING
C16847 ro_div_0/divbuf_0/a_29760_n1600# vdda1 1.48fF **FLOATING
C16848 ro_div_0/divbuf_0/a_29280_n1600# vdda1 1.48fF **FLOATING
C16849 ro_div_0/divbuf_0/a_28800_n1600# vdda1 1.48fF **FLOATING
C16850 ro_div_0/divbuf_0/a_28320_n1600# vdda1 1.48fF **FLOATING
C16851 ro_div_0/divbuf_0/a_27840_n1600# vdda1 1.48fF **FLOATING
C16852 ro_div_0/divbuf_0/a_27360_n1600# vdda1 1.48fF **FLOATING
C16853 ro_div_0/divbuf_0/a_26880_n1600# vdda1 1.48fF **FLOATING
C16854 ro_div_0/divbuf_0/a_26400_n1600# vdda1 1.48fF **FLOATING
C16855 ro_div_0/divbuf_0/a_25920_n1600# vdda1 1.48fF **FLOATING
C16856 ro_div_0/divbuf_0/a_25440_n1600# vdda1 1.48fF **FLOATING
C16857 ro_div_0/divbuf_0/a_24960_n1600# vdda1 1.48fF **FLOATING
C16858 ro_div_0/divbuf_0/a_24480_n1600# vdda1 1.48fF **FLOATING
C16859 ro_div_0/divbuf_0/a_24000_n1600# vdda1 1.48fF **FLOATING
C16860 ro_div_0/divbuf_0/a_23520_n1600# vdda1 1.48fF **FLOATING
C16861 ro_div_0/divbuf_0/a_23040_n1600# vdda1 1.48fF **FLOATING
C16862 ro_div_0/divbuf_0/a_22560_n1600# vdda1 1.48fF **FLOATING
C16863 ro_div_0/divbuf_0/a_22080_n1600# vdda1 1.48fF **FLOATING
C16864 ro_div_0/divbuf_0/a_21600_n1600# vdda1 1.48fF **FLOATING
C16865 ro_div_0/divbuf_0/a_21120_n1600# vdda1 1.48fF **FLOATING
C16866 ro_div_0/divbuf_0/a_20640_n1600# vdda1 1.48fF **FLOATING
C16867 ro_div_0/divbuf_0/a_20160_n1600# vdda1 1.48fF **FLOATING
C16868 ro_div_0/divbuf_0/a_19680_n1600# vdda1 1.48fF **FLOATING
C16869 ro_div_0/divbuf_0/a_19200_n1600# vdda1 1.48fF **FLOATING
C16870 ro_div_0/divbuf_0/a_18720_n1600# vdda1 1.48fF **FLOATING
C16871 ro_div_0/divbuf_0/a_18240_n1600# vdda1 1.48fF **FLOATING
C16872 ro_div_0/divbuf_0/a_17760_n1600# vdda1 1.48fF **FLOATING
C16873 ro_div_0/divbuf_0/a_17280_n1600# vdda1 1.48fF **FLOATING
C16874 ro_div_0/divbuf_0/a_16800_n1600# vdda1 1.48fF **FLOATING
C16875 ro_div_0/divbuf_0/a_16320_n1600# vdda1 1.48fF **FLOATING
C16876 ro_div_0/divbuf_0/a_15840_n1600# vdda1 1.48fF **FLOATING
C16877 ro_div_0/divbuf_0/a_15360_n1600# vdda1 1.48fF **FLOATING
C16878 ro_div_0/divbuf_0/a_14880_n1600# vdda1 1.48fF **FLOATING
C16879 ro_div_0/divbuf_0/a_14400_n1600# vdda1 1.48fF **FLOATING
C16880 ro_div_0/divbuf_0/a_13920_n1600# vdda1 1.48fF **FLOATING
C16881 ro_div_0/divbuf_0/a_13440_n1600# vdda1 1.48fF **FLOATING
C16882 ro_div_0/divbuf_0/a_12960_n1600# vdda1 1.48fF **FLOATING
C16883 ro_div_0/divbuf_0/a_12480_n1600# vdda1 1.48fF **FLOATING
C16884 ro_div_0/divbuf_0/a_12000_n1600# vdda1 1.48fF **FLOATING
C16885 ro_div_0/divbuf_0/a_11520_n1600# vdda1 1.48fF **FLOATING
C16886 ro_div_0/divbuf_0/a_11040_n1600# vdda1 1.48fF **FLOATING
C16887 ro_div_0/divbuf_0/a_10560_n1600# vdda1 1.48fF **FLOATING
C16888 ro_div_0/divbuf_0/a_10080_n1600# vdda1 1.48fF **FLOATING
C16889 ro_div_0/divbuf_0/a_9600_n1600# vdda1 1.48fF **FLOATING
C16890 ro_div_0/divbuf_0/a_9120_n1600# vdda1 1.48fF **FLOATING
C16891 ro_div_0/divbuf_0/a_8640_n1600# vdda1 1.48fF **FLOATING
C16892 ro_div_0/divbuf_0/a_8160_n1600# vdda1 1.48fF **FLOATING
C16893 ro_div_0/divbuf_0/a_7680_n1600# vdda1 1.48fF **FLOATING
C16894 ro_div_0/divbuf_0/a_7200_n1600# vdda1 1.48fF **FLOATING
C16895 ro_div_0/divbuf_0/a_6720_n1600# vdda1 1.48fF **FLOATING
C16896 ro_div_0/divbuf_0/a_6240_n1600# vdda1 1.48fF **FLOATING
C16897 ro_div_0/divbuf_0/a_5760_n1600# vdda1 1.48fF **FLOATING
C16898 ro_div_0/divbuf_0/a_5280_n1600# vdda1 1.48fF **FLOATING
C16899 ro_div_0/divbuf_0/a_4800_n1600# vdda1 1.48fF **FLOATING
C16900 ro_div_0/divbuf_0/a_4320_n1600# vdda1 1.48fF **FLOATING
C16901 ro_div_0/divbuf_0/a_3840_n1600# vdda1 1.48fF **FLOATING
C16902 ro_div_0/divbuf_0/a_3360_n1600# vdda1 1.48fF **FLOATING
C16903 ro_div_0/divbuf_0/a_2880_n1600# vdda1 1.48fF **FLOATING
C16904 ro_div_0/divbuf_0/a_2400_n1600# vdda1 1.48fF **FLOATING
C16905 ro_div_0/divbuf_0/a_1920_n1600# vdda1 1.48fF **FLOATING
C16906 ro_div_0/divbuf_0/a_1440_n1600# vdda1 1.48fF **FLOATING
C16907 ro_div_0/divbuf_0/a_960_n1600# vdda1 1.48fF **FLOATING
C16908 ro_div_0/divbuf_0/a_480_n1600# vdda1 1.48fF **FLOATING
C16909 ro_div_0/divbuf_0/a_0_n1600# vdda1 1.48fF **FLOATING
C16910 ro_div_0/divbuf_0/a_41382_n240# vdda1 0.90fF **FLOATING
C16911 ro_div_0/divbuf_0/a_40902_n240# vdda1 0.90fF **FLOATING
C16912 ro_div_0/divbuf_0/a_40412_n240# vdda1 0.90fF **FLOATING
C16913 ro_div_0/divbuf_0/a_39932_n240# vdda1 0.90fF **FLOATING
C16914 ro_div_0/divbuf_0/a_39442_n240# vdda1 0.90fF **FLOATING
C16915 ro_div_0/divbuf_0/a_38962_n240# vdda1 0.91fF **FLOATING
C16916 ro_div_0/divbuf_0/a_38472_n240# vdda1 0.90fF **FLOATING
C16917 ro_div_0/divbuf_0/a_37992_n240# vdda1 0.90fF **FLOATING
C16918 ro_div_0/divbuf_0/a_37502_n240# vdda1 0.90fF **FLOATING
C16919 ro_div_0/divbuf_0/a_37022_n240# vdda1 0.90fF **FLOATING
C16920 ro_div_0/divbuf_0/a_36532_n240# vdda1 0.90fF **FLOATING
C16921 ro_div_0/divbuf_0/a_36052_n240# vdda1 0.90fF **FLOATING
C16922 ro_div_0/divbuf_0/a_35562_n240# vdda1 0.90fF **FLOATING
C16923 ro_div_0/divbuf_0/a_35082_n240# vdda1 0.91fF **FLOATING
C16924 ro_div_0/divbuf_0/a_34592_n240# vdda1 0.90fF **FLOATING
C16925 ro_div_0/divbuf_0/a_34112_n240# vdda1 0.90fF **FLOATING
C16926 ro_div_0/divbuf_0/a_33622_n240# vdda1 0.90fF **FLOATING
C16927 ro_div_0/divbuf_0/a_33142_n240# vdda1 0.90fF **FLOATING
C16928 ro_div_0/divbuf_0/a_32652_n240# vdda1 0.90fF **FLOATING
C16929 ro_div_0/divbuf_0/a_32172_n240# vdda1 0.90fF **FLOATING
C16930 ro_div_0/divbuf_0/a_31682_n240# vdda1 0.89fF **FLOATING
C16931 ro_div_0/divbuf_0/a_31202_n240# vdda1 0.92fF **FLOATING
C16932 ro_div_0/divbuf_0/a_30712_n240# vdda1 0.90fF **FLOATING
C16933 ro_div_0/divbuf_0/a_30232_n240# vdda1 0.90fF **FLOATING
C16934 ro_div_0/divbuf_0/a_29742_n240# vdda1 0.90fF **FLOATING
C16935 ro_div_0/divbuf_0/a_29262_n240# vdda1 0.90fF **FLOATING
C16936 ro_div_0/divbuf_0/a_28772_n240# vdda1 0.90fF **FLOATING
C16937 ro_div_0/divbuf_0/a_28292_n240# vdda1 0.90fF **FLOATING
C16938 ro_div_0/divbuf_0/a_27802_n240# vdda1 0.89fF **FLOATING
C16939 ro_div_0/divbuf_0/a_27322_n240# vdda1 0.95fF **FLOATING
C16940 ro_div_0/divbuf_0/a_26832_n240# vdda1 0.91fF **FLOATING
C16941 ro_div_0/divbuf_0/a_26352_n240# vdda1 0.91fF **FLOATING
C16942 ro_div_0/divbuf_0/a_25862_n240# vdda1 0.91fF **FLOATING
C16943 ro_div_0/divbuf_0/a_25382_n240# vdda1 0.91fF **FLOATING
C16944 ro_div_0/divbuf_0/a_24892_n240# vdda1 0.91fF **FLOATING
C16945 ro_div_0/divbuf_0/a_24412_n240# vdda1 0.91fF **FLOATING
C16946 ro_div_0/divbuf_0/a_23922_n240# vdda1 0.92fF **FLOATING
C16947 ro_div_0/divbuf_0/a_23442_n240# vdda1 0.94fF **FLOATING
C16948 ro_div_0/divbuf_0/a_22952_n240# vdda1 0.91fF **FLOATING
C16949 ro_div_0/divbuf_0/a_22472_n240# vdda1 0.91fF **FLOATING
C16950 ro_div_0/divbuf_0/a_21982_n240# vdda1 0.91fF **FLOATING
C16951 ro_div_0/divbuf_0/a_21502_n240# vdda1 0.91fF **FLOATING
C16952 ro_div_0/divbuf_0/a_21012_n240# vdda1 0.91fF **FLOATING
C16953 ro_div_0/divbuf_0/a_20532_n240# vdda1 0.91fF **FLOATING
C16954 ro_div_0/divbuf_0/a_20042_n240# vdda1 0.90fF **FLOATING
C16955 ro_div_0/divbuf_0/a_19562_n240# vdda1 0.90fF **FLOATING
C16956 ro_div_0/divbuf_0/a_19072_n240# vdda1 0.90fF **FLOATING
C16957 ro_div_0/divbuf_0/a_18582_n240# vdda1 0.89fF **FLOATING
C16958 ro_div_0/divbuf_0/a_18092_n240# vdda1 0.89fF **FLOATING
C16959 ro_div_0/divbuf_0/a_17612_n240# vdda1 0.89fF **FLOATING
C16960 ro_div_0/divbuf_0/a_17122_n240# vdda1 0.88fF **FLOATING
C16961 ro_div_0/divbuf_0/a_16642_n240# vdda1 0.88fF **FLOATING
C16962 ro_div_0/divbuf_0/a_16152_n240# vdda1 0.88fF **FLOATING
C16963 ro_div_0/divbuf_0/a_15672_n240# vdda1 0.90fF **FLOATING
C16964 ro_div_0/divbuf_0/a_15182_n240# vdda1 0.88fF **FLOATING
C16965 ro_div_0/divbuf_0/a_14702_n240# vdda1 0.88fF **FLOATING
C16966 ro_div_0/divbuf_0/a_14222_n240# vdda1 0.88fF **FLOATING
C16967 ro_div_0/divbuf_0/a_13742_n240# vdda1 0.88fF **FLOATING
C16968 ro_div_0/divbuf_0/a_13252_n240# vdda1 0.88fF **FLOATING
C16969 ro_div_0/divbuf_0/a_12772_n240# vdda1 0.88fF **FLOATING
C16970 ro_div_0/divbuf_0/a_12282_n240# vdda1 0.88fF **FLOATING
C16971 ro_div_0/divbuf_0/a_11802_n240# vdda1 0.88fF **FLOATING
C16972 ro_div_0/divbuf_0/a_11312_n240# vdda1 0.89fF **FLOATING
C16973 ro_div_0/divbuf_0/a_10212_n240# vdda1 0.91fF **FLOATING
C16974 ro_div_0/divbuf_0/a_9732_n240# vdda1 0.91fF **FLOATING
C16975 ro_div_0/divbuf_0/a_9242_n240# vdda1 0.91fF **FLOATING
C16976 ro_div_0/divbuf_0/a_8762_n240# vdda1 0.91fF **FLOATING
C16977 ro_div_0/divbuf_0/a_8272_n240# vdda1 0.91fF **FLOATING
C16978 ro_div_0/divbuf_0/a_7792_n240# vdda1 0.92fF **FLOATING
C16979 ro_div_0/divbuf_0/a_7302_n240# vdda1 0.90fF **FLOATING
C16980 ro_div_0/divbuf_0/a_6822_n240# vdda1 0.90fF **FLOATING
C16981 ro_div_0/divbuf_0/a_6332_n240# vdda1 0.90fF **FLOATING
C16982 ro_div_0/divbuf_0/a_5852_n240# vdda1 0.90fF **FLOATING
C16983 ro_div_0/divbuf_0/a_5362_n240# vdda1 0.90fF **FLOATING
C16984 ro_div_0/divbuf_0/a_4882_n240# vdda1 0.90fF **FLOATING
C16985 ro_div_0/divbuf_0/a_4392_n240# vdda1 0.90fF **FLOATING
C16986 ro_div_0/divbuf_0/a_3912_n240# vdda1 0.90fF **FLOATING
C16987 ro_div_0/divbuf_0/a_3422_n240# vdda1 0.90fF **FLOATING
C16988 ro_div_0/divbuf_0/a_2322_n240# vdda1 0.91fF **FLOATING
C16989 ro_div_0/divbuf_0/a_1842_n240# vdda1 0.91fF **FLOATING
C16990 ro_div_0/divbuf_0/a_1352_n240# vdda1 0.91fF **FLOATING
C16991 ro_div_0/divbuf_0/a_41382_170# vdda1 1.07fF **FLOATING
C16992 ro_div_0/divbuf_0/a_40902_170# vdda1 1.09fF **FLOATING
C16993 ro_div_0/divbuf_0/a_40412_170# vdda1 1.09fF **FLOATING
C16994 ro_div_0/divbuf_0/a_39932_170# vdda1 1.09fF **FLOATING
C16995 ro_div_0/divbuf_0/a_39442_170# vdda1 1.09fF **FLOATING
C16996 ro_div_0/divbuf_0/a_38962_170# vdda1 1.07fF **FLOATING
C16997 ro_div_0/divbuf_0/a_38472_170# vdda1 1.09fF **FLOATING
C16998 ro_div_0/divbuf_0/a_37992_170# vdda1 1.09fF **FLOATING
C16999 ro_div_0/divbuf_0/a_37502_170# vdda1 1.09fF **FLOATING
C17000 ro_div_0/divbuf_0/a_37022_170# vdda1 1.09fF **FLOATING
C17001 ro_div_0/divbuf_0/a_36532_170# vdda1 1.09fF **FLOATING
C17002 ro_div_0/divbuf_0/a_36052_170# vdda1 1.09fF **FLOATING
C17003 ro_div_0/divbuf_0/a_35562_170# vdda1 1.09fF **FLOATING
C17004 ro_div_0/divbuf_0/a_35082_170# vdda1 1.09fF **FLOATING
C17005 ro_div_0/divbuf_0/a_34592_170# vdda1 1.07fF **FLOATING
C17006 ro_div_0/divbuf_0/a_34112_170# vdda1 1.09fF **FLOATING
C17007 ro_div_0/divbuf_0/a_33622_170# vdda1 1.09fF **FLOATING
C17008 ro_div_0/divbuf_0/a_33142_170# vdda1 1.09fF **FLOATING
C17009 ro_div_0/divbuf_0/a_32652_170# vdda1 1.09fF **FLOATING
C17010 ro_div_0/divbuf_0/a_32172_170# vdda1 1.09fF **FLOATING
C17011 ro_div_0/divbuf_0/a_31682_170# vdda1 1.09fF **FLOATING
C17012 ro_div_0/divbuf_0/a_31202_170# vdda1 1.09fF **FLOATING
C17013 ro_div_0/divbuf_0/a_30712_170# vdda1 1.09fF **FLOATING
C17014 ro_div_0/divbuf_0/a_30232_170# vdda1 1.07fF **FLOATING
C17015 ro_div_0/divbuf_0/a_29742_170# vdda1 1.09fF **FLOATING
C17016 ro_div_0/divbuf_0/a_29262_170# vdda1 1.09fF **FLOATING
C17017 ro_div_0/divbuf_0/a_28772_170# vdda1 1.09fF **FLOATING
C17018 ro_div_0/divbuf_0/a_28292_170# vdda1 1.09fF **FLOATING
C17019 ro_div_0/divbuf_0/a_27802_170# vdda1 1.09fF **FLOATING
C17020 ro_div_0/divbuf_0/a_27322_170# vdda1 1.09fF **FLOATING
C17021 ro_div_0/divbuf_0/a_26832_170# vdda1 1.09fF **FLOATING
C17022 ro_div_0/divbuf_0/a_26352_170# vdda1 1.09fF **FLOATING
C17023 ro_div_0/divbuf_0/a_25862_170# vdda1 1.07fF **FLOATING
C17024 ro_div_0/divbuf_0/a_25382_170# vdda1 1.09fF **FLOATING
C17025 ro_div_0/divbuf_0/a_24892_170# vdda1 1.09fF **FLOATING
C17026 ro_div_0/divbuf_0/a_24412_170# vdda1 1.09fF **FLOATING
C17027 ro_div_0/divbuf_0/a_23922_170# vdda1 1.09fF **FLOATING
C17028 ro_div_0/divbuf_0/a_23442_170# vdda1 1.09fF **FLOATING
C17029 ro_div_0/divbuf_0/a_22952_170# vdda1 1.09fF **FLOATING
C17030 ro_div_0/divbuf_0/a_22472_170# vdda1 1.07fF **FLOATING
C17031 ro_div_0/divbuf_0/a_21982_170# vdda1 1.09fF **FLOATING
C17032 ro_div_0/divbuf_0/a_21502_170# vdda1 1.09fF **FLOATING
C17033 ro_div_0/divbuf_0/a_21012_170# vdda1 1.09fF **FLOATING
C17034 ro_div_0/divbuf_0/a_20532_170# vdda1 1.09fF **FLOATING
C17035 ro_div_0/divbuf_0/a_20042_170# vdda1 1.09fF **FLOATING
C17036 ro_div_0/divbuf_0/a_19562_170# vdda1 1.09fF **FLOATING
C17037 ro_div_0/divbuf_0/a_19072_170# vdda1 1.09fF **FLOATING
C17038 ro_div_0/divbuf_0/a_18582_170# vdda1 1.07fF **FLOATING
C17039 ro_div_0/divbuf_0/a_18092_170# vdda1 1.09fF **FLOATING
C17040 ro_div_0/divbuf_0/a_17612_170# vdda1 1.09fF **FLOATING
C17041 ro_div_0/divbuf_0/a_17122_170# vdda1 1.09fF **FLOATING
C17042 ro_div_0/divbuf_0/a_16642_170# vdda1 1.09fF **FLOATING
C17043 ro_div_0/divbuf_0/a_16152_170# vdda1 1.09fF **FLOATING
C17044 ro_div_0/divbuf_0/a_15672_170# vdda1 1.09fF **FLOATING
C17045 ro_div_0/divbuf_0/a_15182_170# vdda1 1.09fF **FLOATING
C17046 ro_div_0/divbuf_0/a_14702_170# vdda1 1.10fF **FLOATING
C17047 ro_div_0/divbuf_0/a_14222_170# vdda1 1.10fF **FLOATING
C17048 ro_div_0/divbuf_0/a_13742_170# vdda1 1.09fF **FLOATING
C17049 ro_div_0/divbuf_0/a_13252_170# vdda1 1.09fF **FLOATING
C17050 ro_div_0/divbuf_0/a_12772_170# vdda1 1.07fF **FLOATING
C17051 ro_div_0/divbuf_0/a_12282_170# vdda1 1.09fF **FLOATING
C17052 ro_div_0/divbuf_0/a_11802_170# vdda1 1.09fF **FLOATING
C17053 ro_div_0/divbuf_0/a_11312_170# vdda1 1.10fF **FLOATING
C17054 ro_div_0/divbuf_0/a_10212_170# vdda1 1.09fF **FLOATING
C17055 ro_div_0/divbuf_0/a_9732_170# vdda1 1.09fF **FLOATING
C17056 ro_div_0/divbuf_0/a_9242_170# vdda1 1.09fF **FLOATING
C17057 ro_div_0/divbuf_0/a_8762_170# vdda1 1.09fF **FLOATING
C17058 ro_div_0/divbuf_0/a_8272_170# vdda1 1.07fF **FLOATING
C17059 ro_div_0/divbuf_0/a_7792_170# vdda1 1.09fF **FLOATING
C17060 ro_div_0/divbuf_0/a_7302_170# vdda1 1.09fF **FLOATING
C17061 ro_div_0/divbuf_0/a_6822_170# vdda1 1.09fF **FLOATING
C17062 ro_div_0/divbuf_0/a_6332_170# vdda1 1.09fF **FLOATING
C17063 ro_div_0/divbuf_0/a_5852_170# vdda1 1.09fF **FLOATING
C17064 ro_div_0/divbuf_0/a_5362_170# vdda1 1.09fF **FLOATING
C17065 ro_div_0/divbuf_0/a_4882_170# vdda1 1.09fF **FLOATING
C17066 ro_div_0/divbuf_0/a_4392_170# vdda1 1.07fF **FLOATING
C17067 ro_div_0/divbuf_0/a_3912_170# vdda1 1.09fF **FLOATING
C17068 ro_div_0/divbuf_0/a_3422_170# vdda1 1.10fF **FLOATING
C17069 ro_div_0/divbuf_0/a_2322_170# vdda1 1.09fF **FLOATING
C17070 ro_div_0/divbuf_0/a_1842_170# vdda1 1.09fF **FLOATING
C17071 ro_div_0/divbuf_0/a_1352_170# vdda1 1.10fF **FLOATING
C17072 ro_div_0/divbuf_0/a_492_n240# vdda1 2.46fF **FLOATING
C17073 ro_div_0/ro_complete_0/cbank_2/v vdda1 17.84fF
C17074 ro_div_0/ro_complete_0/cbank_2/switch_5/vin vdda1 0.78fF
C17075 ro_div_0/ro_complete_0/cbank_2/switch_4/vin vdda1 1.50fF
C17076 ro_div_0/ro_complete_0/cbank_2/switch_2/vin vdda1 1.30fF
C17077 ro_div_0/ro_complete_0/cbank_2/switch_3/vin vdda1 0.56fF
C17078 ro_div_0/ro_complete_0/cbank_2/switch_1/vin vdda1 1.14fF
C17079 ro_div_0/ro_complete_0/cbank_2/switch_0/vin vdda1 1.02fF
C17080 ro_div_0/ro_complete_0/cbank_1/switch_5/vin vdda1 0.78fF
C17081 ro_div_0/ro_complete_0/a0 vdda1 7.88fF
C17082 ro_div_0/ro_complete_0/cbank_1/switch_4/vin vdda1 1.50fF
C17083 ro_div_0/ro_complete_0/a1 vdda1 5.39fF
C17084 ro_div_0/ro_complete_0/cbank_1/switch_2/vin vdda1 1.30fF
C17085 ro_div_0/ro_complete_0/a3 vdda1 6.85fF
C17086 ro_div_0/ro_complete_0/cbank_1/switch_3/vin vdda1 0.56fF
C17087 ro_div_0/ro_complete_0/a2 vdda1 5.48fF
C17088 ro_div_0/ro_complete_0/cbank_1/switch_1/vin vdda1 1.14fF
C17089 ro_div_0/ro_complete_0/a4 vdda1 5.36fF
C17090 ro_div_0/ro_complete_0/cbank_1/switch_0/vin vdda1 1.02fF
C17091 ro_div_0/ro_complete_0/a5 vdda1 5.19fF
C17092 ro_div_0/ro_complete_0/cbank_0/v vdda1 14.98fF
C17093 ro_div_0/ro_complete_0/cbank_0/switch_5/vin vdda1 0.78fF
C17094 ro_div_0/ro_complete_0/cbank_0/switch_4/vin vdda1 1.50fF
C17095 ro_div_0/ro_complete_0/cbank_0/switch_2/vin vdda1 1.30fF
C17096 ro_div_0/ro_complete_0/cbank_0/switch_3/vin vdda1 0.56fF
C17097 ro_div_0/ro_complete_0/cbank_0/switch_1/vin vdda1 1.14fF
C17098 ro_div_0/ro_complete_0/cbank_0/switch_0/vin vdda1 1.02fF
C17099 ro_div_0/ro_complete_0/ro_var_extend_0/vcont vdda1 0.27fF
C17100 filter_0/v vdda1 85.69fF
C17101 filter_0/a_4216_n5230# vdda1 418.47fF **FLOATING
C17102 filter_0/a_4216_n2998# vdda1 1.03fF **FLOATING
C17103 cp_0/down vdda1 3.06fF
C17104 cp_0/out vdda1 12.02fF
C17105 cp_0/upbar vdda1 6.89fF
C17106 cp_0/a_7110_n2840# vdda1 0.17fF **FLOATING
C17107 cp_0/a_3060_n2840# vdda1 1.71fF **FLOATING
C17108 cp_0/a_7110_0# vdda1 0.17fF **FLOATING
C17109 cp_0/a_6370_0# vdda1 0.40fF **FLOATING
C17110 cp_0/a_3060_0# vdda1 4.16fF **FLOATING
C17111 cp_0/a_1710_0# vdda1 6.63fF **FLOATING
C17112 cp_0/a_10_n50# vdda1 3.15fF **FLOATING
C17113 pd_0/and_pd_0/Z1 vdda1 0.39fF
C17114 pd_0/and_pd_0/Out1 vdda1 2.22fF
C17115 pd_0/tspc_r_1/z5 vdda1 1.10fF
C17116 pd_0/tspc_r_1/Z4 vdda1 1.07fF
C17117 pd_0/tspc_r_1/Qbar vdda1 0.88fF
C17118 pd_0/tspc_r_1/Z2 vdda1 1.22fF
C17119 pd_0/tspc_r_1/Z1 vdda1 0.67fF
C17120 pd_0/UP vdda1 2.21fF
C17121 pd_0/tspc_r_1/Qbar1 vdda1 1.34fF
C17122 pd_0/tspc_r_1/Z3 vdda1 2.12fF
C17123 pd_0/REF vdda1 1.80fF
C17124 pd_0/tspc_r_0/z5 vdda1 1.10fF
C17125 pd_0/tspc_r_0/Z4 vdda1 1.07fF
C17126 pd_0/R vdda1 3.05fF
C17127 pd_0/tspc_r_0/Qbar vdda1 0.79fF
C17128 pd_0/tspc_r_0/Z2 vdda1 1.22fF
C17129 pd_0/tspc_r_0/Z1 vdda1 0.67fF
C17130 pd_0/DOWN vdda1 3.08fF
C17131 pd_0/tspc_r_0/Qbar1 vdda1 1.34fF
C17132 pd_0/tspc_r_0/Z3 vdda1 2.12fF
C17133 pd_0/DIV vdda1 1.82fF
C17134 ashish_0/Gnd vdda1 0.54fF
C17135 ashish_0/vop vdda1 16.42fF
C17136 ashish_0/von vdda1 16.41fF
C17137 ashish_0/a_150_n710# vdda1 1.54fF **FLOATING
.ends
